#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC34PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x10, 0x43, 0x0C, 0x20, 0x82, 0x08, 0x61, 0x04, 0x10, 0x42,
  0x08, 0x00, 0x00, 0x00, 0x01, 0x8E, 0x18, 0x21, 0x23, 0x23, 0x62, 0x42,
  0x42, 0x42, 0x46, 0xC6, 0x00, 0x20, 0x80, 0x02, 0x08, 0x00, 0x61, 0x80,
  0x04, 0x10, 0x00, 0x41, 0x00, 0x08, 0x30, 0x00, 0x82, 0x00, 0x08, 0x20,
  0x3F, 0x07, 0xF0, 0x10, 0x40, 0x01, 0x04, 0x00, 0x20, 0x80, 0x02, 0x08,
  0x00, 0x20, 0x80, 0x04, 0x10, 0x0F, 0xC1, 0xFC, 0x04, 0x10, 0x00, 0x82,
  0x00, 0x08, 0x20, 0x00, 0x82, 0x00, 0x10, 0x40, 0x01, 0x04, 0x00, 0x10,
  0x40, 0x02, 0x08, 0x00, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x07,
  0xF8, 0x07, 0x13, 0x83, 0x04, 0x30, 0x83, 0x04, 0x60, 0x80, 0x10, 0x20,
  0x04, 0x08, 0x01, 0x02, 0x00, 0x60, 0x80, 0x08, 0x60, 0x01, 0x90, 0x00,
  0x1E, 0x00, 0x01, 0x70, 0x00, 0x46, 0x00, 0x10, 0xC0, 0x08, 0x10, 0x02,
  0x04, 0x00, 0x81, 0x00, 0x20, 0x48, 0x08, 0x13, 0x02, 0x0C, 0x61, 0x06,
  0x0E, 0x47, 0x00, 0xFF, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xE0, 0x06, 0x0C, 0x30, 0x08, 0x10, 0x20, 0x20, 0x40, 0x40, 0x80,
  0x80, 0x83, 0x01, 0x01, 0x04, 0x02, 0x02, 0x10, 0x04, 0x04, 0x40, 0x08,
  0x11, 0x80, 0x18, 0x42, 0x00, 0x0F, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x63, 0x08, 0x00, 0x88, 0x08, 0x02, 0x10,
  0x10, 0x08, 0x60, 0x20, 0x10, 0x80, 0x40, 0x41, 0x01, 0x81, 0x02, 0x02,
  0x04, 0x04, 0x04, 0x08, 0x04, 0x30, 0x60, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x10, 0x60, 0x02, 0x02, 0x00, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x60, 0x30, 0x02, 0x02, 0x00, 0x30, 0x20, 0x01, 0x04,
  0x00, 0xF9, 0x80, 0x10, 0xE0, 0x02, 0x04, 0x00, 0x40, 0x60, 0x04, 0x02,
  0x00, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0xC0, 0x18, 0x1C, 0x01, 0xC2, 0x40,
  0x24, 0x26, 0x02, 0x24, 0x30, 0xC3, 0xC1, 0xF8, 0x18, 0x69, 0x25, 0xA4,
  0x80, 0x00, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x00, 0x80,
  0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08,
  0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x03, 0x00, 0x06, 0x00, 0x20, 0x04,
  0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x80,
  0x40, 0x30, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x06, 0x03, 0x82, 0x06, 0x79, 0x1C, 0x07, 0xF0, 0x00, 0xC0,
  0x00, 0xD0, 0x00, 0xC8, 0x00, 0xC2, 0x00, 0x41, 0x80, 0x40, 0x40, 0x40,
  0x30, 0x40, 0x08, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0x80,
  0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x1C, 0x61, 0x0C, 0x21, 0x84, 0x10, 0x80,
  0xFF, 0x80, 0x7D, 0x80, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0xF8, 0x01, 0x83, 0x01, 0x00,
  0xC1, 0x00, 0x21, 0x00, 0x18, 0x80, 0x04, 0x80, 0x02, 0x40, 0x01, 0x60,
  0x00, 0xB0, 0x00, 0x50, 0x00, 0x68, 0x18, 0x34, 0x1C, 0x12, 0x00, 0x09,
  0x00, 0x05, 0x80, 0x02, 0xC0, 0x03, 0x20, 0x01, 0x10, 0x01, 0x88, 0x00,
  0x84, 0x00, 0xC1, 0x00, 0xC0, 0xC1, 0xC0, 0x1F, 0x80, 0x00, 0x70, 0x01,
  0xA0, 0x06, 0xC0, 0x11, 0x80, 0xC2, 0x03, 0x04, 0x0C, 0x08, 0x00, 0x10,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x40, 0x7F, 0xFF, 0x00, 0xFC, 0x01, 0x81, 0x81, 0x80,
  0x41, 0x80, 0x10, 0x80, 0x08, 0xC0, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0xFC, 0x01,
  0x83, 0x01, 0x00, 0x41, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x03, 0x00, 0x7E, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0x4C, 0x00, 0x63, 0x00, 0x60, 0xC0, 0x60, 0x1F, 0xC0,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x40, 0x01, 0x20, 0x01, 0x10, 0x01,
  0x98, 0x01, 0x88, 0x00, 0x84, 0x00, 0x82, 0x00, 0x81, 0x00, 0xC0, 0x80,
  0xC0, 0xC0, 0x40, 0x40, 0x40, 0x20, 0x40, 0x10, 0x40, 0x08, 0x60, 0x04,
  0x60, 0x06, 0x3F, 0xFF, 0xE0, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x30, 0x07, 0xFF, 0x82, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0xFC, 0x07, 0x83, 0x83, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x88, 0x00, 0x42,
  0x00, 0x40, 0xC0, 0xC0, 0x1F, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x4F,
  0xC1, 0x60, 0x63, 0x00, 0x6C, 0x00, 0x58, 0x00, 0xA0, 0x01, 0xC0, 0x03,
  0x80, 0x05, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x68, 0x00, 0x88, 0x02, 0x18,
  0x18, 0x0F, 0xC0, 0x7F, 0xFF, 0x40, 0x03, 0x40, 0x02, 0xC0, 0x04, 0x80,
  0x0C, 0x80, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x01, 0xFC, 0x03, 0x03, 0x03, 0x00, 0x43, 0x00, 0x31,
  0x00, 0x08, 0x80, 0x04, 0x40, 0x02, 0x20, 0x03, 0x10, 0x01, 0x0C, 0x01,
  0x03, 0x03, 0x00, 0x7E, 0x01, 0xC0, 0xC1, 0x80, 0x31, 0x00, 0x09, 0x80,
  0x06, 0x80, 0x03, 0x40, 0x01, 0xA0, 0x00, 0xD0, 0x00, 0x4C, 0x00, 0x62,
  0x00, 0x60, 0xC0, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x18, 0x18, 0x40, 0x11,
  0x00, 0x16, 0x00, 0x28, 0x00, 0x50, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x05, 0x00, 0x1A, 0x00, 0x36, 0x00, 0xC6, 0x04, 0x83, 0xF2, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03,
  0x00, 0x18, 0x00, 0x1C, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0xE1, 0x80, 0x07, 0x07, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x18, 0x10, 0x30,
  0x20, 0x60, 0x40, 0x40, 0x80, 0x00, 0x01, 0x00, 0x07, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x08, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x10, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x0F, 0xC0, 0x60, 0xC6,
  0x01, 0x90, 0x02, 0xC0, 0x0E, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18,
  0x00, 0x40, 0x06, 0x01, 0xE0, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0x01, 0xF0, 0x0C, 0x18, 0x30, 0x18, 0xC0, 0x11, 0x00, 0x26,
  0x00, 0x48, 0x00, 0x90, 0x79, 0x41, 0x8A, 0x84, 0x0D, 0x08, 0x0A, 0x20,
  0x1C, 0x40, 0x70, 0x80, 0xA1, 0x01, 0x42, 0x02, 0x84, 0x05, 0x08, 0x1A,
  0x10, 0x74, 0x31, 0x48, 0x3C, 0x90, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x0A, 0x00,
  0x05, 0x00, 0x04, 0x80, 0x02, 0x40, 0x02, 0x20, 0x01, 0x18, 0x01, 0x04,
  0x00, 0x82, 0x00, 0x81, 0x00, 0x40, 0x80, 0x40, 0x40, 0x20, 0x30, 0x30,
  0x18, 0x10, 0x04, 0x1F, 0xFE, 0x08, 0x01, 0x0C, 0x00, 0x84, 0x00, 0x46,
  0x00, 0x32, 0x00, 0x0B, 0x00, 0x05, 0x00, 0x03, 0x80, 0x01, 0x0F, 0xFC,
  0x08, 0x06, 0x18, 0x03, 0x18, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01,
  0x10, 0x01, 0x30, 0x03, 0x30, 0x02, 0x20, 0x0C, 0x3F, 0xF0, 0x20, 0x0C,
  0x20, 0x06, 0x60, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02,
  0x40, 0x02, 0xC0, 0x06, 0xC0, 0x0C, 0x80, 0x18, 0xFF, 0xE0, 0x01, 0xF8,
  0x06, 0x0C, 0x0C, 0x02, 0x18, 0x03, 0x10, 0x01, 0x20, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x04,
  0xC0, 0x0C, 0x40, 0x08, 0x60, 0x10, 0x30, 0x60, 0x0F, 0xC0, 0x0F, 0xF8,
  0x04, 0x06, 0x02, 0x00, 0x83, 0x00, 0x21, 0x80, 0x10, 0x80, 0x0C, 0x40,
  0x02, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0x4C, 0x00, 0x24, 0x00, 0x32,
  0x00, 0x19, 0x00, 0x08, 0x80, 0x04, 0x40, 0x02, 0x60, 0x03, 0x20, 0x01,
  0x10, 0x00, 0x88, 0x00, 0x84, 0x00, 0xC2, 0x00, 0xC3, 0x00, 0xC1, 0xFF,
  0x80, 0x0F, 0xFF, 0xC2, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xFF, 0xFC, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC2, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xF8, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x00, 0x01, 0xF8, 0x06, 0x0C, 0x0C, 0x02, 0x18, 0x03, 0x30, 0x01, 0x20,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x80, 0x00, 0x80, 0xFE, 0x80, 0x06, 0x80, 0x04, 0x80, 0x04, 0x80,
  0x04, 0x80, 0x04, 0x80, 0x0C, 0x40, 0x0C, 0x40, 0x18, 0x30, 0x68, 0x1F,
  0x88, 0x08, 0x00, 0xC6, 0x00, 0x21, 0x80, 0x08, 0x40, 0x02, 0x10, 0x00,
  0x84, 0x00, 0x21, 0x00, 0x18, 0xC0, 0x04, 0x30, 0x01, 0x08, 0x00, 0x42,
  0x00, 0x10, 0xFF, 0xFC, 0x20, 0x03, 0x18, 0x00, 0x86, 0x00, 0x21, 0x00,
  0x08, 0x40, 0x02, 0x10, 0x00, 0x84, 0x00, 0x63, 0x00, 0x10, 0xC0, 0x04,
  0x20, 0x01, 0x08, 0x00, 0x42, 0x00, 0x10, 0x1F, 0xFF, 0xC0, 0x08, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x08, 0xC0, 0x08, 0x40, 0x10, 0x40, 0x30, 0x30, 0x60, 0x1F,
  0x80, 0x08, 0x00, 0x61, 0x00, 0x18, 0x20, 0x06, 0x0C, 0x01, 0x81, 0x80,
  0x60, 0x20, 0x18, 0x04, 0x04, 0x00, 0x81, 0x00, 0x10, 0x40, 0x06, 0x10,
  0x00, 0xC6, 0x00, 0x11, 0x40, 0x02, 0x4C, 0x00, 0x50, 0x80, 0x0C, 0x18,
  0x03, 0x01, 0x00, 0x60, 0x30, 0x08, 0x02, 0x01, 0x00, 0x60, 0x20, 0x04,
  0x04, 0x00, 0xC1, 0x80, 0x08, 0x30, 0x01, 0x84, 0x00, 0x10, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x3F, 0xFF, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x38, 0x02, 0x85,
  0x00, 0xF1, 0xA0, 0x14, 0x34, 0x04, 0x84, 0x40, 0x90, 0x88, 0x22, 0x11,
  0x0C, 0x42, 0x21, 0x18, 0xC2, 0x42, 0x18, 0x48, 0x42, 0x0A, 0x08, 0x41,
  0xC1, 0x08, 0x10, 0x21, 0x04, 0x0C, 0x20, 0x01, 0x0C, 0x00, 0x21, 0x00,
  0x04, 0x20, 0x00, 0x84, 0x00, 0x10, 0x80, 0x06, 0x10, 0x00, 0x86, 0x00,
  0x10, 0x0C, 0x00, 0xC7, 0x00, 0x21, 0x40, 0x08, 0x58, 0x02, 0x12, 0x00,
  0x84, 0x80, 0x21, 0x30, 0x18, 0xC4, 0x04, 0x21, 0x01, 0x08, 0x60, 0x42,
  0x08, 0x10, 0x82, 0x04, 0x20, 0x83, 0x18, 0x10, 0x84, 0x04, 0x21, 0x01,
  0x08, 0x40, 0x22, 0x10, 0x08, 0x84, 0x02, 0x63, 0x00, 0xD0, 0x80, 0x14,
  0x20, 0x05, 0x08, 0x01, 0xC2, 0x00, 0x30, 0x00, 0xF8, 0x01, 0x83, 0x01,
  0x00, 0xC1, 0x00, 0x21, 0x00, 0x18, 0x80, 0x04, 0x80, 0x02, 0x40, 0x01,
  0x60, 0x00, 0xB0, 0x00, 0x50, 0x00, 0x68, 0x00, 0x34, 0x00, 0x12, 0x00,
  0x09, 0x00, 0x05, 0x80, 0x02, 0xC0, 0x03, 0x20, 0x01, 0x10, 0x01, 0x88,
  0x00, 0x84, 0x00, 0xC1, 0x00, 0xC0, 0xC1, 0xC0, 0x1F, 0x80, 0x0F, 0xFE,
  0x02, 0x00, 0xC0, 0x80, 0x18, 0x60, 0x02, 0x18, 0x00, 0x84, 0x00, 0x31,
  0x00, 0x08, 0x40, 0x02, 0x10, 0x00, 0x8C, 0x00, 0x63, 0x00, 0x10, 0x80,
  0x18, 0x3F, 0xF8, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x00, 0x00, 0xF8, 0x01, 0x83, 0x01, 0x00, 0xC1, 0x00,
  0x21, 0x00, 0x18, 0x80, 0x04, 0x80, 0x02, 0x40, 0x01, 0x60, 0x00, 0xB0,
  0x00, 0x50, 0x00, 0x68, 0x00, 0x34, 0x00, 0x1A, 0x00, 0x09, 0x00, 0x05,
  0x80, 0x02, 0xC0, 0x03, 0x20, 0x01, 0x10, 0x01, 0x88, 0x00, 0x84, 0x00,
  0xC1, 0x00, 0xC0, 0xC1, 0xC0, 0x1F, 0x80, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0xC0, 0x08, 0x80, 0x06, 0x80, 0x01, 0x80, 0x0F, 0xFE, 0x02, 0x00,
  0xC0, 0x80, 0x18, 0x60, 0x02, 0x18, 0x00, 0x84, 0x00, 0x31, 0x00, 0x08,
  0x40, 0x02, 0x10, 0x00, 0x8C, 0x00, 0x63, 0x00, 0x10, 0x80, 0x18, 0x3F,
  0xF8, 0x08, 0x30, 0x02, 0x04, 0x01, 0x81, 0x80, 0x60, 0x20, 0x10, 0x08,
  0x04, 0x01, 0x01, 0x00, 0x40, 0x40, 0x08, 0x30, 0x02, 0x0C, 0x00, 0xC2,
  0x00, 0x10, 0x01, 0xFE, 0x01, 0xC0, 0xE0, 0xC0, 0x0C, 0x20, 0x01, 0x18,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x12, 0x00, 0x04, 0xC0,
  0x03, 0x18, 0x01, 0x83, 0x81, 0xC0, 0x3F, 0xC0, 0xFF, 0xFF, 0xC0, 0x20,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x10, 0x01, 0x98, 0x00, 0x8C, 0x00, 0x44, 0x00, 0x22, 0x00,
  0x11, 0x00, 0x08, 0x80, 0x0C, 0xC0, 0x04, 0x60, 0x02, 0x20, 0x01, 0x10,
  0x00, 0x88, 0x00, 0x44, 0x00, 0x66, 0x00, 0x22, 0x00, 0x11, 0x00, 0x08,
  0x80, 0x04, 0x40, 0x06, 0x20, 0x02, 0x10, 0x01, 0x08, 0x01, 0x86, 0x01,
  0x81, 0x81, 0x80, 0x3F, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x90, 0x00, 0x48,
  0x00, 0x44, 0x00, 0x22, 0x00, 0x31, 0x00, 0x10, 0xC0, 0x18, 0x60, 0x08,
  0x10, 0x0C, 0x08, 0x04, 0x04, 0x06, 0x02, 0x02, 0x01, 0x03, 0x00, 0xC1,
  0x00, 0x21, 0x80, 0x10, 0x80, 0x08, 0xC0, 0x04, 0x40, 0x02, 0x60, 0x01,
  0xA0, 0x00, 0x50, 0x00, 0x30, 0x00, 0x18, 0x00, 0x40, 0x00, 0x50, 0x00,
  0x14, 0x00, 0x09, 0x00, 0x02, 0x40, 0x00, 0x90, 0x00, 0x24, 0x00, 0x11,
  0x02, 0x04, 0x41, 0x81, 0x10, 0x60, 0x4C, 0x24, 0x23, 0x09, 0x08, 0x86,
  0x42, 0x21, 0x11, 0x88, 0x44, 0x42, 0x21, 0x10, 0x88, 0x44, 0x24, 0x13,
  0x09, 0x04, 0x82, 0x80, 0xA0, 0xA0, 0x28, 0x38, 0x0E, 0x0C, 0x03, 0x03,
  0x00, 0xC0, 0x0C, 0x00, 0x18, 0x20, 0x01, 0x80, 0x80, 0x08, 0x04, 0x00,
  0x80, 0x10, 0x0C, 0x00, 0x80, 0xC0, 0x02, 0x0C, 0x00, 0x10, 0x40, 0x00,
  0x44, 0x00, 0x02, 0x40, 0x00, 0x1E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x28, 0x00, 0x02, 0x20, 0x00, 0x31, 0x00, 0x03, 0x04, 0x00, 0x30,
  0x20, 0x01, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x10, 0x18, 0x00, 0x81,
  0x80, 0x06, 0x18, 0x00, 0x18, 0xC0, 0x00, 0x68, 0x00, 0x19, 0x80, 0x02,
  0x10, 0x00, 0x83, 0x00, 0x30, 0x20, 0x0C, 0x06, 0x01, 0x00, 0x40, 0x40,
  0x08, 0x10, 0x00, 0x86, 0x00, 0x11, 0x80, 0x01, 0x20, 0x00, 0x28, 0x00,
  0x07, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFC, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0F, 0xF8, 0x00,
  0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x40, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x10, 0x10, 0x10, 0x10, 0x08, 0x08, 0x08, 0x08, 0x08, 0x04, 0x04,
  0x04, 0x04, 0x02, 0x02, 0x02, 0x02, 0x01, 0x07, 0xF8, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC3, 0xFC, 0x00, 0x00, 0x60,
  0x00, 0xA0, 0x01, 0xA0, 0x03, 0x10, 0x02, 0x10, 0x04, 0x08, 0x0C, 0x08,
  0x18, 0x0C, 0x10, 0x04, 0x20, 0x04, 0x40, 0x02, 0xC0, 0x02, 0x80, 0x01,
  0xFF, 0xFF, 0x84, 0x42, 0x21, 0x03, 0xE1, 0x0C, 0x1B, 0x18, 0x06, 0x30,
  0x06, 0x20, 0x02, 0x60, 0x02, 0x40, 0x02, 0x40, 0x06, 0xC0, 0x04, 0xC0,
  0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x0C, 0xC0, 0x0C, 0x40, 0x18, 0x60,
  0x28, 0x30, 0x48, 0x1F, 0x8F, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0xF8, 0x26, 0x18, 0x50, 0x08,
  0xC0, 0x19, 0x80, 0x12, 0x00, 0x2C, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x40,
  0x02, 0x80, 0x0D, 0x00, 0x16, 0x00, 0x2C, 0x00, 0xD8, 0x01, 0x28, 0x04,
  0x58, 0x30, 0x8F, 0xC0, 0x03, 0xE0, 0x30, 0x61, 0x00, 0x88, 0x01, 0x40,
  0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x0A, 0x00, 0x3C, 0x01, 0x10, 0x0C, 0x30, 0xC0, 0x7E, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x07, 0xC2, 0x0C, 0x19, 0x0C, 0x03, 0x8C, 0x00, 0x84,
  0x00, 0x46, 0x00, 0x22, 0x00, 0x11, 0x00, 0x09, 0x80, 0x0C, 0xC0, 0x04,
  0x40, 0x02, 0x20, 0x01, 0x10, 0x01, 0x8C, 0x00, 0xC2, 0x00, 0xE1, 0x80,
  0xA0, 0x60, 0x90, 0x1F, 0x88, 0x00, 0x03, 0xF0, 0x30, 0x61, 0x00, 0x48,
  0x01, 0x60, 0x05, 0x00, 0x1C, 0x00, 0xE0, 0x06, 0x81, 0xE3, 0xF8, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x0A, 0x00, 0x3C, 0x01, 0x90, 0x04, 0x30, 0x60,
  0x7E, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0xFF, 0xFE, 0x08,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x04, 0x04, 0x00, 0x10, 0x20,
  0x00, 0x41, 0x00, 0x01, 0x08, 0x00, 0x04, 0xC0, 0x00, 0x14, 0x00, 0x00,
  0x60, 0x00, 0x03, 0xE1, 0x0C, 0x1B, 0x18, 0x06, 0x30, 0x06, 0x20, 0x02,
  0x60, 0x02, 0x40, 0x02, 0x40, 0x02, 0xC0, 0x04, 0xC0, 0x04, 0x80, 0x04,
  0x80, 0x04, 0xC0, 0x0C, 0xC0, 0x0C, 0x40, 0x18, 0x60, 0x28, 0x30, 0x48,
  0x1F, 0x88, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x80, 0x20,
  0xC0, 0xC0, 0x3F, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x7C, 0x32, 0x18, 0xF0, 0x33, 0x80, 0x4C,
  0x01, 0x20, 0x04, 0x80, 0x16, 0x00, 0x50, 0x03, 0x40, 0x0D, 0x00, 0x24,
  0x00, 0x90, 0x02, 0xC0, 0x0B, 0x00, 0x68, 0x01, 0x20, 0x04, 0x80, 0x10,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x41, 0x02, 0x0C,
  0x30, 0x31, 0x00, 0x98, 0x02, 0xC0, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x41, 0x80, 0x81, 0x81, 0x01, 0x86,
  0x01, 0x88, 0x00, 0x90, 0x00, 0xA0, 0x00, 0xC0, 0x08, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x31, 0xF0,
  0x26, 0x0C, 0x28, 0x04, 0x30, 0x04, 0x30, 0x04, 0x20, 0x04, 0x60, 0x0C,
  0x40, 0x18, 0x40, 0x60, 0x41, 0x80, 0x46, 0x00, 0x42, 0x00, 0xC2, 0x01,
  0x81, 0x02, 0x81, 0x84, 0x80, 0x88, 0x80, 0xD0, 0x80, 0x60, 0xFF, 0x00,
  0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x06, 0x02, 0x20, 0x61, 0x06, 0x08, 0x40, 0x4C, 0x02,
  0x80, 0x38, 0x00, 0x13, 0xC7, 0x85, 0x12, 0x31, 0x83, 0x04, 0x40, 0x81,
  0x30, 0x20, 0x48, 0x08, 0x12, 0x06, 0x04, 0x81, 0x01, 0x20, 0x40, 0xC8,
  0x10, 0x26, 0x04, 0x09, 0x01, 0x02, 0x40, 0xC0, 0x90, 0x20, 0x24, 0x08,
  0x19, 0x02, 0x04, 0xC0, 0x81, 0x20, 0x60, 0x40, 0x11, 0xF0, 0xC8, 0x63,
  0xC0, 0xCE, 0x01, 0x30, 0x04, 0x80, 0x12, 0x00, 0x58, 0x01, 0x40, 0x0D,
  0x00, 0x34, 0x00, 0x90, 0x02, 0x40, 0x0B, 0x00, 0x2C, 0x01, 0xA0, 0x04,
  0x80, 0x12, 0x00, 0x40, 0x07, 0xE0, 0x18, 0x30, 0xC0, 0x31, 0x00, 0x24,
  0x00, 0x48, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x14, 0x00, 0x28, 0x00, 0xD0, 0x01, 0x20, 0x06, 0x20, 0x18, 0x30, 0x60,
  0x3F, 0x00, 0x0C, 0x7C, 0x04, 0xC3, 0x02, 0x80, 0x41, 0x80, 0x30, 0xC0,
  0x08, 0x40, 0x04, 0x60, 0x02, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0x44,
  0x00, 0x62, 0x00, 0x23, 0x00, 0x11, 0x80, 0x18, 0xC0, 0x08, 0x50, 0x08,
  0x2C, 0x18, 0x11, 0xF8, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xE1, 0x0C, 0x1B,
  0x18, 0x07, 0x30, 0x02, 0x20, 0x02, 0x60, 0x02, 0x40, 0x02, 0x40, 0x02,
  0xC0, 0x06, 0xC0, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x0C, 0xC0, 0x0C,
  0x40, 0x1C, 0x60, 0x28, 0x30, 0x48, 0x1F, 0x88, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0xFE, 0x3F,
  0x02, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x03, 0xF8,
  0x0C, 0x0E, 0x18, 0x03, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x80, 0x06, 0x40, 0x04, 0x30, 0x18, 0x0F, 0xE0, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0xFF, 0xFF,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x04, 0x08, 0x0E,
  0x08, 0x30, 0x08, 0x60, 0x09, 0x80, 0x1A, 0x00, 0x1C, 0x00, 0x30, 0x06,
  0x40, 0x08, 0x80, 0x11, 0x00, 0x22, 0x00, 0x4C, 0x00, 0x90, 0x03, 0x20,
  0x04, 0x40, 0x08, 0x80, 0x11, 0x00, 0x26, 0x00, 0xCC, 0x01, 0x90, 0x02,
  0x30, 0x1C, 0x20, 0x28, 0x60, 0x90, 0x3E, 0x20, 0xF8, 0x06, 0x10, 0x04,
  0x20, 0x08, 0x40, 0x11, 0x80, 0x22, 0x00, 0x44, 0x00, 0x88, 0x01, 0x10,
  0x06, 0x20, 0x08, 0x40, 0x31, 0x80, 0x42, 0x01, 0x84, 0x06, 0x08, 0x18,
  0x10, 0x60, 0x23, 0x80, 0x78, 0x00, 0x30, 0x21, 0x10, 0x20, 0x48, 0x10,
  0x24, 0x08, 0x12, 0x04, 0x09, 0x02, 0x05, 0x81, 0x02, 0x81, 0x81, 0x40,
  0x80, 0xA0, 0x40, 0x50, 0x20, 0x28, 0x10, 0x3C, 0x18, 0x14, 0x0C, 0x0A,
  0x0A, 0x0D, 0x05, 0x04, 0x44, 0x84, 0x3C, 0x3C, 0x00, 0x03, 0x03, 0x81,
  0x91, 0x88, 0xC2, 0x60, 0xA0, 0x68, 0x10, 0x06, 0x02, 0x00, 0xC0, 0x40,
  0x18, 0x10, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x08, 0x14, 0x01, 0x02, 0x80, 0x20, 0x50, 0x34, 0x12, 0x18, 0xC4,
  0x26, 0x0F, 0x07, 0x00, 0x0C, 0x01, 0x84, 0x00, 0x82, 0x00, 0x41, 0x00,
  0x20, 0x80, 0x10, 0xC0, 0x08, 0x40, 0x0C, 0x20, 0x04, 0x10, 0x02, 0x08,
  0x01, 0x04, 0x00, 0x86, 0x00, 0xC3, 0x00, 0x61, 0x00, 0x20, 0xC0, 0x70,
  0x20, 0x28, 0x18, 0x24, 0x03, 0xE2, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0xC1, 0x00, 0xC1, 0xC0, 0xC0, 0x1F, 0x80, 0x00, 0x0F, 0xC1,
  0x88, 0x3C, 0x88, 0x03, 0xC4, 0x00, 0x42, 0x00, 0x41, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x81,
  0x80, 0x41, 0x80, 0x21, 0x00, 0x11, 0xFC, 0x04, 0x8F, 0xE2, 0x40, 0x3E,
  0x00, 0x00, 0xFE, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0xC0, 0x7E, 0x00, 0x07, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x07, 0xF0, 0x00,
  0x06, 0x08, 0x10, 0x20, 0x40, 0x83, 0x04, 0x08, 0x10, 0x20, 0x41, 0x82,
  0x04, 0x08, 0x10, 0x20, 0xC1, 0x02, 0x04, 0x08, 0x10, 0x60, 0x81, 0x02,
  0x04, 0x08, 0x30, 0x00, 0x07, 0xF0, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x3F, 0x01, 0xC0,
  0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x3F, 0x80, 0x00, 0x1E, 0x00, 0x99, 0x80, 0x50, 0x60, 0x48, 0x18, 0x68,
  0x06, 0x64, 0x01, 0xE0,
};

const GFXglyph IBMPlexMono_ExtraLightItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 6, 24, 20, 7, -24 },
  { 19, 8, 9, 20, 8, -25 },
  { 28, 20, 24, 20, 1, -24 },
  { 88, 18, 30, 20, 1, -27 },
  { 156, 23, 24, 20, -1, -24 },
  { 225, 20, 24, 20, 0, -24 },
  { 285, 3, 9, 20, 11, -25 },
  { 289, 11, 31, 20, 8, -26 },
  { 332, 11, 31, 20, 2, -26 },
  { 375, 17, 17, 20, 2, -19 },
  { 412, 17, 17, 20, 2, -19 },
  { 449, 6, 9, 20, 5, -3 },
  { 456, 9, 1, 20, 6, -11 },
  { 458, 3, 3, 20, 7, -3 },
  { 460, 19, 31, 20, 1, -26 },
  { 534, 17, 24, 20, 2, -24 },
  { 585, 15, 24, 20, 2, -24 },
  { 630, 17, 24, 20, 1, -24 },
  { 681, 17, 24, 20, 1, -24 },
  { 732, 17, 24, 20, 1, -24 },
  { 783, 17, 24, 20, 2, -24 },
  { 834, 15, 24, 20, 3, -24 },
  { 879, 16, 24, 20, 4, -24 },
  { 927, 17, 24, 20, 2, -24 },
  { 978, 15, 24, 20, 3, -24 },
  { 1023, 6, 18, 20, 7, -18 },
  { 1037, 8, 24, 20, 5, -18 },
  { 1061, 16, 18, 20, 3, -19 },
  { 1097, 17, 7, 20, 2, -14 },
  { 1112, 16, 18, 20, 2, -19 },
  { 1148, 14, 24, 20, 5, -24 },
  { 1190, 15, 28, 20, 3, -24 },
  { 1243, 17, 24, 20, 0, -24 },
  { 1294, 16, 24, 20, 2, -24 },
  { 1342, 16, 24, 20, 3, -24 },
  { 1390, 17, 24, 20, 2, -24 },
  { 1441, 18, 24, 20, 2, -24 },
  { 1495, 18, 24, 20, 2, -24 },
  { 1549, 16, 24, 20, 3, -24 },
  { 1597, 18, 24, 20, 2, -24 },
  { 1651, 18, 24, 20, 2, -24 },
  { 1705, 16, 24, 20, 2, -24 },
  { 1753, 19, 24, 20, 2, -24 },
  { 1810, 14, 24, 20, 3, -24 },
  { 1852, 19, 24, 20, 1, -24 },
  { 1909, 18, 24, 20, 2, -24 },
  { 1963, 17, 24, 20, 2, -24 },
  { 2014, 18, 24, 20, 2, -24 },
  { 2068, 17, 30, 20, 2, -24 },
  { 2132, 18, 24, 20, 2, -24 },
  { 2186, 18, 24, 20, 1, -24 },
  { 2240, 18, 24, 20, 4, -24 },
  { 2294, 17, 24, 20, 3, -24 },
  { 2345, 17, 24, 20, 4, -24 },
  { 2396, 18, 24, 20, 3, -24 },
  { 2450, 21, 24, 20, 0, -24 },
  { 2513, 19, 24, 20, 3, -24 },
  { 2570, 21, 24, 20, 0, -24 },
  { 2633, 14, 31, 20, 6, -26 },
  { 2688, 8, 31, 20, 7, -26 },
  { 2719, 13, 31, 20, 1, -26 },
  { 2770, 16, 13, 20, 3, -24 },
  { 2796, 16, 1, 20, 0, 4 },
  { 2798, 4, 6, 20, 8, -26 },
  { 2801, 16, 18, 20, 2, -18 },
  { 2837, 15, 25, 20, 3, -25 },
  { 2884, 14, 18, 20, 3, -18 },
  { 2916, 17, 25, 20, 2, -25 },
  { 2970, 14, 18, 20, 3, -18 },
  { 3002, 21, 32, 20, 0, -25 },
  { 3086, 16, 25, 20, 2, -18 },
  { 3136, 14, 25, 20, 3, -25 },
  { 3180, 14, 25, 20, 3, -25 },
  { 3224, 15, 32, 20, 3, -25 },
  { 3284, 16, 25, 20, 3, -25 },
  { 3334, 13, 25, 20, 4, -25 },
  { 3375, 18, 18, 20, 1, -18 },
  { 3416, 14, 18, 20, 3, -18 },
  { 3448, 15, 18, 20, 3, -18 },
  { 3482, 17, 25, 20, 1, -18 },
  { 3536, 16, 25, 20, 2, -18 },
  { 3586, 16, 18, 20, 4, -18 },
  { 3622, 16, 18, 20, 2, -18 },
  { 3658, 16, 24, 20, 3, -24 },
  { 3706, 15, 18, 20, 3, -18 },
  { 3740, 15, 18, 20, 3, -18 },
  { 3774, 17, 18, 20, 2, -18 },
  { 3813, 19, 18, 20, 1, -18 },
  { 3856, 17, 25, 20, 1, -18 },
  { 3910, 17, 18, 20, 2, -18 },
  { 3949, 15, 31, 20, 4, -26 },
  { 4008, 7, 31, 20, 7, -26 },
  { 4036, 15, 31, 20, 2, -26 },
  { 4095, 17, 6, 20, 2, -13 },
};

const GFXfont IBMPlexMono_ExtraLightItalic34pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic34pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic34pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC34PT7B_H_
