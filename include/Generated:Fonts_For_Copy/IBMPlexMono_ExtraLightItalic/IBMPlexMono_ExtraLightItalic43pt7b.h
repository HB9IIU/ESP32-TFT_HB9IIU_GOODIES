#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC43PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x03, 0x02, 0x02, 0x02, 0x06, 0x06, 0x06, 0x04, 0x04, 0x04,
  0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0xF0, 0x70, 0x60, 0xB0, 0xD8, 0x6C, 0x34,
  0x12, 0x0B, 0x05, 0x86, 0xC3, 0x61, 0xA0, 0x80, 0x00, 0x06, 0x04, 0x00,
  0x02, 0x06, 0x00, 0x03, 0x02, 0x00, 0x01, 0x01, 0x00, 0x00, 0x81, 0x80,
  0x00, 0xC0, 0x80, 0x00, 0x40, 0x40, 0x00, 0x20, 0x60, 0x00, 0x30, 0x20,
  0x00, 0x10, 0x30, 0x07, 0xF8, 0x1F, 0xE0, 0x0C, 0x08, 0x00, 0x04, 0x0C,
  0x00, 0x06, 0x06, 0x00, 0x03, 0x02, 0x00, 0x01, 0x03, 0x00, 0x00, 0x81,
  0x80, 0x00, 0xC0, 0x80, 0x00, 0x40, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x30,
  0x20, 0x00, 0x10, 0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x08, 0x00, 0x04,
  0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x02, 0x00, 0x01, 0x03, 0x00, 0x01,
  0x81, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xC2, 0x38,
  0x03, 0x02, 0x0C, 0x06, 0x02, 0x06, 0x04, 0x06, 0x03, 0x0C, 0x06, 0x00,
  0x0C, 0x04, 0x00, 0x0C, 0x04, 0x00, 0x0C, 0x04, 0x00, 0x0C, 0x04, 0x00,
  0x0C, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x08, 0x00, 0x01, 0xC8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0B, 0x80, 0x00, 0x18, 0x60, 0x00, 0x18, 0x30,
  0x00, 0x10, 0x10, 0x00, 0x10, 0x18, 0x00, 0x10, 0x18, 0x00, 0x10, 0x18,
  0x00, 0x30, 0x18, 0x00, 0x30, 0x18, 0x40, 0x20, 0x18, 0xC0, 0x20, 0x30,
  0x60, 0x20, 0x20, 0x38, 0x20, 0xC0, 0x0E, 0x63, 0x80, 0x03, 0xFE, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x18, 0x0C, 0x30, 0x01, 0x80, 0xC0, 0x40, 0x08, 0x0C,
  0x02, 0x00, 0x80, 0x40, 0x18, 0x0C, 0x02, 0x00, 0xC0, 0xC0, 0x30, 0x06,
  0x04, 0x01, 0x80, 0x20, 0x40, 0x0C, 0x01, 0x06, 0x00, 0x60, 0x18, 0x60,
  0x03, 0x00, 0x82, 0x00, 0x08, 0x0C, 0x20, 0x00, 0x20, 0xC3, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0x0C, 0x10, 0x00, 0x10, 0xC0, 0x40, 0x01, 0x84, 0x03,
  0x00, 0x18, 0x60, 0x08, 0x00, 0x82, 0x00, 0x40, 0x08, 0x10, 0x06, 0x00,
  0xC0, 0x80, 0x30, 0x0C, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01,
  0x00, 0xC0, 0x60, 0x0C, 0x04, 0x06, 0x00, 0x30, 0xC0, 0x60, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x30, 0x60, 0x00, 0x20, 0x08, 0x00, 0x30,
  0x06, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02,
  0x00, 0x20, 0x01, 0x00, 0x30, 0x00, 0x80, 0x18, 0x00, 0x60, 0x08, 0x00,
  0x10, 0x04, 0x00, 0x0C, 0x04, 0x00, 0x02, 0x04, 0x00, 0x1E, 0x8C, 0x00,
  0x10, 0x78, 0x00, 0x30, 0x10, 0x00, 0x10, 0x0C, 0x00, 0x18, 0x03, 0x00,
  0x08, 0x00, 0x80, 0x04, 0x00, 0x60, 0x06, 0x00, 0x10, 0x03, 0x00, 0x0C,
  0x01, 0x80, 0x07, 0x01, 0x40, 0x02, 0x81, 0xA0, 0x02, 0x60, 0x98, 0x01,
  0x18, 0x86, 0x01, 0x04, 0xC1, 0x83, 0x03, 0x40, 0x3E, 0x00, 0xC0, 0x2D,
  0xB4, 0xB6, 0xDA, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80,
  0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x08,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x10, 0x04, 0x01, 0xF0, 0x20, 0x79, 0xF1, 0x1F,
  0x01, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xC8, 0x00, 0x0C,
  0x60, 0x00, 0xC1, 0x00, 0x04, 0x0C, 0x00, 0x60, 0x20, 0x06, 0x01, 0x80,
  0x60, 0x06, 0x06, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x0C, 0x71, 0x8E, 0x30, 0xC6, 0x18, 0x43, 0x08, 0x00, 0xFF,
  0xF0, 0x7F, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0E,
  0x06, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0x60, 0xC0, 0x01, 0x04, 0x00, 0x08,
  0x60, 0x00, 0x62, 0x00, 0x03, 0x30, 0x00, 0x19, 0x00, 0x00, 0xD8, 0x00,
  0x06, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xA0, 0x38, 0x0D, 0x01, 0xC0, 0x78,
  0x0E, 0x02, 0xC0, 0x00, 0x16, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00,
  0x6C, 0x00, 0x02, 0x60, 0x00, 0x33, 0x00, 0x01, 0x18, 0x00, 0x18, 0x40,
  0x00, 0x82, 0x00, 0x0C, 0x18, 0x00, 0xC0, 0x60, 0x0C, 0x01, 0x81, 0xC0,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x01, 0xB0, 0x00, 0x32, 0x00, 0x06,
  0x20, 0x01, 0x86, 0x00, 0x30, 0x60, 0x06, 0x06, 0x01, 0x80, 0x60, 0x10,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x0E, 0x07, 0x00,
  0xC0, 0x0C, 0x0C, 0x00, 0x20, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x20, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x7F, 0x00, 0x0E, 0x06, 0x00, 0xC0, 0x08, 0x0C, 0x00, 0x60,
  0xC0, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x44, 0x00, 0x06, 0x30, 0x00, 0x20,
  0xC0, 0x06, 0x03, 0x80, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x34, 0x00, 0x01, 0x90, 0x00, 0x0C,
  0x40, 0x00, 0x63, 0x00, 0x01, 0x0C, 0x00, 0x08, 0x30, 0x00, 0x60, 0x80,
  0x03, 0x02, 0x00, 0x18, 0x08, 0x00, 0xC0, 0x60, 0x06, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x40, 0x30, 0x01, 0x01, 0x80, 0x0C,
  0x0C, 0x00, 0x30, 0x60, 0x00, 0xC3, 0x00, 0x02, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x01, 0xFF, 0xFC, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x08, 0x7E, 0x00, 0x26, 0x06, 0x01, 0xE0, 0x0C,
  0x06, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x61, 0x00, 0x03, 0x0E, 0x00, 0x08, 0x0C, 0x00, 0x60,
  0x1C, 0x06, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x0F,
  0xE0, 0x66, 0x06, 0x0B, 0x00, 0x33, 0x80, 0x02, 0x70, 0x00, 0x6C, 0x00,
  0x0D, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x02, 0x40, 0x00, 0xC8, 0x00, 0x11, 0x80, 0x06, 0x18, 0x01,
  0x81, 0x80, 0xC0, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xF4, 0x00, 0x03, 0x40,
  0x00, 0x24, 0x00, 0x06, 0x40, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x01, 0x8C,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x03, 0x01, 0x80, 0x30, 0x01, 0x81, 0x80, 0x02, 0x04, 0x00, 0x0C, 0x30,
  0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x08, 0x00, 0x0C, 0x20, 0x00,
  0x20, 0xC0, 0x01, 0x81, 0x00, 0x04, 0x06, 0x00, 0x60, 0x0E, 0x07, 0x00,
  0x0F, 0xE0, 0x01, 0xC0, 0x60, 0x1C, 0x00, 0x60, 0xC0, 0x00, 0xC2, 0x00,
  0x03, 0x18, 0x00, 0x04, 0x40, 0x00, 0x13, 0x00, 0x00, 0x4C, 0x00, 0x01,
  0x30, 0x00, 0x0C, 0xC0, 0x00, 0x31, 0x00, 0x01, 0x86, 0x00, 0x04, 0x0C,
  0x00, 0x60, 0x1C, 0x07, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0xE0,
  0x60, 0x30, 0x03, 0x0C, 0x00, 0x23, 0x00, 0x06, 0x40, 0x00, 0x58, 0x00,
  0x0A, 0x00, 0x01, 0x40, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x34, 0x00, 0x06, 0x80, 0x01, 0xD8, 0x00, 0x51, 0x80, 0x16, 0x1C, 0x0C,
  0x80, 0xFE, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x1C, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x8F, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x03, 0x81, 0x81, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x10, 0x18, 0x08,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0x80, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x03, 0x81, 0x81, 0x80, 0x30, 0xC0, 0x06, 0x60, 0x00,
  0x90, 0x00, 0x2C, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x00, 0x0F, 0x80, 0x0F,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x0C, 0x0C, 0x01, 0x00, 0x60, 0x20, 0x03, 0x04, 0x00, 0x10, 0xC0, 0x01,
  0x08, 0x00, 0x10, 0x80, 0x01, 0x18, 0x00, 0x11, 0x01, 0xF1, 0x10, 0x30,
  0x93, 0x06, 0x07, 0x20, 0xC0, 0x32, 0x08, 0x02, 0x20, 0x80, 0x26, 0x18,
  0x02, 0x61, 0x80, 0x26, 0x10, 0x06, 0x41, 0x00, 0x64, 0x10, 0x04, 0x41,
  0x00, 0x4C, 0x10, 0x0C, 0xC1, 0x00, 0xCC, 0x10, 0x1C, 0xC1, 0x82, 0xCC,
  0x0F, 0xC8, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x2C, 0x00, 0x01, 0xB0,
  0x00, 0x04, 0xC0, 0x00, 0x31, 0x00, 0x00, 0x84, 0x00, 0x06, 0x10, 0x00,
  0x10, 0x40, 0x00, 0xC1, 0x80, 0x02, 0x06, 0x00, 0x18, 0x18, 0x00, 0x40,
  0x20, 0x03, 0x00, 0x80, 0x08, 0x02, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x30,
  0x0C, 0x00, 0xC0, 0x30, 0x01, 0x01, 0xFF, 0xFC, 0x04, 0x00, 0x10, 0x30,
  0x00, 0x60, 0x80, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x08, 0xC0, 0x00,
  0x23, 0x00, 0x00, 0x98, 0x00, 0x03, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x30,
  0x07, 0xFF, 0xC0, 0x30, 0x03, 0x01, 0x80, 0x0C, 0x08, 0x00, 0x30, 0x40,
  0x01, 0x86, 0x00, 0x04, 0x30, 0x00, 0x21, 0x80, 0x03, 0x0C, 0x00, 0x18,
  0x40, 0x00, 0xC2, 0x00, 0x04, 0x30, 0x00, 0x61, 0x80, 0x06, 0x0C, 0x00,
  0x60, 0x7F, 0xFC, 0x02, 0x00, 0x18, 0x10, 0x00, 0x61, 0x80, 0x01, 0x0C,
  0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x01, 0x10, 0x00, 0x18, 0x80, 0x00,
  0xCC, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x03, 0x18, 0x00, 0x18, 0x80,
  0x01, 0x84, 0x00, 0x38, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x1C, 0x1C,
  0x03, 0x00, 0x60, 0x40, 0x02, 0x0C, 0x00, 0x31, 0x80, 0x01, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x0C, 0xC0, 0x00, 0x84, 0x00, 0x18,
  0x60, 0x03, 0x03, 0x00, 0x60, 0x18, 0x1C, 0x00, 0x7F, 0x00, 0x07, 0xFE,
  0x00, 0x60, 0x0C, 0x03, 0x00, 0x10, 0x18, 0x00, 0x40, 0x80, 0x03, 0x04,
  0x00, 0x08, 0x20, 0x00, 0x43, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00,
  0xC6, 0x00, 0x06, 0x20, 0x00, 0x31, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0,
  0x00, 0x66, 0x00, 0x02, 0x30, 0x00, 0x11, 0x00, 0x01, 0x88, 0x00, 0x0C,
  0xC0, 0x00, 0x66, 0x00, 0x02, 0x30, 0x00, 0x31, 0x80, 0x01, 0x88, 0x00,
  0x08, 0x40, 0x00, 0xC6, 0x00, 0x0C, 0x30, 0x00, 0xC1, 0x80, 0x0C, 0x0C,
  0x01, 0xC0, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x18, 0x1C,
  0x02, 0x00, 0x40, 0x40, 0x06, 0x08, 0x00, 0x31, 0x80, 0x01, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x3F, 0xE8, 0x00, 0x04, 0x80, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0xC8,
  0x00, 0x0C, 0x80, 0x00, 0xC8, 0x00, 0x08, 0xC0, 0x01, 0x8C, 0x00, 0x28,
  0x40, 0x03, 0x82, 0x00, 0x58, 0x18, 0x19, 0x80, 0x7E, 0x10, 0x06, 0x00,
  0x06, 0x0C, 0x00, 0x0C, 0x10, 0x00, 0x10, 0x20, 0x00, 0x20, 0xC0, 0x00,
  0x41, 0x80, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x06, 0x08, 0x00, 0x08,
  0x10, 0x00, 0x10, 0x60, 0x00, 0x20, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x83,
  0x00, 0x03, 0x07, 0xFF, 0xFE, 0x08, 0x00, 0x08, 0x30, 0x00, 0x10, 0x60,
  0x00, 0x60, 0xC0, 0x00, 0xC1, 0x00, 0x01, 0x82, 0x00, 0x03, 0x04, 0x00,
  0x04, 0x18, 0x00, 0x08, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0x80, 0x00,
  0xC1, 0x00, 0x01, 0x82, 0x00, 0x02, 0x0C, 0x00, 0x04, 0x18, 0x00, 0x18,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x80, 0x03, 0x0C, 0x00, 0x20, 0xC0, 0x06, 0x06,
  0x00, 0xC0, 0x30, 0x38, 0x00, 0xFC, 0x00, 0x04, 0x00, 0x07, 0x0C, 0x00,
  0x0C, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x08, 0x00, 0x60, 0x08, 0x00,
  0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x18, 0x06, 0x00, 0x18, 0x0C,
  0x00, 0x10, 0x18, 0x00, 0x10, 0x30, 0x00, 0x30, 0x60, 0x00, 0x30, 0xE0,
  0x00, 0x31, 0xA0, 0x00, 0x32, 0x30, 0x00, 0x2C, 0x10, 0x00, 0x38, 0x18,
  0x00, 0x70, 0x08, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x04, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x02, 0x00, 0x40, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x01,
  0x80, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x80, 0x00, 0xC0, 0x80, 0x00,
  0x60, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x07, 0xFF, 0xFC, 0x06, 0x00, 0x06, 0x1C, 0x00, 0x1C, 0x38,
  0x00, 0x28, 0x78, 0x00, 0xF0, 0x90, 0x01, 0x61, 0x20, 0x04, 0xC2, 0x40,
  0x19, 0x0C, 0xC0, 0x22, 0x18, 0x80, 0xC4, 0x31, 0x03, 0x18, 0x43, 0x04,
  0x30, 0x86, 0x18, 0x61, 0x04, 0x20, 0x86, 0x08, 0x81, 0x0C, 0x1B, 0x02,
  0x18, 0x14, 0x0C, 0x20, 0x38, 0x18, 0x40, 0x60, 0x30, 0x80, 0x80, 0x43,
  0x01, 0x00, 0x86, 0x00, 0x01, 0x0C, 0x00, 0x06, 0x10, 0x00, 0x0C, 0x20,
  0x00, 0x18, 0x40, 0x00, 0x21, 0x80, 0x00, 0x43, 0x00, 0x00, 0x86, 0x00,
  0x03, 0x08, 0x00, 0x06, 0x10, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x06, 0x0E,
  0x00, 0x0C, 0x14, 0x00, 0x10, 0x2C, 0x00, 0x20, 0xD8, 0x00, 0x41, 0x90,
  0x00, 0x83, 0x30, 0x03, 0x04, 0x60, 0x06, 0x08, 0x40, 0x08, 0x10, 0xC0,
  0x10, 0x61, 0x80, 0x20, 0xC1, 0x00, 0x41, 0x83, 0x01, 0x82, 0x06, 0x03,
  0x04, 0x04, 0x06, 0x08, 0x0C, 0x08, 0x30, 0x18, 0x10, 0x60, 0x10, 0x20,
  0xC0, 0x20, 0xC1, 0x00, 0x61, 0x82, 0x00, 0x43, 0x04, 0x00, 0x84, 0x18,
  0x01, 0x88, 0x30, 0x01, 0x10, 0x60, 0x02, 0x60, 0x80, 0x06, 0xC1, 0x00,
  0x0D, 0x82, 0x00, 0x0A, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0x38, 0x00, 0x00,
  0x3F, 0x00, 0x0E, 0x06, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0x60, 0xC0, 0x01,
  0x04, 0x00, 0x08, 0x60, 0x00, 0x62, 0x00, 0x03, 0x30, 0x00, 0x19, 0x00,
  0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xA0, 0x00, 0x0D,
  0x00, 0x00, 0x78, 0x00, 0x02, 0xC0, 0x00, 0x16, 0x00, 0x01, 0xB0, 0x00,
  0x0D, 0x80, 0x00, 0x6C, 0x00, 0x02, 0x60, 0x00, 0x33, 0x00, 0x01, 0x18,
  0x00, 0x18, 0x40, 0x00, 0x82, 0x00, 0x0C, 0x18, 0x00, 0xC0, 0x60, 0x0C,
  0x01, 0x81, 0xC0, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x30, 0x01, 0xC0,
  0xC0, 0x01, 0x83, 0x00, 0x06, 0x08, 0x00, 0x08, 0x20, 0x00, 0x30, 0x80,
  0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x21, 0x00, 0x01,
  0x84, 0x00, 0x06, 0x10, 0x00, 0x30, 0xC0, 0x00, 0x83, 0x00, 0x0C, 0x0F,
  0xFF, 0xC0, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0E, 0x06, 0x00, 0xC0,
  0x18, 0x0C, 0x00, 0x60, 0xC0, 0x01, 0x04, 0x00, 0x08, 0x60, 0x00, 0x62,
  0x00, 0x03, 0x30, 0x00, 0x19, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00,
  0x36, 0x00, 0x01, 0xA0, 0x00, 0x0D, 0x00, 0x00, 0x78, 0x00, 0x02, 0xC0,
  0x00, 0x16, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x02,
  0x60, 0x00, 0x33, 0x00, 0x01, 0x18, 0x00, 0x18, 0x40, 0x00, 0x82, 0x00,
  0x0C, 0x18, 0x00, 0xC0, 0x60, 0x0C, 0x01, 0x81, 0xC0, 0x03, 0xF0, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x20, 0x01, 0x86, 0x00, 0x04,
  0x60, 0x00, 0x36, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x30, 0x01,
  0xC0, 0xC0, 0x01, 0x03, 0x00, 0x06, 0x08, 0x00, 0x08, 0x20, 0x00, 0x30,
  0x80, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x21, 0x00,
  0x01, 0x84, 0x00, 0x06, 0x10, 0x00, 0x30, 0xC0, 0x00, 0x83, 0x00, 0x0C,
  0x0F, 0xFF, 0xC0, 0x20, 0x30, 0x00, 0x80, 0x40, 0x02, 0x01, 0x80, 0x18,
  0x06, 0x00, 0x60, 0x08, 0x01, 0x80, 0x30, 0x04, 0x00, 0x40, 0x10, 0x01,
  0x80, 0x40, 0x02, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x10, 0x30, 0x00, 0x60,
  0x80, 0x01, 0x82, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0x80, 0x70,
  0x0C, 0x00, 0x30, 0x30, 0x00, 0x30, 0x40, 0x00, 0x21, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x40, 0x00, 0x11, 0x80, 0x00, 0x61, 0x80, 0x00, 0x81,
  0xC0, 0x02, 0x00, 0xE0, 0x38, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x18, 0xC0,
  0x00, 0xC4, 0x00, 0x04, 0x20, 0x00, 0x23, 0x00, 0x01, 0x18, 0x00, 0x18,
  0xC0, 0x00, 0xC4, 0x00, 0x06, 0x20, 0x00, 0x21, 0x00, 0x01, 0x18, 0x00,
  0x08, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x20, 0x00, 0x31, 0x00, 0x01, 0x08,
  0x00, 0x08, 0xC0, 0x00, 0x46, 0x00, 0x06, 0x30, 0x00, 0x31, 0x00, 0x01,
  0x88, 0x00, 0x08, 0x40, 0x00, 0x42, 0x00, 0x06, 0x10, 0x00, 0x30, 0x80,
  0x01, 0x04, 0x00, 0x18, 0x30, 0x00, 0x80, 0x80, 0x08, 0x03, 0x01, 0x80,
  0x0F, 0xF0, 0x00, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x64, 0x00, 0x01, 0x90,
  0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00,
  0x30, 0x20, 0x00, 0xC0, 0x80, 0x06, 0x02, 0x00, 0x18, 0x0C, 0x00, 0xC0,
  0x30, 0x03, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x60, 0x04, 0x01, 0x00, 0x10,
  0x0C, 0x00, 0x60, 0x20, 0x01, 0x81, 0x80, 0x06, 0x04, 0x00, 0x18, 0x30,
  0x00, 0x20, 0x80, 0x00, 0x86, 0x00, 0x02, 0x10, 0x00, 0x0C, 0xC0, 0x00,
  0x32, 0x00, 0x00, 0xD8, 0x00, 0x01, 0x40, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x30, 0x00, 0x02, 0x30, 0x00, 0x02, 0x30,
  0x00, 0x06, 0x20, 0x00, 0x06, 0x20, 0x00, 0x04, 0x20, 0x00, 0x04, 0x20,
  0x00, 0x0C, 0x20, 0x00, 0x08, 0x20, 0x38, 0x08, 0x20, 0x38, 0x18, 0x20,
  0x78, 0x18, 0x60, 0x58, 0x10, 0x60, 0x48, 0x10, 0x60, 0xC8, 0x30, 0x60,
  0x88, 0x30, 0x61, 0x88, 0x20, 0x61, 0x08, 0x20, 0x43, 0x0C, 0x60, 0x42,
  0x0C, 0x60, 0x46, 0x0C, 0x40, 0x44, 0x0C, 0x40, 0x44, 0x04, 0xC0, 0x4C,
  0x04, 0xC0, 0x48, 0x04, 0x80, 0xD8, 0x04, 0x80, 0xD0, 0x05, 0x80, 0xF0,
  0x07, 0x80, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x18, 0x04, 0x00, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x08, 0x00,
  0x60, 0x01, 0x80, 0x18, 0x00, 0x10, 0x02, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x20, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x43, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x98, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x84, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x0C, 0x08, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0,
  0x10, 0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00,
  0x60, 0x00, 0x40, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x81, 0x80, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x06, 0x60, 0x00, 0x0C, 0x20,
  0x00, 0x18, 0x30, 0x00, 0x30, 0x10, 0x00, 0x30, 0x18, 0x00, 0x60, 0x08,
  0x00, 0xC0, 0x0C, 0x01, 0x80, 0x04, 0x03, 0x00, 0x06, 0x03, 0x00, 0x02,
  0x06, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x18, 0x00, 0x01, 0xB0, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0x81, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0xFF, 0x80, 0xC0, 0x08, 0x01,
  0x00, 0x20, 0x06, 0x00, 0x40, 0x08, 0x01, 0x00, 0x30, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x30, 0x02, 0x00, 0x40, 0x08, 0x01, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x0C, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x60, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x18, 0x03, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x03,
  0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0D, 0x80, 0x00, 0x44,
  0x00, 0x06, 0x30, 0x00, 0x60, 0x80, 0x06, 0x06, 0x00, 0x20, 0x10, 0x03,
  0x00, 0xC0, 0x30, 0x06, 0x03, 0x00, 0x10, 0x10, 0x00, 0xC1, 0x80, 0x02,
  0x18, 0x00, 0x19, 0x80, 0x00, 0x48, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0xC3, 0x18, 0x61, 0x0C, 0x20, 0x01, 0xFC, 0x30, 0x70, 0x22,
  0x0C, 0x01, 0x21, 0x80, 0x0A, 0x30, 0x00, 0x62, 0x00, 0x06, 0x60, 0x00,
  0x44, 0x00, 0x04, 0x40, 0x00, 0x4C, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00,
  0x0C, 0x80, 0x00, 0x88, 0x00, 0x08, 0x80, 0x01, 0x88, 0x00, 0x18, 0xC0,
  0x01, 0x8C, 0x00, 0x38, 0x40, 0x05, 0x06, 0x00, 0x90, 0x38, 0x31, 0x00,
  0xFC, 0x1F, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x7F, 0x00, 0x8C, 0x18, 0x19, 0x00, 0xC1, 0xA0,
  0x06, 0x1C, 0x00, 0x21, 0x80, 0x03, 0x18, 0x00, 0x31, 0x00, 0x03, 0x30,
  0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x32, 0x00, 0x03, 0x20, 0x00, 0x22,
  0x00, 0x02, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0xC6, 0x00, 0x08,
  0x50, 0x01, 0x85, 0x00, 0x30, 0xCC, 0x0E, 0x0C, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x60, 0x60, 0x10, 0x02, 0x04, 0x00, 0x61, 0x00, 0x04, 0x60, 0x00,
  0x48, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x04,
  0x40, 0x00, 0xCC, 0x00, 0x30, 0x80, 0x0C, 0x18, 0x03, 0x01, 0xC1, 0xC0,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x7F, 0x08, 0x0E, 0x04, 0x40, 0xC0,
  0x12, 0x0C, 0x00, 0x50, 0xC0, 0x01, 0x84, 0x00, 0x0C, 0x60, 0x00, 0x42,
  0x00, 0x02, 0x10, 0x00, 0x11, 0x80, 0x00, 0x8C, 0x00, 0x0C, 0x60, 0x00,
  0x62, 0x00, 0x03, 0x10, 0x00, 0x10, 0x80, 0x00, 0x84, 0x00, 0x0C, 0x30,
  0x00, 0x61, 0x80, 0x07, 0x04, 0x00, 0x58, 0x10, 0x04, 0x80, 0x60, 0xC4,
  0x01, 0xF8, 0x60, 0x00, 0x7E, 0x00, 0x70, 0x30, 0x18, 0x03, 0x04, 0x00,
  0x31, 0x80, 0x06, 0x60, 0x00, 0xC8, 0x00, 0x1B, 0x00, 0x02, 0x60, 0x01,
  0x88, 0x00, 0xE1, 0x01, 0xF0, 0x3F, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x02, 0x40, 0x00, 0xCC, 0x00, 0x10, 0x80, 0x04,
  0x18, 0x01, 0x01, 0xC0, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x80, 0x30, 0x00, 0x18,
  0x06, 0x00, 0x01, 0x80, 0x80, 0x00, 0x18, 0x10, 0x00, 0x01, 0x82, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x18, 0x1C, 0x08, 0x81, 0x80, 0x34, 0x18,
  0x00, 0xA1, 0x80, 0x03, 0x08, 0x00, 0x18, 0xC0, 0x00, 0xC4, 0x00, 0x04,
  0x20, 0x00, 0x23, 0x00, 0x01, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC4, 0x00,
  0x06, 0x20, 0x00, 0x21, 0x00, 0x01, 0x08, 0x00, 0x18, 0x60, 0x00, 0xC3,
  0x00, 0x0E, 0x08, 0x00, 0xB0, 0x20, 0x09, 0x00, 0xC1, 0x88, 0x03, 0xF0,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC1, 0x00, 0x0C, 0x0C, 0x00, 0xC0, 0x38, 0x1C, 0x00, 0x7F, 0x80,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0xF8, 0x06, 0x60, 0xC0, 0x90, 0x0C, 0x14, 0x00, 0x87, 0x00,
  0x10, 0xE0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x40, 0x01, 0x08, 0x00,
  0x23, 0x00, 0x04, 0x60, 0x01, 0x8C, 0x00, 0x31, 0x00, 0x06, 0x20, 0x00,
  0x84, 0x00, 0x11, 0x80, 0x02, 0x30, 0x00, 0xC6, 0x00, 0x18, 0x80, 0x02,
  0x10, 0x00, 0x46, 0x00, 0x08, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x02, 0x02,
  0x00, 0xC0, 0x80, 0xC0, 0x60, 0x60, 0x18, 0x20, 0x06, 0x30, 0x01, 0x10,
  0x00, 0x58, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x80, 0x10, 0x10, 0x04, 0x03, 0x01, 0x00,
  0x60, 0x40, 0x0C, 0x30, 0x01, 0x8C, 0x00, 0x32, 0x00, 0x06, 0x80, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x83, 0xF0, 0x02, 0x30, 0x70, 0x19,
  0x00, 0x40, 0x68, 0x01, 0x81, 0xC0, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00,
  0x60, 0x40, 0x01, 0x03, 0x00, 0x08, 0x0C, 0x00, 0xC0, 0x30, 0x06, 0x00,
  0x80, 0xE0, 0x02, 0x1C, 0x00, 0x08, 0x20, 0x00, 0x60, 0xC0, 0x01, 0x81,
  0x00, 0x36, 0x06, 0x01, 0x10, 0x08, 0x08, 0x40, 0x30, 0xC1, 0x00, 0x66,
  0x0C, 0x00, 0xB0, 0x30, 0x03, 0x80, 0xFF, 0xE0, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x02, 0x0C, 0x03, 0x86,
  0x02, 0x02, 0x06, 0x01, 0x06, 0x00, 0x84, 0x00, 0xCC, 0x00, 0x68, 0x00,
  0x38, 0x00, 0x0C, 0xF0, 0x7C, 0x12, 0x11, 0x0C, 0x28, 0x34, 0x08, 0x60,
  0x30, 0x11, 0x80, 0x60, 0x23, 0x00, 0x80, 0x46, 0x03, 0x00, 0x88, 0x06,
  0x03, 0x10, 0x0C, 0x06, 0x20, 0x10, 0x0C, 0xC0, 0x20, 0x11, 0x80, 0x40,
  0x23, 0x01, 0x80, 0x44, 0x03, 0x01, 0x88, 0x04, 0x03, 0x10, 0x08, 0x06,
  0x60, 0x10, 0x08, 0xC0, 0x60, 0x11, 0x80, 0xC0, 0x22, 0x01, 0x80, 0xC4,
  0x02, 0x01, 0x98, 0x04, 0x03, 0x00, 0x0C, 0x3E, 0x01, 0x18, 0x30, 0x24,
  0x03, 0x05, 0x00, 0x21, 0xC0, 0x04, 0x38, 0x00, 0xC6, 0x00, 0x18, 0xC0,
  0x03, 0x10, 0x00, 0x42, 0x00, 0x08, 0xC0, 0x01, 0x18, 0x00, 0x63, 0x00,
  0x0C, 0x40, 0x01, 0x88, 0x00, 0x21, 0x00, 0x04, 0x60, 0x00, 0x8C, 0x00,
  0x31, 0x80, 0x06, 0x20, 0x00, 0x84, 0x00, 0x11, 0x80, 0x02, 0x00, 0x00,
  0xFC, 0x00, 0x60, 0x60, 0x10, 0x03, 0x04, 0x00, 0x21, 0x00, 0x06, 0x60,
  0x00, 0x48, 0x00, 0x0B, 0x00, 0x01, 0x60, 0x00, 0x28, 0x00, 0x05, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x16, 0x00,
  0x06, 0x40, 0x00, 0xC8, 0x00, 0x31, 0x80, 0x04, 0x18, 0x03, 0x01, 0xC0,
  0xC0, 0x0F, 0xE0, 0x00, 0x04, 0x3F, 0x80, 0x23, 0x06, 0x03, 0x20, 0x18,
  0x1A, 0x00, 0x60, 0xE0, 0x01, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x00,
  0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x20, 0x00, 0x31,
  0x00, 0x01, 0x08, 0x00, 0x08, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00,
  0x61, 0x80, 0x02, 0x0A, 0x00, 0x30, 0x50, 0x03, 0x06, 0x60, 0x70, 0x30,
  0xFC, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x30, 0x70, 0x22, 0x0C, 0x01, 0x21, 0x80, 0x0A,
  0x30, 0x00, 0x62, 0x00, 0x06, 0x60, 0x00, 0x64, 0x00, 0x04, 0x40, 0x00,
  0x4C, 0x00, 0x04, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0x80, 0x00, 0xC8, 0x00,
  0x08, 0x80, 0x00, 0x88, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x38, 0x40,
  0x05, 0x82, 0x00, 0x90, 0x18, 0x31, 0x00, 0xFC, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0xFF, 0x87, 0xF8, 0x0C,
  0xC0, 0x00, 0x68, 0x00, 0x02, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x70, 0x1C, 0x0C,
  0x00, 0x61, 0x80, 0x03, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x48, 0x00, 0x04, 0xC0, 0x00, 0xC6, 0x00, 0x18, 0x38, 0x06, 0x00, 0x7F,
  0x80, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF,
  0xF8, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x01, 0x80, 0x40, 0x18, 0x02, 0x03, 0x00, 0x30, 0x20, 0x01, 0x86, 0x00,
  0x0C, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0x80, 0x00, 0x10, 0x00, 0x4C, 0x00,
  0x13, 0x00, 0x0C, 0xC0, 0x03, 0x20, 0x00, 0xC8, 0x00, 0x22, 0x00, 0x09,
  0x80, 0x02, 0x60, 0x01, 0x98, 0x00, 0x64, 0x00, 0x19, 0x00, 0x04, 0x40,
  0x01, 0x30, 0x00, 0x4C, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x07, 0x30, 0x02,
  0x8C, 0x01, 0x21, 0x80, 0x58, 0x30, 0x66, 0x07, 0xE1, 0x80, 0x7E, 0x00,
  0x28, 0x20, 0x02, 0x06, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30, 0x60,
  0x03, 0x04, 0x00, 0x30, 0x40, 0x03, 0x04, 0x00, 0x30, 0xC0, 0x02, 0x0C,
  0x00, 0x20, 0xC0, 0x06, 0x0C, 0x00, 0x40, 0x80, 0x0C, 0x08, 0x00, 0x80,
  0x80, 0x18, 0x18, 0x03, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x01, 0x83, 0x80,
  0x10, 0xE0, 0x01, 0xF8, 0x00, 0x10, 0x08, 0x11, 0x80, 0xC0, 0xCC, 0x06,
  0x06, 0x60, 0x30, 0x12, 0x01, 0x00, 0x90, 0x08, 0x04, 0x80, 0x40, 0x2C,
  0x06, 0x01, 0x60, 0x30, 0x0B, 0x01, 0x80, 0x50, 0x08, 0x02, 0x80, 0x40,
  0x14, 0x02, 0x01, 0xE0, 0x30, 0x0F, 0x01, 0x80, 0x50, 0x0C, 0x02, 0x80,
  0x40, 0x34, 0x06, 0x01, 0x20, 0x50, 0x19, 0x02, 0xC1, 0x8C, 0x22, 0x18,
  0x3E, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x07, 0x20, 0xC6, 0x1C, 0x31, 0x83,
  0x70, 0x11, 0x01, 0x40, 0x12, 0x01, 0x00, 0x1A, 0x01, 0x00, 0x1C, 0x01,
  0x00, 0x1C, 0x03, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x38, 0x00,
  0x80, 0x38, 0x00, 0x80, 0x58, 0x00, 0x80, 0x48, 0x06, 0x80, 0x88, 0x0C,
  0xC1, 0x8C, 0x30, 0x63, 0x04, 0xC0, 0x3C, 0x03, 0x80, 0x04, 0x00, 0x10,
  0xC0, 0x01, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0x80, 0x02,
  0x08, 0x00, 0x21, 0x80, 0x02, 0x18, 0x00, 0x61, 0x80, 0x06, 0x10, 0x00,
  0x61, 0x00, 0x04, 0x10, 0x00, 0x43, 0x00, 0x04, 0x30, 0x00, 0xC3, 0x00,
  0x0C, 0x30, 0x01, 0xC3, 0x00, 0x28, 0x30, 0x06, 0x81, 0x80, 0x58, 0x0C,
  0x19, 0x80, 0x7E, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x08, 0x00, 0x60, 0xC0, 0x0C, 0x07, 0x03, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x08, 0x60, 0x78, 0x42, 0x00, 0x7A, 0x20,
  0x00, 0x71, 0x00, 0x06, 0x08, 0x00, 0x60, 0x40, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x20, 0x0C, 0x01, 0x01, 0x80, 0x08, 0x18, 0x00, 0x61,
  0x80, 0x03, 0x1F, 0x00, 0x08, 0xBF, 0xC0, 0x4C, 0x0F, 0xE2, 0x60, 0x07,
  0xF0, 0x00, 0x3F, 0xF0, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x0F, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0x01, 0x03, 0x03, 0x02, 0x02, 0x02, 0x02, 0x06,
  0x06, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x18,
  0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0x30, 0x30, 0x20, 0x20, 0x20, 0x60,
  0x60, 0x60, 0x40, 0x40, 0x40, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0xF0, 0x07, 0x80, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x3F, 0xF0, 0x00, 0x07, 0x80, 0x04, 0x23, 0x00, 0x11, 0x06, 0x00, 0x88,
  0x0C, 0x02, 0x60, 0x10, 0x11, 0x00, 0x20, 0xC4, 0x00, 0xC6, 0x30, 0x00,
  0xF0,
};

const GFXglyph IBMPlexMono_ExtraLightItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 8, 30, 26, 9, -30 },
  { 31, 9, 11, 26, 11, -32 },
  { 44, 25, 30, 26, 1, -30 },
  { 138, 24, 38, 26, 1, -34 },
  { 252, 29, 30, 26, -1, -30 },
  { 361, 25, 30, 26, 0, -30 },
  { 455, 3, 11, 26, 14, -32 },
  { 460, 14, 39, 26, 10, -33 },
  { 529, 14, 39, 26, 3, -33 },
  { 598, 21, 21, 26, 3, -24 },
  { 654, 21, 21, 26, 3, -24 },
  { 710, 6, 11, 26, 7, -4 },
  { 719, 12, 1, 26, 7, -14 },
  { 721, 4, 3, 26, 9, -3 },
  { 723, 23, 39, 26, 2, -33 },
  { 836, 21, 30, 26, 3, -30 },
  { 915, 20, 30, 26, 2, -30 },
  { 990, 21, 30, 26, 2, -30 },
  { 1069, 21, 30, 26, 2, -30 },
  { 1148, 22, 30, 26, 1, -30 },
  { 1231, 22, 30, 26, 2, -30 },
  { 1314, 19, 30, 26, 3, -30 },
  { 1386, 20, 30, 26, 5, -30 },
  { 1461, 22, 30, 26, 2, -30 },
  { 1544, 19, 30, 26, 4, -30 },
  { 1616, 7, 22, 26, 9, -22 },
  { 1636, 9, 29, 26, 7, -22 },
  { 1669, 20, 23, 26, 4, -25 },
  { 1727, 22, 9, 26, 2, -18 },
  { 1752, 21, 23, 26, 2, -25 },
  { 1813, 18, 30, 26, 6, -30 },
  { 1881, 20, 35, 26, 3, -30 },
  { 1969, 22, 30, 26, 0, -30 },
  { 2052, 21, 30, 26, 2, -30 },
  { 2131, 20, 30, 26, 4, -30 },
  { 2206, 21, 30, 26, 3, -30 },
  { 2285, 22, 30, 26, 3, -30 },
  { 2368, 23, 30, 26, 3, -30 },
  { 2455, 20, 30, 26, 4, -30 },
  { 2530, 23, 30, 26, 2, -30 },
  { 2617, 23, 30, 26, 2, -30 },
  { 2704, 20, 30, 26, 3, -30 },
  { 2779, 24, 30, 26, 3, -30 },
  { 2869, 17, 30, 26, 4, -30 },
  { 2933, 23, 30, 26, 2, -30 },
  { 3020, 23, 30, 26, 2, -30 },
  { 3107, 21, 30, 26, 3, -30 },
  { 3186, 22, 30, 26, 3, -30 },
  { 3269, 21, 37, 26, 3, -30 },
  { 3367, 22, 30, 26, 3, -30 },
  { 3450, 23, 30, 26, 1, -30 },
  { 3537, 22, 30, 26, 5, -30 },
  { 3620, 21, 30, 26, 4, -30 },
  { 3699, 22, 30, 26, 5, -30 },
  { 3782, 24, 30, 26, 3, -30 },
  { 3872, 27, 30, 26, 0, -30 },
  { 3974, 24, 30, 26, 4, -30 },
  { 4064, 26, 30, 26, 0, -30 },
  { 4162, 17, 39, 26, 8, -33 },
  { 4245, 11, 39, 26, 8, -33 },
  { 4299, 17, 39, 26, 1, -33 },
  { 4382, 21, 17, 26, 3, -30 },
  { 4427, 21, 1, 26, 0, 5 },
  { 4430, 5, 7, 26, 10, -33 },
  { 4435, 20, 22, 26, 3, -22 },
  { 4490, 20, 32, 26, 3, -32 },
  { 4570, 19, 22, 26, 3, -22 },
  { 4623, 21, 32, 26, 3, -32 },
  { 4707, 19, 22, 26, 3, -22 },
  { 4760, 27, 41, 26, 0, -32 },
  { 4899, 21, 31, 26, 2, -22 },
  { 4981, 19, 32, 26, 3, -32 },
  { 5057, 18, 32, 26, 4, -32 },
  { 5129, 18, 41, 26, 4, -32 },
  { 5222, 22, 32, 26, 3, -32 },
  { 5310, 17, 32, 26, 5, -32 },
  { 5378, 23, 22, 26, 1, -22 },
  { 5442, 19, 22, 26, 3, -22 },
  { 5495, 19, 22, 26, 3, -22 },
  { 5548, 21, 31, 26, 2, -22 },
  { 5630, 20, 31, 26, 3, -22 },
  { 5708, 21, 22, 26, 5, -22 },
  { 5766, 20, 22, 26, 3, -22 },
  { 5821, 21, 30, 26, 3, -30 },
  { 5900, 18, 22, 26, 4, -22 },
  { 5950, 20, 22, 26, 3, -22 },
  { 6005, 21, 22, 26, 3, -22 },
  { 6063, 24, 22, 26, 1, -22 },
  { 6129, 20, 31, 26, 2, -22 },
  { 6207, 21, 22, 26, 2, -22 },
  { 6265, 20, 39, 26, 5, -33 },
  { 6363, 8, 39, 26, 9, -33 },
  { 6402, 19, 39, 26, 2, -33 },
  { 6495, 22, 8, 26, 2, -17 },
};

const GFXfont IBMPlexMono_ExtraLightItalic43pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic43pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic43pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC43PT7B_H_
