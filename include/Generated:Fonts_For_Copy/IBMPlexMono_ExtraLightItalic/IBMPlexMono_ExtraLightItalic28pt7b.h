#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC28PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x46, 0x21, 0x08, 0x42, 0x11, 0x08, 0x42, 0x20, 0x00, 0x00,
  0x39, 0x80, 0x45, 0x14, 0x51, 0x8A, 0x28, 0x80, 0x00, 0x42, 0x00, 0x21,
  0x00, 0x21, 0x00, 0x10, 0x80, 0x08, 0x40, 0x08, 0x40, 0x04, 0x20, 0x7E,
  0x1F, 0x02, 0x10, 0x01, 0x08, 0x00, 0x84, 0x00, 0x84, 0x07, 0xC3, 0xE4,
  0x21, 0x00, 0x21, 0x00, 0x10, 0x80, 0x08, 0x40, 0x08, 0x40, 0x04, 0x20,
  0x02, 0x30, 0x00, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x1F, 0x80, 0xC4,
  0xC2, 0x10, 0xC4, 0x21, 0x10, 0x40, 0x20, 0x80, 0x41, 0x00, 0x42, 0x00,
  0xC8, 0x00, 0x78, 0x00, 0x2E, 0x00, 0x46, 0x00, 0x84, 0x01, 0x08, 0x04,
  0x10, 0x08, 0x24, 0x10, 0x44, 0x21, 0x06, 0x4C, 0x07, 0xF0, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x07, 0x80, 0x42, 0x30, 0x21, 0x04, 0x10, 0xC1,
  0x04, 0x20, 0x42, 0x08, 0x11, 0x02, 0x04, 0x80, 0x82, 0x20, 0x11, 0x90,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x01, 0x08, 0x06, 0x82, 0x02, 0x20, 0x40,
  0x88, 0x10, 0x44, 0x08, 0x21, 0x02, 0x10, 0x20, 0x84, 0x08, 0x42, 0x01,
  0xE0, 0x03, 0xE0, 0x06, 0x10, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x04, 0x08, 0x04, 0x10, 0x02, 0x10, 0x0E, 0x60, 0x31, 0x80, 0x41,
  0x00, 0x40, 0x80, 0x80, 0x40, 0x80, 0x40, 0x80, 0x61, 0x80, 0x61, 0x40,
  0x92, 0x61, 0x8A, 0x1E, 0x0C, 0x55, 0xA8, 0x00, 0xC0, 0x40, 0x40, 0x10,
  0x08, 0x04, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00,
  0x40, 0x08, 0x00, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x04, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x01, 0x00,
  0x80, 0x80, 0x40, 0x40, 0x40, 0x40, 0xC0, 0x00, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x03, 0x08, 0x73, 0xAE, 0x01, 0xC0, 0x05, 0x00,
  0x24, 0x01, 0x08, 0x08, 0x20, 0x60, 0x41, 0x01, 0x00, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x03, 0xFF, 0xE0, 0x40, 0x02, 0x00,
  0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x00, 0x19, 0x8C, 0x46, 0x21, 0x10,
  0xFE, 0xF8, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80,
  0x00, 0x03, 0xE0, 0x30, 0xC1, 0x00, 0x8C, 0x02, 0x20, 0x09, 0x00, 0x14,
  0x00, 0x50, 0x01, 0x40, 0x0A, 0x0C, 0x28, 0x30, 0xA0, 0x02, 0x80, 0x0A,
  0x00, 0x68, 0x01, 0x20, 0x04, 0x80, 0x21, 0x01, 0x06, 0x0C, 0x07, 0xC0,
  0x00, 0xE0, 0x0E, 0x00, 0xD0, 0x08, 0x81, 0x84, 0x18, 0x20, 0x01, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x41, 0xFF, 0xF0, 0x03, 0xF0, 0x10,
  0x60, 0x80, 0xC4, 0x01, 0x10, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x3F, 0xFE, 0x03, 0xE0, 0x30, 0x61,
  0x80, 0xC4, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x30,
  0x1F, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06,
  0x80, 0x11, 0x00, 0xC6, 0x06, 0x07, 0xE0, 0x00, 0x08, 0x00, 0x60, 0x02,
  0x80, 0x12, 0x00, 0x88, 0x02, 0x40, 0x11, 0x00, 0x84, 0x04, 0x10, 0x20,
  0x40, 0x81, 0x04, 0x04, 0x20, 0x21, 0x00, 0x88, 0x02, 0x3F, 0xFF, 0x00,
  0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x0F, 0xFC, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x2F, 0xC0, 0xC1, 0x86,
  0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x80, 0x22,
  0x01, 0x86, 0x0C, 0x0F, 0xC0, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x10, 0x02, 0x00, 0x27, 0xC5, 0x86, 0x60, 0x1C, 0x01, 0xC0,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x34, 0x02, 0x60, 0xC1, 0xF0, 0x7F,
  0xFA, 0x00, 0x50, 0x05, 0x00, 0x28, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x01,
  0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x80, 0x00, 0x07, 0xE0, 0x30, 0x61,
  0x00, 0x88, 0x03, 0x20, 0x04, 0x80, 0x22, 0x00, 0x88, 0x06, 0x18, 0x20,
  0x1F, 0x03, 0x86, 0x10, 0x04, 0x80, 0x12, 0x00, 0x28, 0x01, 0xA0, 0x04,
  0x80, 0x12, 0x00, 0x86, 0x0C, 0x0F, 0xC0, 0x0F, 0x83, 0x06, 0x60, 0x34,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x3C, 0x05, 0x60, 0xA3,
  0xF2, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x06,
  0x00, 0x39, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x73, 0x00, 0x0E,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x86, 0x0C,
  0x10, 0x60, 0x81, 0x04, 0x00, 0x00, 0x08, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x08, 0x01, 0x80, 0x10, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x08, 0x00, 0x00, 0x0F,
  0x86, 0x09, 0x00, 0xE0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40,
  0x30, 0x38, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x03, 0xE0, 0x60, 0x82, 0x02, 0x20, 0x12, 0x00, 0x90,
  0x04, 0x87, 0xA8, 0x43, 0x44, 0x1A, 0x20, 0x51, 0x04, 0x90, 0x28, 0x81,
  0x44, 0x0A, 0x20, 0xD1, 0x0A, 0x86, 0xE4, 0x08, 0x20, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x7F, 0x00, 0x00, 0x20, 0x01, 0x80, 0x05, 0x00, 0x24,
  0x00, 0x90, 0x04, 0x40, 0x11, 0x00, 0x84, 0x02, 0x10, 0x10, 0x20, 0x40,
  0x82, 0x02, 0x08, 0x08, 0x7F, 0xE1, 0x00, 0x8C, 0x01, 0x20, 0x05, 0x80,
  0x14, 0x00, 0x70, 0x01, 0x1F, 0xE0, 0x80, 0x88, 0x02, 0x40, 0x12, 0x00,
  0x90, 0x04, 0x80, 0x24, 0x02, 0x40, 0x23, 0xFE, 0x10, 0x08, 0x80, 0x24,
  0x01, 0x20, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x14, 0x01, 0x20, 0x19, 0xFF,
  0x00, 0x03, 0xE0, 0x10, 0x40, 0x80, 0x84, 0x03, 0x20, 0x00, 0x80, 0x06,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x10, 0x04, 0x40, 0x31, 0x00, 0x83, 0x0C, 0x07, 0xC0,
  0x1F, 0xC0, 0x40, 0xC1, 0x01, 0x88, 0x02, 0x20, 0x08, 0x80, 0x22, 0x00,
  0x48, 0x01, 0x20, 0x09, 0x00, 0x24, 0x00, 0x90, 0x02, 0x40, 0x09, 0x00,
  0x24, 0x01, 0x30, 0x04, 0x80, 0x22, 0x01, 0x88, 0x0C, 0x3F, 0xC0, 0x1F,
  0xFC, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x01, 0xFF, 0xE4, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x3F, 0xF8, 0x1F, 0xFE,
  0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0xFF, 0xE1, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x00,
  0x03, 0xE0, 0x30, 0x41, 0x80, 0x84, 0x02, 0x20, 0x00, 0x80, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x7E, 0x80, 0x0A, 0x00,
  0x48, 0x01, 0x20, 0x04, 0x40, 0x31, 0x01, 0x42, 0x0A, 0x07, 0xC8, 0x08,
  0x02, 0x20, 0x04, 0x40, 0x08, 0x80, 0x11, 0x00, 0x62, 0x00, 0x84, 0x01,
  0x10, 0x02, 0x20, 0x04, 0x7F, 0xF8, 0x80, 0x31, 0x00, 0x42, 0x00, 0x88,
  0x01, 0x10, 0x02, 0x20, 0x04, 0x40, 0x18, 0x80, 0x21, 0x00, 0x46, 0x00,
  0x80, 0x1F, 0xFE, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x08, 0x80, 0x44, 0x06, 0x10, 0x60, 0x7C, 0x00,
  0x10, 0x02, 0x20, 0x08, 0x40, 0x21, 0x00, 0x82, 0x02, 0x04, 0x18, 0x08,
  0x60, 0x11, 0x80, 0x26, 0x00, 0x9C, 0x01, 0x64, 0x03, 0x88, 0x06, 0x08,
  0x08, 0x10, 0x10, 0x10, 0x40, 0x20, 0x80, 0x61, 0x00, 0x42, 0x00, 0xC4,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x7F, 0xF0, 0x18, 0x03, 0x18, 0x06, 0x18, 0x06,
  0x14, 0x0A, 0x14, 0x0A, 0x24, 0x12, 0x24, 0x32, 0x22, 0x24, 0x22, 0x44,
  0x22, 0x44, 0x22, 0x84, 0x41, 0x04, 0x41, 0x04, 0x40, 0x08, 0x40, 0x08,
  0x40, 0x08, 0x40, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x10, 0x08, 0x02,
  0x28, 0x04, 0x50, 0x08, 0xA0, 0x11, 0x20, 0x22, 0x40, 0x84, 0x81, 0x10,
  0x82, 0x21, 0x04, 0x42, 0x08, 0x84, 0x11, 0x04, 0x42, 0x08, 0x88, 0x11,
  0x10, 0x12, 0x20, 0x24, 0x40, 0x48, 0x80, 0x61, 0x00, 0xC4, 0x01, 0x80,
  0x03, 0xE0, 0x30, 0xC1, 0x00, 0x8C, 0x02, 0x20, 0x09, 0x00, 0x14, 0x00,
  0x50, 0x01, 0x40, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00,
  0x68, 0x01, 0x20, 0x04, 0x80, 0x21, 0x01, 0x06, 0x0C, 0x07, 0xC0, 0x1F,
  0xF0, 0x40, 0x21, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x48,
  0x03, 0x20, 0x09, 0x00, 0x47, 0xFE, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x03, 0xE0,
  0x30, 0xC1, 0x00, 0x8C, 0x02, 0x20, 0x09, 0x00, 0x14, 0x00, 0x50, 0x01,
  0x40, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x68, 0x01,
  0x20, 0x04, 0x80, 0x21, 0x01, 0x06, 0x08, 0x07, 0xC0, 0x04, 0x00, 0x08,
  0x40, 0x13, 0x80, 0x58, 0x00, 0xC0, 0x1F, 0xF0, 0x40, 0x21, 0x00, 0x48,
  0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x48, 0x03, 0x20, 0x09, 0x00, 0x47,
  0xFE, 0x10, 0x40, 0x41, 0x01, 0x02, 0x04, 0x08, 0x20, 0x20, 0x80, 0x42,
  0x01, 0x08, 0x02, 0x20, 0x0C, 0x03, 0xF0, 0x18, 0x18, 0x40, 0x18, 0x80,
  0x22, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x80,
  0x08, 0x80, 0x20, 0xC1, 0x80, 0xFE, 0x00, 0xFF, 0xFE, 0x02, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x10, 0x04, 0x80,
  0x12, 0x00, 0x48, 0x01, 0x20, 0x08, 0x80, 0x22, 0x00, 0x90, 0x02, 0x40,
  0x09, 0x00, 0x24, 0x01, 0x90, 0x04, 0x40, 0x12, 0x00, 0x48, 0x01, 0x20,
  0x08, 0x80, 0x21, 0x01, 0x86, 0x0C, 0x0F, 0xC0, 0xC0, 0x05, 0x00, 0x14,
  0x00, 0x90, 0x02, 0x40, 0x11, 0x00, 0x44, 0x02, 0x08, 0x08, 0x20, 0x40,
  0x81, 0x02, 0x08, 0x08, 0x20, 0x21, 0x00, 0x84, 0x01, 0x30, 0x04, 0x80,
  0x12, 0x00, 0x50, 0x01, 0x40, 0x06, 0x00, 0x40, 0x02, 0x80, 0x05, 0x00,
  0x0A, 0x00, 0x24, 0x00, 0x48, 0x00, 0x90, 0x41, 0x21, 0x84, 0x43, 0x08,
  0x8A, 0x11, 0x12, 0x22, 0x44, 0x84, 0x89, 0x11, 0x12, 0x24, 0x24, 0x48,
  0x50, 0xA0, 0xA1, 0x41, 0x43, 0x02, 0x86, 0x02, 0x00, 0x08, 0x00, 0x84,
  0x00, 0x81, 0x00, 0x80, 0x80, 0xC0, 0x20, 0x40, 0x10, 0x40, 0x04, 0x40,
  0x02, 0x40, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x28, 0x00, 0x22,
  0x00, 0x31, 0x00, 0x10, 0x40, 0x10, 0x20, 0x10, 0x08, 0x10, 0x04, 0x18,
  0x01, 0x18, 0x00, 0x80, 0x80, 0x03, 0x00, 0x09, 0x00, 0x22, 0x00, 0xC2,
  0x01, 0x04, 0x04, 0x04, 0x10, 0x08, 0x60, 0x10, 0x80, 0x12, 0x00, 0x28,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xE1, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0xFE, 0x00,
  0x80, 0x81, 0x02, 0x04, 0x04, 0x08, 0x10, 0x20, 0x40, 0x40, 0x81, 0x02,
  0x02, 0x04, 0x08, 0x10, 0x10, 0x20, 0x40, 0x81, 0x01, 0x02, 0x0F, 0xE0,
  0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0xFE, 0x00, 0x00, 0x80, 0x0A,
  0x00, 0x90, 0x08, 0xC0, 0x42, 0x04, 0x10, 0x40, 0x44, 0x02, 0x20, 0x0A,
  0x00, 0x60, 0x02, 0xFF, 0xF8, 0x91, 0x22, 0x0F, 0x88, 0xC2, 0x88, 0x0C,
  0x80, 0x24, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x04, 0x80, 0x24, 0x01, 0x20,
  0x19, 0x81, 0x46, 0x12, 0x1F, 0x3C, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x78, 0x2C, 0x31, 0x80, 0x88, 0x02,
  0x40, 0x16, 0x00, 0xA0, 0x05, 0x00, 0x28, 0x02, 0x40, 0x12, 0x00, 0xB0,
  0x09, 0x61, 0x88, 0xF8, 0x00, 0x07, 0xC1, 0x86, 0x20, 0x16, 0x01, 0x40,
  0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x03, 0x40, 0x24, 0x04, 0x20,
  0x81, 0xF0, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x83, 0xE2, 0x18, 0x50, 0x80, 0xC4, 0x01, 0x10, 0x04, 0x80,
  0x12, 0x00, 0x48, 0x02, 0x20, 0x08, 0x80, 0x22, 0x01, 0x8C, 0x0A, 0x18,
  0x68, 0x3E, 0x40, 0x07, 0xC1, 0x83, 0x30, 0x12, 0x01, 0x40, 0x14, 0x03,
  0x81, 0xCF, 0xE0, 0x80, 0x08, 0x00, 0x80, 0x14, 0x02, 0x20, 0xC1, 0xF0,
  0x00, 0x3F, 0x80, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x1F, 0xFE, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x04, 0x08, 0x03, 0x08,
  0x00, 0xC4, 0x00, 0x12, 0x00, 0x05, 0x00, 0x01, 0x80, 0x00, 0x07, 0xC4,
  0x30, 0xD1, 0x00, 0x88, 0x02, 0x20, 0x09, 0x00, 0x24, 0x00, 0x90, 0x04,
  0x40, 0x11, 0x00, 0x44, 0x03, 0x18, 0x14, 0x30, 0x90, 0x7C, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x22, 0x01, 0x04, 0x18, 0x0F, 0xC0, 0x08, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x3C, 0x24, 0x22, 0x81,
  0x30, 0x12, 0x01, 0x20, 0x16, 0x01, 0x40, 0x14, 0x02, 0x40, 0x24, 0x02,
  0x40, 0x28, 0x02, 0x80, 0x60, 0x01, 0x80, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x08, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x10, 0x83, 0x08, 0x40, 0x98, 0x0A, 0x00, 0xC0, 0x00,
  0x30, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x81, 0x0C, 0x10, 0x22, 0x01, 0x20, 0x0A,
  0x00, 0x60, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x03, 0x00, 0x08, 0xF8, 0x24, 0x30, 0xE0, 0x43, 0x01, 0x08, 0x04, 0x60,
  0x21, 0x03, 0x04, 0x70, 0x13, 0x00, 0x44, 0x05, 0x08, 0x2C, 0x11, 0x20,
  0x58, 0x80, 0xC0, 0xFE, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00,
  0x81, 0x10, 0x42, 0x30, 0x48, 0x16, 0x03, 0x00, 0x27, 0x1C, 0x51, 0x4C,
  0xC3, 0x09, 0x04, 0x12, 0x08, 0x28, 0x20, 0x90, 0x41, 0x20, 0x82, 0x41,
  0x04, 0x82, 0x09, 0x04, 0x14, 0x10, 0x48, 0x20, 0x90, 0x41, 0x00, 0x13,
  0xC2, 0x42, 0x28, 0x13, 0x01, 0x20, 0x12, 0x01, 0x20, 0x14, 0x01, 0x40,
  0x24, 0x02, 0x40, 0x24, 0x02, 0x80, 0x28, 0x06, 0x07, 0xC0, 0xC1, 0x08,
  0x04, 0xC0, 0x24, 0x00, 0xA0, 0x06, 0x00, 0x30, 0x02, 0x80, 0x14, 0x00,
  0xA0, 0x08, 0x80, 0xC6, 0x0C, 0x0F, 0x80, 0x11, 0xE0, 0x58, 0x61, 0x80,
  0x84, 0x01, 0x10, 0x04, 0x40, 0x12, 0x00, 0x48, 0x01, 0x20, 0x08, 0x80,
  0x22, 0x00, 0x98, 0x04, 0x58, 0x61, 0x1F, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x0F, 0x88, 0xC2, 0x48, 0x0C, 0x80,
  0x24, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x06, 0x80, 0x24, 0x01, 0x20, 0x19,
  0x81, 0x46, 0x12, 0x1F, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x01, 0x00, 0xFC, 0xFC, 0x14, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x00, 0x0F, 0xC0, 0x81, 0x88, 0x06, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x7E, 0x00, 0x1C, 0x00, 0x10, 0x00, 0x80, 0x05, 0x00, 0x66,
  0x06, 0x0F, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x0F, 0xFF, 0xC1, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x0C, 0x08, 0x60, 0x46, 0x01, 0x60,
  0x06, 0x00, 0x40, 0x34, 0x02, 0x40, 0x24, 0x02, 0x40, 0x28, 0x02, 0x80,
  0x48, 0x04, 0x80, 0x48, 0x04, 0x81, 0xC8, 0x1C, 0xC2, 0x87, 0xC8, 0xF8,
  0x10, 0x40, 0x44, 0x02, 0x20, 0x11, 0x00, 0x88, 0x04, 0x40, 0x42, 0x02,
  0x20, 0x31, 0x01, 0x08, 0x10, 0x41, 0x02, 0x30, 0x1E, 0x00, 0x21, 0x09,
  0x04, 0x24, 0x10, 0x50, 0x41, 0x41, 0x05, 0x04, 0x18, 0x20, 0x60, 0x81,
  0x82, 0x0A, 0x08, 0x28, 0x20, 0xA1, 0x84, 0x8A, 0x31, 0xC7, 0x00, 0x0E,
  0x1C, 0x34, 0x45, 0x85, 0x0C, 0x0C, 0x10, 0x18, 0x20, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x01, 0x06, 0x02, 0x14, 0x14, 0x28, 0x78, 0x8B, 0x0E,
  0x1C, 0x00, 0x10, 0x0C, 0x40, 0x21, 0x00, 0x84, 0x02, 0x10, 0x08, 0x80,
  0x22, 0x01, 0x08, 0x04, 0x20, 0x10, 0x80, 0x42, 0x07, 0x08, 0x1C, 0x30,
  0xA0, 0x7C, 0x80, 0x02, 0x00, 0x08, 0x00, 0x62, 0x01, 0x04, 0x18, 0x0F,
  0x80, 0x0F, 0xC4, 0x41, 0xD2, 0x00, 0xC8, 0x04, 0x20, 0x20, 0x01, 0x00,
  0x18, 0x00, 0x80, 0x04, 0x10, 0x60, 0x42, 0x01, 0x1C, 0x02, 0x5F, 0x8B,
  0x07, 0xE0, 0x01, 0xF8, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x0F, 0xC0, 0x03,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x04, 0x00, 0x1F, 0x80, 0x08, 0x42, 0x11, 0x08, 0x42,
  0x10, 0x88, 0x42, 0x10, 0x84, 0x42, 0x10, 0x84, 0x22, 0x10, 0x80, 0x0F,
  0xE0, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x0F, 0x81, 0xC0, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x10, 0x01, 0x00, 0x08,
  0x00, 0x40, 0xFE, 0x00, 0x1C, 0x02, 0x44, 0x09, 0x04, 0x12, 0x04, 0x48,
  0x07, 0x00,
};

const GFXglyph IBMPlexMono_ExtraLightItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 5, 20, 17, 6, -20 },
  { 14, 6, 7, 17, 7, -21 },
  { 20, 17, 20, 17, 0, -20 },
  { 63, 15, 26, 17, 1, -23 },
  { 112, 18, 20, 17, 0, -20 },
  { 157, 16, 20, 17, 0, -20 },
  { 197, 2, 7, 17, 9, -21 },
  { 199, 10, 25, 17, 6, -21 },
  { 231, 9, 25, 17, 2, -21 },
  { 260, 14, 14, 17, 2, -15 },
  { 285, 13, 13, 17, 2, -15 },
  { 307, 5, 8, 17, 4, -3 },
  { 312, 7, 1, 17, 5, -9 },
  { 313, 3, 2, 17, 6, -2 },
  { 314, 15, 25, 17, 1, -21 },
  { 361, 14, 20, 17, 2, -20 },
  { 396, 13, 20, 17, 1, -20 },
  { 429, 14, 20, 17, 1, -20 },
  { 464, 14, 20, 17, 1, -20 },
  { 499, 14, 20, 17, 1, -20 },
  { 534, 14, 20, 17, 2, -20 },
  { 569, 12, 20, 17, 2, -20 },
  { 599, 13, 20, 17, 3, -20 },
  { 632, 14, 20, 17, 2, -20 },
  { 667, 12, 20, 17, 3, -20 },
  { 697, 5, 15, 17, 6, -15 },
  { 707, 7, 20, 17, 4, -15 },
  { 725, 13, 15, 17, 3, -16 },
  { 750, 15, 7, 17, 1, -12 },
  { 764, 14, 15, 17, 1, -16 },
  { 791, 11, 20, 17, 4, -20 },
  { 819, 13, 23, 17, 2, -20 },
  { 857, 14, 20, 17, 0, -20 },
  { 892, 13, 20, 17, 2, -20 },
  { 925, 14, 20, 17, 2, -20 },
  { 960, 14, 20, 17, 2, -20 },
  { 995, 14, 20, 17, 2, -20 },
  { 1030, 15, 20, 17, 2, -20 },
  { 1068, 14, 20, 17, 2, -20 },
  { 1103, 15, 20, 17, 1, -20 },
  { 1141, 15, 20, 17, 1, -20 },
  { 1179, 13, 20, 17, 2, -20 },
  { 1212, 15, 20, 17, 2, -20 },
  { 1250, 11, 20, 17, 3, -20 },
  { 1278, 16, 20, 17, 1, -20 },
  { 1318, 15, 20, 17, 1, -20 },
  { 1356, 14, 20, 17, 2, -20 },
  { 1391, 14, 20, 17, 2, -20 },
  { 1426, 14, 25, 17, 2, -20 },
  { 1470, 14, 20, 17, 2, -20 },
  { 1505, 15, 20, 17, 1, -20 },
  { 1543, 15, 20, 17, 3, -20 },
  { 1581, 14, 20, 17, 2, -20 },
  { 1616, 14, 20, 17, 3, -20 },
  { 1651, 15, 20, 17, 2, -20 },
  { 1689, 17, 20, 17, 0, -20 },
  { 1732, 15, 20, 17, 3, -20 },
  { 1770, 17, 20, 17, 0, -20 },
  { 1813, 11, 25, 17, 5, -21 },
  { 1848, 7, 25, 17, 5, -21 },
  { 1870, 11, 25, 17, 1, -21 },
  { 1905, 13, 11, 17, 2, -20 },
  { 1923, 13, 1, 17, 0, 3 },
  { 1925, 3, 5, 17, 7, -22 },
  { 1927, 13, 14, 17, 2, -14 },
  { 1950, 13, 21, 17, 2, -21 },
  { 1985, 12, 14, 17, 2, -14 },
  { 2006, 14, 21, 17, 2, -21 },
  { 2043, 12, 14, 17, 2, -14 },
  { 2064, 17, 27, 17, 0, -21 },
  { 2122, 14, 20, 17, 1, -14 },
  { 2157, 12, 21, 17, 2, -21 },
  { 2189, 12, 20, 17, 2, -20 },
  { 2219, 12, 26, 17, 3, -20 },
  { 2258, 14, 21, 17, 2, -21 },
  { 2295, 11, 21, 17, 3, -21 },
  { 2324, 15, 14, 17, 1, -14 },
  { 2351, 12, 14, 17, 2, -14 },
  { 2372, 13, 14, 17, 2, -14 },
  { 2395, 14, 20, 17, 1, -14 },
  { 2430, 13, 20, 17, 2, -14 },
  { 2463, 14, 14, 17, 3, -14 },
  { 2488, 13, 14, 17, 2, -14 },
  { 2511, 14, 20, 17, 2, -20 },
  { 2546, 12, 14, 17, 3, -14 },
  { 2567, 13, 14, 17, 2, -14 },
  { 2590, 14, 14, 17, 2, -14 },
  { 2615, 15, 14, 17, 1, -14 },
  { 2642, 14, 20, 17, 1, -14 },
  { 2677, 14, 14, 17, 1, -14 },
  { 2702, 13, 25, 17, 3, -21 },
  { 2743, 5, 25, 17, 6, -21 },
  { 2759, 13, 25, 17, 1, -21 },
  { 2800, 15, 5, 17, 1, -11 },
};

const GFXfont IBMPlexMono_ExtraLightItalic28pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic28pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic28pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC28PT7B_H_
