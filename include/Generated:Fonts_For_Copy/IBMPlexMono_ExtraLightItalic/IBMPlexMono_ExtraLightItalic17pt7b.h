#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC17PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x29, 0x24, 0xA4, 0x00, 0x40, 0x59, 0x9A, 0x04, 0x81, 0x20, 0x90,
  0x24, 0x39, 0xD4, 0x81, 0x23, 0xCE, 0x24, 0x09, 0x02, 0x41, 0x20, 0x04,
  0x02, 0x07, 0x8D, 0x24, 0x9A, 0x41, 0x20, 0x70, 0x16, 0x08, 0x84, 0x52,
  0x29, 0x23, 0xE0, 0x80, 0x40, 0x18, 0x24, 0x89, 0x12, 0x22, 0x84, 0x50,
  0x70, 0x00, 0xE0, 0xA4, 0x28, 0x89, 0x12, 0x22, 0x43, 0x80, 0x0E, 0x04,
  0x42, 0x10, 0x84, 0x11, 0x0C, 0x84, 0xC2, 0x20, 0x84, 0x20, 0x98, 0x59,
  0xE6, 0x5A, 0x08, 0x88, 0x88, 0x42, 0x10, 0x84, 0x21, 0x08, 0x21, 0x80,
  0x10, 0x40, 0x82, 0x08, 0x10, 0x41, 0x08, 0x20, 0x84, 0x20, 0x8C, 0x00,
  0x08, 0x04, 0x02, 0x19, 0x33, 0xE0, 0xC0, 0x90, 0x8C, 0x08, 0x08, 0x08,
  0x08, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x5A, 0x80, 0xF8, 0x80, 0x00, 0x80,
  0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04,
  0x04, 0x02, 0x00, 0x1E, 0x21, 0x41, 0x41, 0x81, 0x81, 0x89, 0x81, 0x81,
  0x82, 0x46, 0x38, 0x0C, 0x1C, 0x34, 0x48, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x10, 0x10, 0xFF, 0x1E, 0x21, 0x41, 0x01, 0x01, 0x02, 0x04, 0x08, 0x10,
  0x20, 0xC0, 0xFE, 0x1E, 0x21, 0x41, 0x01, 0x02, 0x1C, 0x26, 0x02, 0x02,
  0x82, 0x86, 0x78, 0x01, 0x81, 0x81, 0x41, 0x21, 0x10, 0x88, 0x84, 0x84,
  0x7F, 0xC1, 0x00, 0x80, 0x40, 0x3F, 0x20, 0x40, 0x40, 0x5C, 0x62, 0x01,
  0x01, 0x02, 0x82, 0x86, 0x7C, 0x06, 0x08, 0x10, 0x20, 0x40, 0x5E, 0xE2,
  0x81, 0x81, 0x82, 0x42, 0x3C, 0xFF, 0x82, 0x82, 0x84, 0x04, 0x08, 0x10,
  0x10, 0x20, 0x20, 0x40, 0x80, 0x1E, 0x21, 0x41, 0x41, 0x21, 0x1E, 0x62,
  0x81, 0x81, 0x81, 0x82, 0x7C, 0x3C, 0x86, 0x0C, 0x18, 0x30, 0xDE, 0x82,
  0x08, 0x20, 0x86, 0x00, 0x40, 0x00, 0x80, 0x20, 0x00, 0x02, 0x52, 0x40,
  0x01, 0x06, 0x18, 0x60, 0x80, 0x40, 0x20, 0x18, 0x04, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x40, 0x30, 0x08, 0x06, 0x01, 0x06, 0x18, 0x20, 0xC0, 0x3C,
  0x86, 0x08, 0x10, 0x20, 0x41, 0x1C, 0x20, 0x40, 0x03, 0x00, 0x1E, 0x31,
  0x21, 0x41, 0x4F, 0x91, 0x91, 0xA1, 0xA2, 0x96, 0x88, 0x80, 0x40, 0x3C,
  0x02, 0x03, 0x02, 0x81, 0x41, 0x20, 0x88, 0x44, 0x42, 0x3F, 0x20, 0x90,
  0x50, 0x10, 0x3E, 0x41, 0x41, 0x41, 0x42, 0x7C, 0x82, 0x81, 0x81, 0x81,
  0x82, 0xFC, 0x0E, 0x18, 0x88, 0x48, 0x14, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x41, 0x91, 0x07, 0x00, 0x3E, 0x41, 0x41, 0x41, 0x41, 0x41, 0x41, 0x81,
  0x81, 0x82, 0x86, 0xF8, 0x3F, 0xA0, 0x10, 0x08, 0x04, 0x03, 0xF9, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x1F, 0xC0, 0x3F, 0xA0, 0x10, 0x08, 0x04, 0x03,
  0xF9, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x00, 0x1E, 0x18, 0x90, 0x48,
  0x14, 0x04, 0x02, 0x3D, 0x02, 0x81, 0x41, 0x11, 0x87, 0x40, 0x40, 0xA0,
  0x50, 0x48, 0x24, 0x13, 0xFA, 0x05, 0x02, 0x82, 0x41, 0x20, 0x90, 0x40,
  0x3F, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04,
  0x1F, 0xC0, 0x1F, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02, 0x02, 0x02, 0x82,
  0x84, 0x78, 0x20, 0xD0, 0x44, 0x21, 0x10, 0x48, 0x16, 0x06, 0x81, 0x20,
  0x84, 0x21, 0x08, 0x22, 0x0C, 0x41, 0x04, 0x10, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x3F, 0x20, 0xB0, 0xD8, 0xAC, 0x69, 0x54, 0xAA, 0x25, 0x22, 0x81,
  0x40, 0xA0, 0x90, 0x40, 0x20, 0xB0, 0x54, 0x4A, 0x25, 0x12, 0x4A, 0x25,
  0x12, 0x8A, 0x43, 0x21, 0x90, 0x40, 0x1E, 0x21, 0x41, 0x41, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x82, 0x46, 0x38, 0x3F, 0x20, 0x50, 0x28, 0x14, 0x0A,
  0x09, 0xF9, 0x00, 0x80, 0x40, 0x20, 0x10, 0x00, 0x1E, 0x21, 0x41, 0x41,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x46, 0x38, 0x11, 0x0A, 0x04, 0x3F,
  0x20, 0x50, 0x28, 0x14, 0x0A, 0x09, 0xF9, 0x10, 0x88, 0x42, 0x21, 0x10,
  0x40, 0x1E, 0x30, 0x90, 0x68, 0x04, 0x01, 0xC0, 0x18, 0x02, 0x01, 0x40,
  0xA0, 0x8F, 0x80, 0xFF, 0x88, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x00, 0x40, 0xA0, 0x50, 0x48, 0x24, 0x14, 0x0A,
  0x05, 0x02, 0x82, 0x41, 0x11, 0x8F, 0x80, 0x81, 0xC0, 0xA0, 0x90, 0x48,
  0x42, 0x21, 0x20, 0x90, 0x50, 0x28, 0x14, 0x04, 0x00, 0x40, 0xD0, 0x24,
  0x0A, 0x02, 0x89, 0x26, 0x49, 0x92, 0x94, 0xA6, 0x31, 0x8C, 0x62, 0x18,
  0x20, 0x62, 0x10, 0x42, 0x04, 0x80, 0xA0, 0x08, 0x01, 0x00, 0xD0, 0x12,
  0x04, 0x21, 0x04, 0x40, 0x40, 0x80, 0xC0, 0x90, 0x88, 0x84, 0x81, 0x80,
  0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x00, 0x3F, 0xC0, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x03, 0xFE, 0x1E, 0x40,
  0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x3E, 0x00,
  0x88, 0x84, 0x44, 0x42, 0x22, 0x21, 0x11, 0x10, 0x1E, 0x04, 0x08, 0x10,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x3E, 0x00, 0x04, 0x0C,
  0x12, 0x22, 0x41, 0x41, 0x81, 0xFF, 0xA4, 0x3D, 0x63, 0x42, 0x82, 0x82,
  0x82, 0x82, 0x86, 0x7B, 0x20, 0x20, 0x20, 0x40, 0x5E, 0x61, 0x41, 0x41,
  0x41, 0x81, 0x82, 0x42, 0xBC, 0x1C, 0x22, 0x43, 0x80, 0x80, 0x80, 0x82,
  0x44, 0x38, 0x01, 0x80, 0x80, 0x40, 0x23, 0xD3, 0x19, 0x05, 0x04, 0x82,
  0x41, 0x20, 0x88, 0xC7, 0xA0, 0x1E, 0x21, 0x41, 0x82, 0xFC, 0x80, 0x82,
  0x42, 0x3C, 0x03, 0xE0, 0x40, 0x10, 0x02, 0x03, 0xFC, 0x08, 0x01, 0x00,
  0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x08, 0x81, 0x90, 0x1C, 0x00, 0x80,
  0x3D, 0x63, 0x41, 0x82, 0x82, 0x82, 0x82, 0x46, 0x7C, 0x04, 0x84, 0x78,
  0x20, 0x20, 0x20, 0x20, 0x4E, 0x72, 0x61, 0x42, 0x42, 0x42, 0x82, 0x82,
  0x82, 0x18, 0x00, 0x00, 0x0F, 0x04, 0x08, 0x10, 0x20, 0x45, 0x32, 0x86,
  0x00, 0x02, 0x00, 0x00, 0x07, 0xD0, 0x81, 0x04, 0x08, 0x10, 0x20, 0x48,
  0x9A, 0x1C, 0x08, 0x20, 0x10, 0x08, 0x08, 0x04, 0xE3, 0x89, 0x04, 0x84,
  0x4C, 0x48, 0x24, 0x71, 0x68, 0x40, 0xF0, 0x20, 0x41, 0x02, 0x04, 0x08,
  0x10, 0x40, 0x89, 0x3A, 0x86, 0x00, 0x7B, 0x66, 0x62, 0x31, 0x28, 0x94,
  0x8A, 0x45, 0x22, 0x91, 0x00, 0x4E, 0x72, 0x61, 0x42, 0x42, 0x42, 0x82,
  0x82, 0x82, 0x1E, 0x22, 0x41, 0x81, 0x81, 0x81, 0x82, 0x46, 0x3C, 0x5E,
  0x61, 0x41, 0x41, 0x41, 0x81, 0x82, 0xC2, 0xBC, 0x80, 0x80, 0x80, 0x3D,
  0x63, 0x41, 0x82, 0x82, 0x82, 0x82, 0x46, 0x7A, 0x04, 0x04, 0x04, 0xF7,
  0x38, 0x10, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x3E, 0x41, 0x40, 0x40,
  0x3E, 0x02, 0x02, 0x82, 0x7C, 0x08, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10,
  0x20, 0x21, 0x26, 0x2C, 0x30, 0x83, 0x06, 0x14, 0x28, 0x50, 0xA1, 0x4E,
  0xF8, 0xE1, 0x21, 0x21, 0x21, 0x41, 0x42, 0x42, 0x4C, 0x70, 0x49, 0x24,
  0x62, 0x31, 0x18, 0x8C, 0x8A, 0x45, 0x22, 0xEE, 0x00, 0x19, 0x8A, 0x94,
  0xC4, 0x11, 0x08, 0x22, 0x08, 0x8A, 0x54, 0x66, 0x00, 0x41, 0x41, 0x42,
  0x42, 0x82, 0x82, 0x82, 0x4E, 0x7C, 0x04, 0x8C, 0x78, 0x3D, 0x43, 0x82,
  0x04, 0x18, 0x22, 0x42, 0xF2, 0x9E, 0x0F, 0x10, 0x10, 0x10, 0x10, 0x08,
  0x08, 0xF0, 0x10, 0x10, 0x20, 0x40, 0x40, 0x40, 0x78, 0x25, 0x24, 0x92,
  0x92, 0x49, 0x20, 0x3C, 0x08, 0x10, 0x40, 0x82, 0x04, 0x07, 0x18, 0x40,
  0x40, 0x81, 0x02, 0x3C, 0x00, 0x70, 0xA8, 0xA2, 0x50, 0xC0,
};

const GFXglyph IBMPlexMono_ExtraLightItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 12, 10, 4, -12 },
  { 6, 4, 4, 10, 4, -13 },
  { 8, 10, 12, 10, 0, -12 },
  { 23, 9, 16, 10, 1, -14 },
  { 41, 11, 12, 10, 0, -12 },
  { 58, 10, 12, 10, 0, -12 },
  { 73, 2, 4, 10, 5, -13 },
  { 74, 5, 15, 10, 4, -13 },
  { 84, 6, 15, 10, 1, -13 },
  { 96, 9, 8, 10, 1, -9 },
  { 105, 8, 9, 10, 1, -10 },
  { 114, 2, 5, 10, 3, -2 },
  { 116, 5, 1, 10, 3, -6 },
  { 117, 1, 1, 10, 4, -1 },
  { 118, 9, 15, 10, 1, -13 },
  { 135, 8, 12, 10, 1, -12 },
  { 147, 8, 12, 10, 1, -12 },
  { 159, 8, 12, 10, 1, -12 },
  { 171, 8, 12, 10, 1, -12 },
  { 183, 9, 12, 10, 0, -12 },
  { 197, 8, 12, 10, 1, -12 },
  { 209, 8, 12, 10, 1, -12 },
  { 221, 8, 12, 10, 2, -12 },
  { 233, 8, 12, 10, 1, -12 },
  { 245, 7, 12, 10, 2, -12 },
  { 256, 2, 9, 10, 4, -9 },
  { 259, 3, 12, 10, 3, -9 },
  { 264, 8, 9, 10, 2, -10 },
  { 273, 9, 4, 10, 1, -7 },
  { 278, 8, 9, 10, 1, -10 },
  { 287, 7, 12, 10, 2, -12 },
  { 298, 8, 14, 10, 1, -12 },
  { 312, 9, 12, 10, 0, -12 },
  { 326, 8, 12, 10, 1, -12 },
  { 338, 9, 12, 10, 1, -12 },
  { 352, 8, 12, 10, 1, -12 },
  { 364, 9, 12, 10, 1, -12 },
  { 378, 9, 12, 10, 1, -12 },
  { 392, 9, 12, 10, 1, -12 },
  { 406, 9, 12, 10, 1, -12 },
  { 420, 9, 12, 10, 1, -12 },
  { 434, 8, 12, 10, 1, -12 },
  { 446, 10, 12, 10, 1, -12 },
  { 461, 6, 12, 10, 2, -12 },
  { 470, 9, 12, 10, 1, -12 },
  { 484, 9, 12, 10, 1, -12 },
  { 498, 8, 12, 10, 1, -12 },
  { 510, 9, 12, 10, 1, -12 },
  { 524, 8, 15, 10, 1, -12 },
  { 539, 9, 12, 10, 1, -12 },
  { 553, 9, 12, 10, 1, -12 },
  { 567, 9, 12, 10, 2, -12 },
  { 581, 9, 12, 10, 1, -12 },
  { 595, 9, 12, 10, 2, -12 },
  { 609, 10, 12, 10, 1, -12 },
  { 624, 11, 12, 10, 0, -12 },
  { 641, 9, 12, 10, 2, -12 },
  { 655, 10, 12, 10, 0, -12 },
  { 670, 7, 15, 10, 3, -13 },
  { 684, 4, 15, 10, 3, -13 },
  { 692, 7, 15, 10, 0, -13 },
  { 706, 8, 7, 10, 1, -12 },
  { 713, 8, 1, 10, 0, 2 },
  { 714, 2, 3, 10, 4, -14 },
  { 715, 8, 9, 10, 1, -9 },
  { 724, 8, 13, 10, 1, -13 },
  { 737, 8, 9, 10, 1, -9 },
  { 746, 9, 13, 10, 1, -13 },
  { 761, 8, 9, 10, 1, -9 },
  { 770, 11, 16, 10, 0, -13 },
  { 792, 8, 12, 10, 1, -9 },
  { 804, 8, 13, 10, 1, -13 },
  { 817, 7, 13, 10, 2, -13 },
  { 829, 7, 16, 10, 2, -13 },
  { 843, 9, 13, 10, 1, -13 },
  { 858, 7, 13, 10, 2, -13 },
  { 870, 9, 9, 10, 1, -9 },
  { 881, 8, 9, 10, 1, -9 },
  { 890, 8, 9, 10, 1, -9 },
  { 899, 8, 12, 10, 1, -9 },
  { 911, 8, 12, 10, 1, -9 },
  { 923, 8, 9, 10, 2, -9 },
  { 932, 8, 9, 10, 1, -9 },
  { 941, 8, 12, 10, 1, -12 },
  { 953, 7, 9, 10, 2, -9 },
  { 961, 8, 9, 10, 1, -9 },
  { 970, 9, 9, 10, 1, -9 },
  { 981, 10, 9, 10, 0, -9 },
  { 993, 8, 12, 10, 1, -9 },
  { 1005, 8, 9, 10, 1, -9 },
  { 1014, 8, 15, 10, 2, -13 },
  { 1029, 3, 15, 10, 4, -13 },
  { 1035, 7, 15, 10, 1, -13 },
  { 1049, 9, 4, 10, 1, -7 },
};

const GFXfont IBMPlexMono_ExtraLightItalic17pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic17pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic17pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC17PT7B_H_
