#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC39PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x10, 0xC3, 0x0C, 0x20, 0x82, 0x18, 0x61, 0x04, 0x10, 0x43,
  0x08, 0x20, 0x82, 0x00, 0x00, 0x00, 0x00, 0xE3, 0x8C, 0x00, 0x61, 0x61,
  0x43, 0x43, 0x43, 0xC2, 0xC2, 0xC2, 0x86, 0x86, 0x00, 0x08, 0x10, 0x00,
  0x30, 0x60, 0x00, 0x40, 0x80, 0x00, 0x81, 0x00, 0x03, 0x06, 0x00, 0x04,
  0x08, 0x00, 0x08, 0x30, 0x00, 0x30, 0x40, 0x00, 0x40, 0x80, 0x7F, 0x83,
  0xFC, 0x03, 0x04, 0x00, 0x04, 0x08, 0x00, 0x18, 0x30, 0x00, 0x30, 0x40,
  0x00, 0x40, 0x80, 0x00, 0x83, 0x00, 0x02, 0x04, 0x01, 0xFC, 0x0F, 0xE0,
  0x18, 0x30, 0x00, 0x20, 0x40, 0x00, 0x40, 0x80, 0x01, 0x83, 0x00, 0x02,
  0x04, 0x00, 0x04, 0x08, 0x00, 0x18, 0x30, 0x00, 0x20, 0x40, 0x00, 0x41,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x07, 0xF8, 0x00, 0xC2, 0x70, 0x18, 0x30, 0xC0, 0x81, 0x03, 0x0C,
  0x08, 0x00, 0x40, 0x40, 0x02, 0x02, 0x00, 0x10, 0x10, 0x00, 0x81, 0x80,
  0x04, 0x08, 0x00, 0x30, 0x40, 0x00, 0xE2, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x08, 0xE0, 0x00, 0x41, 0x80, 0x02, 0x04, 0x00, 0x10, 0x30,
  0x00, 0x81, 0x80, 0x0C, 0x04, 0x00, 0x40, 0x60, 0x02, 0x03, 0x10, 0x10,
  0x11, 0xC0, 0x81, 0x83, 0x04, 0x18, 0x0E, 0x63, 0x80, 0x1F, 0xE0, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0xF8,
  0x00, 0x40, 0xC3, 0x00, 0x20, 0x20, 0x60, 0x10, 0x10, 0x08, 0x0C, 0x0C,
  0x02, 0x02, 0x03, 0x00, 0x81, 0x00, 0x80, 0x20, 0x80, 0x20, 0x08, 0x60,
  0x08, 0x06, 0x10, 0x02, 0x01, 0x08, 0x00, 0xC0, 0xC4, 0x00, 0x18, 0x63,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x01,
  0x0C, 0x30, 0x00, 0xC4, 0x04, 0x00, 0x63, 0x01, 0x00, 0x10, 0x80, 0x60,
  0x08, 0x20, 0x18, 0x06, 0x08, 0x06, 0x03, 0x06, 0x01, 0x00, 0x81, 0x80,
  0x40, 0x40, 0x20, 0x30, 0x30, 0x08, 0x08, 0x18, 0x01, 0x0C, 0x0C, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x01, 0x83, 0x00, 0x04, 0x03, 0x00, 0x18,
  0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00,
  0x20, 0x03, 0x00, 0x40, 0x02, 0x01, 0x80, 0x06, 0x02, 0x00, 0x04, 0x08,
  0x00, 0x1C, 0x20, 0x01, 0xCB, 0x80, 0x04, 0x08, 0x00, 0x10, 0x18, 0x00,
  0x60, 0x10, 0x00, 0x80, 0x30, 0x01, 0x00, 0x30, 0x06, 0x00, 0x20, 0x0C,
  0x00, 0x60, 0x18, 0x00, 0xC0, 0xD0, 0x02, 0x41, 0x20, 0x04, 0xC4, 0x60,
  0x10, 0x98, 0x60, 0x41, 0xA0, 0x3F, 0x01, 0x80, 0x32, 0x22, 0x66, 0x44,
  0x4C, 0x00, 0x38, 0x03, 0x00, 0x20, 0x02, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x01, 0x00, 0x18, 0x00, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01,
  0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00,
  0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00,
  0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40,
  0x08, 0x00, 0x80, 0x10, 0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x10, 0x06,
  0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x06, 0x02, 0x07, 0x9C,
  0x23, 0xC0, 0x7F, 0xE0, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xB0, 0x00,
  0x31, 0x00, 0x06, 0x08, 0x00, 0xC0, 0xC0, 0x18, 0x04, 0x01, 0x00, 0x60,
  0x20, 0x02, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x3F,
  0xFF, 0xF0, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x61,
  0x8C, 0x30, 0x86, 0x10, 0x42, 0x00, 0xFF, 0xC0, 0xFF, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x60, 0x60, 0x18,
  0x06, 0x06, 0x00, 0x61, 0x80, 0x04, 0x20, 0x00, 0x8C, 0x00, 0x19, 0x00,
  0x03, 0x60, 0x00, 0x6C, 0x00, 0x0D, 0x00, 0x01, 0xA0, 0x00, 0x3C, 0x0E,
  0x05, 0x81, 0xC0, 0xB0, 0x30, 0x14, 0x00, 0x06, 0x80, 0x00, 0xD0, 0x00,
  0x12, 0x00, 0x02, 0x40, 0x00, 0xC8, 0x00, 0x11, 0x80, 0x06, 0x30, 0x00,
  0x82, 0x00, 0x20, 0x60, 0x0C, 0x06, 0x06, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x0C, 0xC0, 0x06, 0x30, 0x03, 0x08, 0x03, 0x82,
  0x01, 0x80, 0x80, 0x40, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x0F, 0xFF, 0xFC,
  0x00, 0xFE, 0x00, 0x70, 0x30, 0x18, 0x03, 0x06, 0x00, 0x20, 0x80, 0x06,
  0x30, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x60, 0x70, 0x18, 0x03,
  0x06, 0x00, 0x20, 0x80, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x3F, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x20, 0x00, 0x46,
  0x00, 0x18, 0x60, 0x06, 0x06, 0x03, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x34, 0x00, 0x06, 0x40, 0x00,
  0xC4, 0x00, 0x08, 0x40, 0x01, 0x0C, 0x00, 0x20, 0xC0, 0x06, 0x08, 0x00,
  0xC0, 0x80, 0x18, 0x08, 0x03, 0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x80,
  0xC0, 0x10, 0x18, 0x01, 0x03, 0x00, 0x10, 0x60, 0x01, 0x0C, 0x00, 0x30,
  0xFF, 0xFF, 0xF0, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xF0, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x9F, 0xC0,
  0x12, 0x07, 0x01, 0xC0, 0x18, 0x10, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x80, 0x01, 0x8C, 0x00, 0x30, 0x60, 0x06, 0x03, 0x81, 0xC0, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x06, 0x3F, 0x06, 0x60, 0xE3, 0xC0, 0x19, 0x80, 0x05, 0xC0, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0B, 0x00, 0x0C, 0x80, 0x04, 0x60, 0x0C, 0x1C, 0x1C, 0x03, 0xF8, 0x00,
  0x3F, 0xFF, 0xEC, 0x00, 0x0D, 0x80, 0x03, 0x20, 0x00, 0x44, 0x00, 0x18,
  0x80, 0x02, 0x10, 0x00, 0xC4, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x18, 0x1C, 0x06, 0x00,
  0x60, 0xC0, 0x02, 0x08, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x31, 0x80,
  0x02, 0x18, 0x00, 0x20, 0x80, 0x04, 0x0C, 0x00, 0xC0, 0x70, 0x30, 0x01,
  0xFC, 0x00, 0xE0, 0x70, 0x18, 0x01, 0x83, 0x00, 0x0C, 0x60, 0x00, 0x44,
  0x00, 0x04, 0xC0, 0x00, 0x4C, 0x00, 0x04, 0xC0, 0x00, 0x4C, 0x00, 0x0C,
  0xC0, 0x00, 0x84, 0x00, 0x18, 0x20, 0x03, 0x01, 0x80, 0xC0, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x07, 0x03, 0x06, 0x00, 0xC6, 0x00, 0x26, 0x00, 0x1A,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x74, 0x00, 0x33, 0x00, 0x68, 0xE0, 0x6C, 0x1F, 0xC4, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0xF1, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x8E, 0x30, 0x03, 0x83, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x06, 0x06,
  0x03, 0x01, 0x01, 0x80, 0x80, 0x40, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x02, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x10, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x04, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x00, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x30, 0x30, 0xC0, 0x13, 0x00, 0x3C,
  0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0xFC, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0xE0, 0xC0,
  0x60, 0x08, 0x10, 0x03, 0x08, 0x00, 0x46, 0x00, 0x11, 0x00, 0x04, 0x40,
  0x01, 0x30, 0x3C, 0x48, 0x30, 0xD2, 0x08, 0x0D, 0x84, 0x03, 0x61, 0x00,
  0x90, 0xC0, 0x24, 0x20, 0x09, 0x08, 0x02, 0xC2, 0x01, 0xB0, 0x80, 0x6C,
  0x20, 0x12, 0x08, 0x04, 0x82, 0x03, 0x20, 0xC1, 0x48, 0x19, 0xB2, 0x03,
  0xC0, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x0E, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0D,
  0x00, 0x00, 0x90, 0x00, 0x19, 0x00, 0x01, 0x10, 0x00, 0x31, 0x80, 0x02,
  0x18, 0x00, 0x60, 0x80, 0x04, 0x08, 0x00, 0xC0, 0x80, 0x08, 0x08, 0x01,
  0x80, 0xC0, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x04, 0x06, 0x00, 0x40,
  0x7F, 0xFC, 0x0C, 0x00, 0x60, 0x80, 0x06, 0x18, 0x00, 0x61, 0x00, 0x02,
  0x30, 0x00, 0x22, 0x00, 0x02, 0x60, 0x00, 0x24, 0x00, 0x03, 0xC0, 0x00,
  0x30, 0x07, 0xFF, 0x01, 0x80, 0x30, 0x30, 0x01, 0x06, 0x00, 0x30, 0x80,
  0x06, 0x10, 0x00, 0x42, 0x00, 0x08, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00,
  0x08, 0x40, 0x03, 0x08, 0x00, 0x41, 0x00, 0x30, 0x7F, 0xF8, 0x0C, 0x00,
  0xC1, 0x80, 0x04, 0x20, 0x00, 0xC4, 0x00, 0x08, 0x80, 0x01, 0x30, 0x00,
  0x26, 0x00, 0x0C, 0xC0, 0x01, 0x90, 0x00, 0x22, 0x00, 0x0C, 0x40, 0x03,
  0x18, 0x00, 0xC3, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x30, 0x70, 0x08,
  0x03, 0x02, 0x00, 0x20, 0x80, 0x06, 0x30, 0x00, 0x44, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x10, 0x80, 0x03, 0x10, 0x00,
  0xC3, 0x00, 0x30, 0x30, 0x0C, 0x03, 0x03, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x40, 0x30, 0x04, 0x00, 0xC0, 0xC0, 0x04, 0x0C, 0x00, 0x60,
  0x80, 0x02, 0x08, 0x00, 0x20, 0x80, 0x03, 0x08, 0x00, 0x31, 0x80, 0x03,
  0x18, 0x00, 0x31, 0x00, 0x03, 0x10, 0x00, 0x21, 0x00, 0x02, 0x10, 0x00,
  0x23, 0x00, 0x02, 0x30, 0x00, 0x62, 0x00, 0x06, 0x20, 0x00, 0x42, 0x00,
  0x0C, 0x20, 0x00, 0x86, 0x00, 0x08, 0x60, 0x01, 0x04, 0x00, 0x30, 0x40,
  0x06, 0x04, 0x01, 0x80, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x30, 0x70, 0x18, 0x03,
  0x06, 0x00, 0x20, 0x80, 0x06, 0x20, 0x00, 0x44, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x03, 0xFE, 0xC0, 0x00, 0x98, 0x00, 0x13,
  0x00, 0x02, 0x60, 0x00, 0xCC, 0x00, 0x18, 0x80, 0x02, 0x10, 0x00, 0xC3,
  0x00, 0x28, 0x20, 0x0B, 0x03, 0x02, 0x60, 0x1F, 0x8C, 0x00, 0x0C, 0x00,
  0x18, 0x60, 0x00, 0x83, 0x00, 0x04, 0x10, 0x00, 0x20, 0x80, 0x03, 0x04,
  0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x04, 0x18, 0x00, 0x20, 0x80, 0x01,
  0x04, 0x00, 0x18, 0x20, 0x00, 0xC3, 0x00, 0x06, 0x1F, 0xFF, 0xE0, 0xC0,
  0x01, 0x04, 0x00, 0x08, 0x20, 0x00, 0xC1, 0x00, 0x06, 0x18, 0x00, 0x30,
  0xC0, 0x01, 0x06, 0x00, 0x08, 0x20, 0x00, 0x41, 0x00, 0x06, 0x08, 0x00,
  0x30, 0xC0, 0x01, 0x86, 0x00, 0x08, 0x20, 0x00, 0x40, 0x0F, 0xFF, 0xF8,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x08, 0x00, 0xC3,
  0x00, 0x20, 0xC0, 0x10, 0x1C, 0x18, 0x01, 0xF8, 0x00, 0x04, 0x00, 0x0C,
  0x10, 0x00, 0x60, 0xC0, 0x03, 0x03, 0x00, 0x18, 0x0C, 0x00, 0xC0, 0x20,
  0x06, 0x00, 0x80, 0x20, 0x02, 0x01, 0x00, 0x18, 0x18, 0x00, 0x60, 0xC0,
  0x01, 0x86, 0x00, 0x04, 0x30, 0x00, 0x11, 0xE0, 0x00, 0x4C, 0x80, 0x03,
  0x63, 0x00, 0x0F, 0x04, 0x00, 0x38, 0x18, 0x00, 0xC0, 0x20, 0x02, 0x00,
  0xC0, 0x08, 0x01, 0x00, 0x60, 0x06, 0x01, 0x80, 0x08, 0x06, 0x00, 0x30,
  0x10, 0x00, 0x40, 0x40, 0x01, 0x81, 0x00, 0x02, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00,
  0x03, 0xFF, 0xF8, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x70, 0x70, 0x01, 0xC3,
  0x40, 0x0B, 0x0D, 0x00, 0x68, 0x24, 0x01, 0x20, 0x98, 0x0C, 0x82, 0x20,
  0x22, 0x08, 0x81, 0x18, 0x62, 0x0C, 0x61, 0x84, 0x21, 0x04, 0x11, 0x04,
  0x10, 0x4C, 0x10, 0x41, 0xA0, 0xC1, 0x03, 0x83, 0x0C, 0x0C, 0x0C, 0x30,
  0x20, 0x20, 0x80, 0x80, 0x82, 0x00, 0x02, 0x08, 0x00, 0x18, 0x20, 0x00,
  0x61, 0x80, 0x01, 0x86, 0x00, 0x04, 0x10, 0x00, 0x10, 0x40, 0x00, 0x41,
  0x00, 0x03, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x18, 0x70, 0x00, 0x82,
  0x80, 0x04, 0x16, 0x00, 0x20, 0x90, 0x03, 0x04, 0x80, 0x18, 0x66, 0x00,
  0xC3, 0x10, 0x04, 0x10, 0x80, 0x20, 0x86, 0x01, 0x04, 0x10, 0x18, 0x20,
  0x80, 0xC3, 0x06, 0x06, 0x18, 0x10, 0x20, 0x80, 0x81, 0x04, 0x06, 0x08,
  0x20, 0x10, 0xC1, 0x00, 0x86, 0x18, 0x06, 0x30, 0xC0, 0x11, 0x04, 0x00,
  0x88, 0x20, 0x06, 0x41, 0x00, 0x36, 0x08, 0x00, 0xB0, 0xC0, 0x07, 0x86,
  0x00, 0x38, 0x20, 0x00, 0xC0, 0x00, 0xFC, 0x00, 0x60, 0x60, 0x18, 0x06,
  0x06, 0x00, 0x61, 0x80, 0x04, 0x20, 0x00, 0x8C, 0x00, 0x19, 0x00, 0x03,
  0x60, 0x00, 0x6C, 0x00, 0x0D, 0x00, 0x01, 0xA0, 0x00, 0x3C, 0x00, 0x05,
  0x80, 0x00, 0xB0, 0x00, 0x14, 0x00, 0x06, 0x80, 0x00, 0xD0, 0x00, 0x12,
  0x00, 0x02, 0x40, 0x00, 0xC8, 0x00, 0x11, 0x80, 0x06, 0x30, 0x00, 0x82,
  0x00, 0x20, 0x60, 0x0C, 0x06, 0x06, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x40, 0x0E, 0x0C, 0x00, 0x20, 0xC0, 0x03, 0x0C, 0x00, 0x10, 0x80,
  0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x18, 0x00, 0x11, 0x80, 0x03, 0x18,
  0x00, 0x31, 0x00, 0x02, 0x10, 0x00, 0x41, 0x00, 0x18, 0x3F, 0xFE, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x60, 0x60, 0x18,
  0x06, 0x06, 0x00, 0x61, 0x80, 0x04, 0x20, 0x00, 0x8C, 0x00, 0x19, 0x00,
  0x03, 0x60, 0x00, 0x6C, 0x00, 0x0D, 0x00, 0x01, 0xA0, 0x00, 0x3C, 0x00,
  0x05, 0x80, 0x00, 0xB0, 0x00, 0x14, 0x00, 0x06, 0x80, 0x00, 0xD0, 0x00,
  0x12, 0x00, 0x02, 0x40, 0x00, 0xC8, 0x00, 0x11, 0x80, 0x06, 0x30, 0x00,
  0x82, 0x00, 0x20, 0x60, 0x0C, 0x06, 0x06, 0x00, 0x3F, 0x00, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x01, 0x81, 0x00, 0x10, 0x40, 0x03, 0x10, 0x00, 0x24,
  0x00, 0x03, 0x00, 0x07, 0xFF, 0x80, 0x40, 0x0E, 0x0C, 0x00, 0x20, 0xC0,
  0x03, 0x0C, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x18,
  0x00, 0x11, 0x80, 0x03, 0x18, 0x00, 0x31, 0x00, 0x02, 0x10, 0x00, 0x41,
  0x00, 0x18, 0x3F, 0xFE, 0x03, 0x02, 0x00, 0x30, 0x30, 0x02, 0x01, 0x00,
  0x20, 0x18, 0x02, 0x00, 0x80, 0x60, 0x0C, 0x06, 0x00, 0x40, 0x60, 0x06,
  0x04, 0x00, 0x20, 0x40, 0x03, 0x04, 0x00, 0x10, 0xC0, 0x01, 0x80, 0x00,
  0x7F, 0x80, 0x0C, 0x07, 0x01, 0x80, 0x0C, 0x08, 0x00, 0x30, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x31, 0x00, 0x01, 0x1C,
  0x00, 0x18, 0x30, 0x01, 0x80, 0xE0, 0x38, 0x01, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x31,
  0x80, 0x02, 0x18, 0x00, 0x21, 0x00, 0x02, 0x10, 0x00, 0x61, 0x00, 0x06,
  0x30, 0x00, 0x43, 0x00, 0x04, 0x30, 0x00, 0x42, 0x00, 0x04, 0x20, 0x00,
  0xC2, 0x00, 0x0C, 0x60, 0x00, 0x86, 0x00, 0x08, 0x40, 0x00, 0x84, 0x00,
  0x08, 0x40, 0x01, 0x84, 0x00, 0x18, 0xC0, 0x01, 0x0C, 0x00, 0x10, 0xC0,
  0x03, 0x0C, 0x00, 0x30, 0xC0, 0x02, 0x04, 0x00, 0x60, 0x60, 0x0C, 0x03,
  0x01, 0x80, 0x0F, 0xE0, 0x00, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01,
  0x60, 0x00, 0x64, 0x00, 0x08, 0x80, 0x03, 0x10, 0x00, 0x42, 0x00, 0x18,
  0x60, 0x02, 0x0C, 0x00, 0xC1, 0x80, 0x10, 0x10, 0x06, 0x02, 0x00, 0x80,
  0x40, 0x30, 0x08, 0x04, 0x01, 0x81, 0x80, 0x30, 0x20, 0x02, 0x0C, 0x00,
  0x41, 0x00, 0x08, 0x60, 0x01, 0x08, 0x00, 0x33, 0x00, 0x06, 0x40, 0x00,
  0xD8, 0x00, 0x0A, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00,
  0x09, 0x00, 0x00, 0xC8, 0x00, 0x06, 0x40, 0x00, 0x22, 0x00, 0x01, 0x30,
  0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x04, 0x60, 0x60, 0x22, 0x03, 0x03,
  0x10, 0x28, 0x10, 0x81, 0x40, 0x84, 0x1B, 0x04, 0x20, 0x98, 0x61, 0x0C,
  0x42, 0x08, 0x42, 0x10, 0x46, 0x10, 0x82, 0x20, 0x8C, 0x31, 0x04, 0x41,
  0x90, 0x22, 0x0C, 0x81, 0x10, 0x6C, 0x0D, 0x83, 0x40, 0x68, 0x16, 0x03,
  0x40, 0xA0, 0x0E, 0x07, 0x00, 0x70, 0x30, 0x03, 0x00, 0x06, 0x00, 0x03,
  0x02, 0x00, 0x06, 0x03, 0x00, 0x0C, 0x01, 0x00, 0x08, 0x01, 0x80, 0x18,
  0x00, 0x80, 0x30, 0x00, 0xC0, 0x60, 0x00, 0x40, 0xC0, 0x00, 0x60, 0x80,
  0x00, 0x21, 0x00, 0x00, 0x33, 0x00, 0x00, 0x16, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x24, 0x00, 0x00, 0x66, 0x00,
  0x00, 0xC2, 0x00, 0x01, 0x83, 0x00, 0x03, 0x01, 0x00, 0x06, 0x01, 0x80,
  0x04, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x18, 0x00, 0x40, 0x30, 0x00, 0x60,
  0x60, 0x00, 0x20, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x1A, 0x00, 0x01, 0x98,
  0x00, 0x08, 0xC0, 0x00, 0x82, 0x00, 0x0C, 0x18, 0x00, 0xC0, 0x40, 0x0C,
  0x03, 0x00, 0xC0, 0x08, 0x04, 0x00, 0x60, 0x40, 0x01, 0x06, 0x00, 0x0C,
  0x60, 0x00, 0x26, 0x00, 0x01, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xFF, 0xC0,
  0x80, 0x40, 0x20, 0x18, 0x04, 0x02, 0x01, 0x00, 0x80, 0x20, 0x10, 0x08,
  0x04, 0x01, 0x00, 0x80, 0x40, 0x20, 0x18, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x20, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x20, 0x18, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x20, 0x03, 0xFF, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0xFF, 0xC0, 0x00, 0x38, 0x00, 0x0A, 0x00, 0x04, 0x80, 0x03, 0x30, 0x01,
  0x84, 0x00, 0x41, 0x80, 0x20, 0x20, 0x18, 0x0C, 0x0C, 0x01, 0x02, 0x00,
  0x41, 0x00, 0x18, 0xC0, 0x02, 0x60, 0x00, 0xD0, 0x00, 0x18, 0x00, 0x04,
  0xFF, 0xFF, 0xE0, 0x46, 0x18, 0x43, 0x08, 0x60, 0x03, 0xF0, 0x87, 0x06,
  0x46, 0x00, 0xA6, 0x00, 0x52, 0x00, 0x1B, 0x00, 0x0D, 0x00, 0x05, 0x80,
  0x02, 0xC0, 0x01, 0x40, 0x00, 0xA0, 0x00, 0xD0, 0x00, 0x68, 0x00, 0x24,
  0x00, 0x12, 0x00, 0x19, 0x00, 0x0C, 0xC0, 0x0E, 0x30, 0x0B, 0x0C, 0x19,
  0x03, 0xF0, 0xF0, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x3F, 0x01, 0x10, 0x70, 0x58, 0x04, 0x14, 0x00, 0x8E, 0x00, 0x23, 0x00,
  0x0C, 0xC0, 0x03, 0x20, 0x00, 0xC8, 0x00, 0x32, 0x00, 0x0D, 0x80, 0x03,
  0x60, 0x00, 0x90, 0x00, 0x24, 0x00, 0x19, 0x00, 0x04, 0x40, 0x03, 0x38,
  0x00, 0x8D, 0x00, 0xC2, 0x60, 0x60, 0x87, 0xE0, 0x00, 0x01, 0xF8, 0x03,
  0x03, 0x02, 0x00, 0xC2, 0x00, 0x22, 0x00, 0x1B, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x0C, 0x80, 0x04, 0x60, 0x04, 0x10, 0x04, 0x06,
  0x0C, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x7E, 0x10, 0x38, 0x32, 0x0C, 0x01, 0x43, 0x00, 0x28, 0x40,
  0x03, 0x18, 0x00, 0x62, 0x00, 0x08, 0xC0, 0x01, 0x18, 0x00, 0x22, 0x00,
  0x04, 0x40, 0x01, 0x88, 0x00, 0x31, 0x00, 0x04, 0x20, 0x00, 0x84, 0x00,
  0x30, 0x80, 0x06, 0x18, 0x01, 0xC1, 0x80, 0x58, 0x18, 0x32, 0x01, 0xF8,
  0x40, 0x01, 0xFC, 0x03, 0x83, 0x83, 0x00, 0x42, 0x00, 0x33, 0x00, 0x09,
  0x00, 0x0D, 0x00, 0x06, 0x80, 0x06, 0x40, 0x0E, 0x60, 0x7C, 0x3F, 0xC0,
  0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x04, 0x80, 0x06, 0x60,
  0x06, 0x10, 0x06, 0x06, 0x0E, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x80,
  0x60, 0x00, 0xC0, 0x40, 0x00, 0x60, 0x40, 0x00, 0x10, 0x40, 0x00, 0x08,
  0x40, 0x00, 0x04, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xF8, 0x60, 0xE0, 0xC8, 0x30, 0x05, 0x0C, 0x00, 0xA1, 0x00, 0x0C, 0x40,
  0x01, 0x88, 0x00, 0x23, 0x00, 0x04, 0x40, 0x00, 0x88, 0x00, 0x11, 0x00,
  0x06, 0x20, 0x00, 0xC4, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00, 0xC2, 0x00,
  0x28, 0x60, 0x07, 0x06, 0x01, 0x60, 0x60, 0xC8, 0x07, 0xE1, 0x00, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x18, 0x03,
  0x01, 0x81, 0xC0, 0x0F, 0xE0, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x0C, 0x7E, 0x06, 0x41, 0x83, 0x40, 0x61, 0x40, 0x10, 0xC0, 0x0C,
  0x40, 0x06, 0x60, 0x03, 0x30, 0x01, 0x10, 0x00, 0x88, 0x00, 0x44, 0x00,
  0x22, 0x00, 0x33, 0x00, 0x19, 0x80, 0x08, 0x80, 0x04, 0x40, 0x02, 0x20,
  0x01, 0x10, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x40, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x20, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x04, 0x08, 0x0C, 0x04, 0x0C, 0x06,
  0x08, 0x03, 0x18, 0x01, 0x90, 0x00, 0xB0, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x80, 0x20, 0x40, 0x60,
  0x20, 0x60, 0x10, 0x40, 0x08, 0x40, 0x06, 0x40, 0x03, 0x40, 0x01, 0x80,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x0F, 0x80,
  0x46, 0x0C, 0x09, 0x00, 0x81, 0x40, 0x18, 0x70, 0x03, 0x0C, 0x00, 0x61,
  0x80, 0x08, 0x20, 0x03, 0x04, 0x00, 0xC0, 0x80, 0x60, 0x30, 0x70, 0x06,
  0x30, 0x00, 0xC2, 0x00, 0x10, 0x60, 0x0A, 0x04, 0x03, 0x40, 0xC0, 0xD8,
  0x08, 0x23, 0x00, 0x88, 0x60, 0x1A, 0x08, 0x01, 0x80, 0xFF, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x86, 0x03, 0x8C, 0x18, 0x10, 0x60, 0x21, 0x00, 0x4C, 0x01,
  0xA0, 0x01, 0x80, 0x00, 0x09, 0xE0, 0xF0, 0xD0, 0x98, 0xC7, 0x05, 0x02,
  0x30, 0x30, 0x11, 0x81, 0x80, 0x88, 0x0C, 0x04, 0x40, 0x40, 0x66, 0x02,
  0x03, 0x30, 0x10, 0x11, 0x00, 0x80, 0x88, 0x0C, 0x04, 0x40, 0x60, 0x22,
  0x02, 0x03, 0x30, 0x10, 0x19, 0x80, 0x80, 0x88, 0x0C, 0x04, 0x40, 0x60,
  0x22, 0x02, 0x01, 0x10, 0x10, 0x19, 0x80, 0x80, 0xC0, 0x18, 0xFC, 0x0C,
  0x83, 0x04, 0x80, 0xC2, 0x80, 0x21, 0x80, 0x18, 0x80, 0x0C, 0xC0, 0x06,
  0x60, 0x02, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0x44, 0x00, 0x66, 0x00,
  0x33, 0x00, 0x11, 0x00, 0x08, 0x80, 0x04, 0x40, 0x02, 0x20, 0x03, 0x30,
  0x01, 0x98, 0x00, 0x80, 0x01, 0xF8, 0x03, 0x03, 0x02, 0x00, 0xC2, 0x00,
  0x22, 0x00, 0x0B, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0B, 0x00, 0x0D,
  0x80, 0x04, 0x40, 0x06, 0x10, 0x06, 0x06, 0x0E, 0x01, 0xF8, 0x00, 0x0C,
  0x7E, 0x01, 0x10, 0x70, 0x2C, 0x02, 0x05, 0x00, 0x21, 0xC0, 0x04, 0x30,
  0x00, 0xC6, 0x00, 0x18, 0x80, 0x03, 0x10, 0x00, 0x62, 0x00, 0x0C, 0xC0,
  0x01, 0x98, 0x00, 0x22, 0x00, 0x04, 0x40, 0x01, 0x88, 0x00, 0x21, 0x00,
  0x0C, 0x70, 0x01, 0x0D, 0x00, 0xC1, 0x30, 0x30, 0x21, 0xF8, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0xF0, 0xC3, 0x83, 0x21, 0x80,
  0x28, 0xC0, 0x0A, 0x20, 0x01, 0x98, 0x00, 0x64, 0x00, 0x13, 0x00, 0x04,
  0xC0, 0x01, 0x20, 0x00, 0x48, 0x00, 0x32, 0x00, 0x0C, 0x80, 0x02, 0x20,
  0x00, 0x88, 0x00, 0x62, 0x00, 0x28, 0xC0, 0x0E, 0x18, 0x05, 0x83, 0x06,
  0x40, 0x7E, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0xFF, 0x1F, 0xC0,
  0x98, 0x00, 0x28, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x01, 0xFE, 0x00, 0xE0, 0x70, 0x30,
  0x03, 0x0C, 0x00, 0x31, 0x80, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0xC0, 0x01, 0x8C, 0x00,
  0x60, 0x60, 0x38, 0x03, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x07, 0xFF,
  0xFF, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x18, 0x08, 0x0C, 0x01, 0x02,
  0x00, 0x21, 0x80, 0x0C, 0xC0, 0x01, 0xB0, 0x00, 0x38, 0x00, 0x00, 0x20,
  0x01, 0x20, 0x01, 0x20, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x02, 0x40,
  0x02, 0x40, 0x02, 0x40, 0x06, 0xC0, 0x06, 0xC0, 0x04, 0xC0, 0x04, 0x80,
  0x04, 0x80, 0x0C, 0x80, 0x0C, 0x80, 0x1C, 0x80, 0x28, 0xC0, 0x28, 0x60,
  0xC8, 0x3F, 0x08, 0xFC, 0x00, 0x81, 0x00, 0x20, 0x40, 0x0C, 0x10, 0x03,
  0x0C, 0x00, 0xC3, 0x00, 0x30, 0x80, 0x0C, 0x20, 0x03, 0x08, 0x00, 0x82,
  0x00, 0x20, 0x80, 0x18, 0x60, 0x04, 0x18, 0x03, 0x04, 0x00, 0x81, 0x00,
  0x60, 0x40, 0x30, 0x10, 0x18, 0x04, 0x18, 0x03, 0x1C, 0x00, 0x78, 0x00,
  0x20, 0x30, 0x44, 0x04, 0x08, 0x80, 0x81, 0x90, 0x10, 0x16, 0x02, 0x02,
  0xC0, 0xC0, 0x50, 0x18, 0x0A, 0x02, 0x01, 0x40, 0x40, 0x28, 0x08, 0x07,
  0x01, 0x00, 0xE0, 0x60, 0x38, 0x0C, 0x05, 0x01, 0x00, 0xA0, 0x20, 0x34,
  0x0C, 0x04, 0x82, 0x81, 0x90, 0x50, 0x23, 0x11, 0x08, 0x3C, 0x1E, 0x00,
  0x01, 0xC0, 0xF0, 0x19, 0x0C, 0x61, 0x86, 0x20, 0xD8, 0x09, 0x03, 0x00,
  0x28, 0x0C, 0x00, 0xA0, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x02,
  0x01, 0x80, 0x08, 0x06, 0x00, 0x20, 0x2C, 0x04, 0x80, 0x90, 0x3A, 0x04,
  0x43, 0x0C, 0x21, 0xB8, 0x1F, 0x03, 0x80, 0x04, 0x00, 0x20, 0x80, 0x04,
  0x10, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0x82, 0x00, 0x10,
  0x40, 0x02, 0x08, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x02, 0x0C, 0x00, 0x41,
  0x00, 0x08, 0x20, 0x03, 0x04, 0x00, 0x60, 0x80, 0x1C, 0x10, 0x05, 0x03,
  0x00, 0xA0, 0x30, 0x64, 0x03, 0xF0, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x08, 0x01, 0x83, 0xC0, 0xC0, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x21, 0x03, 0xC4, 0x40, 0x0F, 0x88, 0x00, 0x63,
  0x00, 0x18, 0x40, 0x06, 0x08, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x10, 0x18, 0x02, 0x06,
  0x00, 0x61, 0x80, 0x04, 0x70, 0x00, 0x9F, 0xF0, 0x13, 0x0F, 0xE2, 0x40,
  0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x01, 0x80, 0x7F, 0x00, 0x01, 0xC0, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x07, 0xFC, 0x00, 0x03, 0x02, 0x02, 0x02, 0x02, 0x06, 0x06,
  0x04, 0x04, 0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x18, 0x18,
  0x10, 0x10, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0x20, 0x20, 0x60, 0x60,
  0x40, 0x40, 0x40, 0xC0, 0x03, 0xFC, 0x02, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x3F, 0xC0, 0x00, 0x0F, 0x00, 0x11, 0x18, 0x03,
  0x20, 0x40, 0x26, 0x06, 0x06, 0x40, 0x20, 0x4C, 0x01, 0x08, 0x80, 0x0F,
  0x00,
};

const GFXglyph IBMPlexMono_ExtraLightItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 6, 27, 23, 9, -27 },
  { 22, 8, 10, 23, 10, -29 },
  { 32, 23, 27, 23, 1, -27 },
  { 110, 21, 35, 23, 1, -31 },
  { 202, 26, 27, 23, -1, -27 },
  { 290, 23, 27, 23, 0, -27 },
  { 368, 4, 10, 23, 12, -29 },
  { 373, 13, 35, 23, 9, -30 },
  { 430, 12, 35, 23, 3, -30 },
  { 483, 20, 19, 23, 2, -21 },
  { 531, 18, 19, 23, 3, -21 },
  { 574, 6, 10, 23, 6, -4 },
  { 582, 10, 1, 23, 7, -12 },
  { 584, 3, 3, 23, 9, -3 },
  { 586, 21, 35, 23, 1, -30 },
  { 678, 19, 27, 23, 3, -27 },
  { 743, 18, 27, 23, 2, -27 },
  { 804, 19, 27, 23, 2, -27 },
  { 869, 19, 27, 23, 2, -27 },
  { 934, 20, 27, 23, 1, -27 },
  { 1002, 20, 27, 23, 2, -27 },
  { 1070, 17, 27, 23, 3, -27 },
  { 1128, 19, 27, 23, 4, -27 },
  { 1193, 20, 27, 23, 2, -27 },
  { 1261, 17, 27, 23, 4, -27 },
  { 1319, 6, 20, 23, 9, -20 },
  { 1334, 9, 26, 23, 6, -20 },
  { 1364, 18, 21, 23, 4, -22 },
  { 1412, 20, 8, 23, 2, -16 },
  { 1432, 18, 21, 23, 2, -22 },
  { 1480, 15, 27, 23, 6, -27 },
  { 1531, 18, 31, 23, 3, -27 },
  { 1601, 20, 27, 23, 0, -27 },
  { 1669, 19, 27, 23, 2, -27 },
  { 1734, 19, 27, 23, 3, -27 },
  { 1799, 20, 27, 23, 2, -27 },
  { 1867, 21, 27, 23, 2, -27 },
  { 1938, 21, 27, 23, 2, -27 },
  { 2009, 19, 27, 23, 3, -27 },
  { 2074, 21, 27, 23, 2, -27 },
  { 2145, 21, 27, 23, 2, -27 },
  { 2216, 18, 27, 23, 3, -27 },
  { 2277, 22, 27, 23, 2, -27 },
  { 2352, 15, 27, 23, 4, -27 },
  { 2403, 22, 27, 23, 1, -27 },
  { 2478, 21, 27, 23, 2, -27 },
  { 2549, 19, 27, 23, 3, -27 },
  { 2614, 20, 27, 23, 2, -27 },
  { 2682, 19, 34, 23, 3, -27 },
  { 2763, 20, 27, 23, 2, -27 },
  { 2831, 21, 27, 23, 1, -27 },
  { 2902, 21, 27, 23, 4, -27 },
  { 2973, 20, 27, 23, 3, -27 },
  { 3041, 19, 27, 23, 5, -27 },
  { 3106, 21, 27, 23, 3, -27 },
  { 3177, 24, 27, 23, 0, -27 },
  { 3258, 21, 27, 23, 4, -27 },
  { 3329, 24, 27, 23, 0, -27 },
  { 3410, 16, 35, 23, 7, -30 },
  { 3480, 9, 35, 23, 8, -30 },
  { 3520, 16, 35, 23, 1, -30 },
  { 3590, 18, 15, 23, 3, -27 },
  { 3624, 19, 1, 23, 0, 5 },
  { 3627, 5, 7, 23, 9, -30 },
  { 3632, 17, 20, 23, 3, -20 },
  { 3675, 18, 29, 23, 3, -29 },
  { 3741, 17, 20, 23, 3, -20 },
  { 3784, 19, 29, 23, 3, -29 },
  { 3853, 17, 20, 23, 3, -20 },
  { 3896, 24, 37, 23, 0, -29 },
  { 4007, 19, 28, 23, 2, -20 },
  { 4074, 17, 29, 23, 3, -29 },
  { 4136, 17, 29, 23, 3, -29 },
  { 4198, 16, 37, 23, 4, -29 },
  { 4272, 19, 29, 23, 3, -29 },
  { 4341, 15, 29, 23, 5, -29 },
  { 4396, 21, 20, 23, 1, -20 },
  { 4449, 17, 20, 23, 3, -20 },
  { 4492, 17, 20, 23, 3, -20 },
  { 4535, 19, 28, 23, 2, -20 },
  { 4602, 18, 28, 23, 3, -20 },
  { 4665, 18, 20, 23, 5, -20 },
  { 4710, 19, 20, 23, 2, -20 },
  { 4758, 19, 27, 23, 3, -27 },
  { 4823, 16, 20, 23, 4, -20 },
  { 4863, 18, 20, 23, 3, -20 },
  { 4908, 19, 20, 23, 3, -20 },
  { 4956, 22, 20, 23, 1, -20 },
  { 5011, 19, 28, 23, 1, -20 },
  { 5078, 19, 20, 23, 2, -20 },
  { 5126, 17, 35, 23, 5, -30 },
  { 5201, 8, 35, 23, 8, -30 },
  { 5236, 17, 35, 23, 2, -30 },
  { 5311, 20, 7, 23, 2, -15 },
};

const GFXfont IBMPlexMono_ExtraLightItalic39pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic39pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic39pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC39PT7B_H_
