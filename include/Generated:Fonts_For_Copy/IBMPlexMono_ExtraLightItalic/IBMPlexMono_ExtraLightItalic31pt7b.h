#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC31PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x42, 0x31, 0x08, 0x42, 0x11, 0x88, 0x42, 0x10, 0x88, 0x00,
  0x00, 0x0C, 0x60, 0x46, 0x89, 0x16, 0x28, 0x50, 0xA2, 0x44, 0x00, 0x41,
  0x00, 0x10, 0x80, 0x08, 0x20, 0x02, 0x18, 0x00, 0x84, 0x00, 0x41, 0x00,
  0x10, 0x80, 0xFC, 0x3F, 0x02, 0x08, 0x00, 0x84, 0x00, 0x21, 0x00, 0x10,
  0x40, 0x04, 0x30, 0x01, 0x08, 0x0F, 0x83, 0xF0, 0x21, 0x80, 0x08, 0x40,
  0x04, 0x10, 0x01, 0x0C, 0x00, 0x42, 0x00, 0x20, 0x80, 0x08, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x3F, 0x00, 0x62, 0x60, 0x41,
  0x08, 0x41, 0x06, 0x20, 0x80, 0x10, 0x40, 0x08, 0x20, 0x04, 0x10, 0x03,
  0x08, 0x00, 0xC8, 0x00, 0x1E, 0x00, 0x02, 0xE0, 0x01, 0x18, 0x00, 0x86,
  0x00, 0x81, 0x00, 0x40, 0x80, 0x20, 0x40, 0x10, 0x64, 0x08, 0x21, 0x04,
  0x30, 0x64, 0x70, 0x0F, 0xE0, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x03, 0xC0, 0x08, 0x21, 0x80, 0x82, 0x04, 0x08, 0x10, 0x20, 0x81, 0x81,
  0x04, 0x08, 0x08, 0x40, 0x40, 0x44, 0x02, 0x04, 0x40, 0x08, 0x62, 0x00,
  0x3C, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x88,
  0x60, 0x08, 0x81, 0x00, 0x84, 0x08, 0x04, 0x60, 0x40, 0x42, 0x02, 0x04,
  0x10, 0x10, 0x40, 0x81, 0x02, 0x02, 0x18, 0x60, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0xC3, 0x00, 0x40, 0x40, 0x10, 0x10, 0x04, 0x02, 0x01, 0x01, 0x80,
  0x40, 0x40, 0x10, 0x10, 0x02, 0x04, 0x00, 0x82, 0x00, 0xF3, 0x00, 0xC7,
  0x00, 0x60, 0x80, 0x10, 0x10, 0x04, 0x04, 0x03, 0x00, 0x80, 0x80, 0x30,
  0x20, 0x0C, 0x14, 0x02, 0x89, 0x01, 0x32, 0x20, 0x85, 0x07, 0xC0, 0x80,
  0x55, 0xEA, 0x00, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80,
  0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00,
  0x30, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20,
  0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x08, 0x04, 0x02, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x81, 0x01,
  0x71, 0x1E, 0x0F, 0xE0, 0x03, 0x00, 0x02, 0x80, 0x04, 0x80, 0x08, 0x40,
  0x10, 0x40, 0x20, 0x20, 0x40, 0x30, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x7F, 0xFF, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x00, 0x19,
  0x88, 0xC4, 0x22, 0x10, 0xFF, 0x80, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x00, 0x01, 0xF0, 0x0C, 0x18, 0x20,
  0x10, 0x80, 0x13, 0x00, 0x24, 0x00, 0x48, 0x00, 0xA0, 0x01, 0x40, 0x02,
  0x80, 0x05, 0x06, 0x0E, 0x0C, 0x18, 0x00, 0x70, 0x00, 0xA0, 0x01, 0x40,
  0x02, 0x80, 0x09, 0x80, 0x11, 0x00, 0x42, 0x01, 0x83, 0x06, 0x03, 0xF0,
  0x00, 0x00, 0x70, 0x01, 0xE0, 0x06, 0x80, 0x31, 0x00, 0xC2, 0x03, 0x04,
  0x04, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x18, 0x1F, 0xFF, 0xC0, 0x01, 0xF8, 0x06, 0x0C, 0x0C,
  0x02, 0x08, 0x02, 0x10, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40,
  0x00, 0xFF, 0xFC, 0x01, 0xF8, 0x0C, 0x18, 0x20, 0x08, 0xC0, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x30, 0x1F, 0x80,
  0x01, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x0A, 0x00, 0x22, 0x00, 0xC3, 0x03, 0x01, 0xF8, 0x00, 0x00, 0x06, 0x00,
  0x0A, 0x00, 0x1E, 0x00, 0x34, 0x00, 0x24, 0x00, 0x44, 0x00, 0x84, 0x01,
  0x04, 0x02, 0x0C, 0x06, 0x08, 0x04, 0x08, 0x08, 0x08, 0x10, 0x08, 0x20,
  0x08, 0x40, 0x18, 0xC0, 0x10, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x20, 0x0F, 0xFE, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x4F, 0xC0,
  0xA0, 0xC1, 0x80, 0x40, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x12, 0x00, 0x66, 0x00, 0x86, 0x06, 0x03, 0xF0, 0x00, 0x00,
  0x38, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x30, 0x00, 0x9F, 0x86, 0x81, 0x94, 0x02, 0x60, 0x05, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x24, 0x00, 0x90, 0x04, 0x30, 0x60,
  0x7E, 0x00, 0xFF, 0xFE, 0x00, 0x18, 0x00, 0xA0, 0x06, 0x80, 0x12, 0x00,
  0x80, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02,
  0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08,
  0x00, 0x60, 0x03, 0x00, 0x00, 0x03, 0xF0, 0x18, 0x18, 0x60, 0x18, 0x80,
  0x13, 0x00, 0x24, 0x00, 0x48, 0x00, 0x98, 0x03, 0x10, 0x04, 0x10, 0x30,
  0x1F, 0x80, 0xC1, 0x86, 0x00, 0x88, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80,
  0x05, 0x00, 0x0A, 0x00, 0x26, 0x00, 0xC6, 0x07, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x60, 0xC2, 0x00, 0x98, 0x02, 0x40, 0x07, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x80, 0x0F, 0x00, 0x64, 0x02, 0x8C, 0x16, 0x1F, 0x90, 0x00, 0xC0,
  0x02, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01,
  0xC0, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x18,
  0x0E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x0C, 0x10, 0x60, 0x81, 0x04, 0x08, 0x00, 0x00, 0x02, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x10, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x02, 0x00, 0x18,
  0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x80,
  0x00, 0x0F, 0x83, 0x06, 0x40, 0x28, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10,
  0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0xF0, 0x18, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x07, 0x00, 0x01, 0xF0,
  0x0C, 0x18, 0x30, 0x10, 0x40, 0x11, 0x00, 0x22, 0x00, 0x48, 0x3C, 0x90,
  0xC5, 0x22, 0x04, 0x84, 0x09, 0x08, 0x12, 0x20, 0x24, 0x40, 0x48, 0x80,
  0x91, 0x02, 0x62, 0x04, 0x84, 0x19, 0x0C, 0x52, 0x0F, 0xA4, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0F, 0xE0, 0x00, 0x10, 0x00,
  0x28, 0x00, 0x28, 0x00, 0x48, 0x00, 0x48, 0x00, 0x88, 0x00, 0x88, 0x01,
  0x0C, 0x01, 0x04, 0x02, 0x04, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08,
  0x04, 0x0F, 0xFE, 0x18, 0x02, 0x10, 0x02, 0x30, 0x02, 0x20, 0x02, 0x60,
  0x02, 0x40, 0x03, 0xC0, 0x01, 0x1F, 0xF0, 0x20, 0x18, 0x40, 0x10, 0x80,
  0x31, 0x00, 0x26, 0x00, 0xC8, 0x01, 0x10, 0x02, 0x20, 0x0C, 0x40, 0x30,
  0xFF, 0x83, 0x00, 0xC4, 0x00, 0x88, 0x00, 0x90, 0x01, 0x20, 0x02, 0x40,
  0x05, 0x80, 0x1A, 0x00, 0x24, 0x00, 0xC8, 0x03, 0x1F, 0xF8, 0x00, 0x03,
  0xE0, 0x10, 0x61, 0x80, 0xC4, 0x01, 0x20, 0x05, 0x80, 0x04, 0x00, 0x10,
  0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x68, 0x01, 0x10, 0x08, 0x20, 0xC0,
  0x7E, 0x00, 0x1F, 0xE0, 0x20, 0x30, 0x40, 0x10, 0x80, 0x21, 0x00, 0x22,
  0x00, 0x4C, 0x00, 0x90, 0x01, 0x20, 0x02, 0x40, 0x04, 0x80, 0x09, 0x00,
  0x16, 0x00, 0x28, 0x00, 0xD0, 0x01, 0x20, 0x02, 0x40, 0x0C, 0x80, 0x11,
  0x00, 0x44, 0x01, 0x88, 0x06, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x3F, 0xFC, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00,
  0x80, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x3F, 0xFC, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x03, 0xE0, 0x30, 0x61, 0x80, 0xCC, 0x01, 0x20, 0x05, 0x80, 0x04, 0x00,
  0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x81, 0xFA, 0x00,
  0x28, 0x00, 0xA0, 0x02, 0x80, 0x1A, 0x00, 0x48, 0x03, 0x10, 0x14, 0x60,
  0xD0, 0x7C, 0x40, 0x10, 0x01, 0x10, 0x01, 0x10, 0x03, 0x10, 0x02, 0x30,
  0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x06, 0x20, 0x04, 0x7F,
  0xFC, 0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x40, 0x0C, 0x40, 0x08, 0xC0,
  0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x18, 0x80, 0x10, 0x0F,
  0xFF, 0x80, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x07, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x11, 0x00, 0x62, 0x00, 0x82, 0x03, 0x06,
  0x0C, 0x03, 0xE0, 0x00, 0x18, 0x01, 0x88, 0x01, 0x84, 0x01, 0x82, 0x01,
  0x81, 0x01, 0x80, 0x81, 0x80, 0xC1, 0x80, 0x41, 0x80, 0x21, 0x80, 0x11,
  0x80, 0x09, 0x40, 0x05, 0x30, 0x07, 0x08, 0x03, 0x06, 0x01, 0x01, 0x00,
  0x80, 0xC0, 0x40, 0x20, 0x20, 0x18, 0x30, 0x04, 0x10, 0x03, 0x08, 0x00,
  0x84, 0x00, 0x60, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x0F, 0xFF,
  0x08, 0x01, 0x86, 0x00, 0xC5, 0x00, 0xE2, 0x80, 0x51, 0x40, 0x48, 0x90,
  0x28, 0x48, 0x24, 0x24, 0x32, 0x21, 0x11, 0x10, 0x90, 0x88, 0x48, 0x44,
  0x28, 0x42, 0x0C, 0x21, 0x04, 0x11, 0x04, 0x08, 0x80, 0x04, 0x40, 0x02,
  0x20, 0x03, 0x10, 0x01, 0x08, 0x00, 0x88, 0x00, 0x44, 0x00, 0x20, 0x18,
  0x01, 0x18, 0x01, 0x14, 0x03, 0x14, 0x02, 0x34, 0x02, 0x26, 0x02, 0x22,
  0x02, 0x22, 0x02, 0x23, 0x06, 0x21, 0x04, 0x61, 0x04, 0x41, 0x04, 0x40,
  0x84, 0x40, 0x84, 0x40, 0x84, 0x40, 0x48, 0xC0, 0x48, 0x80, 0x48, 0x80,
  0x28, 0x80, 0x28, 0x80, 0x28, 0x80, 0x10, 0x01, 0xF0, 0x0C, 0x18, 0x20,
  0x10, 0x80, 0x13, 0x00, 0x24, 0x00, 0x48, 0x00, 0xA0, 0x01, 0x40, 0x02,
  0x80, 0x05, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xA0, 0x01, 0x40,
  0x02, 0x80, 0x09, 0x80, 0x11, 0x00, 0x42, 0x01, 0x83, 0x06, 0x03, 0xF0,
  0x00, 0x1F, 0xF8, 0x10, 0x06, 0x10, 0x02, 0x10, 0x03, 0x10, 0x01, 0x10,
  0x01, 0x30, 0x03, 0x20, 0x02, 0x20, 0x02, 0x20, 0x06, 0x20, 0x0C, 0x3F,
  0xF0, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x01, 0xF0, 0x0C,
  0x18, 0x20, 0x10, 0x80, 0x13, 0x00, 0x24, 0x00, 0x48, 0x00, 0xA0, 0x01,
  0x40, 0x02, 0x80, 0x05, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xA0,
  0x01, 0x40, 0x02, 0x80, 0x09, 0x80, 0x11, 0x00, 0x42, 0x01, 0x83, 0x06,
  0x03, 0xF0, 0x00, 0x80, 0x00, 0x82, 0x01, 0x88, 0x01, 0x60, 0x01, 0x80,
  0x1F, 0xF8, 0x10, 0x06, 0x10, 0x02, 0x10, 0x03, 0x10, 0x01, 0x10, 0x01,
  0x30, 0x03, 0x20, 0x02, 0x20, 0x02, 0x20, 0x06, 0x20, 0x0C, 0x3F, 0xF0,
  0x60, 0x80, 0x40, 0x80, 0x40, 0xC0, 0x40, 0x40, 0x40, 0x40, 0x40, 0x20,
  0xC0, 0x20, 0x80, 0x10, 0x80, 0x10, 0x80, 0x08, 0x01, 0xF8, 0x03, 0x03,
  0x02, 0x00, 0x42, 0x00, 0x31, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x20, 0x01,
  0x08, 0x01, 0x83, 0x03, 0x80, 0x7F, 0x00, 0xFF, 0xFF, 0x80, 0x40, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x02, 0x40, 0x04, 0x80, 0x19,
  0x00, 0x26, 0x00, 0x48, 0x00, 0x90, 0x01, 0x20, 0x02, 0x40, 0x0C, 0x80,
  0x13, 0x00, 0x24, 0x00, 0x48, 0x00, 0x90, 0x01, 0x20, 0x06, 0x40, 0x08,
  0x80, 0x11, 0x00, 0x22, 0x00, 0x84, 0x03, 0x04, 0x0C, 0x07, 0xE0, 0x00,
  0x80, 0x03, 0x00, 0x0E, 0x00, 0x14, 0x00, 0x64, 0x00, 0x88, 0x03, 0x10,
  0x04, 0x20, 0x18, 0x40, 0x20, 0x80, 0x41, 0x81, 0x01, 0x02, 0x02, 0x08,
  0x04, 0x10, 0x08, 0x40, 0x10, 0x80, 0x22, 0x00, 0x64, 0x00, 0x50, 0x00,
  0xA0, 0x01, 0x80, 0x03, 0x00, 0x00, 0x20, 0x00, 0x90, 0x00, 0x48, 0x00,
  0x24, 0x00, 0x22, 0x00, 0x13, 0x00, 0x09, 0x00, 0x04, 0x83, 0x04, 0x41,
  0x82, 0x20, 0xC1, 0x10, 0x91, 0x88, 0x48, 0x84, 0x44, 0x42, 0x22, 0x21,
  0x21, 0x30, 0x90, 0x90, 0x58, 0x48, 0x28, 0x24, 0x14, 0x16, 0x14, 0x06,
  0x0A, 0x03, 0x06, 0x01, 0x80, 0x08, 0x00, 0x20, 0x80, 0x08, 0x10, 0x02,
  0x01, 0x00, 0xC0, 0x20, 0x30, 0x02, 0x0C, 0x00, 0x41, 0x00, 0x04, 0x40,
  0x00, 0x90, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0A, 0x00,
  0x02, 0x20, 0x00, 0xC4, 0x00, 0x30, 0x40, 0x04, 0x08, 0x01, 0x00, 0x80,
  0x40, 0x10, 0x10, 0x01, 0x06, 0x00, 0x21, 0x80, 0x02, 0x00, 0x80, 0x01,
  0xA0, 0x00, 0x90, 0x00, 0x84, 0x00, 0x82, 0x00, 0xC1, 0x80, 0x40, 0x40,
  0x40, 0x30, 0x40, 0x08, 0x60, 0x04, 0x60, 0x01, 0x20, 0x00, 0xA0, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x0F, 0xF0, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xF0, 0x81, 0x02, 0x02, 0x04,
  0x08, 0x10, 0x10, 0x20, 0x40, 0x80, 0x81, 0x02, 0x04, 0x08, 0x08, 0x10,
  0x20, 0x40, 0x40, 0x81, 0x02, 0x02, 0x04, 0x08, 0x10, 0x0F, 0xF0, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x0F, 0xF0, 0x00, 0x40, 0x01, 0x40, 0x04, 0x80, 0x18, 0x80, 0x21,
  0x00, 0x83, 0x02, 0x02, 0x0C, 0x04, 0x10, 0x04, 0x40, 0x09, 0x00, 0x0E,
  0x00, 0x10, 0xFF, 0xFE, 0xC4, 0x22, 0x10, 0x07, 0xC4, 0x60, 0xD3, 0x01,
  0x48, 0x03, 0x40, 0x0D, 0x00, 0x2C, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00,
  0x28, 0x01, 0xA0, 0x04, 0xC0, 0x31, 0x01, 0x46, 0x09, 0x07, 0xC7, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0xF8, 0x16, 0x18, 0x30, 0x18, 0xC0, 0x11, 0x80, 0x22, 0x00, 0x44,
  0x00, 0xC8, 0x01, 0x10, 0x02, 0x40, 0x04, 0x80, 0x09, 0x00, 0x22, 0x00,
  0x46, 0x01, 0x0A, 0x0C, 0x23, 0xF0, 0x00, 0x07, 0xC0, 0xC1, 0x08, 0x04,
  0x80, 0x24, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x28, 0x02, 0x60, 0x21, 0x82, 0x03, 0xE0, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x03, 0xE2,
  0x18, 0x34, 0x60, 0x28, 0x80, 0x32, 0x00, 0x64, 0x00, 0x98, 0x01, 0x20,
  0x02, 0x40, 0x04, 0x80, 0x09, 0x00, 0x32, 0x00, 0x46, 0x01, 0x84, 0x05,
  0x04, 0x12, 0x07, 0xC4, 0x00, 0x07, 0xE0, 0xC1, 0x88, 0x06, 0x80, 0x14,
  0x00, 0xC0, 0x0A, 0x00, 0xD0, 0x38, 0xFC, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x28, 0x03, 0x60, 0x11, 0x83, 0x03, 0xE0, 0x00, 0x1F, 0xE0, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x7F, 0xFE, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x04, 0x08, 0x00, 0x41, 0x00, 0x06, 0x20, 0x00, 0x64, 0x00, 0x06,
  0x80, 0x00, 0x60, 0x00, 0x03, 0xE2, 0x18, 0x34, 0x60, 0x28, 0x80, 0x32,
  0x00, 0x64, 0x00, 0x98, 0x01, 0x20, 0x02, 0x40, 0x04, 0x80, 0x09, 0x00,
  0x32, 0x00, 0x46, 0x01, 0x84, 0x05, 0x04, 0x12, 0x07, 0xC4, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x44, 0x01, 0x06, 0x0C, 0x03, 0xE0, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x7C, 0x2C,
  0x31, 0x80, 0x8C, 0x06, 0xC0, 0x16, 0x01, 0xA0, 0x09, 0x00, 0x48, 0x02,
  0x40, 0x16, 0x00, 0xA0, 0x0D, 0x00, 0x48, 0x02, 0x40, 0x12, 0x00, 0x80,
  0x01, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x08, 0x00, 0x40, 0xC2, 0x08, 0x11, 0x80, 0x90, 0x0B, 0x00,
  0x70, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x40, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x18, 0x10, 0x60, 0x81, 0x88, 0x02, 0x40, 0x0A, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x11, 0xF0, 0x16, 0x08, 0x18, 0x0C, 0x30, 0x04,
  0x30, 0x04, 0x20, 0x08, 0x20, 0x10, 0x20, 0x60, 0x23, 0x80, 0x66, 0x00,
  0x42, 0x02, 0x41, 0x03, 0x41, 0x04, 0x40, 0x88, 0x40, 0xD0, 0x80, 0x60,
  0xFE, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x03, 0x10, 0xC2, 0x10, 0x26, 0x02, 0xC0, 0x30, 0x00, 0x17,
  0x8E, 0x1C, 0x68, 0x8C, 0x18, 0x66, 0x08, 0x32, 0x04, 0x11, 0x02, 0x08,
  0x82, 0x04, 0xC1, 0x02, 0x40, 0x81, 0x20, 0x40, 0x90, 0x20, 0x88, 0x10,
  0x44, 0x10, 0x26, 0x08, 0x12, 0x04, 0x09, 0x02, 0x0C, 0x23, 0xE1, 0x61,
  0x8C, 0x04, 0x60, 0x36, 0x00, 0xB0, 0x0D, 0x00, 0x48, 0x02, 0x40, 0x12,
  0x00, 0xB0, 0x05, 0x00, 0x68, 0x02, 0x40, 0x12, 0x00, 0x90, 0x04, 0x03,
  0xE0, 0x30, 0x61, 0x00, 0x88, 0x01, 0x60, 0x05, 0x00, 0x14, 0x00, 0x50,
  0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x90, 0x02, 0x40, 0x19, 0x80, 0xC3,
  0x06, 0x03, 0xE0, 0x08, 0xF8, 0x0B, 0x0C, 0x0C, 0x06, 0x18, 0x02, 0x18,
  0x02, 0x10, 0x02, 0x10, 0x03, 0x10, 0x02, 0x10, 0x02, 0x20, 0x02, 0x20,
  0x02, 0x20, 0x04, 0x20, 0x04, 0x30, 0x08, 0x28, 0x30, 0x47, 0xE0, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x07,
  0xC4, 0x60, 0xD3, 0x01, 0x48, 0x03, 0x40, 0x0D, 0x00, 0x2C, 0x00, 0xA0,
  0x02, 0x80, 0x0A, 0x00, 0x28, 0x01, 0xA0, 0x04, 0xC0, 0x31, 0x01, 0x42,
  0x09, 0x07, 0xC4, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0xFC, 0x7C, 0x16, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x07, 0xF0, 0x60, 0x61, 0x00, 0x48,
  0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x03, 0xF0, 0x00, 0x70, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x80, 0x0B, 0x00, 0x67, 0x03, 0x07, 0xF0, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x3F, 0xFF, 0x81,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x0C, 0x10, 0x30, 0x21, 0x80, 0x44, 0x00,
  0xB0, 0x01, 0x80, 0x00, 0x20, 0x09, 0x00, 0x58, 0x02, 0x80, 0x34, 0x01,
  0x20, 0x09, 0x00, 0x48, 0x02, 0x80, 0x14, 0x01, 0xA0, 0x09, 0x00, 0x48,
  0x06, 0x60, 0x51, 0x04, 0x87, 0xCC, 0x78, 0x05, 0x10, 0x08, 0x20, 0x10,
  0x40, 0x30, 0x80, 0x41, 0x00, 0x84, 0x01, 0x08, 0x02, 0x10, 0x0C, 0x20,
  0x10, 0x40, 0x60, 0x80, 0x81, 0x02, 0x04, 0x18, 0x08, 0xE0, 0x1F, 0x00,
  0x20, 0x42, 0x20, 0x82, 0x20, 0x82, 0x20, 0x82, 0x40, 0x81, 0x40, 0x81,
  0x41, 0x82, 0x41, 0x02, 0x41, 0x02, 0xC1, 0x02, 0x81, 0x02, 0x81, 0x06,
  0x83, 0x04, 0x85, 0x0C, 0xC5, 0x18, 0x70, 0xF0, 0x06, 0x0F, 0x0C, 0x88,
  0xD8, 0x48, 0x30, 0x14, 0x10, 0x0C, 0x08, 0x06, 0x04, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0xC0, 0x20, 0x60, 0x10, 0x50, 0x08, 0x28, 0x14,
  0x14, 0x32, 0x31, 0x60, 0xE0, 0xE0, 0x08, 0x02, 0x10, 0x04, 0x60, 0x08,
  0x80, 0x31, 0x00, 0x42, 0x00, 0x84, 0x01, 0x08, 0x02, 0x20, 0x04, 0x40,
  0x10, 0x80, 0x21, 0x00, 0x42, 0x01, 0x86, 0x05, 0x06, 0x12, 0x07, 0xC8,
  0x00, 0x10, 0x00, 0x20, 0x00, 0xC4, 0x01, 0x06, 0x0C, 0x07, 0xE0, 0x00,
  0x1F, 0x82, 0x60, 0xE4, 0x80, 0x3A, 0x00, 0x44, 0x01, 0x00, 0x04, 0x00,
  0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x61, 0x80, 0x44, 0x00,
  0x9F, 0x01, 0x27, 0xF2, 0x40, 0x7C, 0x01, 0xFC, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x40, 0x02, 0x03, 0xF0, 0x00, 0xE0, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x0F, 0xE0, 0x08, 0x42, 0x10, 0x8C, 0x42,
  0x10, 0x84, 0x62, 0x10, 0x84, 0x23, 0x10, 0x84, 0x21, 0x18, 0x84, 0x21,
  0x00, 0x07, 0xF0, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80,
  0x01, 0xF0, 0x1C, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x3F, 0x80, 0x1C, 0x02, 0x44, 0x05, 0x04, 0x0C, 0x0C, 0x28, 0x08, 0x90,
  0x0E, 0x00,
};

const GFXglyph IBMPlexMono_ExtraLightItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 5, 22, 19, 7, -22 },
  { 15, 7, 8, 19, 8, -23 },
  { 22, 18, 22, 19, 1, -22 },
  { 72, 17, 28, 19, 1, -25 },
  { 132, 21, 22, 19, -1, -22 },
  { 190, 18, 22, 19, 0, -22 },
  { 240, 2, 8, 19, 10, -23 },
  { 242, 10, 28, 19, 7, -24 },
  { 277, 10, 28, 19, 2, -24 },
  { 312, 16, 15, 19, 2, -17 },
  { 342, 15, 15, 19, 2, -17 },
  { 371, 5, 8, 19, 5, -3 },
  { 376, 9, 1, 19, 5, -10 },
  { 378, 2, 2, 19, 7, -2 },
  { 379, 17, 28, 19, 1, -24 },
  { 439, 15, 22, 19, 2, -22 },
  { 481, 15, 22, 19, 1, -22 },
  { 523, 16, 22, 19, 1, -22 },
  { 567, 15, 22, 19, 1, -22 },
  { 609, 16, 22, 19, 1, -22 },
  { 653, 15, 22, 19, 2, -22 },
  { 695, 14, 22, 19, 2, -22 },
  { 734, 14, 22, 19, 4, -22 },
  { 773, 15, 22, 19, 2, -22 },
  { 815, 14, 22, 19, 3, -22 },
  { 854, 5, 16, 19, 7, -16 },
  { 864, 7, 21, 19, 5, -16 },
  { 883, 15, 17, 19, 3, -18 },
  { 915, 15, 7, 19, 2, -13 },
  { 929, 15, 17, 19, 1, -18 },
  { 961, 12, 22, 19, 5, -22 },
  { 994, 15, 25, 19, 2, -22 },
  { 1041, 16, 22, 19, 0, -22 },
  { 1085, 15, 22, 19, 2, -22 },
  { 1127, 14, 22, 19, 3, -22 },
  { 1166, 15, 22, 19, 2, -22 },
  { 1208, 16, 22, 19, 2, -22 },
  { 1252, 16, 22, 19, 2, -22 },
  { 1296, 14, 22, 19, 3, -22 },
  { 1335, 16, 22, 19, 2, -22 },
  { 1379, 17, 22, 19, 1, -22 },
  { 1426, 15, 22, 19, 2, -22 },
  { 1468, 17, 22, 19, 2, -22 },
  { 1515, 12, 22, 19, 3, -22 },
  { 1548, 17, 22, 19, 1, -22 },
  { 1595, 16, 22, 19, 2, -22 },
  { 1639, 15, 22, 19, 2, -22 },
  { 1681, 16, 22, 19, 2, -22 },
  { 1725, 15, 27, 19, 2, -22 },
  { 1776, 16, 22, 19, 2, -22 },
  { 1820, 17, 22, 19, 1, -22 },
  { 1867, 17, 22, 19, 3, -22 },
  { 1914, 15, 22, 19, 3, -22 },
  { 1956, 15, 22, 19, 4, -22 },
  { 1998, 17, 22, 19, 2, -22 },
  { 2045, 19, 22, 19, 0, -22 },
  { 2098, 17, 22, 19, 3, -22 },
  { 2145, 19, 22, 19, 0, -22 },
  { 2198, 12, 28, 19, 6, -24 },
  { 2240, 7, 28, 19, 6, -24 },
  { 2265, 12, 28, 19, 1, -24 },
  { 2307, 15, 12, 19, 2, -22 },
  { 2330, 15, 1, 19, 0, 4 },
  { 2332, 4, 5, 19, 7, -23 },
  { 2335, 14, 16, 19, 2, -16 },
  { 2363, 15, 23, 19, 2, -23 },
  { 2407, 13, 16, 19, 3, -16 },
  { 2433, 15, 23, 19, 2, -23 },
  { 2477, 13, 16, 19, 3, -16 },
  { 2503, 19, 29, 19, 0, -23 },
  { 2572, 15, 22, 19, 1, -16 },
  { 2614, 13, 23, 19, 3, -23 },
  { 2652, 13, 23, 19, 3, -23 },
  { 2690, 13, 29, 19, 3, -23 },
  { 2738, 16, 23, 19, 2, -23 },
  { 2784, 12, 23, 19, 4, -23 },
  { 2819, 17, 16, 19, 1, -16 },
  { 2853, 13, 16, 19, 3, -16 },
  { 2879, 14, 16, 19, 2, -16 },
  { 2907, 16, 22, 19, 1, -16 },
  { 2951, 14, 22, 19, 2, -16 },
  { 2990, 14, 16, 19, 4, -16 },
  { 3018, 14, 16, 19, 2, -16 },
  { 3046, 15, 22, 19, 2, -22 },
  { 3088, 13, 16, 19, 3, -16 },
  { 3114, 15, 16, 19, 2, -16 },
  { 3144, 16, 16, 19, 2, -16 },
  { 3176, 17, 16, 19, 1, -16 },
  { 3210, 15, 22, 19, 1, -16 },
  { 3252, 15, 16, 19, 2, -16 },
  { 3282, 14, 28, 19, 4, -24 },
  { 3331, 5, 28, 19, 7, -24 },
  { 3349, 14, 28, 19, 1, -24 },
  { 3398, 15, 6, 19, 2, -12 },
};

const GFXfont IBMPlexMono_ExtraLightItalic31pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic31pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic31pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC31PT7B_H_
