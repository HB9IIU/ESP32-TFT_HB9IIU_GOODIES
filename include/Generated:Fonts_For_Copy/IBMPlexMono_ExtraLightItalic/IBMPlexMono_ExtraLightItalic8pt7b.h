#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC8PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xF0, 0x31, 0x96, 0xCF, 0x50, 0x37, 0x68, 0xE5, 0x69, 0x80,
  0x6D, 0xAC, 0xAF, 0x78, 0x22, 0x95, 0xCA, 0x7C, 0xC0, 0x6A, 0xA8, 0x95,
  0x68, 0x27, 0xD9, 0x60, 0x5E, 0x40, 0xC0, 0xE0, 0x80, 0x18, 0x88, 0x44,
  0x42, 0x00, 0x76, 0xFB, 0x80, 0x26, 0x22, 0x2F, 0x3D, 0x12, 0x4F, 0x35,
  0x13, 0x1F, 0x13, 0x59, 0xA7, 0x34, 0x87, 0x1F, 0x3A, 0x7B, 0xC0, 0xFA,
  0x24, 0x88, 0x3D, 0x5B, 0x9F, 0x76, 0xF5, 0x00, 0x90, 0x42, 0x80, 0x16,
  0x88, 0x60, 0xF8, 0x86, 0x12, 0xC0, 0x74, 0xE9, 0x00, 0x77, 0xDB, 0xB0,
  0x22, 0x55, 0xB9, 0x79, 0x9F, 0x9F, 0x6B, 0x88, 0x8E, 0x65, 0x99, 0x9E,
  0x7A, 0x21, 0xE8, 0x78, 0x7A, 0x21, 0xE8, 0x40, 0x6B, 0x8A, 0xAE, 0x4C,
  0xA5, 0xE9, 0x48, 0x79, 0x08, 0x44, 0x78, 0x64, 0x93, 0x80, 0x4A, 0xA8,
  0xCA, 0x48, 0x92, 0x49, 0xC0, 0x4E, 0x7D, 0x69, 0x48, 0x4E, 0xB5, 0x6B,
  0x58, 0x76, 0xDB, 0x80, 0x72, 0x65, 0xC8, 0x40, 0x76, 0xDB, 0x98, 0x72,
  0x65, 0xCA, 0x48, 0x36, 0x60, 0xE1, 0x78, 0xF4, 0x44, 0x88, 0x9A, 0xAA,
  0xAE, 0x9A, 0xAC, 0xC8, 0x99, 0xEE, 0xEA, 0x8A, 0x98, 0xC6, 0x48, 0x9A,
  0xA4, 0x88, 0x78, 0x88, 0x84, 0x78, 0xF2, 0x49, 0x30, 0xFE, 0x64, 0x92,
  0xB0, 0x56, 0x80, 0xF0, 0x80, 0xF6, 0xF0, 0x93, 0xDB, 0xC0, 0xF2, 0x70,
  0x32, 0xEA, 0xAE, 0xF7, 0x70, 0x39, 0x1E, 0x44, 0x23, 0x08, 0xF9, 0x99,
  0x6E, 0x93, 0xDB, 0x40, 0x43, 0x4A, 0x80, 0x23, 0xA4, 0xB2, 0x88, 0xEA,
  0xCF, 0xCA, 0x4A, 0x80, 0xFD, 0xAD, 0xA0, 0xF6, 0xD0, 0xF6, 0xE0, 0xF9,
  0x99, 0xE8, 0xF6, 0xD4, 0x80, 0xF8, 0x88, 0xF4, 0x3F, 0x4A, 0xCB, 0x80,
  0xB6, 0xF0, 0xB6, 0xE0, 0xED, 0xEE, 0xF9, 0x09, 0xE0, 0xD9, 0x99, 0x6E,
  0xF2, 0x5F, 0x74, 0x48, 0x48, 0xC0, 0xFE, 0x22, 0x43, 0x64, 0xC0, 0xF8,
};

const GFXglyph IBMPlexMono_ExtraLightItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 2, 2, 5, 2, -6 },
  { 3, 5, 6, 5, 0, -6 },
  { 7, 5, 7, 5, 0, -6 },
  { 12, 5, 6, 5, 0, -6 },
  { 16, 5, 6, 5, 0, -6 },
  { 20, 1, 2, 5, 2, -6 },
  { 21, 2, 7, 5, 2, -6 },
  { 23, 2, 7, 5, 1, -6 },
  { 25, 5, 4, 5, 0, -4 },
  { 28, 3, 4, 5, 1, -4 },
  { 30, 1, 2, 5, 1, -1 },
  { 31, 3, 1, 5, 1, -3 },
  { 32, 1, 1, 5, 2, -1 },
  { 33, 5, 7, 5, 0, -6 },
  { 38, 3, 6, 5, 1, -6 },
  { 41, 4, 6, 5, 0, -6 },
  { 44, 4, 6, 5, 0, -6 },
  { 47, 4, 6, 5, 0, -6 },
  { 50, 4, 6, 5, 0, -6 },
  { 53, 4, 6, 5, 0, -6 },
  { 56, 3, 6, 5, 1, -6 },
  { 59, 4, 6, 5, 1, -6 },
  { 62, 4, 6, 5, 0, -6 },
  { 65, 3, 6, 5, 1, -6 },
  { 68, 1, 4, 5, 2, -4 },
  { 69, 2, 5, 5, 1, -4 },
  { 71, 4, 5, 5, 1, -5 },
  { 74, 5, 1, 5, 0, -3 },
  { 75, 4, 5, 5, 0, -5 },
  { 78, 3, 6, 5, 1, -6 },
  { 81, 3, 7, 5, 1, -6 },
  { 84, 4, 6, 5, 0, -6 },
  { 87, 4, 6, 5, 0, -6 },
  { 90, 4, 6, 5, 1, -6 },
  { 93, 4, 6, 5, 0, -6 },
  { 96, 5, 6, 5, 0, -6 },
  { 100, 5, 6, 5, 0, -6 },
  { 104, 4, 6, 5, 1, -6 },
  { 107, 5, 6, 5, 0, -6 },
  { 111, 5, 6, 5, 0, -6 },
  { 115, 3, 6, 5, 1, -6 },
  { 118, 5, 6, 5, 0, -6 },
  { 122, 3, 6, 5, 1, -6 },
  { 125, 5, 6, 5, 0, -6 },
  { 129, 5, 6, 5, 0, -6 },
  { 133, 3, 6, 5, 1, -6 },
  { 136, 5, 6, 5, 0, -6 },
  { 140, 3, 7, 5, 1, -6 },
  { 143, 5, 6, 5, 0, -6 },
  { 147, 5, 6, 5, 0, -6 },
  { 151, 4, 6, 5, 1, -6 },
  { 154, 4, 6, 5, 1, -6 },
  { 157, 4, 6, 5, 1, -6 },
  { 160, 4, 6, 5, 1, -6 },
  { 163, 5, 6, 5, 0, -6 },
  { 167, 4, 6, 5, 1, -6 },
  { 170, 5, 6, 5, 0, -6 },
  { 174, 3, 7, 5, 2, -6 },
  { 177, 1, 7, 5, 2, -6 },
  { 178, 3, 7, 5, 0, -6 },
  { 181, 3, 3, 5, 1, -6 },
  { 183, 4, 1, 5, 0, 1 },
  { 184, 1, 1, 5, 2, -6 },
  { 185, 3, 4, 5, 1, -4 },
  { 187, 3, 6, 5, 1, -6 },
  { 190, 3, 4, 5, 1, -4 },
  { 192, 4, 6, 5, 1, -6 },
  { 195, 3, 4, 5, 1, -4 },
  { 197, 5, 8, 5, 0, -6 },
  { 202, 4, 6, 5, 0, -4 },
  { 205, 3, 6, 5, 1, -6 },
  { 208, 3, 6, 5, 1, -6 },
  { 211, 3, 8, 5, 1, -6 },
  { 214, 4, 6, 5, 1, -6 },
  { 217, 3, 6, 5, 1, -6 },
  { 220, 5, 4, 5, 0, -4 },
  { 223, 3, 4, 5, 1, -4 },
  { 225, 3, 4, 5, 1, -4 },
  { 227, 4, 6, 5, 0, -4 },
  { 230, 3, 6, 5, 1, -4 },
  { 233, 4, 4, 5, 1, -4 },
  { 235, 4, 4, 5, 0, -4 },
  { 237, 3, 6, 5, 1, -6 },
  { 240, 3, 4, 5, 1, -4 },
  { 242, 3, 4, 5, 1, -4 },
  { 244, 4, 4, 5, 1, -4 },
  { 246, 5, 4, 5, 0, -4 },
  { 249, 4, 6, 5, 0, -4 },
  { 252, 4, 4, 5, 0, -4 },
  { 254, 4, 7, 5, 1, -6 },
  { 258, 1, 7, 5, 2, -6 },
  { 259, 4, 7, 5, 0, -6 },
  { 263, 5, 1, 5, 0, -3 },
};

const GFXfont IBMPlexMono_ExtraLightItalic8pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic8pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic8pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC8PT7B_H_
