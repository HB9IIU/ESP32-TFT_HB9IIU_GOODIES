#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC51PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x7C, 0x3C, 0x0E, 0x00, 0x30, 0x66, 0x0C, 0x81, 0xB0, 0x26,
  0x0C, 0xC1, 0x98, 0x33, 0x06, 0x40, 0xD8, 0x13, 0x06, 0x60, 0xCC, 0x18,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x40, 0x20, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x20, 0x10, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x10,
  0x08, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x01, 0x80, 0x0F, 0xF8, 0x07,
  0xFC, 0x7F, 0xE0, 0x3F, 0xF0, 0x01, 0x80, 0xC0, 0x00, 0x04, 0x02, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x02, 0x01, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x00, 0x80, 0x0F, 0xFC,
  0x07, 0xFE, 0x3F, 0xF0, 0x1F, 0xF8, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0x84, 0x78, 0x03, 0x80, 0x81, 0x80, 0xE0, 0x30,
  0x18, 0x18, 0x06, 0x01, 0x83, 0x00, 0xC0, 0x20, 0xC0, 0x10, 0x00, 0x18,
  0x02, 0x00, 0x03, 0x00, 0x40, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x03, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x18, 0x08, 0x00, 0x03, 0x81, 0x00, 0x00, 0x38,
  0x20, 0x00, 0x03, 0xEC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x04, 0xF8, 0x00, 0x00, 0x83, 0x80, 0x00, 0x10, 0x38, 0x00, 0x06,
  0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x02, 0x00, 0xC0,
  0x00, 0x40, 0x18, 0x00, 0x08, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0x60,
  0x0C, 0x60, 0x0C, 0x03, 0x0E, 0x01, 0x00, 0x60, 0xE0, 0x20, 0x18, 0x0E,
  0x04, 0x0E, 0x00, 0xF1, 0x87, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xC0, 0x1F,
  0xF0, 0x00, 0x60, 0x0E, 0x0C, 0x00, 0x30, 0x06, 0x01, 0x80, 0x08, 0x03,
  0x00, 0x20, 0x06, 0x00, 0xC0, 0x08, 0x03, 0x00, 0x60, 0x02, 0x01, 0x80,
  0x18, 0x00, 0x80, 0x40, 0x06, 0x00, 0x20, 0x30, 0x01, 0x80, 0x18, 0x18,
  0x00, 0x40, 0x06, 0x0C, 0x00, 0x10, 0x01, 0x82, 0x00, 0x06, 0x00, 0xC1,
  0x80, 0x01, 0x80, 0x70, 0xC0, 0x00, 0x38, 0x38, 0x60, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x06, 0x1E, 0x1C, 0x00, 0x03, 0x06, 0x01, 0x80, 0x01, 0x83, 0x00, 0x60,
  0x00, 0x40, 0x80, 0x08, 0x00, 0x30, 0x60, 0x02, 0x00, 0x18, 0x18, 0x00,
  0x80, 0x0C, 0x06, 0x00, 0x20, 0x02, 0x01, 0x00, 0x18, 0x01, 0x80, 0x40,
  0x06, 0x00, 0xC0, 0x10, 0x01, 0x80, 0x60, 0x04, 0x00, 0x40, 0x10, 0x01,
  0x80, 0x30, 0x0C, 0x00, 0x60, 0x18, 0x06, 0x00, 0x0E, 0x1E, 0x01, 0x00,
  0x01, 0xFE, 0x00, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0x80, 0x18, 0x00, 0x1C,
  0x00, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x60, 0x06, 0x00, 0x03,
  0x00, 0x20, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x20, 0x70, 0x00, 0x1F, 0x8F,
  0x00, 0x03, 0xCF, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x30, 0x06, 0x00, 0x03, 0x00, 0x18, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x60, 0x01, 0x00, 0x01,
  0x80, 0x08, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x0F, 0x00, 0x06, 0xC0,
  0xD8, 0x00, 0x27, 0x0C, 0xE0, 0x03, 0x18, 0x63, 0x00, 0x30, 0x66, 0x0E,
  0x07, 0x03, 0x70, 0x3F, 0xF0, 0x0F, 0x00, 0x7E, 0x00, 0x30, 0x00, 0x33,
  0x33, 0x32, 0x66, 0x66, 0x64, 0xC0, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x38, 0x03, 0x00,
  0x77, 0xC0, 0xC0, 0xF8, 0x3E, 0x31, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x00, 0x80,
  0x03, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0xE0, 0x01, 0x80, 0x30, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x07, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x00, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0F, 0x0E, 0x0E, 0x1C, 0x1C, 0x18, 0x38, 0x30, 0x70, 0x60, 0x60, 0xC0,
  0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x77, 0xFC, 0xE0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0xF0, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x0C, 0x07, 0x00, 0x06, 0x06,
  0x00, 0x06, 0x0C, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x30,
  0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0xC0, 0x1C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x38, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x60, 0x60, 0x00, 0xE0, 0x30,
  0x01, 0xC0, 0x3C, 0x07, 0x80, 0x0F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x0E, 0x60, 0x00,
  0x3C, 0x40, 0x00, 0x78, 0xC0, 0x00, 0xE0, 0xC0, 0x01, 0xC0, 0xC0, 0x07,
  0x80, 0xC0, 0x0F, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x1E, 0x07, 0x80, 0x18, 0x00, 0xE0,
  0x18, 0x00, 0x38, 0x18, 0x00, 0x0C, 0x1C, 0x00, 0x06, 0x0C, 0x00, 0x03,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x3C,
  0x07, 0x80, 0x38, 0x00, 0xE0, 0x38, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x18,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x20, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x61, 0x00, 0x00, 0x31, 0x80, 0x00, 0x30, 0x60, 0x00, 0x38, 0x1C,
  0x00, 0x38, 0x07, 0x80, 0x78, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x01, 0x90, 0x00, 0x00, 0x66, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x0C,
  0x08, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x0C, 0x00,
  0x04, 0x01, 0x80, 0x01, 0x00, 0x30, 0x00, 0x60, 0x04, 0x00, 0x18, 0x01,
  0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x20, 0x00, 0xC0, 0x08,
  0x00, 0x18, 0x03, 0x00, 0x02, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x18,
  0x0C, 0x00, 0x03, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x60, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0xFE,
  0x00, 0x19, 0xFF, 0xC0, 0x0B, 0x80, 0xF0, 0x0F, 0x00, 0x1C, 0x07, 0x00,
  0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x61,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x70, 0x60, 0x00, 0x30, 0x18, 0x00, 0x70,
  0x07, 0x80, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x87, 0xF0, 0x06, 0x7F, 0xF8, 0x33, 0x80, 0xF0, 0xD8, 0x00, 0xE6,
  0x80, 0x01, 0x9C, 0x00, 0x03, 0x70, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x6C, 0x00, 0x01, 0x98,
  0x00, 0x0C, 0x60, 0x00, 0x60, 0xC0, 0x07, 0x03, 0xC0, 0x78, 0x03, 0xFF,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x0C, 0x40, 0x00, 0x0C, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x3C,
  0x07, 0x80, 0x38, 0x00, 0xE0, 0x30, 0x00, 0x38, 0x30, 0x00, 0x0C, 0x18,
  0x00, 0x06, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18,
  0x18, 0x00, 0x18, 0x06, 0x00, 0x18, 0x01, 0xC0, 0x78, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x01, 0xC1, 0xC0, 0x00,
  0x60, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x02, 0x60, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x18, 0x38,
  0x00, 0x38, 0x0F, 0x80, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x03, 0xFF, 0xC0, 0x1E, 0x03, 0xC0, 0x70, 0x01, 0xC1,
  0xC0, 0x01, 0xC7, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x30, 0x00, 0x03, 0x60,
  0x00, 0x06, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x0E, 0x60, 0x00,
  0x3C, 0xE0, 0x00, 0xF0, 0xE0, 0x03, 0x60, 0xF0, 0x1C, 0xC0, 0xFF, 0xF3,
  0x00, 0x7F, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x0F, 0x0F, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0xF8, 0xF0, 0x70, 0x00,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x70,
  0x0C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x20,
  0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0,
  0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x03, 0xC0, 0x78,
  0x38, 0x00, 0xE3, 0x80, 0x03, 0x18, 0x00, 0x1D, 0x80, 0x00, 0x6C, 0x00,
  0x03, 0xC0, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xF0, 0x3C,
  0x01, 0xC0, 0x0C, 0x03, 0x00, 0x06, 0x07, 0x00, 0x06, 0x06, 0x00, 0x02,
  0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03,
  0x18, 0x07, 0xC2, 0x10, 0x0F, 0xF2, 0x30, 0x1C, 0x1A, 0x30, 0x30, 0x0E,
  0x20, 0x60, 0x06, 0x20, 0x60, 0x06, 0x60, 0x40, 0x04, 0x60, 0xC0, 0x04,
  0x60, 0xC0, 0x04, 0x60, 0xC0, 0x0C, 0x40, 0x80, 0x0C, 0xC1, 0x80, 0x0C,
  0xC1, 0x80, 0x08, 0xC1, 0x80, 0x18, 0xC1, 0x80, 0x18, 0xC1, 0x80, 0x38,
  0xC0, 0xC0, 0x38, 0xC0, 0xC0, 0x58, 0xC0, 0x71, 0x90, 0xC0, 0x7F, 0x10,
  0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x05, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0x98, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x10, 0x80, 0x00, 0x0C, 0x20, 0x00, 0x03, 0x0C, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C,
  0x00, 0x06, 0x01, 0x00, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x30,
  0x06, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00,
  0xC0, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x38, 0x00,
  0x06, 0x0C, 0x00, 0x01, 0x87, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0xE0,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x9C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x06, 0x00, 0x1E,
  0x06, 0x00, 0x06, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x01,
  0x04, 0x00, 0x01, 0x0C, 0x00, 0x01, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03,
  0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x08, 0x00, 0x06, 0x18, 0x00, 0x06,
  0x18, 0x00, 0x0C, 0x18, 0x00, 0x38, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x10, 0x00, 0x38, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0E, 0x30, 0x00, 0x06,
  0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x20, 0x00, 0x06, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x0E, 0x60, 0x00, 0x0C,
  0x40, 0x00, 0x1C, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x3C, 0x0F,
  0x00, 0x38, 0x01, 0xC0, 0x38, 0x00, 0x60, 0x18, 0x00, 0x18, 0x18, 0x00,
  0x0C, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x60, 0xE0, 0x00, 0x60, 0x30, 0x00, 0x60, 0x0C, 0x00,
  0x60, 0x07, 0x80, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0xC0, 0x0F, 0x00, 0x40, 0x01, 0xC0,
  0x60, 0x00, 0x60, 0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x03,
  0x06, 0x00, 0x01, 0x82, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x10, 0x00,
  0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x18, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60,
  0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x84,
  0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xE0,
  0xC0, 0x00, 0xE0, 0x60, 0x00, 0xE0, 0x20, 0x01, 0xE0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x3C, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x30, 0x00, 0x60,
  0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0xFF, 0xE6, 0x00, 0x7F, 0xF3, 0x00, 0x00, 0x11, 0x80, 0x00, 0x08, 0xC0,
  0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C,
  0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x70,
  0x30, 0x00, 0x58, 0x1C, 0x00, 0x4C, 0x07, 0x81, 0xE4, 0x01, 0xFF, 0xC6,
  0x00, 0x3F, 0x80, 0x00, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x18,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x08, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x20, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x30, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x10,
  0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00,
  0x03, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x18, 0x00, 0x01, 0x03,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x30, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x81, 0x80, 0x00, 0x30, 0x30,
  0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x10,
  0x00, 0x18, 0x20, 0x00, 0x30, 0x60, 0x00, 0xE0, 0xC0, 0x01, 0x80, 0xC0,
  0x0E, 0x00, 0xE0, 0x78, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x18, 0x00, 0x03, 0x00, 0x80, 0x00, 0x30, 0x0C, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x30, 0x03, 0x00, 0x03, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x30, 0x00, 0x60, 0x03, 0x00, 0x03,
  0x00, 0x70, 0x00, 0x18, 0x07, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x06, 0x07,
  0x00, 0x00, 0x20, 0x70, 0x00, 0x03, 0x07, 0x00, 0x00, 0x18, 0x7C, 0x00,
  0x00, 0xC7, 0x60, 0x00, 0x06, 0x73, 0x80, 0x00, 0x36, 0x0C, 0x00, 0x01,
  0x60, 0x60, 0x00, 0x1E, 0x01, 0x80, 0x00, 0xE0, 0x0C, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x30, 0x01, 0x80, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x30, 0x00, 0x18, 0x01,
  0x80, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x40, 0x00, 0x18, 0x06, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x00, 0x70, 0x38, 0x00, 0x07, 0x07,
  0x80, 0x00, 0xF0, 0x68, 0x00, 0x0F, 0x06, 0xC0, 0x01, 0xA0, 0x6C, 0x00,
  0x32, 0x06, 0xC0, 0x03, 0x60, 0x44, 0x00, 0x66, 0x0C, 0x60, 0x04, 0x60,
  0xC6, 0x00, 0xC6, 0x0C, 0x60, 0x18, 0x40, 0xC2, 0x01, 0x84, 0x0C, 0x30,
  0x30, 0xC0, 0x83, 0x02, 0x0C, 0x18, 0x10, 0x60, 0xC1, 0x81, 0x0C, 0x0C,
  0x18, 0x18, 0xC0, 0x81, 0x81, 0x98, 0x08, 0x18, 0x09, 0x01, 0x81, 0x00,
  0xF0, 0x18, 0x30, 0x0E, 0x01, 0x83, 0x00, 0x60, 0x18, 0x30, 0x04, 0x01,
  0x83, 0x00, 0x80, 0x10, 0x30, 0x00, 0x03, 0x02, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x20, 0x60, 0x00, 0x06, 0x04, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x40, 0x07, 0x00,
  0x00, 0x60, 0xF0, 0x00, 0x08, 0x1E, 0x00, 0x03, 0x03, 0x40, 0x00, 0x60,
  0x6C, 0x00, 0x0C, 0x09, 0x80, 0x01, 0x83, 0x30, 0x00, 0x20, 0x63, 0x00,
  0x04, 0x0C, 0x60, 0x01, 0x81, 0x8C, 0x00, 0x30, 0x30, 0xC0, 0x06, 0x04,
  0x18, 0x00, 0xC1, 0x83, 0x00, 0x10, 0x30, 0x30, 0x02, 0x06, 0x06, 0x00,
  0xC0, 0xC0, 0xC0, 0x18, 0x18, 0x0C, 0x03, 0x02, 0x01, 0x80, 0x60, 0xC0,
  0x30, 0x0C, 0x18, 0x02, 0x01, 0x03, 0x00, 0x60, 0x60, 0x60, 0x0C, 0x0C,
  0x0C, 0x00, 0x81, 0x81, 0x00, 0x18, 0x30, 0x60, 0x03, 0x06, 0x0C, 0x00,
  0x20, 0x81, 0x80, 0x06, 0x30, 0x30, 0x00, 0xC6, 0x06, 0x00, 0x18, 0xC0,
  0x80, 0x01, 0x98, 0x30, 0x00, 0x33, 0x06, 0x00, 0x06, 0x40, 0xC0, 0x00,
  0x78, 0x18, 0x00, 0x0F, 0x03, 0x00, 0x01, 0xE0, 0x40, 0x00, 0x1C, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x0C,
  0x07, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x18, 0x00, 0x03,
  0x18, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x60,
  0x60, 0x00, 0xE0, 0x30, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x0F, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x30, 0x00,
  0x70, 0x18, 0x00, 0x06, 0x06, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x30, 0x60,
  0x00, 0x0C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0E, 0x18, 0x00, 0x07, 0x06, 0x00,
  0x07, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x0C,
  0x07, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x18, 0x00, 0x03,
  0x18, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x60,
  0x60, 0x00, 0xE0, 0x30, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x0F, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x04, 0x00, 0x38, 0x0E,
  0x00, 0x18, 0x38, 0x00, 0x0C, 0x70, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x30, 0x00,
  0x70, 0x18, 0x00, 0x06, 0x06, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x30, 0x60,
  0x00, 0x0C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0E, 0x18, 0x00, 0x07, 0x06, 0x00,
  0x07, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x18, 0x04, 0x00, 0x0C,
  0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x03, 0x00,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00,
  0xC0, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x60,
  0x00, 0x30, 0x10, 0x00, 0x04, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x70,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xC0, 0x3C, 0x01, 0xC0,
  0x00, 0xC0, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x10,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x30, 0x00, 0x01, 0x87, 0x00, 0x00, 0x30,
  0x70, 0x00, 0x0C, 0x07, 0x00, 0x07, 0x00, 0x7C, 0x03, 0xC0, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x82,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x10, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x03,
  0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x40, 0x00, 0x0C, 0x30, 0x00,
  0x03, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x30,
  0x00, 0x06, 0x08, 0x00, 0x01, 0x82, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30,
  0x60, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x30, 0x40, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x01,
  0x80, 0x01, 0x80, 0x60, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x78,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x64, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03,
  0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0x20, 0x00,
  0x0C, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x30,
  0x00, 0x30, 0x0C, 0x00, 0x18, 0x01, 0x00, 0x06, 0x00, 0x40, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x60, 0x0C,
  0x00, 0x18, 0x03, 0x00, 0x02, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30,
  0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x02, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x10, 0x40, 0x00, 0x04, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0x33, 0x00, 0x00, 0x02,
  0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x43, 0x00,
  0x00, 0x04, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00,
  0x82, 0x00, 0x00, 0x18, 0x20, 0x00, 0x01, 0x82, 0x00, 0xC0, 0x18, 0x60,
  0x1E, 0x01, 0x06, 0x01, 0xE0, 0x30, 0x60, 0x16, 0x03, 0x06, 0x03, 0x60,
  0x30, 0x60, 0x26, 0x02, 0x06, 0x06, 0x60, 0x60, 0x60, 0x42, 0x06, 0x06,
  0x0C, 0x20, 0x60, 0x60, 0xC2, 0x04, 0x06, 0x18, 0x30, 0xC0, 0x41, 0x83,
  0x0C, 0x04, 0x10, 0x30, 0xC0, 0x43, 0x03, 0x08, 0x04, 0x20, 0x31, 0x80,
  0xC6, 0x03, 0x18, 0x0C, 0x60, 0x11, 0x80, 0xCC, 0x01, 0x10, 0x0C, 0xC0,
  0x13, 0x00, 0xD8, 0x01, 0xB0, 0x0D, 0x80, 0x1B, 0x00, 0xD0, 0x01, 0xA0,
  0x0F, 0x00, 0x1E, 0x00, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x1E, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x01, 0x80, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x60, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x30, 0x00, 0xE0, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x06, 0x1C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0x03, 0x00, 0x06, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x18, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x03, 0x81, 0x80, 0x00, 0x70, 0x18, 0x00, 0x06, 0x01,
  0x80, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x30, 0x00, 0x60, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x18, 0x00,
  0x01, 0x83, 0x80, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x80, 0x0C, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x06, 0x00, 0x60, 0x02, 0x00, 0x20, 0x03, 0x00, 0x30,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x18, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0C,
  0x00, 0xC0, 0x04, 0x00, 0x40, 0x06, 0x00, 0x60, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00,
  0x80, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x60, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x30, 0x03, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10,
  0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x0D, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x30, 0x40,
  0x00, 0x60, 0x60, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x30,
  0x03, 0x00, 0x18, 0x06, 0x00, 0x18, 0x06, 0x00, 0x08, 0x0C, 0x00, 0x0C,
  0x18, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x60, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x43, 0x06, 0x08, 0x30, 0x41, 0x82, 0x0C, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0xC3, 0x03, 0xC0, 0xE2, 0x07, 0x00, 0x32, 0x0E, 0x00, 0x1E, 0x1C, 0x00,
  0x0E, 0x18, 0x00, 0x0E, 0x30, 0x00, 0x06, 0x30, 0x00, 0x04, 0x30, 0x00,
  0x04, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00,
  0x0C, 0x40, 0x00, 0x08, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x38, 0x40, 0x00, 0x30, 0x60, 0x00,
  0x70, 0x60, 0x00, 0xF0, 0x30, 0x01, 0xB0, 0x38, 0x03, 0x30, 0x1E, 0x0E,
  0x3F, 0x0F, 0xFC, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0xFE, 0x00, 0xC7, 0xFF, 0x01, 0x9C, 0x0F, 0x02,
  0x60, 0x06, 0x0D, 0x80, 0x06, 0x1A, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x70,
  0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x66, 0x00, 0x00, 0xCC, 0x00,
  0x01, 0x98, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0x80, 0x00,
  0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x98, 0x00, 0x03,
  0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x40, 0x01, 0x86,
  0xC0, 0x07, 0x0C, 0xE0, 0x3C, 0x18, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x07, 0xFF, 0x00, 0x3C, 0x0E, 0x01, 0xC0, 0x0C, 0x0C,
  0x00, 0x18, 0x60, 0x00, 0x63, 0x80, 0x00, 0xCC, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x04, 0xC0, 0x00, 0x39, 0x80, 0x00,
  0xC6, 0x00, 0x06, 0x0C, 0x00, 0x30, 0x38, 0x01, 0x80, 0x78, 0x1C, 0x00,
  0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0xFC, 0x0C, 0x01, 0xFF, 0xC3, 0x00,
  0xF0, 0x38, 0xC0, 0x70, 0x03, 0x20, 0x38, 0x00, 0x68, 0x1C, 0x00, 0x0E,
  0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x30, 0x00,
  0x04, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x60,
  0x00, 0x0C, 0x10, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x83, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x81, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x50, 0x18, 0x00, 0x1C, 0x03, 0x00, 0x0B, 0x00, 0xE0,
  0x0C, 0xC0, 0x1E, 0x06, 0x30, 0x03, 0xFF, 0x0C, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x03, 0xFF, 0xC0, 0x3C, 0x07, 0x81, 0xC0, 0x06, 0x0C,
  0x00, 0x0C, 0x60, 0x00, 0x31, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x20, 0x00,
  0x0D, 0x80, 0x00, 0x66, 0x00, 0x07, 0x10, 0x00, 0x78, 0xC0, 0x3F, 0x83,
  0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x06, 0x40, 0x00, 0x19, 0x80, 0x00,
  0xC6, 0x00, 0x07, 0x0C, 0x00, 0x38, 0x38, 0x01, 0xC0, 0x78, 0x1E, 0x00,
  0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0xF0, 0x06, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x03, 0x01,
  0x00, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x0E,
  0x60, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xF0, 0xC0, 0x78,
  0x1C, 0x60, 0x70, 0x03, 0x20, 0x70, 0x00, 0x70, 0x70, 0x00, 0x38, 0x30,
  0x00, 0x0C, 0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x08, 0x00, 0x01, 0x0C,
  0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30,
  0x80, 0x00, 0x18, 0xC0, 0x00, 0x08, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06,
  0x18, 0x00, 0x03, 0x04, 0x00, 0x03, 0x83, 0x00, 0x02, 0xC1, 0x80, 0x01,
  0xC0, 0x60, 0x01, 0x60, 0x38, 0x03, 0x30, 0x0F, 0x03, 0x98, 0x03, 0xFF,
  0x0C, 0x00, 0x7E, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x20,
  0x00, 0x60, 0x38, 0x00, 0xF0, 0x07, 0x01, 0xF0, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x07, 0xF0,
  0x0C, 0x3F, 0xE0, 0x33, 0x81, 0xC0, 0xC8, 0x03, 0x83, 0x40, 0x06, 0x0E,
  0x00, 0x0C, 0x68, 0x00, 0x31, 0xC0, 0x00, 0xC7, 0x00, 0x03, 0x18, 0x00,
  0x0C, 0x60, 0x00, 0x21, 0x80, 0x01, 0x84, 0x00, 0x06, 0x30, 0x00, 0x18,
  0xC0, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x04, 0x20, 0x00, 0x30, 0x80,
  0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x00,
  0x84, 0x00, 0x06, 0x10, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x80, 0xC0, 0x1C, 0x04, 0x01, 0xC0, 0x60, 0x38,
  0x03, 0x03, 0x80, 0x18, 0x78, 0x00, 0xC7, 0x00, 0x04, 0x70, 0x00, 0x6E,
  0x00, 0x03, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x04, 0x00, 0x60, 0x38, 0x01, 0x00, 0x70, 0x0C, 0x00,
  0xE0, 0x30, 0x01, 0xC0, 0xC0, 0x03, 0x83, 0x00, 0x07, 0x0C, 0x00, 0x0E,
  0x20, 0x00, 0x0D, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x81, 0xF8, 0x00,
  0xC3, 0xFF, 0x00, 0x67, 0x01, 0xC0, 0x36, 0x00, 0x60, 0x32, 0x00, 0x18,
  0x1A, 0x00, 0x0C, 0x0E, 0x00, 0x06, 0x07, 0x00, 0x03, 0x03, 0x00, 0x01,
  0x81, 0x80, 0x01, 0x81, 0x80, 0x01, 0xC0, 0xC0, 0x01, 0xC0, 0x60, 0x01,
  0xC0, 0x30, 0x03, 0x80, 0x18, 0x0F, 0x00, 0x0C, 0x3C, 0x00, 0x0C, 0x18,
  0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x09, 0x80, 0xC0, 0x06, 0xC0,
  0x60, 0x06, 0x60, 0x18, 0x06, 0x20, 0x0C, 0x06, 0x30, 0x03, 0x0E, 0x18,
  0x00, 0xCE, 0x0C, 0x00, 0x6E, 0x06, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x20, 0x60, 0x0F, 0x06, 0x01, 0xC0, 0x40, 0x38, 0x04, 0x0E, 0x00, 0xC1,
  0xC0, 0x0C, 0x78, 0x00, 0xCE, 0x00, 0x09, 0xC0, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x7C, 0x0F, 0x81, 0x9F, 0xC7, 0xF8, 0x36, 0x19, 0xC3,
  0x05, 0x01, 0xA0, 0x30, 0xA0, 0x38, 0x06, 0x38, 0x07, 0x00, 0xC6, 0x00,
  0xC0, 0x18, 0xC0, 0x18, 0x03, 0x18, 0x03, 0x00, 0x42, 0x00, 0x40, 0x08,
  0x40, 0x08, 0x03, 0x18, 0x03, 0x00, 0x63, 0x00, 0x60, 0x0C, 0x60, 0x0C,
  0x01, 0x8C, 0x01, 0x80, 0x21, 0x00, 0x20, 0x04, 0x20, 0x04, 0x01, 0x8C,
  0x01, 0x80, 0x31, 0x80, 0x30, 0x06, 0x30, 0x06, 0x00, 0xC6, 0x00, 0xC0,
  0x10, 0x80, 0x10, 0x02, 0x10, 0x06, 0x00, 0xC6, 0x00, 0xC0, 0x18, 0xC0,
  0x18, 0x03, 0x18, 0x03, 0x00, 0x63, 0x00, 0x60, 0x08, 0x00, 0x00, 0x1F,
  0xC0, 0x30, 0xFF, 0x80, 0xCE, 0x07, 0x03, 0x20, 0x0E, 0x0D, 0x00, 0x18,
  0x38, 0x00, 0x30, 0xA0, 0x00, 0xC7, 0x00, 0x03, 0x1C, 0x00, 0x0C, 0x60,
  0x00, 0x31, 0x80, 0x00, 0x86, 0x00, 0x06, 0x10, 0x00, 0x18, 0xC0, 0x00,
  0x63, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x10, 0x80, 0x00, 0xC2,
  0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00,
  0x02, 0x10, 0x00, 0x18, 0x40, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x06,
  0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0x03, 0xC0, 0x30, 0x01,
  0xC0, 0xC0, 0x01, 0x83, 0x00, 0x01, 0x8E, 0x00, 0x03, 0x18, 0x00, 0x02,
  0x30, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0,
  0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x66, 0x00, 0x00, 0xCC, 0x00,
  0x01, 0x98, 0x00, 0x06, 0x18, 0x00, 0x1C, 0x38, 0x00, 0x70, 0x38, 0x01,
  0xC0, 0x3C, 0x0F, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x01, 0x8F, 0xFE, 0x00, 0xCE, 0x07, 0x80, 0x6C, 0x00, 0xC0, 0x2C,
  0x00, 0x30, 0x34, 0x00, 0x18, 0x1C, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x06,
  0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30,
  0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x10, 0x00, 0x03,
  0x08, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x30, 0x68, 0x00,
  0x30, 0x36, 0x00, 0x38, 0x19, 0xC0, 0x78, 0x0C, 0x7F, 0xF0, 0x04, 0x0F,
  0xE0, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xC3,
  0x03, 0xC0, 0xE3, 0x07, 0x00, 0x32, 0x0E, 0x00, 0x1A, 0x1C, 0x00, 0x0E,
  0x18, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x04,
  0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C,
  0x40, 0x00, 0x0C, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x38, 0x40, 0x00, 0x38, 0x60, 0x00, 0x50,
  0x60, 0x00, 0x70, 0x30, 0x00, 0xB0, 0x38, 0x03, 0x30, 0x1E, 0x06, 0x30,
  0x0F, 0xFC, 0x30, 0x03, 0xF0, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC3, 0xFF, 0x00, 0x4E, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xD0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xF8, 0x03, 0xC0, 0x3C,
  0x07, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x0C, 0x00, 0x02, 0x0C, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x0C,
  0x60, 0x00, 0x18, 0x78, 0x00, 0x38, 0x1E, 0x00, 0xF0, 0x0F, 0xFF, 0xC0,
  0x01, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x0C, 0x01, 0x00, 0x3C, 0x03, 0x00, 0x70, 0x03, 0x01, 0xC0,
  0x03, 0x07, 0x80, 0x03, 0x0E, 0x00, 0x02, 0x3C, 0x00, 0x02, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x08, 0xC0, 0x00, 0xC4,
  0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00,
  0x44, 0x00, 0x06, 0x20, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0,
  0x00, 0x66, 0x00, 0x02, 0x20, 0x00, 0x31, 0x00, 0x01, 0x98, 0x00, 0x0C,
  0xC0, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00,
  0x1C, 0x60, 0x01, 0x63, 0x00, 0x1B, 0x0C, 0x01, 0x98, 0x78, 0x38, 0x81,
  0xFF, 0x8C, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0D, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x80,
  0x01, 0x81, 0x00, 0x03, 0x02, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00,
  0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0xC0, 0x80, 0x01, 0x81, 0x00, 0x03,
  0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x60, 0x30, 0x01, 0xC0,
  0x60, 0x07, 0x00, 0x80, 0x0C, 0x01, 0x00, 0x70, 0x06, 0x01, 0xC0, 0x0C,
  0x0F, 0x00, 0x18, 0x7C, 0x00, 0x3F, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x08,
  0x03, 0x01, 0x02, 0x00, 0xC0, 0x61, 0x80, 0x30, 0x18, 0x60, 0x0C, 0x02,
  0x18, 0x02, 0x00, 0xC6, 0x01, 0x80, 0x31, 0x00, 0x60, 0x0C, 0x40, 0x18,
  0x03, 0x30, 0x06, 0x00, 0xCC, 0x01, 0x80, 0x33, 0x00, 0x40, 0x0C, 0xC0,
  0x30, 0x03, 0x20, 0x0C, 0x00, 0xC8, 0x03, 0x00, 0x36, 0x00, 0xC0, 0x09,
  0x80, 0x30, 0x02, 0x60, 0x08, 0x01, 0x98, 0x06, 0x00, 0x64, 0x01, 0x80,
  0x19, 0x00, 0x60, 0x0C, 0xC0, 0x18, 0x03, 0x30, 0x0E, 0x01, 0x8C, 0x02,
  0x80, 0x63, 0x01, 0x20, 0x30, 0x61, 0xCC, 0x38, 0x1F, 0xE1, 0xFC, 0x01,
  0xE0, 0x3E, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x07, 0xC0, 0x7F, 0x00, 0xF3,
  0x07, 0x1C, 0x1E, 0x18, 0x60, 0x61, 0xC0, 0x66, 0x01, 0xB8, 0x03, 0x20,
  0x0C, 0x00, 0x1B, 0x00, 0x60, 0x00, 0x50, 0x03, 0x00, 0x02, 0x80, 0x18,
  0x00, 0x14, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x30, 0x02, 0x80, 0x01,
  0x80, 0x14, 0x00, 0x0C, 0x01, 0xA0, 0x00, 0x60, 0x09, 0x00, 0x13, 0x00,
  0xCC, 0x03, 0x98, 0x04, 0x60, 0x70, 0xC0, 0x61, 0x87, 0x03, 0x0E, 0x0C,
  0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x01,
  0x03, 0x00, 0x03, 0x02, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03,
  0x06, 0x00, 0x03, 0x06, 0x00, 0x02, 0x04, 0x00, 0x06, 0x04, 0x00, 0x06,
  0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x04,
  0x08, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C,
  0x18, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x18, 0x00, 0x38, 0x18, 0x00, 0x58,
  0x18, 0x00, 0xD8, 0x0C, 0x01, 0x98, 0x0F, 0x07, 0x18, 0x07, 0xFE, 0x30,
  0x01, 0xF8, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x40, 0x01, 0xC0,
  0xE0, 0x03, 0x80, 0x78, 0x0F, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0xC3, 0x81, 0xF0, 0x63, 0x00, 0x1F,
  0x21, 0x80, 0x01, 0xF0, 0x80, 0x00, 0x30, 0x40, 0x00, 0x30, 0x20, 0x00,
  0x30, 0x30, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x01,
  0xC0, 0x01, 0x01, 0xC0, 0x00, 0x81, 0x80, 0x00, 0x41, 0xC0, 0x00, 0x31,
  0xFF, 0x00, 0x18, 0xC7, 0xF8, 0x0C, 0x60, 0x1F, 0xE2, 0x20, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x60,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x04, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x04, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x0C, 0x06, 0x00, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0xC3, 0xF8, 0x00, 0x21, 0xC7, 0x00, 0x18, 0xC0, 0xE0, 0x06, 0x30,
  0x18, 0x03, 0x18, 0x03, 0x00, 0xC4, 0x00, 0x60, 0x63, 0x00, 0x1C, 0x30,
  0xC0, 0x03, 0xFC, 0x20, 0x00, 0x3C, 0x00,
};

const GFXglyph IBMPlexMono_ExtraLightItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 9, 36, 31, 11, -36 },
  { 42, 11, 13, 31, 13, -38 },
  { 60, 30, 36, 31, 1, -36 },
  { 195, 27, 47, 31, 2, -41 },
  { 354, 34, 37, 31, -1, -36 },
  { 512, 29, 37, 31, 1, -36 },
  { 647, 4, 13, 31, 16, -38 },
  { 654, 16, 46, 31, 12, -39 },
  { 746, 17, 46, 31, 3, -39 },
  { 844, 26, 25, 31, 3, -28 },
  { 926, 25, 26, 31, 3, -29 },
  { 1008, 8, 13, 31, 8, -5 },
  { 1021, 14, 2, 31, 9, -17 },
  { 1025, 5, 4, 31, 11, -4 },
  { 1028, 27, 46, 31, 2, -39 },
  { 1184, 24, 37, 31, 4, -36 },
  { 1295, 24, 36, 31, 2, -36 },
  { 1403, 25, 36, 31, 2, -36 },
  { 1516, 25, 37, 31, 2, -36 },
  { 1632, 27, 36, 31, 1, -36 },
  { 1754, 25, 37, 31, 3, -36 },
  { 1870, 22, 37, 31, 4, -36 },
  { 1972, 24, 36, 31, 6, -36 },
  { 2080, 25, 37, 31, 3, -36 },
  { 2196, 23, 36, 31, 5, -36 },
  { 2300, 8, 27, 31, 11, -27 },
  { 2327, 11, 35, 31, 8, -27 },
  { 2376, 24, 28, 31, 5, -30 },
  { 2460, 26, 11, 31, 3, -21 },
  { 2496, 25, 28, 31, 2, -30 },
  { 2584, 21, 36, 31, 7, -36 },
  { 2679, 24, 41, 31, 4, -36 },
  { 2802, 26, 36, 31, 0, -36 },
  { 2919, 24, 36, 31, 3, -36 },
  { 3027, 25, 37, 31, 4, -36 },
  { 3143, 25, 36, 31, 3, -36 },
  { 3256, 27, 36, 31, 3, -36 },
  { 3378, 27, 36, 31, 3, -36 },
  { 3500, 25, 37, 31, 4, -36 },
  { 3616, 27, 36, 31, 3, -36 },
  { 3738, 28, 36, 31, 2, -36 },
  { 3864, 23, 37, 31, 4, -36 },
  { 3971, 29, 36, 31, 3, -36 },
  { 4102, 20, 36, 31, 5, -36 },
  { 4192, 28, 36, 31, 2, -36 },
  { 4318, 27, 36, 31, 3, -36 },
  { 4440, 24, 37, 31, 4, -36 },
  { 4551, 26, 36, 31, 3, -36 },
  { 4668, 24, 45, 31, 4, -36 },
  { 4803, 26, 36, 31, 3, -36 },
  { 4920, 27, 37, 31, 2, -36 },
  { 5045, 27, 36, 31, 5, -36 },
  { 5167, 26, 37, 31, 4, -36 },
  { 5288, 26, 36, 31, 6, -36 },
  { 5405, 28, 36, 31, 4, -36 },
  { 5531, 32, 36, 31, 0, -36 },
  { 5675, 28, 36, 31, 5, -36 },
  { 5801, 31, 36, 31, 0, -36 },
  { 5941, 20, 46, 31, 10, -39 },
  { 6056, 12, 46, 31, 10, -39 },
  { 6125, 21, 46, 31, 1, -39 },
  { 6246, 24, 20, 31, 4, -36 },
  { 6306, 24, 2, 31, 0, 6 },
  { 6312, 6, 9, 31, 12, -39 },
  { 6319, 24, 28, 31, 3, -27 },
  { 6403, 23, 39, 31, 4, -38 },
  { 6516, 22, 28, 31, 4, -27 },
  { 6593, 26, 39, 31, 3, -38 },
  { 6720, 22, 28, 31, 4, -27 },
  { 6797, 33, 49, 31, -1, -38 },
  { 7000, 25, 38, 31, 2, -27 },
  { 7119, 22, 38, 31, 4, -38 },
  { 7224, 21, 39, 31, 5, -38 },
  { 7327, 22, 49, 31, 5, -38 },
  { 7462, 25, 39, 31, 4, -38 },
  { 7584, 20, 39, 31, 6, -38 },
  { 7682, 27, 27, 31, 2, -27 },
  { 7774, 22, 27, 31, 4, -27 },
  { 7849, 23, 28, 31, 4, -27 },
  { 7930, 25, 37, 31, 2, -27 },
  { 8046, 24, 37, 31, 3, -27 },
  { 8157, 24, 26, 31, 6, -26 },
  { 8235, 24, 28, 31, 3, -27 },
  { 8319, 24, 37, 31, 4, -36 },
  { 8430, 21, 27, 31, 5, -26 },
  { 8501, 23, 27, 31, 4, -27 },
  { 8579, 26, 27, 31, 3, -26 },
  { 8667, 29, 28, 31, 1, -27 },
  { 8769, 24, 37, 31, 2, -26 },
  { 8880, 25, 28, 31, 3, -27 },
  { 8968, 23, 46, 31, 6, -39 },
  { 9101, 9, 46, 31, 11, -39 },
  { 9153, 23, 46, 31, 2, -39 },
  { 9286, 26, 10, 31, 3, -20 },
};

const GFXfont IBMPlexMono_ExtraLightItalic51pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic51pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic51pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC51PT7B_H_
