#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC27PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0x84, 0x21, 0x08, 0x84, 0x21, 0x08, 0x84, 0x00, 0x00, 0x06,
  0x30, 0x45, 0x28, 0xA2, 0x8A, 0x28, 0x80, 0x00, 0x46, 0x00, 0x42, 0x00,
  0x21, 0x00, 0x11, 0x00, 0x10, 0x80, 0x08, 0x40, 0xFC, 0x7E, 0x04, 0x20,
  0x02, 0x10, 0x01, 0x10, 0x01, 0x08, 0x00, 0x84, 0x07, 0xC7, 0xE4, 0x42,
  0x00, 0x21, 0x00, 0x11, 0x00, 0x10, 0x80, 0x08, 0x40, 0x0C, 0x40, 0x00,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x01, 0xFC, 0x0C, 0x98, 0x42, 0x12, 0x08,
  0x08, 0x20, 0x21, 0x00, 0x84, 0x01, 0x10, 0x03, 0x40, 0x03, 0xC0, 0x04,
  0xC0, 0x21, 0x00, 0x82, 0x02, 0x08, 0x08, 0x28, 0x21, 0x30, 0x84, 0x64,
  0x60, 0x7E, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x07, 0x00, 0xC6, 0x20,
  0x41, 0x04, 0x10, 0x81, 0x08, 0x20, 0x44, 0x08, 0x12, 0x02, 0x08, 0x80,
  0xC6, 0x40, 0x1E, 0x20, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x19, 0x18, 0x08,
  0x82, 0x02, 0x40, 0x81, 0x10, 0x20, 0x84, 0x08, 0x41, 0x04, 0x10, 0x23,
  0x08, 0x07, 0x00, 0x03, 0xE0, 0x04, 0x30, 0x0C, 0x10, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x10, 0x04, 0x10, 0x02, 0x20, 0x3F, 0xC0, 0x61,
  0x00, 0x41, 0x00, 0x80, 0x80, 0x80, 0x40, 0x80, 0x41, 0x80, 0xA2, 0x40,
  0x92, 0x61, 0x14, 0x1E, 0x0C, 0x5A, 0xA8, 0x01, 0x81, 0x01, 0x01, 0x01,
  0x00, 0x80, 0x80, 0x40, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x18, 0x00,
  0x08, 0x02, 0x00, 0x80, 0x40, 0x20, 0x08, 0x04, 0x02, 0x01, 0x00, 0x40,
  0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0x80, 0x80,
  0x80, 0x40, 0x40, 0xC0, 0x00, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x71, 0x1C, 0x7F, 0x00, 0xC0, 0x0F, 0x00, 0x48, 0x04, 0x20, 0x41,
  0x04, 0x04, 0x00, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x03, 0xFF, 0xE0, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x00, 0x33, 0x24, 0x48, 0xFE, 0xF0, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x80, 0x00, 0x07, 0xC0, 0x61, 0x84, 0x04, 0x40, 0x12,
  0x00, 0xA0, 0x05, 0x00, 0x28, 0x01, 0x82, 0x0C, 0x30, 0x60, 0x03, 0x00,
  0x28, 0x01, 0x40, 0x0A, 0x00, 0x90, 0x04, 0x40, 0x43, 0x0C, 0x07, 0xC0,
  0x00, 0xC0, 0x0A, 0x01, 0x90, 0x18, 0x81, 0x88, 0x10, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x02, 0x00, 0x10, 0x3F, 0xFE, 0x03, 0xE0, 0x30, 0x40, 0x80,
  0x84, 0x02, 0x20, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xE0, 0x60, 0xC4, 0x02, 0x20, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x60, 0x06, 0x07, 0xC0, 0x03, 0x00, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x50, 0x02, 0xC0, 0x23, 0x06, 0x07, 0xE0,
  0x00, 0x18, 0x00, 0xA0, 0x07, 0x00, 0x14, 0x00, 0x90, 0x04, 0x40, 0x21,
  0x01, 0x04, 0x08, 0x20, 0x20, 0x81, 0x02, 0x08, 0x08, 0x40, 0x22, 0x00,
  0x8F, 0xFF, 0xC0, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x1F, 0xF8,
  0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x05, 0xF0, 0x50,
  0x63, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x90, 0x04,
  0x80, 0x43, 0x04, 0x0F, 0xC0, 0x00, 0x60, 0x18, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x02, 0xF8, 0x50, 0x66, 0x02, 0xC0, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x02, 0x40, 0x66, 0x0C, 0x1F, 0x00, 0x7F, 0xFA,
  0x00, 0xA0, 0x05, 0x00, 0x48, 0x02, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01,
  0x00, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x01, 0x00, 0x10, 0x00, 0x03, 0xF0, 0x30, 0x60, 0x80, 0x44, 0x01,
  0x10, 0x04, 0x40, 0x11, 0x00, 0x44, 0x02, 0x08, 0x30, 0x1F, 0x01, 0x83,
  0x08, 0x06, 0x40, 0x09, 0x00, 0x28, 0x00, 0x90, 0x02, 0x40, 0x10, 0x81,
  0x81, 0xF8, 0x00, 0x0F, 0x83, 0x04, 0x40, 0x24, 0x02, 0x80, 0x18, 0x01,
  0x80, 0x38, 0x02, 0x80, 0x28, 0x06, 0x61, 0xC3, 0xE4, 0x00, 0x80, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x60, 0x00, 0x33, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xCC, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x30, 0xC2, 0x10, 0x42, 0x00, 0x00, 0x08, 0x00, 0x80, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x00, 0x80, 0x18, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x30, 0x06, 0x00, 0x40, 0x0C,
  0x01, 0x80, 0x30, 0x02, 0x00, 0x00, 0x1F, 0x04, 0x19, 0x01, 0x40, 0x18,
  0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x81, 0xE0, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x61,
  0x84, 0x04, 0x20, 0x12, 0x00, 0x90, 0x05, 0x07, 0x48, 0x46, 0x44, 0x12,
  0x20, 0x92, 0x05, 0x10, 0x28, 0x82, 0x44, 0x12, 0x20, 0x90, 0x9C, 0x83,
  0x04, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x0F, 0xC0, 0x00, 0x60, 0x01,
  0x80, 0x0A, 0x00, 0x28, 0x01, 0x20, 0x04, 0x40, 0x21, 0x00, 0x84, 0x04,
  0x10, 0x10, 0x40, 0x81, 0x02, 0x02, 0x1F, 0xF8, 0x40, 0x22, 0x00, 0x88,
  0x02, 0x40, 0x09, 0x00, 0x18, 0x00, 0x40, 0x1F, 0xE1, 0x01, 0x88, 0x04,
  0x40, 0x22, 0x00, 0x90, 0x08, 0x80, 0x48, 0x02, 0x40, 0x63, 0xFC, 0x10,
  0x18, 0x80, 0x64, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x06, 0x80, 0x24, 0x02,
  0x3F, 0xE0, 0x03, 0xE0, 0x61, 0x86, 0x06, 0x20, 0x12, 0x00, 0x10, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x48, 0x04, 0x40, 0x41, 0x06, 0x07, 0xC0, 0x1F, 0xC0, 0x81,
  0x08, 0x04, 0x40, 0x32, 0x00, 0x90, 0x04, 0x80, 0x24, 0x01, 0x40, 0x0A,
  0x00, 0x50, 0x02, 0x80, 0x24, 0x01, 0x20, 0x0A, 0x00, 0x90, 0x04, 0x80,
  0x44, 0x0C, 0x3F, 0xC0, 0x1F, 0xFC, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0xFF, 0xC4, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0xFF, 0xC4, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x00,
  0x03, 0xE0, 0x61, 0x84, 0x06, 0x60, 0x12, 0x00, 0x30, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x06, 0x00, 0x20, 0x7D, 0x04, 0x28, 0x01, 0x40, 0x0A, 0x00,
  0x88, 0x04, 0x40, 0x61, 0x05, 0x07, 0xC8, 0x10, 0x02, 0x20, 0x08, 0x40,
  0x10, 0x80, 0x21, 0x00, 0x42, 0x00, 0x88, 0x01, 0x10, 0x04, 0x20, 0x08,
  0x7F, 0xF0, 0x80, 0x21, 0x00, 0x44, 0x00, 0x88, 0x02, 0x10, 0x04, 0x20,
  0x08, 0x40, 0x10, 0x80, 0x22, 0x00, 0x40, 0x1F, 0xFE, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x10, 0x08, 0x80, 0x82, 0x08,
  0x0F, 0x80, 0x10, 0x06, 0x20, 0x10, 0x80, 0x41, 0x01, 0x02, 0x04, 0x04,
  0x10, 0x08, 0x40, 0x11, 0x00, 0x46, 0x00, 0x94, 0x01, 0x44, 0x03, 0x08,
  0x04, 0x08, 0x08, 0x10, 0x20, 0x30, 0x40, 0x20, 0x80, 0x61, 0x00, 0x42,
  0x00, 0xC0, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x0F, 0xFC, 0x18, 0x06, 0x30, 0x0C, 0x60, 0x29, 0x40, 0x62, 0x41, 0x44,
  0x86, 0x89, 0x09, 0x12, 0x22, 0x22, 0x44, 0x45, 0x11, 0x0A, 0x22, 0x08,
  0x44, 0x20, 0x88, 0x01, 0x10, 0x02, 0x20, 0x08, 0x80, 0x11, 0x00, 0x22,
  0x00, 0x40, 0x18, 0x02, 0x30, 0x08, 0x50, 0x10, 0xA0, 0x21, 0x40, 0x42,
  0x40, 0x88, 0x81, 0x11, 0x04, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x04,
  0x44, 0x08, 0x88, 0x12, 0x10, 0x14, 0x20, 0x28, 0x40, 0x50, 0x80, 0x62,
  0x00, 0xC0, 0x07, 0xC0, 0x61, 0x84, 0x04, 0x40, 0x12, 0x00, 0xA0, 0x05,
  0x00, 0x28, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x28, 0x01, 0x40,
  0x0A, 0x00, 0x90, 0x04, 0x40, 0x43, 0x0C, 0x07, 0xC0, 0x1F, 0xE0, 0x40,
  0x62, 0x00, 0x88, 0x02, 0x20, 0x04, 0x80, 0x22, 0x00, 0x88, 0x02, 0x40,
  0x19, 0x00, 0xC7, 0xFC, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x00, 0x07, 0xC0, 0x61, 0x84, 0x04,
  0x40, 0x12, 0x00, 0xA0, 0x05, 0x00, 0x28, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x90, 0x04, 0x40, 0x43, 0x0C,
  0x07, 0xC0, 0x08, 0x00, 0x21, 0x01, 0x10, 0x05, 0x00, 0x30, 0x1F, 0xE0,
  0x40, 0x62, 0x00, 0x88, 0x02, 0x20, 0x04, 0x80, 0x22, 0x00, 0x88, 0x02,
  0x40, 0x19, 0x00, 0xC7, 0xFC, 0x10, 0x80, 0x41, 0x01, 0x04, 0x08, 0x08,
  0x20, 0x20, 0x80, 0x42, 0x01, 0x08, 0x02, 0x00, 0x07, 0xF0, 0x30, 0x61,
  0x00, 0x48, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x0F, 0x00, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0xA0, 0x04,
  0xC0, 0x11, 0x81, 0x81, 0xF8, 0x00, 0xFF, 0xFC, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x80, 0x00, 0x20, 0x04, 0x80, 0x22, 0x00, 0x88, 0x02, 0x20,
  0x08, 0x80, 0x24, 0x00, 0x90, 0x04, 0x40, 0x11, 0x00, 0x44, 0x01, 0x10,
  0x04, 0x80, 0x32, 0x00, 0x88, 0x02, 0x20, 0x08, 0x40, 0x41, 0x82, 0x03,
  0xF0, 0x00, 0x80, 0x0D, 0x00, 0x24, 0x00, 0x90, 0x04, 0x40, 0x11, 0x00,
  0x84, 0x02, 0x10, 0x10, 0x20, 0x40, 0x82, 0x02, 0x08, 0x08, 0x40, 0x21,
  0x00, 0x88, 0x01, 0x20, 0x05, 0x00, 0x14, 0x00, 0x60, 0x01, 0x80, 0x00,
  0x40, 0x02, 0x80, 0x09, 0x00, 0x12, 0x00, 0x24, 0x00, 0x48, 0x01, 0x10,
  0xC2, 0x21, 0x84, 0x45, 0x08, 0x8A, 0x21, 0x24, 0x44, 0x48, 0x89, 0x11,
  0x12, 0x14, 0x24, 0x28, 0x50, 0x50, 0xA0, 0xA1, 0x81, 0x83, 0x03, 0x00,
  0x18, 0x01, 0x84, 0x01, 0x81, 0x00, 0x80, 0x80, 0x80, 0x20, 0x80, 0x10,
  0x80, 0x04, 0xC0, 0x02, 0x40, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x50, 0x00,
  0x48, 0x00, 0x62, 0x00, 0x21, 0x00, 0x20, 0x40, 0x20, 0x20, 0x20, 0x08,
  0x20, 0x04, 0x30, 0x01, 0x00, 0x80, 0x07, 0x00, 0x11, 0x00, 0x62, 0x00,
  0x82, 0x02, 0x04, 0x08, 0x04, 0x20, 0x08, 0xC0, 0x09, 0x00, 0x14, 0x00,
  0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x60, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x40, 0x00, 0xFF, 0xFC, 0x0F, 0xE1, 0x00, 0x20, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x20, 0x04, 0x00, 0xFE, 0x00, 0x81, 0x01, 0x02, 0x04, 0x08, 0x10,
  0x10, 0x20, 0x40, 0x80, 0x81, 0x02, 0x04, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x40, 0x81, 0x02, 0x02, 0x0F, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0xFC, 0x00,
  0x01, 0x80, 0x1C, 0x00, 0x90, 0x08, 0x80, 0x82, 0x0C, 0x10, 0x40, 0x84,
  0x02, 0x40, 0x14, 0x00, 0x40, 0xFF, 0xF8, 0x89, 0x12, 0x0F, 0x93, 0x05,
  0x20, 0x34, 0x03, 0x40, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x06,
  0x80, 0x48, 0x0C, 0x61, 0x43, 0xE7, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x02, 0x00, 0x27, 0xC2, 0x82, 0x30, 0x12, 0x01, 0x20, 0x14, 0x01,
  0x40, 0x14, 0x01, 0x40, 0x14, 0x01, 0x40, 0x2C, 0x06, 0xA0, 0xC9, 0xF0,
  0x07, 0x81, 0x86, 0x20, 0x24, 0x03, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x02, 0x80, 0x24, 0x04, 0x61, 0x81, 0xE0, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x3E, 0x46, 0x0A, 0x20, 0x32,
  0x00, 0x90, 0x09, 0x00, 0x48, 0x02, 0x40, 0x12, 0x00, 0x90, 0x0C, 0x80,
  0x44, 0x06, 0x18, 0x50, 0x7C, 0x80, 0x07, 0xC1, 0x82, 0x20, 0x14, 0x01,
  0x40, 0x14, 0x02, 0x81, 0xCF, 0xC0, 0x80, 0x08, 0x00, 0x80, 0x24, 0x04,
  0x60, 0xC1, 0xF0, 0x00, 0x3F, 0x80, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x3F, 0xFC, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x10, 0x40, 0x0C, 0x20, 0x03,
  0x10, 0x00, 0xC8, 0x00, 0x34, 0x00, 0x04, 0x00, 0x00, 0x07, 0xC8, 0xC1,
  0x44, 0x06, 0x40, 0x12, 0x01, 0x20, 0x09, 0x00, 0x48, 0x02, 0x40, 0x12,
  0x01, 0x90, 0x08, 0x80, 0xC3, 0x0A, 0x0F, 0x90, 0x00, 0x80, 0x08, 0x80,
  0x42, 0x0C, 0x0F, 0xC0, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x23, 0xC2, 0x42, 0x38, 0x23, 0x01, 0x20, 0x12, 0x02, 0x40, 0x24,
  0x02, 0x40, 0x24, 0x02, 0x40, 0x24, 0x04, 0x80, 0x48, 0x04, 0x01, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x20, 0x83, 0x08, 0xC0,
  0x90, 0x0E, 0x01, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x41, 0x0C, 0x20, 0xC4, 0x0C, 0x80,
  0xD0, 0x04, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10,
  0x00, 0x8F, 0x05, 0x84, 0x30, 0x11, 0x00, 0x88, 0x08, 0x80, 0x44, 0x0C,
  0x23, 0x81, 0x30, 0x08, 0x81, 0x42, 0x1C, 0x11, 0xA0, 0x51, 0x03, 0x00,
  0xFE, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x10, 0x87, 0x11, 0x84,
  0xC0, 0xB0, 0x18, 0x00, 0x27, 0x38, 0xE5, 0x12, 0x18, 0x48, 0x21, 0x41,
  0x05, 0x04, 0x14, 0x10, 0x50, 0x41, 0x41, 0x09, 0x08, 0x28, 0x20, 0xA0,
  0x82, 0x82, 0x0A, 0x08, 0x20, 0x23, 0xC2, 0x42, 0x38, 0x23, 0x01, 0x20,
  0x12, 0x02, 0x40, 0x24, 0x02, 0x40, 0x24, 0x02, 0x40, 0x24, 0x04, 0x80,
  0x48, 0x04, 0x0F, 0x81, 0x86, 0x20, 0x34, 0x01, 0x40, 0x1C, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x02, 0x80, 0x24, 0x04, 0x60, 0x81, 0xF0, 0x13,
  0xE0, 0xA0, 0x86, 0x02, 0x20, 0x11, 0x00, 0x90, 0x04, 0x80, 0x24, 0x01,
  0x20, 0x09, 0x00, 0x48, 0x04, 0xC0, 0x65, 0x06, 0x27, 0xC1, 0x00, 0x08,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x0F, 0x93, 0x05, 0x20, 0x34, 0x01,
  0x40, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x06, 0x80, 0x48, 0x0C,
  0x61, 0x43, 0xE4, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0xFC,
  0xF8, 0x38, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x0F, 0xC3,
  0x03, 0x20, 0x14, 0x00, 0x20, 0x02, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x20,
  0x02, 0x00, 0x28, 0x02, 0x60, 0x43, 0xF8, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x08, 0x00, 0x40, 0x7F, 0xFC, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0xC2, 0x18, 0x11, 0x00, 0xB0,
  0x06, 0x00, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x28, 0x05, 0x00, 0xA0, 0x14,
  0x02, 0x80, 0x50, 0x12, 0x02, 0x41, 0xCC, 0x28, 0xF9, 0x00, 0xF8, 0x11,
  0x01, 0x10, 0x11, 0x01, 0x10, 0x11, 0x01, 0x10, 0x12, 0x01, 0x20, 0x22,
  0x06, 0x20, 0x42, 0x18, 0x27, 0x03, 0xC0, 0x41, 0x0A, 0x08, 0x50, 0x42,
  0x82, 0x14, 0x20, 0xA1, 0x06, 0x08, 0x30, 0x41, 0x82, 0x0C, 0x10, 0x61,
  0x05, 0x18, 0x28, 0xA2, 0x38, 0xE0, 0x0C, 0x3C, 0x64, 0xC9, 0x0A, 0x0C,
  0x0C, 0x10, 0x10, 0x20, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x01, 0x06,
  0x02, 0x14, 0x14, 0x28, 0x48, 0x93, 0x0E, 0x18, 0x00, 0x10, 0x08, 0x80,
  0x44, 0x02, 0x20, 0x22, 0x01, 0x10, 0x08, 0x80, 0x44, 0x02, 0x20, 0x11,
  0x01, 0x08, 0x08, 0x41, 0xC3, 0x0A, 0x0F, 0x10, 0x01, 0x80, 0x08, 0x80,
  0xC6, 0x0C, 0x0F, 0x80, 0x0F, 0x84, 0x43, 0xD2, 0x01, 0x88, 0x04, 0x20,
  0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x20, 0x60, 0x42, 0x01, 0x1C,
  0x04, 0x5F, 0x92, 0x07, 0xC0, 0x03, 0xF0, 0x20, 0x02, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x60, 0xF8,
  0x00, 0xC0, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x3F, 0x00, 0x08, 0x44, 0x21, 0x08, 0x42,
  0x21, 0x08, 0x42, 0x11, 0x08, 0x42, 0x10, 0x88, 0x42, 0x10, 0x80, 0x0F,
  0xC0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x30, 0x00, 0xF0, 0x30, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0xFC,
  0x00, 0x1C, 0x04, 0x88, 0x14, 0x10, 0x90, 0x66, 0x80, 0xF0,
};

const GFXglyph IBMPlexMono_ExtraLightItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 5, 19, 16, 6, -19 },
  { 13, 6, 7, 16, 7, -20 },
  { 19, 17, 19, 16, 0, -19 },
  { 60, 14, 25, 16, 1, -22 },
  { 104, 18, 19, 16, 0, -19 },
  { 147, 16, 19, 16, 0, -19 },
  { 185, 2, 7, 16, 9, -20 },
  { 187, 9, 25, 16, 6, -21 },
  { 216, 9, 25, 16, 2, -21 },
  { 245, 13, 13, 16, 2, -15 },
  { 267, 13, 13, 16, 2, -15 },
  { 289, 4, 6, 16, 4, -2 },
  { 292, 7, 1, 16, 5, -9 },
  { 293, 2, 2, 16, 6, -2 },
  { 294, 15, 25, 16, 1, -21 },
  { 341, 13, 19, 16, 2, -19 },
  { 372, 13, 19, 16, 1, -19 },
  { 403, 14, 19, 16, 1, -19 },
  { 437, 13, 19, 16, 1, -19 },
  { 468, 14, 19, 16, 1, -19 },
  { 502, 13, 19, 16, 2, -19 },
  { 533, 12, 19, 16, 2, -19 },
  { 562, 13, 19, 16, 3, -19 },
  { 593, 14, 19, 16, 1, -19 },
  { 627, 12, 19, 16, 3, -19 },
  { 656, 4, 14, 16, 6, -14 },
  { 663, 6, 18, 16, 4, -14 },
  { 677, 13, 15, 16, 2, -16 },
  { 702, 14, 6, 16, 1, -11 },
  { 713, 13, 15, 16, 1, -16 },
  { 738, 11, 19, 16, 4, -19 },
  { 765, 13, 22, 16, 2, -19 },
  { 801, 14, 19, 16, 0, -19 },
  { 835, 13, 19, 16, 2, -19 },
  { 866, 13, 19, 16, 2, -19 },
  { 897, 13, 19, 16, 2, -19 },
  { 928, 14, 19, 16, 2, -19 },
  { 962, 14, 19, 16, 2, -19 },
  { 996, 13, 19, 16, 2, -19 },
  { 1027, 15, 19, 16, 1, -19 },
  { 1063, 15, 19, 16, 1, -19 },
  { 1099, 13, 19, 16, 2, -19 },
  { 1130, 15, 19, 16, 2, -19 },
  { 1166, 10, 19, 16, 3, -19 },
  { 1190, 15, 19, 16, 1, -19 },
  { 1226, 15, 19, 16, 1, -19 },
  { 1262, 13, 19, 16, 2, -19 },
  { 1293, 14, 19, 16, 2, -19 },
  { 1327, 13, 24, 16, 2, -19 },
  { 1366, 14, 19, 16, 2, -19 },
  { 1400, 14, 19, 16, 1, -19 },
  { 1434, 14, 19, 16, 3, -19 },
  { 1468, 14, 19, 16, 2, -19 },
  { 1502, 14, 19, 16, 3, -19 },
  { 1536, 15, 19, 16, 2, -19 },
  { 1572, 17, 19, 16, 0, -19 },
  { 1613, 15, 19, 16, 3, -19 },
  { 1649, 16, 19, 16, 0, -19 },
  { 1687, 11, 25, 16, 5, -21 },
  { 1722, 7, 25, 16, 5, -21 },
  { 1744, 10, 25, 16, 1, -21 },
  { 1776, 13, 10, 16, 2, -19 },
  { 1793, 13, 1, 16, 0, 3 },
  { 1795, 3, 5, 16, 6, -21 },
  { 1797, 12, 14, 16, 2, -14 },
  { 1818, 12, 20, 16, 2, -20 },
  { 1848, 12, 14, 16, 2, -14 },
  { 1869, 13, 20, 16, 2, -20 },
  { 1902, 12, 14, 16, 2, -14 },
  { 1923, 17, 25, 16, 0, -20 },
  { 1977, 13, 19, 16, 1, -14 },
  { 2008, 12, 20, 16, 2, -20 },
  { 2038, 12, 20, 16, 2, -20 },
  { 2068, 11, 25, 16, 3, -20 },
  { 2103, 13, 20, 16, 2, -20 },
  { 2136, 11, 20, 16, 3, -20 },
  { 2164, 14, 14, 16, 1, -14 },
  { 2189, 12, 14, 16, 2, -14 },
  { 2210, 12, 14, 16, 2, -14 },
  { 2231, 13, 19, 16, 1, -14 },
  { 2262, 12, 19, 16, 2, -14 },
  { 2291, 13, 14, 16, 3, -14 },
  { 2314, 12, 14, 16, 2, -14 },
  { 2335, 13, 19, 16, 2, -19 },
  { 2366, 11, 14, 16, 3, -14 },
  { 2386, 12, 14, 16, 2, -14 },
  { 2407, 13, 14, 16, 2, -14 },
  { 2430, 15, 14, 16, 1, -14 },
  { 2457, 13, 19, 16, 1, -14 },
  { 2488, 14, 14, 16, 1, -14 },
  { 2513, 12, 25, 16, 3, -21 },
  { 2551, 5, 25, 16, 6, -21 },
  { 2567, 12, 25, 16, 1, -21 },
  { 2605, 14, 5, 16, 1, -11 },
};

const GFXfont IBMPlexMono_ExtraLightItalic27pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic27pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic27pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC27PT7B_H_
