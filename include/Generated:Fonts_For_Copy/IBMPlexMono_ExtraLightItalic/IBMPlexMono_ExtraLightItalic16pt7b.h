#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC16PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x94, 0x92, 0x03, 0x00, 0xBA, 0xAA, 0x05, 0x82, 0x40, 0x91,
  0xE7, 0x12, 0x04, 0x81, 0x43, 0x9E, 0x24, 0x0A, 0x04, 0x80, 0x08, 0x08,
  0x3E, 0x49, 0x48, 0x48, 0x70, 0x1C, 0x12, 0x12, 0x92, 0xA2, 0x7C, 0x20,
  0x20, 0x38, 0x51, 0x24, 0x51, 0x24, 0x3A, 0x00, 0x01, 0x70, 0xA2, 0x48,
  0xA2, 0x28, 0x70, 0x1E, 0x11, 0x08, 0x44, 0x41, 0x23, 0xE2, 0x21, 0x08,
  0x84, 0xC5, 0x5E, 0x40, 0xF0, 0x19, 0x11, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x20, 0x20, 0x82, 0x10, 0x84, 0x21, 0x08, 0x84, 0x44, 0x40, 0x08,
  0x08, 0x10, 0xD7, 0x38, 0x28, 0x48, 0x84, 0x08, 0x08, 0x10, 0x10, 0xFF,
  0x10, 0x10, 0x10, 0x10, 0x29, 0x40, 0xF0, 0xC0, 0x01, 0x02, 0x02, 0x04,
  0x04, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x80, 0x80, 0x1E, 0x21,
  0x41, 0x81, 0x81, 0x99, 0x81, 0x82, 0x82, 0x84, 0x78, 0x0C, 0x30, 0xA2,
  0x40, 0x81, 0x04, 0x08, 0x10, 0x23, 0xF8, 0x1E, 0x22, 0x41, 0x01, 0x02,
  0x04, 0x08, 0x10, 0x20, 0xC0, 0xFE, 0x1E, 0x22, 0x43, 0x02, 0x3C, 0x04,
  0x02, 0x02, 0x82, 0x84, 0x78, 0x01, 0x01, 0x81, 0x41, 0x21, 0x21, 0x11,
  0x08, 0x84, 0x7F, 0xC1, 0x01, 0x00, 0x3F, 0x20, 0x40, 0x40, 0x7C, 0x42,
  0x02, 0x02, 0x82, 0x84, 0x78, 0x06, 0x30, 0x82, 0x07, 0xC8, 0x60, 0xC1,
  0x83, 0x09, 0xE0, 0xFF, 0x06, 0x10, 0x20, 0x82, 0x04, 0x10, 0x40, 0x82,
  0x00, 0x1E, 0x21, 0x41, 0x41, 0x42, 0x3C, 0x62, 0x82, 0x82, 0x82, 0x7C,
  0x3D, 0x8A, 0x0C, 0x18, 0x30, 0x9F, 0x04, 0x10, 0x43, 0x00, 0x20, 0x00,
  0x06, 0x10, 0x00, 0x00, 0x02, 0x44, 0x80, 0x01, 0x06, 0x08, 0x30, 0xC0,
  0x40, 0x30, 0x08, 0x06, 0xFF, 0x00, 0x00, 0xFF, 0x40, 0x40, 0x60, 0x20,
  0x20, 0x86, 0x30, 0x80, 0x3C, 0x86, 0x08, 0x10, 0x40, 0x8E, 0x10, 0x20,
  0x01, 0x80, 0x1E, 0x22, 0x41, 0x4D, 0x92, 0xA2, 0xA2, 0xA2, 0x96, 0x9A,
  0x80, 0x40, 0x7C, 0x04, 0x0A, 0x0A, 0x12, 0x12, 0x22, 0x22, 0x3F, 0x41,
  0x41, 0x81, 0x3E, 0x42, 0x41, 0x42, 0x42, 0x7C, 0x82, 0x82, 0x82, 0x82,
  0xFC, 0x1C, 0x22, 0x41, 0x40, 0x80, 0x80, 0x80, 0x80, 0x82, 0x44, 0x38,
  0x3C, 0x42, 0x41, 0x41, 0x41, 0x41, 0x81, 0x82, 0x82, 0x84, 0xF8, 0x3F,
  0x40, 0x40, 0x40, 0x40, 0x7E, 0x80, 0x80, 0x80, 0x80, 0xFE, 0x3F, 0x40,
  0x40, 0x40, 0x40, 0x7E, 0x80, 0x80, 0x80, 0x80, 0x80, 0x1E, 0x22, 0x41,
  0x40, 0x80, 0x80, 0x8E, 0x82, 0x82, 0x46, 0x3A, 0x41, 0x41, 0x41, 0x41,
  0x81, 0x7E, 0x82, 0x82, 0x82, 0x82, 0x84, 0x3F, 0x08, 0x08, 0x08, 0x08,
  0x10, 0x10, 0x10, 0x10, 0x10, 0xFE, 0x1F, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x04, 0x84, 0x84, 0x78, 0x41, 0xA1, 0x11, 0x09, 0x05, 0x05, 0x81,
  0x21, 0x10, 0x84, 0x42, 0x20, 0x80, 0x41, 0x04, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x0F, 0xC0, 0x41, 0x63, 0x63, 0xA5, 0xA5, 0x99, 0x92, 0x92, 0x82,
  0x82, 0x82, 0x21, 0x61, 0x61, 0x51, 0x91, 0x92, 0x8A, 0x8A, 0x8A, 0x86,
  0x84, 0x1E, 0x21, 0x41, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0x84, 0x78,
  0x3E, 0x41, 0x41, 0x41, 0x41, 0x41, 0x7E, 0x80, 0x80, 0x80, 0x80, 0x1E,
  0x21, 0x41, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0x84, 0x78, 0x12, 0x0A,
  0x0C, 0x3E, 0x41, 0x41, 0x41, 0x41, 0x41, 0x7E, 0x88, 0x88, 0x84, 0x86,
  0x3E, 0x41, 0x40, 0x40, 0x60, 0x1C, 0x02, 0x02, 0x82, 0x82, 0x7C, 0xFF,
  0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x41, 0x41,
  0x41, 0x41, 0x82, 0x82, 0x82, 0x82, 0x82, 0x84, 0x78, 0x81, 0x82, 0x82,
  0x84, 0x84, 0x88, 0x48, 0x50, 0x50, 0x60, 0x20, 0xC0, 0xC0, 0x60, 0x51,
  0x29, 0x94, 0xD2, 0xA9, 0x54, 0xCA, 0x66, 0x21, 0x00, 0x20, 0x48, 0x21,
  0x10, 0x48, 0x0C, 0x02, 0x00, 0xC0, 0x50, 0x22, 0x10, 0x88, 0x10, 0x81,
  0x82, 0x84, 0x44, 0x48, 0x30, 0x20, 0x20, 0x20, 0x20, 0x40, 0x3F, 0xC0,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x0F, 0xF0,
  0x3C, 0x82, 0x10, 0x41, 0x04, 0x10, 0x82, 0x08, 0x20, 0x83, 0xC0, 0x88,
  0x88, 0x44, 0x44, 0x22, 0x22, 0x11, 0x1E, 0x04, 0x10, 0x20, 0x40, 0x81,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x9E, 0x00, 0x08, 0x14, 0x24, 0x22, 0x42,
  0x81, 0xFF, 0xAC, 0x3E, 0x8E, 0x0C, 0x18, 0x30, 0xA3, 0x39, 0x20, 0x40,
  0x40, 0x40, 0x5C, 0x62, 0x41, 0x41, 0x82, 0x82, 0xC6, 0xB8, 0x3C, 0x86,
  0x0C, 0x08, 0x10, 0x51, 0x3C, 0x01, 0x01, 0x01, 0x02, 0x3E, 0x46, 0x82,
  0x82, 0x82, 0x84, 0x8C, 0x7C, 0x1E, 0xC6, 0x0F, 0xE8, 0x10, 0x51, 0x3C,
  0x03, 0xC1, 0x00, 0x40, 0x10, 0x3F, 0x81, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x82, 0x40, 0x90, 0x1C, 0x03, 0x00, 0x3E, 0x8E, 0x0C, 0x18, 0x30,
  0xA3, 0x3A, 0x05, 0x11, 0xC0, 0x20, 0x41, 0x02, 0x05, 0xCC, 0x50, 0xA1,
  0x43, 0x06, 0x14, 0x20, 0x08, 0x00, 0x07, 0x81, 0x02, 0x04, 0x11, 0x26,
  0x50, 0xC0, 0x04, 0x00, 0x3F, 0x08, 0x20, 0x82, 0x08, 0x49, 0x24, 0x50,
  0xC0, 0x20, 0x20, 0x40, 0x40, 0x5E, 0x62, 0x42, 0x44, 0x98, 0x91, 0x8A,
  0x8C, 0xF0, 0x42, 0x08, 0x20, 0x84, 0x10, 0x45, 0x35, 0x18, 0xB7, 0xC9,
  0x89, 0x91, 0x91, 0x92, 0x92, 0x92, 0x5C, 0xC5, 0x0A, 0x14, 0x30, 0x61,
  0x42, 0x3C, 0x86, 0x0C, 0x18, 0x30, 0x51, 0x3C, 0x5C, 0x62, 0x41, 0x41,
  0x82, 0x82, 0xC6, 0xB8, 0x80, 0x80, 0x80, 0x3E, 0x8E, 0x0C, 0x18, 0x30,
  0xA3, 0x3A, 0x04, 0x08, 0x10, 0xEF, 0x10, 0x20, 0x20, 0x40, 0x40, 0x40,
  0x40, 0x3C, 0x85, 0x03, 0xC0, 0x60, 0x60, 0xBE, 0x10, 0x10, 0x10, 0xFF,
  0x10, 0x20, 0x20, 0x20, 0x26, 0x28, 0x30, 0x86, 0x18, 0x61, 0x86, 0x69,
  0xBA, 0xE2, 0x21, 0x42, 0x42, 0x42, 0x44, 0x4C, 0x70, 0x49, 0x89, 0x89,
  0x91, 0x91, 0x91, 0xB2, 0xEC, 0x1B, 0x96, 0x51, 0x21, 0x18, 0x84, 0xC6,
  0x64, 0xCC, 0x42, 0x85, 0x0C, 0x18, 0x31, 0xA1, 0x3E, 0x05, 0x11, 0xC0,
  0x7D, 0x43, 0x84, 0x08, 0x30, 0x42, 0xE2, 0x9E, 0x1E, 0x20, 0x40, 0x81,
  0x02, 0x38, 0x18, 0x10, 0x41, 0x02, 0x04, 0x0F, 0x00, 0x24, 0x92, 0x92,
  0x49, 0x49, 0x00, 0x3C, 0x08, 0x20, 0x41, 0x02, 0x03, 0x98, 0x20, 0x40,
  0x40, 0x81, 0x1C, 0x00, 0x71, 0x9A, 0x8E,
};

const GFXglyph IBMPlexMono_ExtraLightItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 11, 10, 3, -11 },
  { 6, 4, 4, 10, 4, -12 },
  { 8, 10, 11, 10, 0, -11 },
  { 22, 8, 15, 10, 1, -13 },
  { 37, 10, 11, 10, 0, -11 },
  { 51, 9, 11, 10, 0, -11 },
  { 64, 1, 4, 10, 5, -12 },
  { 65, 5, 14, 10, 4, -12 },
  { 74, 5, 14, 10, 1, -12 },
  { 83, 8, 8, 10, 1, -9 },
  { 91, 8, 9, 10, 1, -9 },
  { 100, 3, 4, 10, 2, -1 },
  { 102, 4, 1, 10, 3, -5 },
  { 103, 2, 1, 10, 3, -1 },
  { 104, 8, 14, 10, 1, -12 },
  { 118, 8, 11, 10, 1, -11 },
  { 129, 7, 11, 10, 1, -11 },
  { 139, 8, 11, 10, 1, -11 },
  { 150, 8, 11, 10, 1, -11 },
  { 161, 9, 11, 10, 0, -11 },
  { 174, 8, 11, 10, 1, -11 },
  { 185, 7, 11, 10, 1, -11 },
  { 195, 7, 11, 10, 2, -11 },
  { 205, 8, 11, 10, 1, -11 },
  { 216, 7, 11, 10, 2, -11 },
  { 226, 3, 8, 10, 3, -8 },
  { 229, 4, 11, 10, 2, -8 },
  { 235, 8, 9, 10, 1, -9 },
  { 244, 8, 4, 10, 1, -7 },
  { 248, 7, 9, 10, 1, -9 },
  { 256, 7, 11, 10, 2, -11 },
  { 266, 8, 13, 10, 1, -11 },
  { 279, 8, 11, 10, 0, -11 },
  { 290, 8, 11, 10, 1, -11 },
  { 301, 8, 11, 10, 1, -11 },
  { 312, 8, 11, 10, 1, -11 },
  { 323, 8, 11, 10, 1, -11 },
  { 334, 8, 11, 10, 1, -11 },
  { 345, 8, 11, 10, 1, -11 },
  { 356, 8, 11, 10, 1, -11 },
  { 367, 8, 11, 10, 1, -11 },
  { 378, 8, 11, 10, 1, -11 },
  { 389, 9, 11, 10, 1, -11 },
  { 402, 6, 11, 10, 2, -11 },
  { 411, 8, 11, 10, 1, -11 },
  { 422, 8, 11, 10, 1, -11 },
  { 433, 8, 11, 10, 1, -11 },
  { 444, 8, 11, 10, 1, -11 },
  { 455, 8, 14, 10, 1, -11 },
  { 469, 8, 11, 10, 1, -11 },
  { 480, 8, 11, 10, 1, -11 },
  { 491, 8, 11, 10, 2, -11 },
  { 502, 8, 11, 10, 1, -11 },
  { 513, 8, 11, 10, 2, -11 },
  { 524, 9, 11, 10, 1, -11 },
  { 537, 10, 11, 10, 0, -11 },
  { 551, 8, 11, 10, 2, -11 },
  { 562, 10, 11, 10, 0, -11 },
  { 576, 6, 14, 10, 3, -12 },
  { 587, 4, 14, 10, 3, -12 },
  { 594, 7, 14, 10, 0, -12 },
  { 607, 8, 6, 10, 1, -11 },
  { 613, 8, 1, 10, 0, 2 },
  { 614, 2, 3, 10, 4, -13 },
  { 615, 7, 8, 10, 1, -8 },
  { 622, 8, 12, 10, 1, -12 },
  { 634, 7, 8, 10, 1, -8 },
  { 641, 8, 12, 10, 1, -12 },
  { 653, 7, 8, 10, 1, -8 },
  { 660, 10, 15, 10, 0, -12 },
  { 679, 7, 11, 10, 1, -8 },
  { 689, 7, 12, 10, 1, -12 },
  { 700, 7, 11, 10, 1, -11 },
  { 710, 6, 14, 10, 2, -11 },
  { 721, 8, 12, 10, 1, -12 },
  { 733, 6, 12, 10, 2, -12 },
  { 742, 8, 8, 10, 1, -8 },
  { 750, 7, 8, 10, 1, -8 },
  { 757, 7, 8, 10, 1, -8 },
  { 764, 8, 11, 10, 1, -8 },
  { 775, 7, 11, 10, 1, -8 },
  { 785, 8, 8, 10, 2, -8 },
  { 793, 7, 8, 10, 1, -8 },
  { 800, 8, 11, 10, 1, -11 },
  { 811, 6, 8, 10, 2, -8 },
  { 817, 8, 8, 10, 1, -8 },
  { 825, 8, 8, 10, 1, -8 },
  { 833, 9, 8, 10, 0, -8 },
  { 842, 7, 11, 10, 1, -8 },
  { 852, 8, 8, 10, 1, -8 },
  { 860, 7, 14, 10, 2, -12 },
  { 873, 3, 14, 10, 3, -12 },
  { 879, 7, 14, 10, 1, -12 },
  { 892, 8, 3, 10, 1, -7 },
};

const GFXfont IBMPlexMono_ExtraLightItalic16pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic16pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic16pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC16PT7B_H_
