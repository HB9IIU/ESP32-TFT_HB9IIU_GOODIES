#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC10PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0x88, 0xBB, 0x00, 0x38, 0xA6, 0xD4, 0xC9, 0x4A, 0x00, 0x10,
  0xE5, 0x58, 0x38, 0xAA, 0x9C, 0x20, 0x66, 0x66, 0x80, 0x5A, 0x99, 0x80,
  0x31, 0x24, 0x9C, 0xA2, 0xD6, 0x80, 0xE0, 0x34, 0x88, 0x88, 0x88, 0x40,
  0x48, 0x92, 0x52, 0x80, 0x22, 0x3F, 0x4A, 0x00, 0x24, 0xF4, 0x40, 0xE0,
  0xC0, 0x80, 0x0C, 0x21, 0x04, 0x20, 0x84, 0x10, 0x80, 0x74, 0xA3, 0xE9,
  0x4B, 0x80, 0x11, 0x94, 0x22, 0x13, 0xE0, 0x3A, 0x42, 0x11, 0x33, 0xE0,
  0x3A, 0x4C, 0x10, 0xC5, 0xC0, 0x09, 0xD3, 0x27, 0xC8, 0x40, 0x7C, 0x3D,
  0x21, 0x4B, 0x80, 0x34, 0x8F, 0x99, 0xE0, 0xFC, 0x84, 0x44, 0x22, 0x00,
  0x74, 0x64, 0xC9, 0x4B, 0x80, 0x79, 0x9F, 0x12, 0xC0, 0x40, 0x80, 0x40,
  0xA8, 0x1B, 0x20, 0x83, 0x00, 0xFF, 0x80, 0x41, 0x82, 0x6C, 0x00, 0x79,
  0x12, 0x40, 0x40, 0x79, 0xBD, 0xDF, 0x8E, 0x11, 0x8C, 0x97, 0xC6, 0x20,
  0x79, 0x9E, 0x99, 0xF0, 0x74, 0xA3, 0x08, 0x4B, 0x80, 0x74, 0xA3, 0x29,
  0x4B, 0x80, 0x7C, 0x21, 0xE8, 0x43, 0xC0, 0x7C, 0x21, 0xE8, 0x42, 0x00,
  0x74, 0xA3, 0x69, 0x5B, 0xC0, 0x8C, 0x65, 0xE9, 0x4A, 0x40, 0x3C, 0x41,
  0x08, 0x20, 0x8F, 0x80, 0x71, 0x11, 0x1A, 0xE0, 0x8C, 0xA9, 0x8A, 0x52,
  0x40, 0x88, 0x88, 0x88, 0xF0, 0x45, 0x1A, 0xEE, 0xAA, 0x28, 0x80, 0x8E,
  0x75, 0xAB, 0x5A, 0x40, 0x74, 0xA3, 0x29, 0x4B, 0x80, 0x74, 0x63, 0x1F,
  0x42, 0x00, 0x74, 0xA3, 0x29, 0x4B, 0x8A, 0x30, 0x74, 0x63, 0x1F, 0x52,
  0xC0, 0x39, 0x14, 0x0E, 0x0A, 0x27, 0x00, 0xF9, 0x08, 0x84, 0x21, 0x00,
  0x8C, 0x65, 0x29, 0x4B, 0x80, 0x8C, 0xA5, 0x2A, 0x51, 0x00, 0x8C, 0x6B,
  0x6F, 0x4A, 0x40, 0x45, 0x23, 0x08, 0x31, 0x48, 0x80, 0x8C, 0xA4, 0xC4,
  0x21, 0x00, 0x7C, 0x21, 0x08, 0x42, 0x0F, 0x80, 0x74, 0x88, 0x88, 0x88,
  0xC0, 0xAA, 0x95, 0x40, 0x31, 0x11, 0x22, 0x22, 0xE0, 0x22, 0xA5, 0x30,
  0xF8, 0xC0, 0x79, 0x99, 0xF0, 0x88, 0x79, 0x99, 0xE0, 0x69, 0x8B, 0xE0,
  0x08, 0x9D, 0x29, 0x4B, 0x80, 0x79, 0xE9, 0xE0, 0x0C, 0x47, 0xC8, 0x20,
  0x8A, 0x28, 0x40, 0x3A, 0x63, 0x17, 0x49, 0xC0, 0x88, 0xBD, 0x99, 0x90,
  0x20, 0xC4, 0x4B, 0x40, 0x10, 0xF2, 0x22, 0xAA, 0x60, 0x84, 0x2D, 0xAE,
  0x66, 0xC0, 0xE4, 0x44, 0x4B, 0x40, 0xED, 0x5A, 0xAA, 0xA8, 0xBD, 0x99,
  0x90, 0x79, 0x99, 0xE0, 0x3A, 0x53, 0x1F, 0x42, 0x00, 0x79, 0x99, 0xE2,
  0x20, 0xDB, 0x10, 0x84, 0x00, 0x78, 0x71, 0xE0, 0x42, 0x3E, 0x84, 0x59,
  0x00, 0x99, 0x99, 0xE0, 0x99, 0x99, 0xE0, 0xAE, 0x73, 0xAB, 0x00, 0x2F,
  0x5A, 0x6A, 0x50, 0x4A, 0x63, 0x17, 0x49, 0xC0, 0xF9, 0x69, 0xF0, 0x39,
  0x10, 0x4C, 0x11, 0x10, 0x60, 0x56, 0xAA, 0x80, 0x30, 0x88, 0x41, 0x90,
  0x84, 0xE0, 0xCE, 0xAC,
};

const GFXglyph IBMPlexMono_ExtraLightItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 7, 6, 2, -7 },
  { 3, 3, 3, 6, 2, -7 },
  { 5, 6, 7, 6, 0, -7 },
  { 11, 6, 9, 6, 0, -8 },
  { 18, 6, 7, 6, 0, -7 },
  { 24, 6, 7, 6, 0, -7 },
  { 30, 1, 3, 6, 3, -7 },
  { 31, 4, 9, 6, 2, -8 },
  { 36, 3, 9, 6, 1, -8 },
  { 40, 5, 5, 6, 1, -5 },
  { 44, 4, 5, 6, 1, -6 },
  { 47, 1, 3, 6, 2, -1 },
  { 48, 2, 1, 6, 2, -4 },
  { 49, 1, 1, 6, 2, -1 },
  { 50, 6, 9, 6, 0, -8 },
  { 57, 5, 7, 6, 1, -7 },
  { 62, 5, 7, 6, 0, -7 },
  { 67, 5, 7, 6, 0, -7 },
  { 72, 5, 7, 6, 0, -7 },
  { 77, 5, 7, 6, 0, -7 },
  { 82, 5, 7, 6, 1, -7 },
  { 87, 4, 7, 6, 1, -7 },
  { 91, 5, 7, 6, 1, -7 },
  { 96, 5, 7, 6, 1, -7 },
  { 101, 4, 7, 6, 1, -7 },
  { 105, 2, 5, 6, 2, -5 },
  { 107, 2, 7, 6, 2, -5 },
  { 109, 5, 5, 6, 1, -6 },
  { 113, 5, 2, 6, 1, -4 },
  { 115, 5, 5, 6, 0, -6 },
  { 119, 4, 7, 6, 1, -7 },
  { 123, 4, 8, 6, 1, -7 },
  { 127, 5, 7, 6, 0, -7 },
  { 132, 4, 7, 6, 1, -7 },
  { 136, 5, 7, 6, 1, -7 },
  { 141, 5, 7, 6, 1, -7 },
  { 146, 5, 7, 6, 1, -7 },
  { 151, 5, 7, 6, 1, -7 },
  { 156, 5, 7, 6, 1, -7 },
  { 161, 5, 7, 6, 1, -7 },
  { 166, 6, 7, 6, 0, -7 },
  { 172, 4, 7, 6, 1, -7 },
  { 176, 5, 7, 6, 1, -7 },
  { 181, 4, 7, 6, 1, -7 },
  { 185, 6, 7, 6, 0, -7 },
  { 191, 5, 7, 6, 1, -7 },
  { 196, 5, 7, 6, 1, -7 },
  { 201, 5, 7, 6, 1, -7 },
  { 206, 5, 9, 6, 1, -7 },
  { 212, 5, 7, 6, 1, -7 },
  { 217, 6, 7, 6, 0, -7 },
  { 223, 5, 7, 6, 1, -7 },
  { 228, 5, 7, 6, 1, -7 },
  { 233, 5, 7, 6, 1, -7 },
  { 238, 5, 7, 6, 1, -7 },
  { 243, 6, 7, 6, 0, -7 },
  { 249, 5, 7, 6, 1, -7 },
  { 254, 6, 7, 6, 0, -7 },
  { 260, 4, 9, 6, 2, -8 },
  { 265, 2, 9, 6, 2, -8 },
  { 268, 4, 9, 6, 0, -8 },
  { 273, 5, 4, 6, 1, -7 },
  { 276, 5, 1, 6, 0, 1 },
  { 277, 1, 2, 6, 2, -8 },
  { 278, 4, 5, 6, 1, -5 },
  { 281, 4, 7, 6, 1, -7 },
  { 285, 4, 5, 6, 1, -5 },
  { 288, 5, 7, 6, 1, -7 },
  { 293, 4, 5, 6, 1, -5 },
  { 296, 6, 9, 6, 0, -7 },
  { 303, 5, 7, 6, 0, -5 },
  { 308, 4, 7, 6, 1, -7 },
  { 312, 4, 7, 6, 1, -7 },
  { 316, 4, 9, 6, 1, -7 },
  { 321, 5, 7, 6, 1, -7 },
  { 326, 4, 7, 6, 1, -7 },
  { 330, 6, 5, 6, 0, -5 },
  { 334, 4, 5, 6, 1, -5 },
  { 337, 4, 5, 6, 1, -5 },
  { 340, 5, 7, 6, 0, -5 },
  { 345, 4, 7, 6, 1, -5 },
  { 349, 5, 5, 6, 1, -5 },
  { 353, 4, 5, 6, 1, -5 },
  { 356, 5, 7, 6, 1, -7 },
  { 361, 4, 5, 6, 1, -5 },
  { 364, 4, 5, 6, 1, -5 },
  { 367, 5, 5, 6, 1, -5 },
  { 371, 6, 5, 6, 0, -5 },
  { 375, 5, 7, 6, 0, -5 },
  { 380, 4, 5, 6, 1, -5 },
  { 383, 5, 9, 6, 1, -8 },
  { 389, 2, 9, 6, 2, -8 },
  { 392, 5, 9, 6, 0, -8 },
  { 398, 5, 3, 6, 1, -4 },
};

const GFXfont IBMPlexMono_ExtraLightItalic10pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic10pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic10pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC10PT7B_H_
