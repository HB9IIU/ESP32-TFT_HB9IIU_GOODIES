#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC20PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x22, 0x22, 0x24, 0x40, 0x00, 0x4C, 0xD9, 0x99, 0x90, 0x02,
  0x20, 0x24, 0x04, 0x40, 0x48, 0x3C, 0x70, 0x88, 0x08, 0x80, 0x90, 0x11,
  0x0F, 0x1E, 0x12, 0x02, 0x20, 0x22, 0x02, 0x40, 0x02, 0x00, 0x81, 0xF0,
  0x8B, 0x44, 0x51, 0x04, 0x40, 0x90, 0x1C, 0x02, 0xC0, 0x88, 0x22, 0x08,
  0xA2, 0x24, 0x90, 0xF8, 0x10, 0x04, 0x00, 0x1C, 0x09, 0x10, 0x90, 0x88,
  0x84, 0x84, 0x24, 0x11, 0x40, 0xF0, 0x00, 0x38, 0x1A, 0x20, 0xA1, 0x09,
  0x08, 0x88, 0x48, 0x44, 0x41, 0xC0, 0x0F, 0x01, 0x88, 0x10, 0x81, 0x08,
  0x10, 0x81, 0x08, 0x1B, 0x06, 0x40, 0x84, 0x08, 0x20, 0x81, 0x28, 0x33,
  0x44, 0xA3, 0x84, 0x56, 0x80, 0x0C, 0x42, 0x08, 0x42, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x40, 0x80, 0x10, 0x10, 0x10, 0x20, 0x40,
  0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x41, 0x02, 0x08, 0x21, 0x80, 0x04,
  0x01, 0x00, 0x42, 0x11, 0x75, 0x83, 0x81, 0x40, 0x48, 0x22, 0x10, 0x40,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x3F, 0xF0, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x29, 0x48, 0xFC, 0x70, 0x00, 0x60, 0x08, 0x02, 0x00, 0x40,
  0x10, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x02, 0x00,
  0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x00, 0x0F, 0x04, 0x22, 0x05, 0x01,
  0x40, 0x50, 0x14, 0x06, 0x11, 0x80, 0x60, 0x28, 0x09, 0x04, 0x43, 0x0F,
  0x00, 0x06, 0x07, 0x06, 0x84, 0x44, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x01, 0x00, 0x87, 0xFC, 0x0F, 0x04, 0x22, 0x05, 0x01, 0x00, 0x40,
  0x20, 0x08, 0x04, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x3F, 0xE0, 0x0F,
  0x04, 0x22, 0x04, 0x01, 0x00, 0x80, 0x61, 0xE0, 0x0C, 0x00, 0x80, 0x20,
  0x0A, 0x04, 0x43, 0x0F, 0x00, 0x00, 0x80, 0x60, 0x28, 0x12, 0x09, 0x04,
  0x42, 0x10, 0x84, 0x41, 0x20, 0x4F, 0xFC, 0x08, 0x02, 0x00, 0x80, 0x1F,
  0xC4, 0x02, 0x00, 0x80, 0x20, 0x17, 0xC2, 0x19, 0x02, 0x00, 0x80, 0x20,
  0x0A, 0x02, 0x43, 0x0F, 0x80, 0x01, 0x83, 0x02, 0x02, 0x02, 0x01, 0x79,
  0xC6, 0x81, 0x40, 0xC0, 0x60, 0x30, 0x14, 0x11, 0xF0, 0x7F, 0xE0, 0x28,
  0x0A, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80,
  0x20, 0x10, 0x00, 0x0F, 0x84, 0x12, 0x04, 0x81, 0x20, 0x48, 0x21, 0xF0,
  0xC6, 0x40, 0xA0, 0x28, 0x0A, 0x02, 0x41, 0x0F, 0x80, 0x1E, 0x30, 0x90,
  0x30, 0x18, 0x0C, 0x06, 0x04, 0x86, 0x3D, 0x01, 0x01, 0x01, 0x01, 0x03,
  0x00, 0x32, 0x00, 0x00, 0x00, 0x04, 0xC0, 0x18, 0x80, 0x00, 0x00, 0x00,
  0x01, 0x10, 0x88, 0x40, 0x00, 0x80, 0x81, 0x83, 0x06, 0x04, 0x01, 0x00,
  0x40, 0x18, 0x02, 0x00, 0xC0, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x20, 0x04,
  0x00, 0xC0, 0x08, 0x01, 0x00, 0x30, 0x10, 0x18, 0x18, 0x18, 0x08, 0x00,
  0x3E, 0x43, 0x81, 0x81, 0x01, 0x02, 0x04, 0x38, 0x20, 0x20, 0x00, 0x00,
  0x60, 0x60, 0x1E, 0x10, 0x90, 0x28, 0x18, 0xEC, 0x8E, 0x45, 0x42, 0xA1,
  0x50, 0xA8, 0xD3, 0xA8, 0x04, 0x02, 0x00, 0xF8, 0x01, 0x00, 0xC0, 0x50,
  0x12, 0x04, 0x82, 0x20, 0x88, 0x42, 0x10, 0x8F, 0xE2, 0x05, 0x01, 0x40,
  0x60, 0x10, 0x3F, 0x88, 0x32, 0x04, 0x81, 0x40, 0x90, 0x27, 0xF1, 0x06,
  0x40, 0x90, 0x28, 0x0A, 0x02, 0x81, 0x3F, 0x80, 0x0E, 0x18, 0x90, 0x28,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x50, 0x2C, 0x21, 0xE0,
  0x3F, 0x08, 0x22, 0x04, 0x81, 0x20, 0x50, 0x14, 0x05, 0x01, 0x40, 0x50,
  0x24, 0x0A, 0x02, 0x83, 0x3F, 0x00, 0x3F, 0xE4, 0x00, 0x80, 0x10, 0x04,
  0x00, 0x80, 0x1F, 0xE2, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01,
  0xFF, 0x00, 0x3F, 0xE4, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x1F, 0xE2,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x00, 0x1E, 0x10,
  0x90, 0x28, 0x08, 0x04, 0x02, 0x01, 0x1F, 0x81, 0x40, 0xA0, 0x50, 0x2C,
  0x73, 0xC8, 0x20, 0x64, 0x08, 0x81, 0x20, 0x24, 0x04, 0x80, 0x9F, 0xF2,
  0x04, 0x40, 0x90, 0x12, 0x02, 0x40, 0x48, 0x09, 0x02, 0x00, 0x3F, 0xE0,
  0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x81, 0xFE, 0x00, 0x1F, 0xC0, 0x10, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x12, 0x04, 0x42, 0x0F, 0x00,
  0x20, 0x24, 0x08, 0x82, 0x10, 0x82, 0x20, 0x88, 0x13, 0x02, 0xA0, 0x62,
  0x08, 0x41, 0x08, 0x40, 0x88, 0x11, 0x01, 0x00, 0x20, 0x20, 0x20, 0x40,
  0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x20, 0x24,
  0x0D, 0x43, 0x28, 0xA5, 0x14, 0x94, 0x92, 0x92, 0x62, 0x88, 0x90, 0x12,
  0x02, 0x40, 0x48, 0x09, 0x01, 0x00, 0x30, 0x66, 0x08, 0xC1, 0x24, 0x24,
  0x84, 0x90, 0x91, 0x12, 0x24, 0x44, 0x90, 0x92, 0x0A, 0x41, 0x48, 0x29,
  0x02, 0x00, 0x0F, 0x04, 0x22, 0x05, 0x01, 0x40, 0x50, 0x14, 0x06, 0x01,
  0x80, 0x60, 0x28, 0x09, 0x04, 0x43, 0x0F, 0x00, 0x3F, 0x84, 0x08, 0x81,
  0x10, 0x32, 0x04, 0x80, 0x90, 0x33, 0xF8, 0x40, 0x08, 0x01, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x00, 0x0F, 0x04, 0x22, 0x05, 0x01, 0x40, 0x50, 0x14,
  0x06, 0x01, 0x80, 0x60, 0x28, 0x09, 0x04, 0x43, 0x0F, 0x00, 0x80, 0x12,
  0x05, 0x80, 0x80, 0x3F, 0x84, 0x08, 0x81, 0x10, 0x32, 0x04, 0x80, 0x90,
  0x33, 0xF8, 0x44, 0x08, 0x81, 0x08, 0x41, 0x08, 0x11, 0x03, 0x00, 0x1F,
  0x08, 0x34, 0x05, 0x00, 0x40, 0x08, 0x01, 0xC0, 0x0C, 0x00, 0x80, 0x20,
  0x0A, 0x02, 0x41, 0x0F, 0x80, 0xFF, 0xE0, 0x80, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x00, 0x40, 0xD0, 0x24, 0x0A, 0x02, 0x80, 0xA0, 0x28, 0x12, 0x04, 0x81,
  0x20, 0x48, 0x12, 0x08, 0x86, 0x1F, 0x00, 0x80, 0x60, 0x14, 0x09, 0x02,
  0x41, 0x10, 0x44, 0x21, 0x08, 0x44, 0x09, 0x02, 0x80, 0xA0, 0x30, 0x04,
  0x00, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x14, 0x44, 0x98, 0x93, 0x12, 0x54,
  0x52, 0x92, 0x52, 0x8A, 0x51, 0x8C, 0x31, 0x82, 0x00, 0x10, 0x11, 0x02,
  0x08, 0x40, 0x84, 0x04, 0x80, 0x50, 0x02, 0x00, 0x60, 0x09, 0x00, 0x90,
  0x10, 0x82, 0x08, 0x40, 0x48, 0x04, 0x80, 0x30, 0x09, 0x02, 0x20, 0x82,
  0x20, 0x48, 0x05, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x00, 0x1F, 0xF0, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x0F, 0xFC, 0x1F,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0xF8, 0x84, 0x21, 0x08, 0x21, 0x08, 0x41, 0x08,
  0x42, 0x08, 0x42, 0x10, 0x40, 0x3E, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x09, 0xF0, 0x04, 0x05, 0x04,
  0x84, 0x44, 0x12, 0x0A, 0x03, 0x01, 0xFF, 0xC0, 0xA4, 0x1E, 0x90, 0xD0,
  0x28, 0x18, 0x0C, 0x0A, 0x05, 0x02, 0x43, 0x1E, 0xC0, 0x10, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x0B, 0xC3, 0x08, 0x81, 0x40, 0x50, 0x14, 0x09, 0x02,
  0x40, 0xA8, 0x49, 0xE0, 0x3C, 0x62, 0x81, 0x80, 0x80, 0x80, 0x81, 0x82,
  0x84, 0x78, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x47, 0xA2, 0x19, 0x02,
  0x40, 0xA0, 0x28, 0x0A, 0x04, 0x81, 0x10, 0xC3, 0xD0, 0x1E, 0x61, 0x81,
  0x83, 0xFC, 0x80, 0x81, 0x82, 0xC6, 0x7C, 0x01, 0xF0, 0x10, 0x01, 0x00,
  0x20, 0x02, 0x01, 0xFF, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x08, 0x80, 0x48, 0x02, 0x80, 0x18, 0x00,
  0x1E, 0xC8, 0x64, 0x09, 0x02, 0x80, 0xA0, 0x28, 0x12, 0x04, 0x43, 0x0F,
  0x40, 0x10, 0x08, 0x86, 0x1F, 0x00, 0x20, 0x20, 0x40, 0x40, 0x40, 0x4E,
  0x71, 0x41, 0x41, 0x81, 0x81, 0x82, 0x82, 0x82, 0x82, 0x0C, 0x00, 0x00,
  0x00, 0xF8, 0x10, 0x10, 0x10, 0x10, 0x20, 0x21, 0x26, 0x28, 0x30, 0x01,
  0x00, 0x00, 0x00, 0x7E, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04,
  0x04, 0x84, 0x68, 0x38, 0x18, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x09,
  0xC3, 0x88, 0x82, 0x20, 0x90, 0xC4, 0xC1, 0x21, 0x44, 0x61, 0x68, 0x30,
  0xF8, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x23,
  0x24, 0x38, 0x30, 0x5D, 0xD9, 0x94, 0x45, 0x11, 0x84, 0x62, 0x18, 0x86,
  0x22, 0x88, 0xA2, 0x20, 0x4E, 0x71, 0x41, 0x41, 0x81, 0x81, 0x82, 0x82,
  0x82, 0x82, 0x3E, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x7C,
  0x2F, 0x0C, 0x22, 0x05, 0x01, 0x40, 0x50, 0x24, 0x09, 0x02, 0xA1, 0x27,
  0x88, 0x02, 0x00, 0x80, 0x20, 0x00, 0x1E, 0xC8, 0x64, 0x09, 0x02, 0x80,
  0xA0, 0x28, 0x12, 0x04, 0x43, 0x0F, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80,
  0xFB, 0xC5, 0x01, 0x80, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x00, 0x1F, 0x08, 0x24, 0x05, 0x00, 0x3E, 0x00, 0x60, 0x08, 0x02, 0xC1,
  0x0F, 0x80, 0x08, 0x08, 0x04, 0x02, 0x0F, 0xF8, 0x80, 0x40, 0x40, 0x20,
  0x10, 0x08, 0x44, 0xC2, 0x81, 0x80, 0x41, 0x41, 0x81, 0x81, 0x81, 0x82,
  0x82, 0x82, 0x8E, 0x72, 0xE1, 0x10, 0x50, 0x28, 0x14, 0x12, 0x09, 0x0C,
  0x84, 0x8C, 0x38, 0x00, 0x44, 0x51, 0x14, 0x45, 0x11, 0x84, 0x62, 0x18,
  0x86, 0x61, 0x98, 0x99, 0xC0, 0x0C, 0xE3, 0x51, 0x46, 0x10, 0x21, 0x02,
  0x00, 0x40, 0x84, 0x08, 0xC2, 0x8A, 0xC7, 0x10, 0x20, 0x90, 0x50, 0x28,
  0x14, 0x0A, 0x09, 0x04, 0x82, 0x47, 0x1E, 0x80, 0x40, 0x48, 0x63, 0xC0,
  0x3E, 0x50, 0x74, 0x08, 0x04, 0x06, 0x02, 0x03, 0x11, 0x02, 0xF8, 0xA3,
  0xE0, 0x07, 0x84, 0x02, 0x01, 0x00, 0x80, 0x20, 0x10, 0x08, 0xF8, 0x0C,
  0x02, 0x01, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x1F, 0x00, 0x11, 0x12,
  0x22, 0x22, 0x24, 0x44, 0x44, 0x48, 0x88, 0x1E, 0x01, 0x00, 0x80, 0x40,
  0x40, 0x40, 0x20, 0x10, 0x07, 0x86, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20,
  0x10, 0x08, 0x7C, 0x00, 0x30, 0x52, 0x18, 0x4A, 0x0C,
};

const GFXglyph IBMPlexMono_ExtraLightItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 14, 12, 4, -14 },
  { 8, 4, 5, 12, 5, -15 },
  { 11, 12, 14, 12, 0, -14 },
  { 32, 10, 18, 12, 1, -16 },
  { 55, 13, 14, 12, 0, -14 },
  { 78, 12, 14, 12, 0, -14 },
  { 99, 2, 5, 12, 6, -15 },
  { 101, 6, 18, 12, 5, -15 },
  { 115, 7, 18, 12, 1, -15 },
  { 131, 10, 10, 12, 1, -11 },
  { 144, 10, 11, 12, 1, -12 },
  { 158, 3, 5, 12, 3, -2 },
  { 160, 6, 1, 12, 3, -7 },
  { 161, 2, 2, 12, 4, -2 },
  { 162, 11, 18, 12, 1, -15 },
  { 187, 10, 14, 12, 1, -14 },
  { 205, 9, 14, 12, 1, -14 },
  { 221, 10, 14, 12, 1, -14 },
  { 239, 10, 14, 12, 1, -14 },
  { 257, 10, 14, 12, 1, -14 },
  { 275, 10, 14, 12, 1, -14 },
  { 293, 9, 14, 12, 1, -14 },
  { 309, 10, 14, 12, 2, -14 },
  { 327, 10, 14, 12, 1, -14 },
  { 345, 9, 14, 12, 2, -14 },
  { 361, 4, 11, 12, 4, -11 },
  { 367, 5, 14, 12, 3, -11 },
  { 376, 9, 11, 12, 2, -12 },
  { 389, 10, 4, 12, 1, -8 },
  { 394, 10, 11, 12, 1, -12 },
  { 408, 8, 14, 12, 3, -14 },
  { 422, 9, 16, 12, 2, -14 },
  { 440, 10, 14, 12, 0, -14 },
  { 458, 10, 14, 12, 1, -14 },
  { 476, 9, 14, 12, 2, -14 },
  { 492, 10, 14, 12, 1, -14 },
  { 510, 11, 14, 12, 1, -14 },
  { 530, 11, 14, 12, 1, -14 },
  { 550, 9, 14, 12, 2, -14 },
  { 566, 11, 14, 12, 1, -14 },
  { 586, 11, 14, 12, 1, -14 },
  { 606, 10, 14, 12, 1, -14 },
  { 624, 11, 14, 12, 1, -14 },
  { 644, 8, 14, 12, 2, -14 },
  { 658, 11, 14, 12, 1, -14 },
  { 678, 11, 14, 12, 1, -14 },
  { 698, 10, 14, 12, 1, -14 },
  { 716, 11, 14, 12, 1, -14 },
  { 736, 10, 18, 12, 1, -14 },
  { 759, 11, 14, 12, 1, -14 },
  { 779, 10, 14, 12, 1, -14 },
  { 797, 11, 14, 12, 2, -14 },
  { 817, 10, 14, 12, 2, -14 },
  { 835, 10, 14, 12, 2, -14 },
  { 853, 11, 14, 12, 1, -14 },
  { 873, 12, 14, 12, 0, -14 },
  { 894, 11, 14, 12, 2, -14 },
  { 914, 12, 14, 12, 0, -14 },
  { 935, 8, 18, 12, 4, -15 },
  { 953, 5, 18, 12, 4, -15 },
  { 965, 7, 18, 12, 1, -15 },
  { 981, 9, 8, 12, 2, -14 },
  { 990, 10, 1, 12, 0, 2 },
  { 992, 2, 3, 12, 5, -15 },
  { 993, 9, 10, 12, 1, -10 },
  { 1005, 10, 15, 12, 1, -15 },
  { 1024, 8, 10, 12, 2, -10 },
  { 1034, 10, 15, 12, 1, -15 },
  { 1053, 8, 10, 12, 2, -10 },
  { 1063, 12, 19, 12, 0, -15 },
  { 1092, 10, 14, 12, 1, -10 },
  { 1110, 8, 15, 12, 2, -15 },
  { 1125, 8, 14, 12, 2, -14 },
  { 1139, 8, 18, 12, 2, -14 },
  { 1157, 10, 15, 12, 1, -15 },
  { 1176, 8, 15, 12, 2, -15 },
  { 1191, 10, 10, 12, 1, -10 },
  { 1204, 8, 10, 12, 2, -10 },
  { 1214, 8, 10, 12, 2, -10 },
  { 1224, 10, 14, 12, 1, -10 },
  { 1242, 10, 14, 12, 1, -10 },
  { 1260, 10, 10, 12, 2, -10 },
  { 1273, 10, 10, 12, 1, -10 },
  { 1286, 9, 14, 12, 2, -14 },
  { 1302, 8, 10, 12, 2, -10 },
  { 1312, 9, 10, 12, 2, -10 },
  { 1324, 10, 10, 12, 1, -10 },
  { 1337, 12, 10, 12, 0, -10 },
  { 1352, 9, 14, 12, 1, -10 },
  { 1368, 10, 10, 12, 1, -10 },
  { 1381, 9, 18, 12, 2, -15 },
  { 1402, 4, 18, 12, 4, -15 },
  { 1411, 9, 18, 12, 1, -15 },
  { 1432, 10, 4, 12, 1, -8 },
};

const GFXfont IBMPlexMono_ExtraLightItalic20pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic20pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic20pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC20PT7B_H_
