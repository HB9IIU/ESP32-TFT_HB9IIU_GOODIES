#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC68PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x00,
  0x18, 0x0E, 0x30, 0x1C, 0xE0, 0x39, 0xC0, 0x63, 0x80, 0xC6, 0x01, 0x8C,
  0x07, 0x18, 0x0E, 0x70, 0x1C, 0xE0, 0x31, 0xC0, 0x63, 0x00, 0xC6, 0x03,
  0x8C, 0x07, 0x38, 0x0E, 0x70, 0x18, 0xE0, 0x30, 0x00, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x83,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x60, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x0C, 0x00,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x7C, 0x18, 0xFC, 0x00, 0x0F, 0x00, 0xC0, 0xF0,
  0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x60, 0x03,
  0x00, 0x1C, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x03, 0xC1, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x37, 0xF0, 0x00, 0x00, 0x01, 0x83, 0xC0, 0x00, 0x00,
  0x0C, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x06, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x03, 0x00, 0x0C, 0x0C, 0x00,
  0x30, 0x00, 0xE0, 0xE0, 0x01, 0x80, 0x06, 0x03, 0x80, 0x0C, 0x00, 0x70,
  0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x03, 0x00, 0x70, 0x00, 0xF0, 0x18,
  0x0F, 0x00, 0x03, 0xF1, 0x83, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xC0, 0x07, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x70, 0x00, 0xC0, 0x00, 0xE0, 0x03,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x30, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x70, 0x03, 0x00, 0x07, 0x00, 0x03, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x70, 0x18, 0x00, 0x03, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x60, 0x03, 0x80, 0xC0, 0x00,
  0x03, 0x80, 0x38, 0x0C, 0x00, 0x00, 0x0F, 0x07, 0x80, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x08, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x38, 0x0F, 0x07, 0x80, 0x00, 0x01, 0x80, 0xE0,
  0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x00, 0x01, 0x80, 0xE0, 0x01,
  0x80, 0x00, 0x1C, 0x06, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x30,
  0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x0E, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x70, 0x03, 0x00, 0x01, 0x80, 0x07, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xE0, 0x03, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x38, 0x00, 0x18, 0x00, 0x70, 0x03, 0x80, 0x00, 0xC0,
  0x03, 0x00, 0x18, 0x00, 0x03, 0x00, 0x70, 0x01, 0x80, 0x00, 0x1E, 0x0F,
  0x00, 0x1C, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x1C, 0x00,
  0x00, 0x07, 0xC0, 0x70, 0x00, 0x00, 0x7F, 0x83, 0xC0, 0x00, 0x03, 0xC1,
  0xBC, 0x00, 0x00, 0x1C, 0x03, 0xE0, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x07, 0x00, 0x00, 0x03, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0xB0, 0x00, 0x00, 0xF0, 0x01, 0xE0,
  0x00, 0x03, 0x60, 0x06, 0xC0, 0x00, 0x04, 0xE0, 0x1D, 0xC0, 0x00, 0x18,
  0xC0, 0x31, 0x80, 0x00, 0x31, 0xC0, 0xC3, 0x80, 0x00, 0xC1, 0xC3, 0x83,
  0x80, 0x03, 0x01, 0x86, 0x07, 0x80, 0x0E, 0x03, 0x98, 0x07, 0xC0, 0x78,
  0x03, 0x70, 0x03, 0xFF, 0xC0, 0x07, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0x00,
  0x19, 0xCE, 0x73, 0x18, 0xCE, 0x73, 0x98, 0xC6, 0x73, 0x9C, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x1F, 0xFC, 0x01, 0xC0, 0x1F, 0xC7, 0xF0, 0x30, 0x1F,
  0xC0, 0x1F, 0xC6, 0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x76, 0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x1C, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0E,
  0x03, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x60, 0x1C,
  0x03, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7B, 0xFF, 0xFE,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x18, 0x07, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x0E, 0x30, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x01, 0xCC, 0x00,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x00, 0x19, 0xC0, 0x07, 0x00, 0x0C, 0xC0, 0x07, 0xC0, 0x06, 0x60,
  0x03, 0xE0, 0x07, 0x70, 0x01, 0xE0, 0x03, 0xB8, 0x00, 0xF0, 0x01, 0xDC,
  0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x01, 0x87, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF3, 0x80, 0x00,
  0x01, 0xE3, 0x00, 0x00, 0x03, 0xC3, 0x00, 0x00, 0x0F, 0x03, 0x00, 0x00,
  0x1E, 0x07, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00, 0x01,
  0xE0, 0x06, 0x00, 0x03, 0xC0, 0x06, 0x00, 0x07, 0x80, 0x06, 0x00, 0x02,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x0E, 0x01, 0x80, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x07, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30,
  0x40, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x3F, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x70, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x00, 0x60, 0x0E, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x01, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x1C, 0x0F, 0xF0, 0x00, 0x06, 0x1F, 0xFF, 0x80, 0x01, 0x9E, 0x01,
  0xF0, 0x00, 0x6E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x81, 0x00, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0x18, 0x07, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x81, 0xFF, 0x00, 0x0C, 0x3F, 0xFF, 0x00, 0x71,
  0xE0, 0x1F, 0x01, 0x9C, 0x00, 0x1E, 0x0E, 0xC0, 0x00, 0x1C, 0x36, 0x00,
  0x00, 0x38, 0xD0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x01, 0x9E, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x1C, 0x60, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x06, 0x00, 0x00,
  0xE0, 0x1E, 0x00, 0x0F, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x30, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0,
  0xC0, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xF8, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x03,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0x61,
  0xC0, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x01,
  0x8E, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x00, 0x30, 0xE0, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x06, 0x07, 0x00,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0x80, 0x78, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x00, 0x00, 0x60,
  0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03, 0x86, 0x00, 0x00, 0x06, 0x38,
  0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x79,
  0x80, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x0B, 0x1C, 0x00, 0x00, 0x5C, 0x38,
  0x00, 0x03, 0x70, 0x78, 0x00, 0x39, 0x80, 0xF8, 0x07, 0x8E, 0x00, 0xFF,
  0xFC, 0x30, 0x00, 0xFF, 0x81, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x07,
  0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x02,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0x80, 0x78, 0x03, 0x80, 0x03, 0xC1, 0xE0, 0x00,
  0x38, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x33, 0x80, 0x00, 0x07, 0x60,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F,
  0x80, 0xF0, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x07, 0x00,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x0E, 0x00,
  0x3F, 0x83, 0x0C, 0x00, 0xFF, 0xC7, 0x0C, 0x01, 0xE0, 0x66, 0x1C, 0x03,
  0x80, 0x16, 0x18, 0x03, 0x00, 0x16, 0x18, 0x06, 0x00, 0x0E, 0x18, 0x06,
  0x00, 0x0E, 0x18, 0x0C, 0x00, 0x0E, 0x38, 0x0C, 0x00, 0x0C, 0x30, 0x0C,
  0x00, 0x0C, 0x30, 0x1C, 0x00, 0x0C, 0x30, 0x18, 0x00, 0x0C, 0x30, 0x18,
  0x00, 0x0C, 0x70, 0x18, 0x00, 0x1C, 0x70, 0x18, 0x00, 0x18, 0x60, 0x38,
  0x00, 0x18, 0x60, 0x30, 0x00, 0x18, 0x60, 0x30, 0x00, 0x18, 0x60, 0x30,
  0x00, 0x38, 0x60, 0x30, 0x00, 0x38, 0xE0, 0x30, 0x00, 0x30, 0xE0, 0x38,
  0x00, 0x70, 0xE0, 0x18, 0x00, 0xF0, 0xC0, 0x18, 0x00, 0xB0, 0xC0, 0x1C,
  0x01, 0x30, 0xC0, 0x0E, 0x06, 0x70, 0xC0, 0x07, 0xFC, 0x60, 0xC0, 0x03,
  0xF8, 0x60, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x03,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00,
  0x07, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x18, 0x06, 0x00,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x38, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x03, 0x00, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x38, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x38, 0x60, 0x00,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x0C, 0xE0,
  0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x18, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00,
  0x0C, 0x07, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x03, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0x70, 0x30, 0x00,
  0x00, 0x30, 0x38, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x0E, 0x06, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x07, 0x01, 0x80,
  0x00, 0x03, 0x01, 0xC0, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x70,
  0x00, 0x0F, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0C,
  0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x06, 0x03,
  0x80, 0x00, 0x03, 0x81, 0x80, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x70,
  0x60, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00,
  0x1C, 0x18, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00,
  0x7C, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x0E, 0x01, 0x80, 0x00, 0x07, 0x03, 0x00, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x20, 0xE0, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0xE0, 0x30, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0C,
  0x00, 0x1F, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00,
  0x18, 0x0E, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x00, 0x70, 0x30, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x1C, 0x18,
  0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x00, 0x60,
  0xE0, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x03,
  0x83, 0x00, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00,
  0x0E, 0x1C, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x00, 0xC1, 0xC0, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0x30, 0x38,
  0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x3C, 0x00, 0x60, 0x00, 0x3E,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xC0,
  0x00, 0x0C, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x06, 0x07, 0x00,
  0x00, 0x07, 0x06, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0xFF, 0xFC, 0xC0, 0x00, 0xFF, 0xFC, 0xC0, 0x01, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x38, 0xC0, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x00, 0xF0, 0x60, 0x00, 0x00, 0xE0, 0x60, 0x00,
  0x01, 0xE0, 0x70, 0x00, 0x03, 0x60, 0x38, 0x00, 0x02, 0x60, 0x38, 0x00,
  0x0C, 0xE0, 0x1E, 0x00, 0x1C, 0xE0, 0x0F, 0x80, 0x70, 0xC0, 0x03, 0xFF,
  0xE0, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x1C, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x18,
  0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x0C,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x30, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0x38, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x00, 0x70,
  0x0C, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00,
  0x06, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x0E, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x38, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00,
  0x1C, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x40, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x18, 0x00, 0x00,
  0xF0, 0x00, 0x60, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0xF0, 0x00, 0x00, 0x06, 0x07, 0xC0, 0x00, 0x00, 0x38, 0x3F, 0x00, 0x00,
  0x00, 0xE1, 0xCE, 0x00, 0x00, 0x03, 0x8E, 0x38, 0x00, 0x00, 0x0C, 0x70,
  0x70, 0x00, 0x00, 0x33, 0x81, 0xC0, 0x00, 0x00, 0xDC, 0x03, 0x80, 0x00,
  0x07, 0xE0, 0x0E, 0x00, 0x00, 0x1F, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00,
  0x18, 0x03, 0x80, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x00,
  0x00, 0x38, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x1B, 0x00, 0x00, 0x1B, 0x80, 0xD8, 0x00, 0x01,
  0xD8, 0x0E, 0xE0, 0x00, 0x0C, 0xC0, 0x73, 0x00, 0x00, 0xC6, 0x03, 0x18,
  0x00, 0x06, 0x30, 0x18, 0xC0, 0x00, 0x63, 0x80, 0xC7, 0x00, 0x07, 0x1C,
  0x06, 0x18, 0x00, 0x30, 0xC0, 0x70, 0xC0, 0x03, 0x06, 0x03, 0x87, 0x00,
  0x38, 0x30, 0x18, 0x18, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x18, 0x1C, 0x06,
  0x06, 0x00, 0xC0, 0xE0, 0x30, 0x38, 0x0C, 0x06, 0x03, 0x80, 0xC0, 0xE0,
  0x30, 0x1C, 0x06, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x60, 0x0C, 0x06, 0x00,
  0xC7, 0x00, 0xE0, 0x30, 0x06, 0x30, 0x07, 0x01, 0x80, 0x33, 0x80, 0x30,
  0x1C, 0x01, 0xD8, 0x01, 0x80, 0xE0, 0x07, 0x80, 0x0C, 0x06, 0x00, 0x3C,
  0x00, 0x60, 0x30, 0x01, 0xC0, 0x07, 0x01, 0x80, 0x06, 0x00, 0x30, 0x1C,
  0x00, 0x20, 0x01, 0x80, 0xE0, 0x02, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x00, 0x38, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x00, 0x60, 0x38,
  0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x01,
  0xC0, 0x60, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x30, 0x0F, 0x80, 0x00, 0x03, 0x00, 0xF8, 0x00, 0x00,
  0x30, 0x0D, 0x80, 0x00, 0x07, 0x00, 0xDC, 0x00, 0x00, 0x70, 0x1D, 0xC0,
  0x00, 0x06, 0x01, 0xCC, 0x00, 0x00, 0x60, 0x18, 0xC0, 0x00, 0x06, 0x01,
  0x8E, 0x00, 0x00, 0x60, 0x18, 0x60, 0x00, 0x0E, 0x01, 0x86, 0x00, 0x00,
  0xE0, 0x38, 0x70, 0x00, 0x0C, 0x03, 0x83, 0x00, 0x00, 0xC0, 0x30, 0x30,
  0x00, 0x0C, 0x03, 0x03, 0x80, 0x00, 0xC0, 0x30, 0x18, 0x00, 0x1C, 0x03,
  0x01, 0x80, 0x01, 0xC0, 0x70, 0x1C, 0x00, 0x18, 0x07, 0x00, 0xC0, 0x01,
  0x80, 0x60, 0x0C, 0x00, 0x18, 0x06, 0x00, 0xE0, 0x01, 0x80, 0x60, 0x06,
  0x00, 0x38, 0x06, 0x00, 0x60, 0x03, 0x80, 0xE0, 0x07, 0x00, 0x30, 0x0E,
  0x00, 0x70, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x38, 0x03,
  0x00, 0xC0, 0x03, 0x80, 0x70, 0x0C, 0x00, 0x18, 0x07, 0x01, 0xC0, 0x01,
  0xC0, 0x60, 0x1C, 0x00, 0x1C, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x18,
  0x00, 0x0E, 0x06, 0x01, 0x80, 0x00, 0xE0, 0xE0, 0x18, 0x00, 0x06, 0x0E,
  0x03, 0x80, 0x00, 0x70, 0xC0, 0x38, 0x00, 0x07, 0x0C, 0x03, 0x00, 0x00,
  0x30, 0xC0, 0x30, 0x00, 0x03, 0x8C, 0x03, 0x00, 0x00, 0x39, 0xC0, 0x30,
  0x00, 0x01, 0x9C, 0x07, 0x00, 0x00, 0x1D, 0x80, 0x70, 0x00, 0x01, 0xD8,
  0x06, 0x00, 0x00, 0x0D, 0x80, 0x60, 0x00, 0x00, 0xF8, 0x06, 0x00, 0x00,
  0x0F, 0x80, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x18,
  0x07, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00,
  0x07, 0x38, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x00, 0x19, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x01, 0x87, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x03, 0x00, 0x00, 0x7C, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x1C, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x03, 0x80, 0x60, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x00, 0x0C, 0x0E, 0x00, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00,
  0x38, 0x18, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x60, 0x00,
  0x00, 0x30, 0x1C, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x07, 0x80, 0x70,
  0x00, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x18, 0x07, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x0E, 0x30, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x01, 0xCC, 0x00,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x01, 0x87, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x01, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x03, 0x00, 0x00, 0x7C, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x1C, 0x00,
  0x00, 0x18, 0x03, 0x80, 0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x0C,
  0x0E, 0x00, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x0E, 0x06, 0x00, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0x38, 0x18,
  0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x30,
  0x1C, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x07, 0x80, 0x70, 0x00, 0x03,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x30, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x30, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00,
  0x60, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x38, 0x03, 0x00,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0x83, 0x80, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x00, 0x18, 0x38, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x07, 0x06, 0x00, 0x00, 0x03, 0x83, 0x00, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x00, 0xC1, 0xC0, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x01, 0x83, 0x80, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00,
  0x07, 0x03, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x80, 0xC0, 0x00,
  0x01, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x01, 0xC0, 0x0E, 0x00,
  0x01, 0xE0, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xD8,
  0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00,
  0xE0, 0xC0, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00,
  0x07, 0x03, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x00, 0x30, 0x0E, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x70, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x60, 0x01,
  0x80, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x1C, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x07,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x0C, 0x0E, 0x00, 0x00, 0x03, 0x83, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x00, 0x38, 0x60, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x00,
  0xC7, 0x00, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00,
  0x07, 0x06, 0x00, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x03, 0xC0, 0x06,
  0x07, 0x00, 0x1E, 0x00, 0x30, 0x38, 0x01, 0xF0, 0x01, 0x81, 0x80, 0x0D,
  0x80, 0x1C, 0x0C, 0x00, 0xEC, 0x00, 0xC0, 0x60, 0x06, 0x60, 0x06, 0x03,
  0x00, 0x73, 0x00, 0x30, 0x18, 0x03, 0x18, 0x03, 0x80, 0xC0, 0x38, 0xC0,
  0x18, 0x06, 0x01, 0x87, 0x00, 0xC0, 0x30, 0x0C, 0x38, 0x0E, 0x01, 0x80,
  0xC0, 0xC0, 0x70, 0x0C, 0x06, 0x06, 0x03, 0x00, 0xE0, 0x70, 0x30, 0x18,
  0x07, 0x03, 0x01, 0x81, 0xC0, 0x38, 0x38, 0x0C, 0x0C, 0x01, 0x81, 0x80,
  0x60, 0x60, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0x60, 0xC0, 0x1C, 0x38, 0x03,
  0x06, 0x00, 0xE1, 0x80, 0x18, 0x70, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x18,
  0x60, 0x06, 0x38, 0x00, 0xC7, 0x00, 0x31, 0x80, 0x06, 0x30, 0x01, 0x9C,
  0x00, 0x31, 0x80, 0x0C, 0xC0, 0x01, 0x8C, 0x00, 0xE6, 0x00, 0x0C, 0xE0,
  0x07, 0x60, 0x00, 0x76, 0x00, 0x3B, 0x00, 0x03, 0xB0, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x0D, 0x80, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x07,
  0x00, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x00,
  0x0C, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0x00, 0x67,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x00, 0x03, 0x83, 0x00, 0x00, 0x00, 0x18, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x06, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x03,
  0x38, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xE6,
  0x00, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x07, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x30, 0x01, 0xC0, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x38, 0x03, 0x80, 0x00, 0x18, 0x07, 0x00, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00,
  0x06, 0x38, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x20, 0xE0, 0x70, 0x70, 0x38, 0x18, 0x18, 0x0C, 0x0C, 0x06,
  0x06, 0x03, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x1C, 0x03, 0xE0,
  0x3C, 0x30, 0x0F, 0x00, 0x0C, 0x60, 0x38, 0x00, 0x0C, 0xC0, 0xE0, 0x00,
  0x09, 0x83, 0x80, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00,
  0xC7, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x0C,
  0x70, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x00, 0xE1, 0x80, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x07, 0x06, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x2C, 0x1C, 0x00, 0x00, 0xD8, 0x18, 0x00,
  0x01, 0x70, 0x38, 0x00, 0x06, 0xE0, 0x38, 0x00, 0x19, 0x80, 0x38, 0x00,
  0xE3, 0x00, 0x3C, 0x07, 0x87, 0xF8, 0x3F, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x3F, 0x80,
  0x01, 0x83, 0xFF, 0xE0, 0x03, 0x0F, 0x01, 0xE0, 0x0E, 0x30, 0x00, 0xE0,
  0x1C, 0xC0, 0x00, 0xE0, 0x33, 0x00, 0x00, 0xC0, 0x6C, 0x00, 0x01, 0xC0,
  0xD0, 0x00, 0x01, 0x81, 0xE0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0xC7, 0x00,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x0E, 0x30, 0x00,
  0x00, 0x1C, 0x60, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x63, 0x80, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0x03, 0x06, 0x80, 0x00, 0x0E, 0x0D, 0x80, 0x00, 0x38,
  0x19, 0x80, 0x00, 0xE0, 0x71, 0x80, 0x07, 0x80, 0xE1, 0xC0, 0x3E, 0x01,
  0x81, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x1C, 0x00, 0x3C, 0x03, 0x80,
  0x00, 0xE0, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x43, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x01, 0xC6, 0x00, 0x00, 0x18, 0x70, 0x00, 0x03, 0x03, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x1E, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xC0, 0x18, 0x00, 0x7F, 0xFC, 0x1C,
  0x00, 0xF8, 0x0F, 0x0E, 0x00, 0xF0, 0x00, 0xC6, 0x00, 0xE0, 0x00, 0x33,
  0x00, 0xE0, 0x00, 0x0D, 0x80, 0xE0, 0x00, 0x02, 0xC0, 0x60, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x07, 0x06, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x01, 0x83, 0x80, 0x00,
  0x00, 0xC1, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0x38, 0x30, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x81, 0x80,
  0x00, 0x01, 0xC0, 0xC0, 0x00, 0x01, 0xE0, 0x60, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x00, 0xB0, 0x1C, 0x00, 0x00, 0x58, 0x06, 0x00, 0x00, 0x5C, 0x03,
  0x80, 0x00, 0x6E, 0x00, 0xE0, 0x00, 0x67, 0x00, 0x38, 0x00, 0xE3, 0x00,
  0x0F, 0x01, 0xE1, 0x80, 0x03, 0xFF, 0xC0, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0x01, 0xF0,
  0x03, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x38,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x01, 0xCC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x67, 0x00, 0x00, 0x07,
  0x30, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x78, 0xC0,
  0x00, 0x0F, 0x06, 0x00, 0x07, 0xE0, 0x30, 0x07, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0x30, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x38, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x38, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x18, 0x00, 0x00, 0x00, 0x03, 0x83, 0x00, 0x00, 0x00, 0x00, 0x38, 0x60,
  0x00, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC1, 0xC0, 0x0F, 0x80, 0xF0,
  0xE0, 0x0F, 0x00, 0x0C, 0x60, 0x0E, 0x00, 0x03, 0x30, 0x0E, 0x00, 0x00,
  0xD8, 0x0E, 0x00, 0x00, 0x2C, 0x06, 0x00, 0x00, 0x1E, 0x06, 0x00, 0x00,
  0x0F, 0x07, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x00, 0xC1, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x70, 0x60, 0x00,
  0x00, 0x30, 0x70, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x0C, 0x1C, 0x00,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x83, 0x00,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x1C, 0x0C,
  0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0F, 0x01,
  0xC0, 0x00, 0x05, 0x80, 0x60, 0x00, 0x05, 0xC0, 0x38, 0x00, 0x06, 0xE0,
  0x0E, 0x00, 0x06, 0x60, 0x03, 0x80, 0x0E, 0x30, 0x00, 0xF0, 0x1E, 0x18,
  0x00, 0x3F, 0xFC, 0x0C, 0x00, 0x03, 0xF8, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x60, 0x04, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x01, 0xFC, 0x00, 0x70, 0x7F, 0xF0, 0x06,
  0x1E, 0x07, 0xC0, 0x63, 0x80, 0x1E, 0x06, 0x60, 0x00, 0xE0, 0x64, 0x00,
  0x07, 0x0E, 0x80, 0x00, 0x70, 0xF8, 0x00, 0x03, 0x0D, 0x00, 0x00, 0x30,
  0xE0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x1C, 0x00,
  0x00, 0x31, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x71, 0x80, 0x00, 0x07,
  0x18, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x38, 0x00, 0x00, 0x63, 0x80,
  0x00, 0x06, 0x30, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x01, 0xC6, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x18, 0xE0, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0x38, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x40, 0x06, 0x00, 0x0F, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xC0,
  0x1C, 0x00, 0x06, 0x03, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x1C, 0x70, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x06, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x04, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x60,
  0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x0C, 0x00, 0x0E,
  0x00, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0xF1, 0xC0, 0x00, 0x03, 0x98, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x07, 0xF0, 0x00, 0x0C,
  0x0F, 0xFF, 0x00, 0x03, 0x0F, 0x01, 0xF0, 0x01, 0xC7, 0x00, 0x1C, 0x00,
  0x73, 0x00, 0x03, 0x80, 0x1D, 0x80, 0x00, 0x60, 0x06, 0xC0, 0x00, 0x18,
  0x01, 0xA0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x06, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x30, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x00, 0x70, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x60, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x78, 0x00, 0x06, 0x00, 0xF8, 0x00, 0x01, 0x81, 0xF0, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x08, 0xC0, 0x1C, 0x00, 0x03, 0x30, 0x03, 0x00,
  0x03, 0x9C, 0x00, 0xE0, 0x01, 0xC7, 0x00, 0x18, 0x00, 0xE1, 0xC0, 0x07,
  0x00, 0x70, 0x60, 0x00, 0xE0, 0x38, 0x18, 0x00, 0x18, 0x1C, 0x06, 0x00,
  0x07, 0x0E, 0x03, 0x80, 0x00, 0xC7, 0x00, 0xE0, 0x00, 0x3B, 0x80, 0x38,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x30,
  0x18, 0x00, 0x1C, 0x06, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0x30, 0x07, 0x00, 0x0C, 0x03, 0x80, 0x03, 0x03, 0x80, 0x01, 0xC1,
  0xC0, 0x00, 0x71, 0xE0, 0x00, 0x18, 0xE0, 0x00, 0x06, 0x70, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x30,
  0xFF, 0x03, 0xFE, 0x03, 0x18, 0x38, 0x60, 0xE0, 0x32, 0x01, 0x8C, 0x07,
  0x03, 0x40, 0x1D, 0x80, 0x30, 0x78, 0x00, 0xD0, 0x03, 0x07, 0x80, 0x0E,
  0x00, 0x30, 0x70, 0x00, 0xE0, 0x03, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x60,
  0x01, 0xC0, 0x03, 0x06, 0x00, 0x1C, 0x00, 0x30, 0xE0, 0x01, 0x80, 0x03,
  0x0E, 0x00, 0x18, 0x00, 0x70, 0xC0, 0x01, 0x80, 0x07, 0x0C, 0x00, 0x18,
  0x00, 0x60, 0xC0, 0x03, 0x80, 0x06, 0x0C, 0x00, 0x38, 0x00, 0x61, 0xC0,
  0x03, 0x00, 0x06, 0x1C, 0x00, 0x30, 0x00, 0x61, 0x80, 0x03, 0x00, 0x0E,
  0x18, 0x00, 0x30, 0x00, 0xC1, 0x80, 0x07, 0x00, 0x0C, 0x18, 0x00, 0x70,
  0x00, 0xC3, 0x80, 0x06, 0x00, 0x0C, 0x38, 0x00, 0x60, 0x00, 0xC3, 0x00,
  0x06, 0x00, 0x1C, 0x30, 0x00, 0x60, 0x01, 0x83, 0x00, 0x0E, 0x00, 0x18,
  0x30, 0x00, 0xE0, 0x01, 0x87, 0x00, 0x0C, 0x00, 0x18, 0x70, 0x00, 0xC0,
  0x01, 0x86, 0x00, 0x0C, 0x00, 0x38, 0x60, 0x00, 0xC0, 0x03, 0x06, 0x00,
  0x1C, 0x00, 0x30, 0x60, 0x01, 0xC0, 0x03, 0x0E, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x01, 0xFC, 0x00, 0x70, 0x7F, 0xF0, 0x06, 0x1E, 0x07, 0xC0, 0x63,
  0x80, 0x1E, 0x06, 0x60, 0x00, 0xE0, 0x64, 0x00, 0x07, 0x0E, 0x80, 0x00,
  0x70, 0xF8, 0x00, 0x03, 0x0D, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x03, 0x0E,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x31, 0xC0, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x71, 0x80, 0x00, 0x07, 0x18, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x06, 0x38, 0x00, 0x00, 0x63, 0x80, 0x00, 0x06, 0x30, 0x00,
  0x00, 0xE3, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C,
  0x70, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0xC6, 0x00,
  0x00, 0x1C, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x01,
  0x8E, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x06, 0x07, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0x31, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x01,
  0x9C, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x71, 0x80,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x06, 0x0E, 0x00,
  0x00, 0x1C, 0x0C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x60,
  0xFF, 0xF8, 0x00, 0x30, 0xF0, 0x1E, 0x00, 0x38, 0xC0, 0x03, 0x80, 0x1C,
  0xC0, 0x00, 0xE0, 0x0C, 0xC0, 0x00, 0x30, 0x06, 0xC0, 0x00, 0x1C, 0x03,
  0x40, 0x00, 0x06, 0x01, 0xE0, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x03,
  0x07, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00,
  0xE0, 0xC0, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00,
  0x18, 0x38, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00,
  0x07, 0x06, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x01, 0x81, 0xC0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0xC0, 0x68, 0x00,
  0x00, 0xE0, 0x36, 0x00, 0x00, 0xE0, 0x19, 0x80, 0x00, 0xE0, 0x1C, 0x60,
  0x01, 0xE0, 0x0E, 0x1C, 0x03, 0xE0, 0x06, 0x07, 0xFF, 0xC0, 0x03, 0x00,
  0xFF, 0x80, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0xFC, 0x1C, 0x03, 0xE0, 0x3C, 0x38, 0x0F, 0x00, 0x0C,
  0x60, 0x38, 0x00, 0x0C, 0xC0, 0xE0, 0x00, 0x0D, 0x83, 0x80, 0x00, 0x0B,
  0x06, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x18, 0xE0,
  0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xE1, 0x80, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0x07, 0x86, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x3C, 0x1C, 0x00, 0x00, 0x58, 0x18, 0x00, 0x01, 0x30, 0x38, 0x00, 0x06,
  0xE0, 0x38, 0x00, 0x19, 0xC0, 0x38, 0x00, 0xE3, 0x00, 0x3C, 0x07, 0x86,
  0x00, 0x3F, 0xFE, 0x0C, 0x00, 0x1F, 0xE0, 0x18, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0x80, 0x07, 0x1E, 0x00, 0x00,
  0x03, 0x98, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x00, 0x68, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7C, 0x01, 0xF8,
  0x00, 0xE0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x07,
  0x03, 0x00, 0x00, 0x02, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x40, 0x00, 0x00, 0x18,
  0xE0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0xE0,
  0x1E, 0x00, 0x01, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x07, 0x00, 0x03,
  0x80, 0x03, 0x00, 0x07, 0x80, 0x01, 0x80, 0x07, 0x00, 0x00, 0xC0, 0x0E,
  0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38, 0x3C,
  0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x06, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x31, 0xC0, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x07,
  0x18, 0x00, 0x00, 0x71, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x63, 0x80,
  0x00, 0x06, 0x38, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00,
  0xE3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x0C, 0x70,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x01, 0xC6, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x38, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x07, 0x0C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x0F, 0x0C, 0x00, 0x00, 0xF0,
  0xC0, 0x00, 0x17, 0x0C, 0x00, 0x03, 0x60, 0xE0, 0x00, 0x26, 0x06, 0x00,
  0x04, 0x60, 0x70, 0x01, 0x86, 0x03, 0xC0, 0x70, 0xE0, 0x1F, 0xFE, 0x0E,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0C, 0xFF, 0xC0, 0x00, 0x3A,
  0x01, 0x80, 0x00, 0x38, 0x03, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x60,
  0x1C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x18, 0x0E,
  0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x01, 0xC0, 0x30, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x70, 0x03, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x0E,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x60, 0x01, 0xE0, 0x00, 0xC0, 0x07, 0x80,
  0x01, 0x80, 0x3C, 0x00, 0x07, 0x01, 0xF0, 0x00, 0x0E, 0x1F, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x18, 0x01,
  0x81, 0x80, 0x06, 0x00, 0xE0, 0x60, 0x01, 0x80, 0x18, 0x38, 0x00, 0x60,
  0x07, 0x0E, 0x00, 0x38, 0x00, 0xC3, 0x00, 0x0E, 0x00, 0x30, 0xC0, 0x03,
  0x00, 0x0C, 0x30, 0x00, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0x00, 0xC7, 0x00,
  0x0C, 0x00, 0x31, 0xC0, 0x07, 0x00, 0x0C, 0x60, 0x01, 0xC0, 0x03, 0x18,
  0x00, 0x60, 0x00, 0xC6, 0x00, 0x18, 0x00, 0x31, 0x80, 0x06, 0x00, 0x0C,
  0xE0, 0x01, 0x80, 0x03, 0x38, 0x00, 0x60, 0x00, 0xCC, 0x00, 0x38, 0x00,
  0x33, 0x00, 0x0C, 0x00, 0x0C, 0xC0, 0x03, 0x00, 0x03, 0x30, 0x00, 0xC0,
  0x00, 0xDC, 0x00, 0x30, 0x00, 0x77, 0x00, 0x0C, 0x00, 0x19, 0x80, 0x07,
  0x00, 0x06, 0x60, 0x01, 0x80, 0x01, 0x98, 0x00, 0x60, 0x00, 0xE6, 0x00,
  0x18, 0x00, 0x31, 0x80, 0x0E, 0x00, 0x1C, 0xE0, 0x03, 0x80, 0x06, 0x38,
  0x01, 0xE0, 0x03, 0x86, 0x00, 0x58, 0x00, 0xC1, 0x80, 0x33, 0x00, 0x70,
  0x70, 0x18, 0xC0, 0x38, 0x1E, 0x1C, 0x38, 0x3C, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x3F, 0xF0, 0x01, 0xF3, 0x80, 0xE0, 0xE0, 0x0F, 0x87, 0x03, 0x80,
  0xE0, 0x7C, 0x06, 0x0E, 0x00, 0xC1, 0xE0, 0x0E, 0x18, 0x01, 0xCF, 0x00,
  0x0C, 0x60, 0x03, 0x88, 0x00, 0x18, 0x80, 0x07, 0x00, 0x00, 0x33, 0x00,
  0x0E, 0x00, 0x00, 0x64, 0x00, 0x1C, 0x00, 0x00, 0x68, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x03, 0x60, 0x00, 0x07, 0x00, 0x04, 0xC0, 0x00, 0x0E, 0x00, 0x19,
  0x80, 0x00, 0x1C, 0x00, 0x23, 0x00, 0x06, 0x38, 0x00, 0xC6, 0x00, 0x3E,
  0x30, 0x03, 0x0E, 0x00, 0xE0, 0x60, 0x0E, 0x0C, 0x07, 0x80, 0xE0, 0x38,
  0x1C, 0x3C, 0x00, 0xE0, 0xE0, 0x19, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x01, 0xC0,
  0x00, 0x03, 0x01, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x07, 0x01, 0x80,
  0x00, 0x07, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x03, 0x80,
  0x00, 0x06, 0x03, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0E, 0x03, 0x00,
  0x00, 0x0E, 0x03, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x0C, 0x07, 0x00,
  0x00, 0x0C, 0x07, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x1C, 0x06, 0x00,
  0x00, 0x1C, 0x06, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x18, 0x0E, 0x00,
  0x00, 0x18, 0x0E, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x38, 0x0C, 0x00,
  0x00, 0x38, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x70, 0x0C, 0x00,
  0x00, 0x70, 0x0C, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0xF0, 0x0C, 0x00,
  0x01, 0xF0, 0x0C, 0x00, 0x03, 0x60, 0x0E, 0x00, 0x02, 0x60, 0x07, 0x00,
  0x04, 0x60, 0x07, 0x80, 0x1C, 0x60, 0x03, 0xC0, 0x78, 0xE0, 0x01, 0xFF,
  0xE0, 0xE0, 0x00, 0x3F, 0x80, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x40, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xC0, 0xF0, 0x1F, 0x80, 0xE0, 0xE0,
  0x01, 0xF0, 0x70, 0x60, 0x00, 0x1F, 0x30, 0x60, 0x00, 0x01, 0xF8, 0x30,
  0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x80, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x18, 0x00, 0xE0, 0x00,
  0x0C, 0x01, 0xC0, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x01, 0x81, 0xC0, 0x00,
  0x00, 0xC1, 0xF8, 0x00, 0x00, 0x61, 0xFF, 0xC0, 0x00, 0x30, 0xC1, 0xFF,
  0x00, 0x18, 0x60, 0x0F, 0xF8, 0x0E, 0x30, 0x00, 0x7F, 0xE7, 0x18, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03,
  0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xC0, 0xFF, 0x00, 0x00, 0x30, 0x70, 0xE0, 0x00, 0x1C, 0x30, 0x1C,
  0x00, 0x06, 0x18, 0x03, 0x80, 0x01, 0x8E, 0x00, 0x70, 0x00, 0xC3, 0x00,
  0x0E, 0x00, 0x71, 0x80, 0x01, 0x80, 0x18, 0x60, 0x00, 0x30, 0x0C, 0x30,
  0x00, 0x0F, 0x0E, 0x0C, 0x00, 0x00, 0xFF, 0x03, 0x00, 0x00, 0x1F, 0x80,
};

const GFXglyph IBMPlexMono_ExtraLightItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 12, 47, 41, 15, -47 },
  { 72, 15, 17, 41, 17, -50 },
  { 104, 41, 47, 41, 1, -47 },
  { 345, 37, 63, 41, 2, -55 },
  { 637, 45, 49, 41, -1, -48 },
  { 913, 39, 49, 41, 1, -48 },
  { 1152, 5, 17, 41, 22, -50 },
  { 1163, 22, 61, 41, 16, -52 },
  { 1331, 23, 61, 41, 4, -52 },
  { 1507, 35, 34, 41, 4, -37 },
  { 1656, 32, 34, 41, 5, -38 },
  { 1792, 11, 17, 41, 10, -6 },
  { 1816, 18, 2, 41, 12, -22 },
  { 1821, 6, 5, 41, 15, -5 },
  { 1825, 37, 61, 41, 2, -52 },
  { 2108, 33, 49, 41, 5, -48 },
  { 2311, 32, 47, 41, 3, -47 },
  { 2499, 34, 48, 41, 3, -48 },
  { 2703, 33, 49, 41, 3, -48 },
  { 2906, 35, 47, 41, 2, -47 },
  { 3112, 34, 48, 41, 4, -47 },
  { 3316, 30, 48, 41, 5, -47 },
  { 3496, 32, 47, 41, 8, -47 },
  { 3684, 34, 49, 41, 4, -48 },
  { 3893, 30, 48, 41, 7, -48 },
  { 4073, 11, 35, 41, 15, -35 },
  { 4122, 16, 46, 41, 10, -35 },
  { 4214, 33, 37, 41, 6, -39 },
  { 4367, 34, 14, 41, 4, -28 },
  { 4427, 33, 37, 41, 3, -39 },
  { 4580, 27, 48, 41, 10, -48 },
  { 4742, 32, 55, 41, 5, -48 },
  { 4962, 35, 47, 41, 0, -47 },
  { 5168, 33, 47, 41, 4, -47 },
  { 5362, 32, 49, 41, 6, -48 },
  { 5558, 34, 47, 41, 4, -47 },
  { 5758, 36, 47, 41, 4, -47 },
  { 5970, 36, 47, 41, 4, -47 },
  { 6182, 32, 49, 41, 6, -48 },
  { 6378, 36, 47, 41, 3, -47 },
  { 6590, 37, 47, 41, 3, -47 },
  { 6808, 32, 48, 41, 5, -47 },
  { 7000, 38, 47, 41, 4, -47 },
  { 7224, 26, 47, 41, 7, -47 },
  { 7377, 37, 47, 41, 3, -47 },
  { 7595, 36, 47, 41, 3, -47 },
  { 7807, 33, 49, 41, 5, -48 },
  { 8010, 35, 47, 41, 4, -47 },
  { 8216, 33, 60, 41, 5, -48 },
  { 8464, 35, 47, 41, 4, -47 },
  { 8670, 37, 49, 41, 2, -48 },
  { 8897, 36, 47, 41, 7, -47 },
  { 9109, 33, 48, 41, 6, -47 },
  { 9307, 34, 47, 41, 8, -47 },
  { 9507, 37, 47, 41, 5, -47 },
  { 9725, 42, 47, 41, 0, -47 },
  { 9972, 37, 47, 41, 7, -47 },
  { 10190, 41, 47, 41, 0, -47 },
  { 10431, 27, 61, 41, 13, -52 },
  { 10637, 16, 61, 41, 13, -52 },
  { 10759, 27, 61, 41, 2, -52 },
  { 10965, 32, 26, 41, 5, -47 },
  { 11069, 33, 2, 41, 0, 8 },
  { 11078, 8, 12, 41, 16, -52 },
  { 11090, 31, 37, 41, 5, -36 },
  { 11234, 31, 51, 41, 5, -50 },
  { 11432, 28, 37, 41, 6, -36 },
  { 11562, 33, 51, 41, 5, -50 },
  { 11773, 29, 37, 41, 6, -36 },
  { 11908, 43, 64, 41, -1, -50 },
  { 12252, 33, 50, 41, 3, -36 },
  { 12459, 28, 50, 41, 6, -50 },
  { 12634, 29, 52, 41, 6, -51 },
  { 12823, 28, 65, 41, 7, -51 },
  { 13051, 34, 51, 41, 5, -50 },
  { 13268, 26, 51, 41, 8, -50 },
  { 13434, 36, 36, 41, 2, -36 },
  { 13596, 28, 36, 41, 6, -36 },
  { 13722, 31, 37, 41, 5, -36 },
  { 13866, 33, 50, 41, 3, -36 },
  { 14073, 31, 50, 41, 5, -36 },
  { 14267, 33, 35, 41, 8, -35 },
  { 14412, 32, 37, 41, 4, -36 },
  { 14560, 33, 48, 41, 5, -47 },
  { 14758, 28, 36, 41, 7, -35 },
  { 14884, 31, 35, 41, 5, -35 },
  { 15020, 34, 36, 41, 4, -35 },
  { 15173, 39, 37, 41, 1, -36 },
  { 15354, 32, 49, 41, 3, -35 },
  { 15550, 33, 37, 41, 4, -36 },
  { 15703, 31, 61, 41, 8, -52 },
  { 15940, 12, 61, 41, 15, -52 },
  { 16032, 31, 61, 41, 3, -52 },
  { 16269, 34, 12, 41, 4, -27 },
};

const GFXfont IBMPlexMono_ExtraLightItalic68pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic68pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic68pt7bGlyphs,
  0x20, 0x7E, 88
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC68PT7B_H_
