#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC46PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x03, 0x03, 0x02, 0x02, 0x06, 0x06, 0x06, 0x06, 0x04, 0x04,
  0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0xF0, 0xF0, 0xE0, 0x30, 0x66, 0x08,
  0xC1, 0x18, 0x62, 0x0C, 0x41, 0x98, 0x33, 0x04, 0x60, 0x8C, 0x31, 0x06,
  0x60, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x40, 0x40, 0x00, 0x18, 0x18,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x40, 0x40, 0x00, 0x18, 0x18, 0x00, 0x02,
  0x03, 0x00, 0x00, 0x40, 0x40, 0x00, 0x18, 0x18, 0x00, 0x02, 0x03, 0x00,
  0x00, 0x40, 0x40, 0x0F, 0xF8, 0x1F, 0xF0, 0x02, 0x02, 0x00, 0x00, 0xC0,
  0x40, 0x00, 0x18, 0x18, 0x00, 0x02, 0x02, 0x00, 0x00, 0xC0, 0x40, 0x00,
  0x18, 0x18, 0x00, 0x02, 0x02, 0x00, 0x00, 0xC0, 0x40, 0x0F, 0xF8, 0x1F,
  0xF0, 0x02, 0x02, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x18, 0x18, 0x00, 0x02,
  0x02, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x18, 0x18, 0x00, 0x02, 0x02, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x02, 0x02, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xC2, 0x3C, 0x03,
  0x02, 0x0E, 0x06, 0x02, 0x03, 0x0C, 0x02, 0x01, 0x0C, 0x06, 0x00, 0x08,
  0x06, 0x00, 0x18, 0x06, 0x00, 0x18, 0x04, 0x00, 0x18, 0x04, 0x00, 0x18,
  0x04, 0x00, 0x08, 0x04, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x03,
  0x08, 0x00, 0x01, 0xC8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1B, 0x80, 0x00,
  0x18, 0x60, 0x00, 0x18, 0x30, 0x00, 0x10, 0x18, 0x00, 0x10, 0x18, 0x00,
  0x10, 0x08, 0x00, 0x10, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x0C, 0x00,
  0x20, 0x08, 0x00, 0x20, 0x18, 0x80, 0x20, 0x18, 0xC0, 0x20, 0x30, 0x60,
  0x60, 0x20, 0x30, 0x60, 0xE0, 0x1C, 0x63, 0x80, 0x07, 0xFE, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0x86, 0x00, 0x0C, 0x04, 0x06,
  0x00, 0x30, 0x10, 0x04, 0x00, 0xC0, 0x20, 0x0C, 0x01, 0x00, 0xC0, 0x18,
  0x04, 0x01, 0x00, 0x30, 0x18, 0x02, 0x00, 0x60, 0x60, 0x04, 0x00, 0x80,
  0x80, 0x18, 0x01, 0x02, 0x00, 0x10, 0x02, 0x0C, 0x00, 0x20, 0x0C, 0x30,
  0x00, 0x40, 0x10, 0x40, 0x00, 0xC0, 0x41, 0x00, 0x00, 0xC3, 0x06, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0x83, 0x0C, 0x00, 0x02, 0x08, 0x0C, 0x00,
  0x08, 0x20, 0x08, 0x00, 0x30, 0xC0, 0x10, 0x00, 0xC1, 0x00, 0x30, 0x01,
  0x02, 0x00, 0x60, 0x04, 0x04, 0x00, 0x80, 0x18, 0x18, 0x01, 0x00, 0x60,
  0x30, 0x02, 0x00, 0x80, 0x60, 0x0C, 0x02, 0x00, 0xC0, 0x10, 0x0C, 0x00,
  0x80, 0x20, 0x30, 0x01, 0x80, 0x80, 0x40, 0x01, 0x86, 0x01, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x00, 0x40,
  0x00, 0x60, 0x0C, 0x00, 0x08, 0x00, 0x80, 0x03, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80,
  0x06, 0x00, 0x20, 0x00, 0x40, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80,
  0x60, 0x00, 0x18, 0x08, 0x00, 0x03, 0x02, 0x00, 0x03, 0xB1, 0x80, 0x01,
  0x83, 0xC0, 0x00, 0x40, 0x60, 0x00, 0x18, 0x06, 0x00, 0x02, 0x00, 0x40,
  0x00, 0xC0, 0x0C, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40,
  0x01, 0x80, 0x18, 0x00, 0x30, 0x03, 0x00, 0x07, 0x00, 0xA0, 0x00, 0xA0,
  0x24, 0x00, 0x16, 0x0C, 0xC0, 0x04, 0x41, 0x18, 0x00, 0x8C, 0x61, 0x80,
  0x20, 0xC8, 0x1C, 0x18, 0x0A, 0x00, 0xFC, 0x01, 0xC0, 0x2D, 0xB6, 0x96,
  0xDB, 0x40, 0x00, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x10, 0x06, 0xF0, 0x20, 0xF8,
  0x3C, 0x4F, 0x80, 0x0F, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x36, 0x00, 0x00, 0xC6, 0x00, 0x03, 0x04, 0x00, 0x0C, 0x0C, 0x00, 0x30,
  0x08, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x06, 0x00, 0x30, 0x18, 0x00,
  0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x0E, 0x1C, 0x30, 0xE1, 0x87, 0x0C, 0x18, 0x60, 0xC1,
  0x06, 0x00, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xC0, 0xC0, 0x06, 0x00, 0xC0,
  0x18, 0x00, 0xC0, 0x60, 0x00, 0x81, 0x80, 0x01, 0x82, 0x00, 0x01, 0x0C,
  0x00, 0x02, 0x18, 0x00, 0x04, 0x20, 0x00, 0x08, 0xC0, 0x00, 0x19, 0x80,
  0x00, 0x32, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x98, 0x00, 0x01, 0x30, 0x1C,
  0x02, 0x60, 0x38, 0x0C, 0x80, 0x70, 0x19, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x98, 0x00, 0x01, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C,
  0xC0, 0x00, 0x11, 0x80, 0x00, 0x61, 0x00, 0x00, 0x82, 0x00, 0x03, 0x06,
  0x00, 0x04, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x08, 0x01, 0x80, 0x0C,
  0x0C, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x6C, 0x00, 0x06,
  0x60, 0x00, 0x63, 0x00, 0x0C, 0x10, 0x00, 0xC1, 0x80, 0x0C, 0x0C, 0x01,
  0x80, 0x60, 0x18, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xC0, 0xE0, 0x06,
  0x00, 0x60, 0x18, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x80, 0x00, 0x83, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0x81, 0x80, 0x30, 0x01,
  0x81, 0x80, 0x02, 0x04, 0x00, 0x0C, 0x10, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0xFE, 0x00, 0x04, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x23,
  0x00, 0x01, 0x86, 0x00, 0x0C, 0x1C, 0x00, 0x60, 0x1C, 0x07, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x4C, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x8C, 0x00,
  0x03, 0x08, 0x00, 0x06, 0x08, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x18, 0x00,
  0x18, 0x18, 0x00, 0x30, 0x18, 0x00, 0x60, 0x10, 0x00, 0xC0, 0x10, 0x01,
  0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x30, 0x0C,
  0x00, 0x20, 0x18, 0x00, 0x20, 0x30, 0x00, 0x60, 0x60, 0x00, 0x60, 0xE0,
  0x00, 0x60, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x03, 0xFF, 0xFE, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x1F, 0xC0, 0x06, 0xC0, 0x60, 0x0A, 0x00, 0x60,
  0x18, 0x00, 0x60, 0x40, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x08, 0x00,
  0x0C, 0x18, 0x00, 0x18, 0x18, 0x00, 0x60, 0x1E, 0x07, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x3F, 0x80, 0x4E, 0x07, 0x06, 0xC0, 0x0C, 0x28, 0x00, 0x33, 0x80, 0x01,
  0x9C, 0x00, 0x04, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x12, 0x00, 0x01, 0x90, 0x00, 0x0C,
  0x80, 0x00, 0xC6, 0x00, 0x06, 0x10, 0x00, 0x60, 0x40, 0x06, 0x01, 0x81,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0xFD, 0x80, 0x00, 0x36, 0x00, 0x01,
  0x98, 0x00, 0x06, 0x40, 0x00, 0x31, 0x00, 0x01, 0x84, 0x00, 0x06, 0x30,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01,
  0x80, 0xE0, 0x0C, 0x00, 0x60, 0x30, 0x00, 0x60, 0x40, 0x00, 0xC1, 0x80,
  0x00, 0x82, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00,
  0x08, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x60, 0x80, 0x01, 0x81, 0x80, 0x02,
  0x01, 0x80, 0x18, 0x01, 0xC0, 0xE0, 0x00, 0xFE, 0x00, 0x0E, 0x03, 0x80,
  0x60, 0x01, 0x81, 0x80, 0x01, 0x86, 0x00, 0x01, 0x08, 0x00, 0x03, 0x30,
  0x00, 0x06, 0x60, 0x00, 0x0C, 0x80, 0x00, 0x19, 0x00, 0x00, 0x32, 0x00,
  0x00, 0x64, 0x00, 0x00, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x18, 0x00,
  0x10, 0x18, 0x00, 0xC0, 0x1C, 0x07, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x70, 0x38, 0x0C, 0x00, 0xC1, 0x80, 0x06, 0x30, 0x00, 0x26, 0x00,
  0x02, 0x40, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x06, 0xC0, 0x00, 0x6C,
  0x00, 0x0E, 0x60, 0x01, 0x63, 0x00, 0x24, 0x18, 0x0C, 0xC0, 0x7F, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x1C, 0x78,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x3C, 0x78, 0xE0, 0x01, 0xC0, 0x70, 0x3C, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0xE0,
  0x30, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x08, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x03, 0x01, 0x83, 0x80, 0x11, 0x80, 0x02, 0x60, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x01,
  0xF0, 0x03, 0xF0, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0x81, 0x80, 0x18, 0x01,
  0x00, 0x40, 0x06, 0x02, 0x00, 0x08, 0x18, 0x00, 0x30, 0x40, 0x00, 0xC3,
  0x00, 0x03, 0x08, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0xFC, 0xC4, 0x06,
  0x0B, 0x10, 0x30, 0x28, 0xC1, 0x80, 0x63, 0x04, 0x01, 0x88, 0x30, 0x06,
  0x20, 0xC0, 0x18, 0x82, 0x00, 0x66, 0x08, 0x01, 0x18, 0x20, 0x04, 0x61,
  0x80, 0x11, 0x86, 0x00, 0xC4, 0x18, 0x03, 0x10, 0x60, 0x0C, 0x41, 0x80,
  0x61, 0x02, 0x01, 0x84, 0x0C, 0x0A, 0x30, 0x18, 0x48, 0x40, 0x3E, 0x61,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x05, 0x80, 0x00, 0x1B,
  0x00, 0x00, 0x26, 0x00, 0x00, 0xC4, 0x00, 0x01, 0x08, 0x00, 0x06, 0x18,
  0x00, 0x08, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x01, 0x80, 0x80,
  0x03, 0x01, 0x00, 0x0C, 0x02, 0x00, 0x18, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x10, 0x06, 0x00, 0x20, 0x18, 0x00, 0x40, 0x3F,
  0xFF, 0xC0, 0xC0, 0x01, 0x81, 0x00, 0x03, 0x06, 0x00, 0x02, 0x0C, 0x00,
  0x04, 0x30, 0x00, 0x08, 0x60, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x07, 0xFF, 0xC0,
  0x10, 0x01, 0xC0, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x08, 0x30,
  0x00, 0x30, 0x80, 0x00, 0xC2, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00,
  0x21, 0x80, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x30, 0x40, 0x01, 0x83,
  0x00, 0x0C, 0x0F, 0xFF, 0xC0, 0x30, 0x00, 0xC0, 0xC0, 0x01, 0x82, 0x00,
  0x03, 0x08, 0x00, 0x04, 0x60, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x01,
  0x98, 0x00, 0x06, 0x40, 0x00, 0x11, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30,
  0x00, 0x08, 0xC0, 0x00, 0x63, 0x00, 0x03, 0x0C, 0x00, 0x38, 0x3F, 0xFF,
  0x80, 0x00, 0x3F, 0x80, 0x03, 0x83, 0x80, 0x18, 0x03, 0x00, 0x80, 0x06,
  0x06, 0x00, 0x08, 0x30, 0x00, 0x30, 0x80, 0x00, 0x86, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x04, 0x30, 0x00, 0x18, 0x40, 0x00, 0x61, 0x80, 0x03, 0x03,
  0x00, 0x18, 0x04, 0x00, 0xC0, 0x0C, 0x0E, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x0C, 0x01, 0x80, 0x10, 0x00, 0xC0, 0x20, 0x00, 0xC0, 0xC0,
  0x00, 0x81, 0x80, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x02, 0x08, 0x00,
  0x04, 0x10, 0x00, 0x08, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00,
  0x43, 0x00, 0x00, 0x84, 0x00, 0x01, 0x08, 0x00, 0x06, 0x30, 0x00, 0x0C,
  0x60, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x00, 0x84,
  0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x08, 0x60, 0x00, 0x30, 0xC0,
  0x00, 0x41, 0x80, 0x01, 0x82, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x18, 0x00,
  0x60, 0x30, 0x03, 0x80, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0x03,
  0x80, 0x10, 0x03, 0x00, 0x80, 0x06, 0x04, 0x00, 0x18, 0x30, 0x00, 0x31,
  0x80, 0x00, 0x84, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x07, 0xFC, 0xC0, 0x20, 0x33, 0x00, 0x00, 0xC8, 0x00, 0x03, 0x20, 0x00,
  0x08, 0x80, 0x00, 0x23, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x18,
  0x40, 0x00, 0xE1, 0x80, 0x05, 0x06, 0x00, 0x14, 0x0C, 0x00, 0xB0, 0x1C,
  0x0C, 0xC0, 0x1F, 0xC0, 0x00, 0x02, 0x00, 0x01, 0x83, 0x00, 0x00, 0x81,
  0x80, 0x00, 0x40, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x20, 0x00, 0x18,
  0x10, 0x00, 0x0C, 0x18, 0x00, 0x04, 0x0C, 0x00, 0x02, 0x06, 0x00, 0x03,
  0x03, 0x00, 0x01, 0x81, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x60, 0xC0, 0x00,
  0x20, 0x60, 0x00, 0x10, 0x3F, 0xFF, 0xF8, 0x18, 0x00, 0x0C, 0x08, 0x00,
  0x06, 0x04, 0x00, 0x03, 0x06, 0x00, 0x01, 0x03, 0x00, 0x01, 0x81, 0x80,
  0x00, 0xC0, 0xC0, 0x00, 0x60, 0x40, 0x00, 0x30, 0x20, 0x00, 0x18, 0x30,
  0x00, 0x08, 0x18, 0x00, 0x04, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x02,
  0x00, 0x01, 0x81, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x40, 0x07, 0xFF, 0xFF,
  0x80, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x01, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x01, 0x80, 0x0C, 0x06,
  0x00, 0x60, 0x0E, 0x06, 0x00, 0x0F, 0xE0, 0x00, 0x06, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0xC0, 0x40, 0x00, 0x60, 0x10, 0x00, 0x30, 0x0C, 0x00, 0x18,
  0x03, 0x00, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x08, 0x01,
  0x80, 0x02, 0x01, 0xC0, 0x01, 0x80, 0xE0, 0x00, 0x60, 0x70, 0x00, 0x18,
  0x38, 0x00, 0x06, 0x18, 0x00, 0x01, 0x0F, 0x00, 0x00, 0x46, 0xC0, 0x00,
  0x33, 0x18, 0x00, 0x0D, 0x86, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0xE0, 0x30,
  0x00, 0x30, 0x06, 0x00, 0x08, 0x01, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x60, 0x04, 0x00, 0x0C, 0x01,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x03,
  0x03, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x07, 0xFF, 0xFF, 0x06, 0x00, 0x01, 0x83,
  0x80, 0x01, 0xC1, 0xC0, 0x01, 0xE1, 0xA0, 0x00, 0xB0, 0xD8, 0x00, 0xD8,
  0x6C, 0x00, 0xC8, 0x32, 0x00, 0x44, 0x11, 0x00, 0x66, 0x08, 0xC0, 0x23,
  0x0C, 0x60, 0x31, 0x86, 0x10, 0x30, 0xC3, 0x0C, 0x10, 0x41, 0x86, 0x18,
  0x20, 0x81, 0x18, 0x30, 0x40, 0x88, 0x18, 0x60, 0x6C, 0x0C, 0x30, 0x34,
  0x04, 0x18, 0x0E, 0x02, 0x0C, 0x06, 0x01, 0x04, 0x02, 0x01, 0x82, 0x01,
  0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x10, 0x60,
  0x00, 0x08, 0x20, 0x00, 0x0C, 0x10, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0C,
  0x00, 0x01, 0x06, 0x00, 0x00, 0x83, 0x00, 0x00, 0x41, 0x00, 0x00, 0x60,
  0x03, 0x00, 0x01, 0x83, 0xC0, 0x00, 0x81, 0xE0, 0x00, 0x40, 0xD0, 0x00,
  0x60, 0x6C, 0x00, 0x30, 0x26, 0x00, 0x18, 0x11, 0x00, 0x0C, 0x18, 0xC0,
  0x04, 0x0C, 0x60, 0x02, 0x06, 0x10, 0x03, 0x03, 0x0C, 0x01, 0x81, 0x06,
  0x00, 0xC0, 0x81, 0x00, 0x60, 0xC0, 0xC0, 0x20, 0x60, 0x60, 0x10, 0x30,
  0x30, 0x18, 0x18, 0x0C, 0x0C, 0x08, 0x06, 0x06, 0x04, 0x03, 0x03, 0x06,
  0x00, 0x81, 0x03, 0x00, 0x60, 0x81, 0x80, 0x30, 0xC0, 0xC0, 0x08, 0x60,
  0x40, 0x06, 0x30, 0x20, 0x03, 0x18, 0x30, 0x00, 0x88, 0x18, 0x00, 0x64,
  0x0C, 0x00, 0x36, 0x04, 0x00, 0x0B, 0x02, 0x00, 0x07, 0x81, 0x00, 0x03,
  0xC1, 0x80, 0x00, 0xC0, 0x00, 0x1F, 0x80, 0x01, 0xC0, 0xC0, 0x06, 0x00,
  0xC0, 0x18, 0x00, 0xC0, 0x60, 0x00, 0x81, 0x80, 0x01, 0x82, 0x00, 0x01,
  0x0C, 0x00, 0x02, 0x18, 0x00, 0x04, 0x20, 0x00, 0x08, 0xC0, 0x00, 0x19,
  0x80, 0x00, 0x32, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x98, 0x00, 0x01, 0x30,
  0x00, 0x02, 0x60, 0x00, 0x0C, 0x80, 0x00, 0x19, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x98, 0x00, 0x01, 0x30, 0x00, 0x06, 0x60, 0x00,
  0x0C, 0xC0, 0x00, 0x11, 0x80, 0x00, 0x61, 0x00, 0x00, 0x82, 0x00, 0x03,
  0x06, 0x00, 0x04, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x08, 0x01, 0x80,
  0x0C, 0x0C, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x08, 0x00, 0x30,
  0x10, 0x00, 0x30, 0x20, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x00, 0x43,
  0x00, 0x00, 0x86, 0x00, 0x01, 0x08, 0x00, 0x02, 0x10, 0x00, 0x0C, 0x60,
  0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x84, 0x00,
  0x06, 0x08, 0x00, 0x38, 0x3F, 0xFF, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xC0, 0xC0, 0x06, 0x00, 0xC0, 0x18,
  0x00, 0xC0, 0x60, 0x00, 0x81, 0x80, 0x01, 0x82, 0x00, 0x01, 0x0C, 0x00,
  0x02, 0x18, 0x00, 0x04, 0x20, 0x00, 0x08, 0xC0, 0x00, 0x19, 0x80, 0x00,
  0x32, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x98, 0x00, 0x01, 0x30, 0x00, 0x02,
  0x60, 0x00, 0x0C, 0x80, 0x00, 0x19, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0xD8, 0x00, 0x01, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0,
  0x00, 0x11, 0x80, 0x00, 0x61, 0x00, 0x00, 0x82, 0x00, 0x03, 0x06, 0x00,
  0x04, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x08, 0x01, 0x80, 0x0C, 0x0C,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x80, 0x03, 0x01,
  0x80, 0x03, 0x04, 0x00, 0x02, 0x30, 0x00, 0x06, 0xC0, 0x00, 0x07, 0x00,
  0x07, 0xFF, 0xE0, 0x08, 0x00, 0x30, 0x10, 0x00, 0x30, 0x20, 0x00, 0x30,
  0xC0, 0x00, 0x61, 0x80, 0x00, 0x43, 0x00, 0x00, 0x86, 0x00, 0x01, 0x08,
  0x00, 0x02, 0x10, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80,
  0x00, 0xC3, 0x00, 0x01, 0x84, 0x00, 0x06, 0x08, 0x00, 0x38, 0x3F, 0xFF,
  0x80, 0x60, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x80, 0x60, 0x02, 0x00, 0xC0,
  0x04, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x01, 0x00, 0x60, 0x03, 0x00,
  0xC0, 0x02, 0x01, 0x00, 0x06, 0x02, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x18,
  0x00, 0x18, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0x00, 0x3F, 0xE0, 0x00,
  0xC0, 0x38, 0x03, 0x00, 0x0E, 0x06, 0x00, 0x03, 0x04, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x80, 0x00, 0x18, 0xC0,
  0x00, 0x30, 0x60, 0x00, 0x20, 0x30, 0x00, 0xC0, 0x1E, 0x03, 0x80, 0x03,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x06, 0x30, 0x00, 0x08, 0x60, 0x00, 0x10, 0xC0,
  0x00, 0x61, 0x80, 0x00, 0xC2, 0x00, 0x01, 0x84, 0x00, 0x03, 0x18, 0x00,
  0x04, 0x30, 0x00, 0x08, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x00, 0x00,
  0xC2, 0x00, 0x01, 0x8C, 0x00, 0x02, 0x18, 0x00, 0x04, 0x30, 0x00, 0x18,
  0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x0C,
  0x00, 0x02, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0,
  0x00, 0x41, 0x00, 0x00, 0x82, 0x00, 0x03, 0x06, 0x00, 0x04, 0x0C, 0x00,
  0x18, 0x08, 0x00, 0x20, 0x18, 0x00, 0x80, 0x1C, 0x06, 0x00, 0x0F, 0xF0,
  0x00, 0x80, 0x00, 0x07, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x26, 0x00, 0x00,
  0xCC, 0x00, 0x01, 0x08, 0x00, 0x06, 0x10, 0x00, 0x08, 0x20, 0x00, 0x30,
  0x60, 0x00, 0x40, 0xC0, 0x01, 0x81, 0x80, 0x02, 0x03, 0x00, 0x0C, 0x02,
  0x00, 0x18, 0x04, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30,
  0x06, 0x00, 0x60, 0x18, 0x00, 0x40, 0x30, 0x00, 0x80, 0xC0, 0x01, 0x01,
  0x80, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60,
  0x00, 0x11, 0x80, 0x00, 0x23, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC4, 0x00, 0x00, 0x21, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0x43, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30,
  0x00, 0x02, 0x0C, 0x07, 0x00, 0x83, 0x01, 0xC0, 0x60, 0x80, 0x70, 0x18,
  0x20, 0x3C, 0x04, 0x08, 0x09, 0x03, 0x02, 0x06, 0x40, 0xC0, 0x81, 0x10,
  0x30, 0x20, 0xC4, 0x08, 0x18, 0x31, 0x06, 0x06, 0x18, 0x61, 0x81, 0x86,
  0x18, 0x40, 0x61, 0x06, 0x10, 0x18, 0xC1, 0x8C, 0x06, 0x20, 0x23, 0x01,
  0x98, 0x08, 0x80, 0x44, 0x02, 0x20, 0x13, 0x00, 0x98, 0x04, 0xC0, 0x26,
  0x01, 0x60, 0x0D, 0x00, 0x58, 0x03, 0x40, 0x14, 0x00, 0xF0, 0x0F, 0x00,
  0x3C, 0x03, 0x80, 0x06, 0x00, 0x03, 0x00, 0x00, 0x38, 0x08, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x18, 0x01, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x00,
  0x20, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0x04, 0x01, 0x80, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x10, 0xC0,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x80, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x10, 0x01, 0x80,
  0x00, 0xC0, 0x18, 0x00, 0x02, 0x01, 0x80, 0x00, 0x18, 0x1C, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0x90, 0x00, 0x01, 0x8C, 0x00,
  0x01, 0x82, 0x00, 0x01, 0x81, 0x80, 0x01, 0x80, 0x40, 0x00, 0xC0, 0x30,
  0x00, 0xC0, 0x18, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x00,
  0xC0, 0x60, 0x00, 0x60, 0x60, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x60, 0x00,
  0x02, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x80, 0x18, 0x01, 0x00, 0x20, 0x04,
  0x00, 0xC0, 0x18, 0x01, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00,
  0x20, 0x06, 0x00, 0x40, 0x08, 0x01, 0x00, 0x30, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x80, 0x30, 0x02, 0x00, 0x40, 0x08, 0x01, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x0C, 0x00, 0x80, 0x10, 0x02, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x60, 0x01, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0xFF, 0xF0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0C, 0x80, 0x00, 0x46, 0x00, 0x06,
  0x30, 0x00, 0x60, 0x80, 0x06, 0x06, 0x00, 0x20, 0x10, 0x03, 0x00, 0xC0,
  0x30, 0x02, 0x03, 0x00, 0x18, 0x10, 0x00, 0xC1, 0x80, 0x02, 0x18, 0x00,
  0x19, 0x80, 0x00, 0x48, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0xFF, 0xFF, 0xFC, 0x46, 0x18, 0xC3, 0x08, 0x61, 0x00, 0xFE, 0x18, 0x1C,
  0x18, 0xC1, 0x80, 0x36, 0x18, 0x00, 0xB1, 0x80, 0x03, 0x18, 0x00, 0x18,
  0xC0, 0x00, 0xC4, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x01, 0x90, 0x00,
  0x09, 0x80, 0x00, 0x4C, 0x00, 0x02, 0x60, 0x00, 0x33, 0x00, 0x01, 0x98,
  0x00, 0x0C, 0xC0, 0x00, 0x46, 0x00, 0x06, 0x30, 0x00, 0x30, 0x80, 0x03,
  0x84, 0x00, 0x1C, 0x30, 0x01, 0x60, 0xC0, 0x12, 0x03, 0x83, 0x1F, 0x07,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC1, 0xF8, 0x03, 0x18, 0x30, 0x0D,
  0x80, 0x20, 0x24, 0x00, 0xC0, 0xA0, 0x01, 0x87, 0x00, 0x06, 0x1C, 0x00,
  0x08, 0x60, 0x00, 0x21, 0x80, 0x00, 0x84, 0x00, 0x03, 0x10, 0x00, 0x08,
  0xC0, 0x00, 0x23, 0x00, 0x00, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x18, 0x80,
  0x00, 0x62, 0x00, 0x01, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x01,
  0x87, 0x00, 0x04, 0x14, 0x00, 0x30, 0x48, 0x01, 0x83, 0x18, 0x18, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x60, 0x70, 0x30, 0x03, 0x0C, 0x00,
  0x21, 0x00, 0x06, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x01,
  0x60, 0x00, 0x64, 0x00, 0x18, 0xC0, 0x06, 0x0C, 0x01, 0x80, 0xE0, 0xE0,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x03, 0xF8, 0x20, 0x1C,
  0x0C, 0xC0, 0x60, 0x0D, 0x81, 0x80, 0x0B, 0x06, 0x00, 0x0C, 0x18, 0x00,
  0x18, 0x30, 0x00, 0x30, 0x40, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x01,
  0x84, 0x00, 0x03, 0x18, 0x00, 0x04, 0x30, 0x00, 0x08, 0x60, 0x00, 0x30,
  0xC0, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x06, 0x0C,
  0x00, 0x0C, 0x08, 0x00, 0x38, 0x18, 0x00, 0x70, 0x30, 0x01, 0x60, 0x30,
  0x04, 0xC0, 0x38, 0x31, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x38,
  0x18, 0x06, 0x00, 0x40, 0xC0, 0x06, 0x18, 0x00, 0x23, 0x00, 0x02, 0x20,
  0x00, 0x36, 0x00, 0x02, 0x40, 0x00, 0x6C, 0x00, 0x0C, 0xC0, 0x01, 0x8C,
  0x00, 0x70, 0xC0, 0xF8, 0x0F, 0xF8, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x04, 0xC0, 0x00, 0x6C, 0x00, 0x0C, 0x40, 0x00,
  0x86, 0x00, 0x10, 0x30, 0x06, 0x01, 0xC0, 0xC0, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x02,
  0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x06, 0x40, 0x00,
  0x00, 0x0D, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7F, 0x04, 0x07,
  0x03, 0x30, 0x30, 0x06, 0xC1, 0x80, 0x0B, 0x0C, 0x00, 0x18, 0x60, 0x00,
  0x61, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x18, 0x80, 0x00, 0x62,
  0x00, 0x01, 0x18, 0x00, 0x04, 0x60, 0x00, 0x11, 0x80, 0x00, 0xC6, 0x00,
  0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x21, 0x80, 0x01, 0x82, 0x00, 0x0A,
  0x08, 0x00, 0x38, 0x30, 0x01, 0x60, 0x60, 0x09, 0x80, 0xE0, 0xC6, 0x00,
  0xFC, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x08, 0x00, 0x30, 0x30, 0x01, 0x80,
  0x70, 0x1C, 0x00, 0x3F, 0x80, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0xFC, 0x0C, 0x60, 0xC1, 0x90,
  0x0C, 0x34, 0x00, 0xC7, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x26, 0x00,
  0x0C, 0xC0, 0x01, 0x98, 0x00, 0x33, 0x00, 0x06, 0x40, 0x00, 0xC8, 0x00,
  0x13, 0x00, 0x02, 0x60, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x03, 0x20, 0x00,
  0x64, 0x00, 0x09, 0x80, 0x01, 0x30, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x01,
  0x90, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x02, 0x01, 0x00, 0x70, 0x30,
  0x0C, 0x03, 0x01, 0x00, 0x30, 0x60, 0x03, 0x0C, 0x00, 0x21, 0x00, 0x06,
  0x60, 0x00, 0x6C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x60, 0x08, 0x06, 0x01, 0x00, 0x60,
  0x20, 0x06, 0x0C, 0x00, 0x61, 0x80, 0x06, 0x30, 0x00, 0x66, 0x00, 0x06,
  0x80, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x7E, 0x00,
  0x63, 0x07, 0x00, 0xD8, 0x03, 0x01, 0x20, 0x06, 0x02, 0x80, 0x04, 0x0E,
  0x00, 0x08, 0x18, 0x00, 0x10, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x80,
  0x03, 0x01, 0x00, 0x0C, 0x06, 0x00, 0x20, 0x0C, 0x03, 0x80, 0x18, 0x18,
  0x00, 0x30, 0xC0, 0x00, 0x41, 0x80, 0x00, 0x81, 0x80, 0x03, 0x03, 0x00,
  0x16, 0x03, 0x00, 0x4C, 0x02, 0x01, 0x18, 0x06, 0x04, 0x20, 0x04, 0x30,
  0x40, 0x0C, 0xC1, 0x80, 0x0B, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0xE0, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x61, 0x80, 0x40, 0x80, 0xC0, 0xC0,
  0xC0, 0x60, 0x80, 0x31, 0x80, 0x19, 0x00, 0x0B, 0x00, 0x07, 0x00, 0x00,
  0x18, 0xF0, 0x3C, 0x19, 0x08, 0xC6, 0x1E, 0x0D, 0x03, 0x1C, 0x06, 0x03,
  0x18, 0x06, 0x03, 0x10, 0x04, 0x03, 0x30, 0x0C, 0x03, 0x30, 0x0C, 0x03,
  0x30, 0x0C, 0x03, 0x30, 0x08, 0x02, 0x20, 0x08, 0x02, 0x20, 0x08, 0x06,
  0x60, 0x18, 0x06, 0x60, 0x18, 0x06, 0x60, 0x18, 0x06, 0x60, 0x10, 0x04,
  0x40, 0x10, 0x04, 0x40, 0x10, 0x0C, 0xC0, 0x30, 0x0C, 0xC0, 0x30, 0x0C,
  0xC0, 0x30, 0x0C, 0xC0, 0x20, 0x08, 0x80, 0x20, 0x08, 0x80, 0x60, 0x18,
  0x08, 0x3F, 0x03, 0x18, 0x30, 0x64, 0x03, 0x0D, 0x00, 0x31, 0xC0, 0x06,
  0x30, 0x00, 0xC6, 0x00, 0x09, 0x80, 0x03, 0x30, 0x00, 0x66, 0x00, 0x0C,
  0xC0, 0x01, 0x90, 0x00, 0x32, 0x00, 0x04, 0xC0, 0x00, 0x98, 0x00, 0x33,
  0x00, 0x06, 0x60, 0x00, 0xC8, 0x00, 0x19, 0x00, 0x02, 0x60, 0x00, 0x4C,
  0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x64, 0x00, 0x08, 0x00, 0xFE, 0x00,
  0x30, 0x38, 0x0C, 0x00, 0xC1, 0x80, 0x04, 0x10, 0x00, 0x23, 0x00, 0x02,
  0x60, 0x00, 0x36, 0x00, 0x03, 0x40, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x28, 0x00,
  0x06, 0x80, 0x00, 0x68, 0x00, 0x06, 0x80, 0x00, 0xCC, 0x00, 0x0C, 0x40,
  0x01, 0x86, 0x00, 0x30, 0x30, 0x06, 0x01, 0x81, 0xC0, 0x07, 0xF0, 0x00,
  0x06, 0x0F, 0xC0, 0x0C, 0x60, 0xC0, 0x1B, 0x00, 0x40, 0x24, 0x00, 0xC0,
  0x50, 0x00, 0xC1, 0xC0, 0x01, 0x83, 0x80, 0x01, 0x06, 0x00, 0x02, 0x0C,
  0x00, 0x04, 0x10, 0x00, 0x0C, 0x20, 0x00, 0x10, 0xC0, 0x00, 0x21, 0x80,
  0x00, 0x43, 0x00, 0x01, 0x86, 0x00, 0x03, 0x08, 0x00, 0x06, 0x10, 0x00,
  0x08, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x01, 0x83, 0x80, 0x02,
  0x05, 0x00, 0x0C, 0x09, 0x00, 0x30, 0x31, 0x81, 0x80, 0x60, 0xFE, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x08, 0x1C, 0x0C, 0xC1, 0x80, 0x36, 0x18, 0x00, 0xB1, 0x80, 0x03,
  0x18, 0x00, 0x18, 0xC0, 0x00, 0xC4, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00,
  0x01, 0x90, 0x00, 0x09, 0x80, 0x00, 0x4C, 0x00, 0x02, 0x60, 0x00, 0x33,
  0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x46, 0x00, 0x06, 0x30, 0x00,
  0x30, 0x80, 0x03, 0x86, 0x00, 0x1C, 0x30, 0x01, 0x60, 0xC0, 0x12, 0x03,
  0x83, 0x10, 0x07, 0xE0, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0xFF, 0xC3, 0xFC, 0x03, 0x30, 0x00, 0x0D, 0x00, 0x00, 0x28,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x1C,
  0x07, 0x01, 0x80, 0x0C, 0x18, 0x00, 0x31, 0x80, 0x01, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x6C, 0x00, 0x02, 0x30, 0x00, 0x30, 0xC0, 0x03, 0x03, 0x80, 0x60, 0x03,
  0xFC, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x30, 0x18,
  0x03, 0x00, 0x60, 0x18, 0x01, 0x81, 0x80, 0x06, 0x0C, 0x00, 0x18, 0xC0,
  0x00, 0x46, 0x00, 0x01, 0x60, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x31,
  0x80, 0x03, 0x10, 0x00, 0x21, 0x00, 0x02, 0x30, 0x00, 0x23, 0x00, 0x06,
  0x30, 0x00, 0x63, 0x00, 0x06, 0x20, 0x00, 0x42, 0x00, 0x04, 0x60, 0x00,
  0x46, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x40, 0x00, 0xC4, 0x00,
  0x08, 0x40, 0x00, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x38, 0x40,
  0x05, 0x86, 0x00, 0x50, 0x60, 0x09, 0x03, 0x83, 0x30, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x30, 0x30, 0x01, 0x81, 0x80, 0x04, 0x0C, 0x00, 0x20, 0x40,
  0x01, 0x02, 0x00, 0x0C, 0x10, 0x00, 0x41, 0x80, 0x02, 0x0C, 0x00, 0x10,
  0x60, 0x00, 0x83, 0x00, 0x0C, 0x10, 0x00, 0x60, 0x80, 0x02, 0x04, 0x00,
  0x30, 0x60, 0x01, 0x03, 0x00, 0x18, 0x18, 0x00, 0x80, 0xC0, 0x0C, 0x04,
  0x00, 0xC0, 0x20, 0x0C, 0x01, 0x00, 0xC0, 0x18, 0x18, 0x00, 0xC3, 0x80,
  0x03, 0xE0, 0x00, 0x18, 0x04, 0x0C, 0x20, 0x18, 0x08, 0x40, 0x30, 0x10,
  0x80, 0x60, 0x33, 0x00, 0xC0, 0x66, 0x01, 0x00, 0xCC, 0x02, 0x01, 0x90,
  0x04, 0x01, 0x20, 0x18, 0x02, 0x40, 0x30, 0x05, 0x80, 0x60, 0x1B, 0x00,
  0x80, 0x36, 0x01, 0x00, 0x6C, 0x02, 0x00, 0xD0, 0x0C, 0x01, 0xA0, 0x18,
  0x02, 0xC0, 0x30, 0x05, 0x80, 0x60, 0x1B, 0x00, 0x80, 0x26, 0x03, 0x00,
  0x4C, 0x0A, 0x01, 0x98, 0x14, 0x06, 0x30, 0x44, 0x08, 0x31, 0x8C, 0x60,
  0x3C, 0x0F, 0x80, 0x00, 0xE0, 0x1F, 0x00, 0xEC, 0x08, 0x60, 0xE1, 0x84,
  0x0C, 0xE0, 0x62, 0x03, 0x60, 0x09, 0x00, 0xC0, 0x02, 0x40, 0x30, 0x00,
  0xE0, 0x0C, 0x00, 0x38, 0x03, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x30, 0x06,
  0x00, 0x0C, 0x02, 0xC0, 0x02, 0x00, 0xB0, 0x00, 0x80, 0x64, 0x03, 0x30,
  0x11, 0x01, 0x8C, 0x08, 0x61, 0x81, 0x84, 0x09, 0xC0, 0x3E, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x40, 0x00, 0x81, 0x00, 0x02,
  0x0C, 0x00, 0x08, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x08,
  0x00, 0x18, 0x20, 0x00, 0x41, 0x80, 0x01, 0x06, 0x00, 0x0C, 0x18, 0x00,
  0x30, 0x60, 0x00, 0xC1, 0x00, 0x03, 0x04, 0x00, 0x08, 0x30, 0x00, 0x60,
  0xC0, 0x01, 0x83, 0x00, 0x0E, 0x04, 0x00, 0x58, 0x18, 0x01, 0x60, 0x60,
  0x09, 0x00, 0xE0, 0xC4, 0x00, 0xFC, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x08,
  0x00, 0x30, 0x30, 0x01, 0x80, 0x70, 0x18, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x06, 0x0C, 0x0F, 0x0C, 0x30, 0x03, 0xD8, 0x40, 0x01, 0xF1, 0x80,
  0x01, 0x83, 0x00, 0x06, 0x04, 0x00, 0x18, 0x08, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x10, 0x03, 0x00, 0x30,
  0x0C, 0x00, 0x60, 0x30, 0x00, 0xC0, 0xC0, 0x00, 0x83, 0x00, 0x01, 0x09,
  0xE0, 0x02, 0x10, 0x3C, 0x06, 0x60, 0x07, 0xCC, 0x00, 0x00, 0x70, 0x00,
  0x3F, 0xF0, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x1C,
  0x00, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0x01, 0x03, 0x03, 0x03, 0x03,
  0x02, 0x02, 0x06, 0x06, 0x06, 0x04, 0x04, 0x04, 0x0C, 0x0C, 0x0C, 0x08,
  0x08, 0x08, 0x18, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0x30, 0x30, 0x20,
  0x20, 0x20, 0x60, 0x60, 0x60, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0x01,
  0xFF, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0x80, 0x1E, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xC0, 0x03, 0x0C, 0x60, 0x02, 0x18, 0x30, 0x02, 0x30, 0x18, 0x06, 0x20,
  0x08, 0x04, 0x60, 0x04, 0x08, 0x40, 0x06, 0x10, 0xC0, 0x01, 0xE0,
};

const GFXglyph IBMPlexMono_ExtraLightItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 8, 32, 28, 10, -32 },
  { 33, 11, 12, 28, 11, -34 },
  { 50, 27, 32, 28, 1, -32 },
  { 158, 24, 44, 28, 2, -38 },
  { 290, 31, 34, 28, -1, -33 },
  { 422, 27, 34, 28, 0, -33 },
  { 537, 3, 12, 28, 15, -34 },
  { 542, 14, 41, 28, 11, -35 },
  { 614, 15, 41, 28, 3, -35 },
  { 691, 23, 23, 28, 3, -25 },
  { 758, 22, 22, 28, 3, -26 },
  { 819, 7, 12, 28, 7, -4 },
  { 830, 12, 1, 28, 8, -15 },
  { 832, 4, 4, 28, 10, -4 },
  { 834, 25, 41, 28, 2, -35 },
  { 963, 23, 34, 28, 3, -33 },
  { 1061, 21, 32, 28, 2, -32 },
  { 1145, 23, 33, 28, 2, -33 },
  { 1240, 22, 34, 28, 2, -33 },
  { 1334, 24, 32, 28, 1, -32 },
  { 1430, 23, 33, 28, 3, -32 },
  { 1525, 21, 33, 28, 3, -32 },
  { 1612, 22, 32, 28, 5, -32 },
  { 1700, 23, 34, 28, 3, -33 },
  { 1798, 20, 33, 28, 5, -33 },
  { 1881, 7, 25, 28, 10, -25 },
  { 1903, 10, 33, 28, 7, -25 },
  { 1945, 22, 25, 28, 4, -27 },
  { 2014, 24, 10, 28, 2, -19 },
  { 2044, 22, 25, 28, 2, -27 },
  { 2113, 18, 33, 28, 7, -33 },
  { 2188, 22, 38, 28, 3, -33 },
  { 2293, 23, 32, 28, 0, -32 },
  { 2385, 22, 32, 28, 3, -32 },
  { 2473, 22, 34, 28, 4, -33 },
  { 2567, 23, 32, 28, 3, -32 },
  { 2659, 24, 32, 28, 3, -32 },
  { 2755, 24, 32, 28, 3, -32 },
  { 2851, 22, 34, 28, 4, -33 },
  { 2945, 25, 32, 28, 2, -32 },
  { 3045, 25, 32, 28, 2, -32 },
  { 3145, 22, 33, 28, 3, -32 },
  { 3236, 26, 32, 28, 3, -32 },
  { 3340, 19, 32, 28, 4, -32 },
  { 3416, 25, 32, 28, 2, -32 },
  { 3516, 25, 32, 28, 2, -32 },
  { 3616, 23, 34, 28, 3, -33 },
  { 3714, 23, 32, 28, 3, -32 },
  { 3806, 23, 41, 28, 3, -33 },
  { 3924, 23, 32, 28, 3, -32 },
  { 4016, 24, 34, 28, 2, -33 },
  { 4118, 24, 32, 28, 5, -32 },
  { 4214, 23, 33, 28, 4, -32 },
  { 4309, 23, 32, 28, 6, -32 },
  { 4401, 26, 32, 28, 3, -32 },
  { 4505, 29, 32, 28, 0, -32 },
  { 4621, 25, 32, 28, 5, -32 },
  { 4721, 28, 32, 28, 0, -32 },
  { 4833, 18, 41, 28, 9, -35 },
  { 4926, 11, 41, 28, 9, -35 },
  { 4983, 18, 41, 28, 1, -35 },
  { 5076, 21, 18, 28, 4, -32 },
  { 5124, 22, 1, 28, 0, 6 },
  { 5127, 5, 8, 28, 11, -35 },
  { 5132, 21, 25, 28, 3, -24 },
  { 5198, 22, 35, 28, 3, -34 },
  { 5295, 19, 25, 28, 4, -24 },
  { 5355, 23, 35, 28, 3, -34 },
  { 5456, 20, 25, 28, 4, -24 },
  { 5519, 30, 44, 28, -1, -34 },
  { 5684, 22, 34, 28, 2, -24 },
  { 5778, 19, 34, 28, 4, -34 },
  { 5859, 20, 35, 28, 4, -34 },
  { 5947, 19, 44, 28, 5, -34 },
  { 6052, 23, 35, 28, 3, -34 },
  { 6153, 17, 35, 28, 6, -34 },
  { 6228, 24, 24, 28, 2, -24 },
  { 6300, 19, 24, 28, 4, -24 },
  { 6357, 20, 25, 28, 4, -24 },
  { 6420, 23, 33, 28, 2, -24 },
  { 6515, 21, 33, 28, 3, -24 },
  { 6602, 22, 24, 28, 5, -24 },
  { 6668, 21, 25, 28, 3, -24 },
  { 6734, 22, 33, 28, 4, -32 },
  { 6825, 20, 25, 28, 4, -24 },
  { 6888, 21, 24, 28, 4, -24 },
  { 6951, 23, 25, 28, 3, -24 },
  { 7023, 26, 25, 28, 1, -24 },
  { 7105, 22, 34, 28, 2, -24 },
  { 7199, 23, 25, 28, 2, -24 },
  { 7271, 20, 41, 28, 6, -35 },
  { 7374, 8, 41, 28, 10, -35 },
  { 7415, 21, 41, 28, 2, -35 },
  { 7523, 24, 8, 28, 2, -18 },
};

const GFXfont IBMPlexMono_ExtraLightItalic46pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic46pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic46pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC46PT7B_H_
