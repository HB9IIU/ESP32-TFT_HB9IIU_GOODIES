#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC26PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x11, 0x22, 0x22, 0x24, 0x44, 0x00, 0x00, 0xCC, 0x65, 0x14,
  0x51, 0x49, 0x28, 0x80, 0x00, 0x84, 0x00, 0x84, 0x00, 0x88, 0x01, 0x08,
  0x01, 0x10, 0x01, 0x10, 0x3E, 0x1F, 0x02, 0x20, 0x02, 0x20, 0x04, 0x20,
  0x04, 0x40, 0x78, 0x7C, 0x88, 0x40, 0x08, 0x80, 0x10, 0x80, 0x10, 0x80,
  0x11, 0x00, 0x21, 0x00, 0x00, 0x80, 0x02, 0x00, 0x08, 0x01, 0xF8, 0x18,
  0x98, 0x42, 0x32, 0x10, 0x08, 0x40, 0x21, 0x00, 0x84, 0x01, 0x90, 0x03,
  0xC0, 0x02, 0xE0, 0x08, 0xC0, 0x21, 0x00, 0x84, 0x02, 0x12, 0x10, 0x4C,
  0x43, 0x19, 0x18, 0x1F, 0x80, 0x10, 0x00, 0x40, 0x02, 0x00, 0x0F, 0x01,
  0x8C, 0x40, 0x88, 0x20, 0x84, 0x10, 0x82, 0x08, 0x81, 0x04, 0x40, 0x82,
  0x40, 0x62, 0x40, 0x1E, 0x00, 0x00, 0x3C, 0x01, 0x31, 0x01, 0x10, 0x80,
  0x90, 0x40, 0x88, 0x20, 0x84, 0x10, 0x82, 0x08, 0x41, 0x88, 0x40, 0x78,
  0x00, 0x03, 0xC0, 0x08, 0x60, 0x20, 0x40, 0x40, 0x80, 0x81, 0x01, 0x02,
  0x02, 0x04, 0x02, 0x10, 0x1E, 0xC0, 0x46, 0x01, 0x04, 0x02, 0x08, 0x08,
  0x08, 0x10, 0x08, 0x60, 0x30, 0xA0, 0x52, 0x61, 0x14, 0x7C, 0x30, 0x55,
  0x68, 0x01, 0x02, 0x04, 0x08, 0x10, 0x20, 0x20, 0x40, 0x40, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20,
  0x10, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x02, 0x02, 0x02, 0x04, 0x04, 0x08, 0x10, 0x10, 0x20,
  0xC0, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x08, 0x20, 0xB1, 0x38, 0x7E,
  0x00, 0xC0, 0x0A, 0x00, 0x88, 0x08, 0x40, 0x81, 0x08, 0x04, 0x00, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0xFF, 0xF0, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x32, 0x64, 0x48, 0xFF, 0xF0,
  0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x07, 0xC1, 0x82, 0x10, 0x12, 0x01,
  0x40, 0x14, 0x01, 0x40, 0x18, 0x01, 0x86, 0x18, 0x61, 0x80, 0x18, 0x01,
  0x80, 0x28, 0x02, 0x80, 0x4C, 0x04, 0x61, 0x83, 0xE0, 0x00, 0xC0, 0x34,
  0x06, 0x80, 0x88, 0x30, 0x82, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x0F, 0xFF,
  0x03, 0xE0, 0x61, 0x84, 0x02, 0x20, 0x12, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x07, 0xFF, 0x80, 0x07, 0xE0, 0x61, 0x84, 0x06, 0x40,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x04, 0x0F, 0xC0, 0x03, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x00, 0x0A, 0x00, 0x98, 0x04, 0x60, 0xC0, 0xF8, 0x00,
  0x00, 0x10, 0x01, 0x80, 0x14, 0x01, 0x20, 0x11, 0x01, 0x10, 0x10, 0x80,
  0x84, 0x08, 0x20, 0x81, 0x08, 0x08, 0x80, 0x88, 0x04, 0x7F, 0xFC, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x0F, 0xFC, 0x20, 0x00, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x09, 0xF0, 0x38, 0x60, 0x80, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x48, 0x03, 0x10, 0x08, 0x20, 0xC0,
  0x7E, 0x00, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x20, 0x08, 0x02,
  0x7C, 0x50, 0x5C, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x02,
  0x61, 0x87, 0xE0, 0x7F, 0xF8, 0x01, 0x80, 0x28, 0x02, 0x80, 0x40, 0x08,
  0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x03, 0xE0, 0x60, 0xC4, 0x02, 0x20,
  0x11, 0x00, 0x88, 0x04, 0x40, 0x21, 0x06, 0x07, 0xC0, 0xC3, 0x08, 0x04,
  0x80, 0x24, 0x00, 0xC0, 0x0A, 0x00, 0x48, 0x06, 0x60, 0x60, 0xFC, 0x00,
  0x1F, 0x86, 0x19, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80,
  0xA8, 0x38, 0xF9, 0x00, 0x40, 0x10, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C,
  0x00, 0x33, 0x00, 0x00, 0x00, 0x00, 0x00, 0xCC, 0x0C, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x86, 0x10, 0x42, 0x00, 0x00, 0x08,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x20, 0x00, 0xC0, 0x01,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x02, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0x40, 0x00, 0x1F, 0x08, 0x24, 0x06, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x02, 0x03, 0x07, 0x01, 0x00, 0x40, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x18, 0x00, 0x07, 0xC0, 0x82, 0x10, 0x12, 0x01,
  0x20, 0x14, 0x3D, 0x46, 0x34, 0x41, 0x48, 0x14, 0x82, 0x88, 0x28, 0x82,
  0x88, 0x28, 0x86, 0x8C, 0xA8, 0x74, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00,
  0x3F, 0x80, 0x00, 0x40, 0x05, 0x00, 0x28, 0x02, 0x40, 0x12, 0x01, 0x10,
  0x08, 0x80, 0x82, 0x04, 0x10, 0x40, 0x82, 0x04, 0x3F, 0xE1, 0x01, 0x10,
  0x04, 0x80, 0x28, 0x01, 0x40, 0x0C, 0x00, 0x40, 0x1F, 0xE0, 0x80, 0x84,
  0x02, 0x20, 0x11, 0x00, 0x90, 0x04, 0x80, 0x44, 0x04, 0x3F, 0xC1, 0x01,
  0x08, 0x04, 0x80, 0x24, 0x01, 0x20, 0x09, 0x00, 0x48, 0x06, 0x40, 0x67,
  0xFC, 0x00, 0x03, 0xC0, 0x61, 0x04, 0x04, 0x40, 0x22, 0x00, 0xA0, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x11, 0x00, 0x88, 0x08, 0x20, 0x80, 0xF8, 0x00, 0x1F, 0x82, 0x06, 0x20,
  0x32, 0x01, 0x20, 0x12, 0x01, 0x20, 0x14, 0x01, 0x40, 0x14, 0x01, 0x40,
  0x14, 0x01, 0x80, 0x28, 0x02, 0x80, 0x68, 0x04, 0x81, 0x8F, 0xE0, 0x1F,
  0xF9, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00,
  0x7F, 0xF2, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF9, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x7F, 0xE2, 0x00, 0x10, 0x00, 0x80,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x00, 0x07,
  0xC0, 0x41, 0x04, 0x04, 0x40, 0x22, 0x00, 0xA0, 0x01, 0x00, 0x08, 0x00,
  0x80, 0x04, 0x00, 0x20, 0xFD, 0x00, 0x48, 0x02, 0x40, 0x12, 0x00, 0x88,
  0x0C, 0x60, 0xA0, 0xFA, 0x00, 0x10, 0x04, 0x40, 0x11, 0x00, 0x44, 0x02,
  0x20, 0x08, 0x80, 0x22, 0x00, 0x88, 0x02, 0x3F, 0xF8, 0x80, 0x42, 0x01,
  0x10, 0x04, 0x40, 0x11, 0x00, 0x44, 0x01, 0x10, 0x08, 0x40, 0x22, 0x00,
  0x80, 0x1F, 0xFC, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x03, 0xFF, 0x80, 0x0F, 0xF0, 0x01,
  0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x80, 0x88, 0x08, 0x43, 0x03, 0xE0,
  0x30, 0x0C, 0x80, 0x62, 0x03, 0x08, 0x18, 0x20, 0x80, 0x84, 0x04, 0x20,
  0x11, 0x00, 0x4A, 0x01, 0x48, 0x06, 0x10, 0x10, 0x40, 0x81, 0x82, 0x02,
  0x08, 0x0C, 0x20, 0x10, 0x80, 0x62, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x3F, 0xF0, 0x10, 0x04, 0x60, 0x32, 0x81,
  0x4A, 0x05, 0x24, 0x24, 0x91, 0x22, 0x44, 0x89, 0x22, 0x42, 0x89, 0x0C,
  0x24, 0x20, 0x90, 0x84, 0x40, 0x11, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80,
  0x12, 0x00, 0x80, 0x18, 0x04, 0x60, 0x11, 0x40, 0x45, 0x02, 0x24, 0x08,
  0x88, 0x22, 0x20, 0x88, 0x82, 0x21, 0x08, 0x84, 0x44, 0x11, 0x10, 0x44,
  0x40, 0x91, 0x02, 0x44, 0x09, 0x10, 0x18, 0x80, 0x62, 0x01, 0x80, 0x07,
  0xC1, 0x82, 0x10, 0x12, 0x01, 0x40, 0x14, 0x01, 0x40, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x28, 0x02, 0x80, 0x4C, 0x04, 0x61,
  0x83, 0xE0, 0x1F, 0xE1, 0x00, 0x88, 0x02, 0x40, 0x12, 0x00, 0x90, 0x05,
  0x00, 0x28, 0x02, 0x40, 0x23, 0xFE, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x00, 0x07, 0xC1, 0x82, 0x10,
  0x12, 0x01, 0x40, 0x14, 0x01, 0x40, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x28, 0x02, 0x80, 0x4C, 0x04, 0x61, 0x83, 0xE0, 0x04,
  0x00, 0x42, 0x02, 0x30, 0x34, 0x01, 0x80, 0x1F, 0xE1, 0x00, 0x88, 0x02,
  0x40, 0x12, 0x00, 0x90, 0x05, 0x00, 0x28, 0x02, 0x40, 0x23, 0xFE, 0x10,
  0x80, 0x84, 0x08, 0x10, 0x40, 0x82, 0x02, 0x10, 0x10, 0x80, 0x44, 0x03,
  0x00, 0x07, 0xE0, 0x60, 0x61, 0x00, 0xC8, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x48, 0x01, 0x30, 0x0C, 0x60, 0x60, 0x7E, 0x00, 0xFF, 0xFC, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x10, 0x00, 0x40, 0x00, 0x20, 0x09, 0x00, 0x48, 0x02, 0x40, 0x22,
  0x01, 0x20, 0x09, 0x00, 0x48, 0x02, 0x40, 0x12, 0x01, 0x20, 0x09, 0x00,
  0x48, 0x02, 0x40, 0x12, 0x01, 0x10, 0x08, 0x41, 0x81, 0xF8, 0x00, 0x80,
  0x0C, 0x00, 0x90, 0x04, 0x80, 0x44, 0x02, 0x20, 0x21, 0x01, 0x08, 0x10,
  0x40, 0x81, 0x0C, 0x08, 0x40, 0x42, 0x02, 0x20, 0x11, 0x00, 0x90, 0x02,
  0x80, 0x18, 0x00, 0xC0, 0x00, 0x40, 0x05, 0x00, 0x14, 0x00, 0x90, 0x02,
  0x40, 0x09, 0x08, 0x24, 0x21, 0x11, 0x44, 0x85, 0x12, 0x24, 0x48, 0x92,
  0x24, 0x48, 0x91, 0x22, 0x84, 0x8A, 0x14, 0x28, 0x50, 0xC0, 0xC3, 0x03,
  0x00, 0x18, 0x01, 0x08, 0x02, 0x04, 0x04, 0x04, 0x08, 0x02, 0x10, 0x02,
  0x30, 0x01, 0x20, 0x01, 0x40, 0x00, 0x80, 0x01, 0x80, 0x02, 0x40, 0x06,
  0x40, 0x04, 0x20, 0x08, 0x20, 0x10, 0x10, 0x20, 0x10, 0x40, 0x08, 0xC0,
  0x08, 0x80, 0x0E, 0x00, 0x24, 0x01, 0x10, 0x08, 0x20, 0x40, 0x81, 0x02,
  0x08, 0x04, 0x40, 0x12, 0x00, 0x38, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x00, 0x0F, 0xFF, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0xFF, 0xF8, 0x0F, 0xC4, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x03, 0xF0, 0x82, 0x08, 0x10, 0x41, 0x04, 0x10, 0x20, 0x82, 0x08,
  0x10, 0x41, 0x04, 0x08, 0x20, 0x82, 0x08, 0x10, 0x41, 0x0F, 0xC4, 0x10,
  0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x43, 0xF0, 0x01, 0x00, 0x28, 0x04, 0x80, 0x44, 0x08, 0x41, 0x02,
  0x20, 0x22, 0x02, 0x40, 0x18, 0x01, 0xFF, 0xF0, 0xC9, 0x10, 0x0F, 0x13,
  0x0E, 0x60, 0x24, 0x02, 0x80, 0x28, 0x02, 0x80, 0x48, 0x04, 0x80, 0x48,
  0x04, 0x81, 0xC4, 0x34, 0x3C, 0x70, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x27, 0xC2, 0x86, 0x30, 0x22, 0x01, 0x40, 0x14, 0x01,
  0x40, 0x14, 0x01, 0x40, 0x28, 0x02, 0xC0, 0x4A, 0x08, 0x9F, 0x00, 0x0F,
  0x82, 0x08, 0x80, 0xA0, 0x24, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x50,
  0x0D, 0x02, 0x30, 0xC1, 0xE0, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x3C, 0x46, 0x1C, 0x60, 0x22, 0x01, 0x20, 0x09, 0x00,
  0x48, 0x02, 0x40, 0x22, 0x01, 0x10, 0x08, 0x80, 0xC2, 0x0A, 0x0F, 0x90,
  0x0F, 0xC2, 0x0C, 0x80, 0xA0, 0x18, 0x03, 0x03, 0xBF, 0x84, 0x00, 0x80,
  0x10, 0x05, 0x01, 0x30, 0xC1, 0xF0, 0x00, 0x3F, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x1F, 0xFE, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x82, 0x00, 0x42, 0x00,
  0x32, 0x00, 0x1A, 0x00, 0x0C, 0x00, 0x07, 0x88, 0xC3, 0x8C, 0x04, 0x40,
  0x24, 0x01, 0x20, 0x09, 0x00, 0x48, 0x04, 0x40, 0x22, 0x01, 0x10, 0x18,
  0x41, 0x41, 0xF4, 0x00, 0x20, 0x01, 0x10, 0x18, 0x41, 0x81, 0xF0, 0x00,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x09, 0xF1, 0x43, 0x30,
  0x24, 0x04, 0x80, 0xA0, 0x14, 0x02, 0x80, 0x50, 0x12, 0x02, 0x80, 0x50,
  0x0A, 0x01, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x08,
  0x46, 0x11, 0x02, 0xC0, 0x60, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x41, 0x04, 0x20, 0x44,
  0x07, 0x00, 0x60, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10,
  0x00, 0x9F, 0x05, 0x0C, 0x30, 0x21, 0x01, 0x18, 0x08, 0x80, 0x84, 0x38,
  0x26, 0x01, 0x10, 0x50, 0x83, 0x82, 0x24, 0x0A, 0x20, 0x60, 0xFC, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x0C, 0x84, 0x26, 0x0A, 0x03, 0x00, 0x2E, 0x38,
  0xC5, 0x32, 0x18, 0x48, 0x41, 0x41, 0x09, 0x04, 0x24, 0x10, 0x90, 0x82,
  0x42, 0x0A, 0x08, 0x28, 0x21, 0x20, 0x84, 0x84, 0x10, 0x27, 0xC5, 0x0C,
  0xC0, 0x90, 0x12, 0x02, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x48, 0x0A, 0x01,
  0x40, 0x28, 0x04, 0x0F, 0x81, 0x04, 0x20, 0x24, 0x02, 0x40, 0x18, 0x01,
  0x80, 0x28, 0x02, 0x80, 0x28, 0x06, 0xC0, 0x46, 0x18, 0x1E, 0x00, 0x13,
  0xE0, 0xA1, 0x86, 0x04, 0x20, 0x12, 0x00, 0x90, 0x04, 0x80, 0x24, 0x01,
  0x20, 0x12, 0x00, 0x98, 0x08, 0xA0, 0x84, 0xF8, 0x20, 0x01, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x00, 0x0F, 0x13, 0x0E, 0x60, 0x24, 0x02, 0x80,
  0x28, 0x02, 0x80, 0x28, 0x04, 0x80, 0x48, 0x04, 0x80, 0xC4, 0x14, 0x3E,
  0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0xF9, 0xF8, 0x50, 0x03,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x02, 0x00, 0x00, 0x0F, 0xC3, 0x06, 0x20, 0x34, 0x00,
  0x40, 0x03, 0x00, 0x0F, 0xC0, 0x06, 0x00, 0x20, 0x02, 0x80, 0x2C, 0x0C,
  0x3F, 0x00, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x0F, 0xFF, 0x04,
  0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x02, 0x10,
  0xC1, 0x10, 0x16, 0x01, 0x80, 0x20, 0x32, 0x02, 0x20, 0x24, 0x02, 0x40,
  0x24, 0x02, 0x40, 0x44, 0x04, 0x80, 0x48, 0x0C, 0x41, 0x44, 0x24, 0x3C,
  0x80, 0xF0, 0x21, 0x01, 0x10, 0x11, 0x01, 0x10, 0x12, 0x01, 0x20, 0x22,
  0x02, 0x20, 0x42, 0x0C, 0x21, 0x82, 0x70, 0x3C, 0x00, 0x41, 0x12, 0x10,
  0x90, 0x82, 0x84, 0x14, 0x20, 0xC1, 0x06, 0x08, 0x30, 0x82, 0x84, 0x14,
  0x20, 0xA1, 0x09, 0x14, 0xCF, 0x3C, 0x00, 0x0C, 0x38, 0xC9, 0x1C, 0x28,
  0x40, 0xC1, 0x01, 0x04, 0x04, 0x00, 0x20, 0x00, 0x80, 0x82, 0x02, 0x18,
  0x08, 0x51, 0xA2, 0x48, 0x70, 0xC0, 0x10, 0x18, 0x80, 0x84, 0x04, 0x40,
  0x22, 0x01, 0x10, 0x08, 0x80, 0x84, 0x04, 0x40, 0x22, 0x03, 0x08, 0x28,
  0x42, 0x81, 0xE4, 0x00, 0x20, 0x01, 0x10, 0x10, 0xC1, 0x81, 0xF0, 0x00,
  0x1F, 0x89, 0x87, 0xC8, 0x06, 0x40, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00,
  0x80, 0x18, 0x21, 0x01, 0x18, 0x04, 0xFE, 0x28, 0x1F, 0x00, 0x03, 0xF0,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x06, 0x0F, 0x80, 0x0C, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x03, 0xF0, 0x11, 0x11,
  0x11, 0x22, 0x22, 0x22, 0x44, 0x44, 0x44, 0x88, 0x88, 0x88, 0x0F, 0xC0,
  0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x02, 0x00, 0x1F, 0x07, 0x00, 0x40, 0x08, 0x00, 0x40, 0x04, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x0F, 0xC0, 0x1C, 0x04,
  0x88, 0x24, 0x30, 0x90, 0x44, 0x80, 0xE0,
};

const GFXglyph IBMPlexMono_ExtraLightItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 4, 18, 16, 6, -18 },
  { 10, 6, 7, 16, 6, -19 },
  { 16, 16, 18, 16, 0, -18 },
  { 52, 14, 24, 16, 1, -21 },
  { 94, 17, 18, 16, 0, -18 },
  { 133, 15, 18, 16, 0, -18 },
  { 167, 2, 7, 16, 8, -19 },
  { 169, 8, 24, 16, 6, -20 },
  { 193, 8, 24, 16, 2, -20 },
  { 217, 13, 13, 16, 2, -14 },
  { 239, 12, 13, 16, 2, -14 },
  { 259, 4, 6, 16, 4, -2 },
  { 262, 8, 1, 16, 4, -8 },
  { 263, 2, 2, 16, 6, -2 },
  { 264, 14, 24, 16, 1, -20 },
  { 306, 12, 18, 16, 2, -18 },
  { 333, 12, 18, 16, 1, -18 },
  { 360, 13, 18, 16, 1, -18 },
  { 390, 13, 18, 16, 1, -18 },
  { 420, 13, 18, 16, 1, -18 },
  { 450, 14, 18, 16, 1, -18 },
  { 482, 11, 18, 16, 2, -18 },
  { 507, 12, 18, 16, 3, -18 },
  { 534, 13, 18, 16, 1, -18 },
  { 564, 11, 18, 16, 3, -18 },
  { 589, 4, 14, 16, 6, -14 },
  { 596, 6, 18, 16, 4, -14 },
  { 610, 13, 14, 16, 2, -15 },
  { 633, 14, 6, 16, 1, -11 },
  { 644, 13, 14, 16, 1, -15 },
  { 667, 10, 18, 16, 4, -18 },
  { 690, 12, 21, 16, 2, -18 },
  { 722, 13, 18, 16, 0, -18 },
  { 752, 13, 18, 16, 1, -18 },
  { 782, 13, 18, 16, 2, -18 },
  { 812, 12, 18, 16, 2, -18 },
  { 839, 13, 18, 16, 2, -18 },
  { 869, 13, 18, 16, 2, -18 },
  { 899, 13, 18, 16, 2, -18 },
  { 929, 14, 18, 16, 1, -18 },
  { 961, 14, 18, 16, 1, -18 },
  { 993, 12, 18, 16, 2, -18 },
  { 1020, 14, 18, 16, 2, -18 },
  { 1052, 10, 18, 16, 3, -18 },
  { 1075, 14, 18, 16, 1, -18 },
  { 1107, 14, 18, 16, 1, -18 },
  { 1139, 12, 18, 16, 2, -18 },
  { 1166, 13, 18, 16, 2, -18 },
  { 1196, 12, 23, 16, 2, -18 },
  { 1231, 13, 18, 16, 2, -18 },
  { 1261, 14, 18, 16, 1, -18 },
  { 1293, 14, 18, 16, 3, -18 },
  { 1325, 13, 18, 16, 2, -18 },
  { 1355, 13, 18, 16, 3, -18 },
  { 1385, 14, 18, 16, 2, -18 },
  { 1417, 16, 18, 16, 0, -18 },
  { 1453, 14, 18, 16, 3, -18 },
  { 1485, 16, 18, 16, 0, -18 },
  { 1521, 10, 24, 16, 5, -20 },
  { 1551, 6, 24, 16, 5, -20 },
  { 1569, 10, 24, 16, 1, -20 },
  { 1599, 12, 10, 16, 2, -18 },
  { 1614, 12, 1, 16, 0, 3 },
  { 1616, 3, 4, 16, 6, -19 },
  { 1618, 12, 13, 16, 2, -13 },
  { 1638, 12, 19, 16, 2, -19 },
  { 1667, 11, 13, 16, 2, -13 },
  { 1685, 13, 19, 16, 2, -19 },
  { 1716, 11, 13, 16, 2, -13 },
  { 1734, 16, 24, 16, 0, -19 },
  { 1782, 13, 18, 16, 1, -13 },
  { 1812, 11, 19, 16, 2, -19 },
  { 1839, 11, 19, 16, 2, -19 },
  { 1866, 11, 24, 16, 3, -19 },
  { 1899, 13, 19, 16, 2, -19 },
  { 1930, 10, 19, 16, 3, -19 },
  { 1954, 14, 13, 16, 1, -13 },
  { 1977, 11, 13, 16, 2, -13 },
  { 1995, 12, 13, 16, 2, -13 },
  { 2015, 13, 18, 16, 1, -13 },
  { 2045, 12, 18, 16, 2, -13 },
  { 2072, 13, 13, 16, 3, -13 },
  { 2094, 12, 13, 16, 2, -13 },
  { 2114, 12, 18, 16, 2, -18 },
  { 2141, 12, 13, 16, 2, -13 },
  { 2161, 12, 13, 16, 2, -13 },
  { 2181, 13, 13, 16, 2, -13 },
  { 2203, 14, 13, 16, 1, -13 },
  { 2226, 13, 18, 16, 1, -13 },
  { 2256, 13, 13, 16, 1, -13 },
  { 2278, 12, 24, 16, 3, -20 },
  { 2314, 4, 24, 16, 6, -20 },
  { 2326, 12, 24, 16, 1, -20 },
  { 2362, 14, 5, 16, 1, -10 },
};

const GFXfont IBMPlexMono_ExtraLightItalic26pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic26pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic26pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC26PT7B_H_
