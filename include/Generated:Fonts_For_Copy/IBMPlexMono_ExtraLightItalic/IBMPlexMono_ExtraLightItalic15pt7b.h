#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC15PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0x24, 0x90, 0x18, 0xB6, 0xE0, 0x09, 0x04, 0x82, 0x8E, 0x71,
  0x21, 0x23, 0x9C, 0x48, 0x48, 0x24, 0x00, 0x08, 0x08, 0x3C, 0x4A, 0x91,
  0x50, 0x70, 0x1C, 0x12, 0xA2, 0xA4, 0x78, 0x20, 0x20, 0x38, 0xD2, 0x24,
  0x91, 0x28, 0x34, 0x05, 0xC2, 0x91, 0x24, 0x89, 0x21, 0x80, 0x1C, 0x11,
  0x08, 0x84, 0x43, 0x42, 0x42, 0x21, 0x09, 0x8B, 0x39, 0x80, 0xF0, 0x09,
  0x88, 0x84, 0x42, 0x10, 0x84, 0x20, 0x82, 0x00, 0x20, 0x84, 0x10, 0x84,
  0x21, 0x10, 0x88, 0x88, 0x00, 0x10, 0x10, 0x10, 0xFF, 0x30, 0x48, 0xCC,
  0x10, 0x20, 0x47, 0xF1, 0x02, 0x08, 0x00, 0x6A, 0x00, 0xF0, 0xC0, 0x03,
  0x02, 0x04, 0x04, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x80, 0x80, 0x80,
  0x1C, 0x45, 0x0C, 0x18, 0x32, 0x60, 0xC2, 0x84, 0xF0, 0x08, 0x71, 0xA2,
  0x41, 0x02, 0x04, 0x08, 0x11, 0xFC, 0x1C, 0x45, 0x08, 0x10, 0x41, 0x84,
  0x10, 0xC1, 0xF8, 0x1C, 0xC4, 0x08, 0x23, 0x81, 0x81, 0x02, 0x84, 0xF0,
  0x01, 0x06, 0x0A, 0x12, 0x22, 0x42, 0x44, 0xFF, 0x04, 0x04, 0x3E, 0x81,
  0x03, 0xE4, 0x40, 0x40, 0x82, 0x84, 0xF0, 0x0C, 0x20, 0x82, 0x07, 0xD8,
  0x60, 0xC1, 0x84, 0xF0, 0xFF, 0x0A, 0x20, 0x41, 0x02, 0x08, 0x20, 0x41,
  0x00, 0x3E, 0x85, 0x0A, 0x13, 0xCC, 0xA0, 0xC1, 0x84, 0xF0, 0x7A, 0x18,
  0x61, 0x8F, 0xE0, 0x84, 0x23, 0x00, 0x60, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x06, 0x48, 0x03, 0x04, 0x18, 0x60, 0xC0, 0x20, 0x18, 0x04, 0xFE, 0x03,
  0xF8, 0x40, 0x40, 0x60, 0x20, 0x63, 0x08, 0x60, 0x39, 0x18, 0x41, 0x04,
  0x62, 0x10, 0x01, 0x00, 0x1C, 0x45, 0x0A, 0xF9, 0x34, 0x69, 0x52, 0x9D,
  0x02, 0x03, 0xC0, 0x04, 0x0C, 0x14, 0x12, 0x22, 0x22, 0x3E, 0x42, 0x82,
  0x81, 0x7C, 0x85, 0x0C, 0x17, 0xD0, 0xA0, 0xC1, 0x85, 0xF0, 0x1C, 0x45,
  0x0C, 0x08, 0x10, 0x20, 0x43, 0x44, 0xF0, 0x3C, 0x85, 0x0A, 0x18, 0x30,
  0x60, 0xC1, 0x85, 0xF0, 0x3F, 0x40, 0x40, 0x40, 0x7E, 0x80, 0x80, 0x80,
  0x80, 0xFC, 0x3F, 0x40, 0x40, 0x40, 0x7E, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x1C, 0x45, 0x0C, 0x08, 0x11, 0xE0, 0xC2, 0x84, 0xF8, 0x41, 0x42, 0x42,
  0x82, 0x7E, 0x82, 0x82, 0x84, 0x84, 0x84, 0x7F, 0x08, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x20, 0xFC, 0x3E, 0x04, 0x08, 0x20, 0x40, 0x81, 0x42,
  0x88, 0xE0, 0x41, 0x42, 0x44, 0x58, 0x90, 0xF0, 0x88, 0x88, 0x84, 0x86,
  0x21, 0x04, 0x10, 0x41, 0x04, 0x20, 0x83, 0xF0, 0x41, 0x67, 0xA6, 0xAA,
  0xB2, 0x92, 0x82, 0x82, 0x84, 0x84, 0x41, 0x62, 0x62, 0xA2, 0x92, 0x92,
  0x8A, 0x8C, 0x8C, 0x84, 0x1C, 0x45, 0x0C, 0x18, 0x30, 0x60, 0xC2, 0x84,
  0xF0, 0x3E, 0x42, 0x41, 0x41, 0x82, 0x7C, 0x80, 0x80, 0x80, 0x80, 0x1C,
  0x45, 0x0C, 0x18, 0x30, 0x60, 0xC2, 0x84, 0xF0, 0x40, 0xB0, 0xC0, 0x3E,
  0x42, 0x41, 0x41, 0x82, 0x7C, 0x90, 0x88, 0x88, 0x84, 0x3C, 0x42, 0x81,
  0x40, 0x30, 0x0C, 0x02, 0x82, 0x84, 0x78, 0xFF, 0x10, 0x10, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x40, 0x40, 0x41, 0x42, 0x42, 0x82, 0x82, 0x82, 0x82,
  0x84, 0x84, 0x78, 0x83, 0x06, 0x14, 0x28, 0x91, 0x24, 0x28, 0x60, 0x80,
  0x81, 0x81, 0x81, 0x9A, 0xAA, 0xAA, 0xAA, 0xCC, 0xC4, 0x84, 0x20, 0x90,
  0x84, 0x82, 0x80, 0x80, 0x40, 0x50, 0x48, 0x42, 0x41, 0x80, 0x81, 0xA1,
  0x10, 0x84, 0x82, 0x80, 0x80, 0x40, 0x20, 0x20, 0x10, 0x00, 0x3F, 0x80,
  0x40, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x7F, 0x80, 0x3D, 0x04,
  0x10, 0x41, 0x08, 0x20, 0x82, 0x08, 0x20, 0xF0, 0x92, 0x48, 0x92, 0x44,
  0x92, 0x1C, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x20, 0x84, 0xF0, 0x08,
  0x28, 0x92, 0x24, 0x30, 0x40, 0xFE, 0xE0, 0x3A, 0x8E, 0x14, 0x28, 0x50,
  0xA3, 0x3B, 0x40, 0x81, 0x02, 0xE6, 0x28, 0x60, 0xC1, 0x83, 0x8A, 0xE0,
  0x38, 0x8A, 0x0C, 0x08, 0x10, 0xA2, 0x38, 0x02, 0x04, 0x09, 0xD4, 0x70,
  0x61, 0x42, 0x85, 0x19, 0xD0, 0x3C, 0x86, 0x17, 0xC8, 0x10, 0x91, 0x3C,
  0x07, 0x82, 0x01, 0x07, 0xF0, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x24,
  0x12, 0x05, 0x01, 0x80, 0x3A, 0x8E, 0x14, 0x28, 0x50, 0xA3, 0x3A, 0x09,
  0x11, 0xC0, 0x20, 0x81, 0x02, 0xE6, 0x48, 0x51, 0x42, 0x85, 0x0A, 0x10,
  0x08, 0x00, 0x07, 0x81, 0x04, 0x08, 0x12, 0x26, 0x70, 0xC0, 0x02, 0x00,
  0x03, 0xE0, 0x40, 0x82, 0x04, 0x08, 0x12, 0x22, 0x43, 0x02, 0x00, 0x40,
  0x40, 0x40, 0x5C, 0x62, 0x42, 0x84, 0xB8, 0x91, 0x96, 0x8C, 0xE0, 0x82,
  0x08, 0x41, 0x04, 0x10, 0x4E, 0xC4, 0x00, 0xB6, 0x96, 0x4C, 0x99, 0x32,
  0x64, 0xD1, 0x5C, 0xC9, 0x0A, 0x28, 0x50, 0xA1, 0x42, 0x3C, 0x86, 0x0C,
  0x18, 0x30, 0xA1, 0x3C, 0x5C, 0xC5, 0x0C, 0x18, 0x30, 0x71, 0x5C, 0x81,
  0x02, 0x00, 0x3A, 0x8E, 0x14, 0x28, 0x50, 0xA3, 0x3A, 0x04, 0x10, 0x20,
  0xEE, 0x60, 0x82, 0x04, 0x08, 0x10, 0x20, 0x3C, 0x86, 0x03, 0xC0, 0x40,
  0xA1, 0x3C, 0x10, 0x23, 0xF9, 0x02, 0x04, 0x08, 0x13, 0x58, 0x40, 0x42,
  0x86, 0x14, 0x28, 0x50, 0xA3, 0x3A, 0xE2, 0x85, 0x0A, 0x14, 0x48, 0x92,
  0x38, 0x8B, 0x26, 0x4C, 0x99, 0x32, 0x64, 0xF6, 0x13, 0x36, 0x42, 0x21,
  0x00, 0x84, 0x42, 0x6C, 0xC8, 0x42, 0x86, 0x14, 0x28, 0x50, 0xA3, 0x3A,
  0x09, 0x11, 0xC0, 0x7B, 0x0E, 0x10, 0x43, 0x08, 0xB9, 0x4E, 0x1E, 0x40,
  0x81, 0x01, 0x02, 0x38, 0x18, 0x20, 0x81, 0x02, 0x07, 0x00, 0x24, 0xA4,
  0x92, 0x52, 0x48, 0x38, 0x20, 0x84, 0x20, 0x81, 0xCC, 0x20, 0x81, 0x08,
  0xE0, 0x63, 0x26, 0x30,
};

const GFXglyph IBMPlexMono_ExtraLightItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 10, 9, 3, -10 },
  { 5, 3, 4, 9, 4, -11 },
  { 7, 9, 10, 9, 0, -10 },
  { 19, 8, 14, 9, 1, -12 },
  { 33, 10, 10, 9, 0, -10 },
  { 46, 9, 10, 9, 0, -10 },
  { 58, 1, 4, 9, 5, -11 },
  { 59, 5, 13, 9, 3, -11 },
  { 68, 5, 13, 9, 1, -11 },
  { 77, 8, 7, 9, 1, -8 },
  { 84, 7, 7, 9, 1, -8 },
  { 91, 3, 3, 9, 2, -1 },
  { 93, 4, 1, 9, 3, -5 },
  { 94, 2, 1, 9, 3, -1 },
  { 95, 8, 13, 9, 1, -11 },
  { 108, 7, 10, 9, 1, -10 },
  { 117, 7, 10, 9, 1, -10 },
  { 126, 7, 10, 9, 1, -10 },
  { 135, 7, 10, 9, 1, -10 },
  { 144, 8, 10, 9, 0, -10 },
  { 154, 7, 10, 9, 1, -10 },
  { 163, 7, 10, 9, 1, -10 },
  { 172, 7, 10, 9, 2, -10 },
  { 181, 7, 10, 9, 1, -10 },
  { 190, 6, 10, 9, 2, -10 },
  { 198, 3, 8, 9, 3, -8 },
  { 201, 4, 10, 9, 2, -8 },
  { 206, 8, 8, 9, 1, -9 },
  { 214, 7, 3, 9, 1, -6 },
  { 217, 7, 8, 9, 1, -9 },
  { 224, 6, 10, 9, 2, -10 },
  { 232, 7, 12, 9, 1, -10 },
  { 243, 8, 10, 9, 0, -10 },
  { 253, 7, 10, 9, 1, -10 },
  { 262, 7, 10, 9, 1, -10 },
  { 271, 7, 10, 9, 1, -10 },
  { 280, 8, 10, 9, 1, -10 },
  { 290, 8, 10, 9, 1, -10 },
  { 300, 7, 10, 9, 1, -10 },
  { 309, 8, 10, 9, 1, -10 },
  { 319, 8, 10, 9, 1, -10 },
  { 329, 7, 10, 9, 1, -10 },
  { 338, 8, 10, 9, 1, -10 },
  { 348, 6, 10, 9, 1, -10 },
  { 356, 8, 10, 9, 1, -10 },
  { 366, 8, 10, 9, 1, -10 },
  { 376, 7, 10, 9, 1, -10 },
  { 385, 8, 10, 9, 1, -10 },
  { 395, 7, 13, 9, 1, -10 },
  { 407, 8, 10, 9, 1, -10 },
  { 417, 8, 10, 9, 1, -10 },
  { 427, 8, 10, 9, 2, -10 },
  { 437, 8, 10, 9, 1, -10 },
  { 447, 7, 10, 9, 2, -10 },
  { 456, 8, 10, 9, 1, -10 },
  { 466, 9, 10, 9, 0, -10 },
  { 478, 9, 10, 9, 1, -10 },
  { 490, 9, 10, 9, 0, -10 },
  { 502, 6, 13, 9, 3, -11 },
  { 512, 3, 13, 9, 3, -11 },
  { 517, 6, 13, 9, 0, -11 },
  { 527, 7, 6, 9, 1, -10 },
  { 533, 7, 1, 9, 0, 1 },
  { 534, 1, 3, 9, 4, -13 },
  { 535, 7, 8, 9, 1, -8 },
  { 542, 7, 11, 9, 1, -11 },
  { 552, 7, 8, 9, 1, -8 },
  { 559, 7, 11, 9, 1, -11 },
  { 569, 7, 8, 9, 1, -8 },
  { 576, 9, 14, 9, 0, -11 },
  { 592, 7, 11, 9, 1, -8 },
  { 602, 7, 11, 9, 1, -11 },
  { 612, 7, 11, 9, 1, -11 },
  { 622, 7, 14, 9, 1, -11 },
  { 635, 8, 11, 9, 1, -11 },
  { 646, 6, 11, 9, 2, -11 },
  { 655, 7, 8, 9, 1, -8 },
  { 662, 7, 8, 9, 1, -8 },
  { 669, 7, 8, 9, 1, -8 },
  { 676, 7, 11, 9, 1, -8 },
  { 686, 7, 11, 9, 1, -8 },
  { 696, 7, 8, 9, 2, -8 },
  { 703, 7, 8, 9, 1, -8 },
  { 710, 7, 10, 9, 1, -10 },
  { 719, 7, 8, 9, 1, -8 },
  { 726, 7, 8, 9, 1, -8 },
  { 733, 7, 8, 9, 1, -8 },
  { 740, 9, 8, 9, 0, -8 },
  { 749, 7, 11, 9, 1, -8 },
  { 759, 7, 8, 9, 1, -8 },
  { 766, 7, 13, 9, 2, -11 },
  { 778, 3, 13, 9, 3, -11 },
  { 783, 6, 13, 9, 1, -11 },
  { 793, 7, 3, 9, 1, -6 },
};

const GFXfont IBMPlexMono_ExtraLightItalic15pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic15pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC15PT7B_H_
