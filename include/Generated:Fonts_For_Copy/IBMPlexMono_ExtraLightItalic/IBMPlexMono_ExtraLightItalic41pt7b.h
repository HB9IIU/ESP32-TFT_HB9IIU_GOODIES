#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC41PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x0C, 0x18, 0x30, 0x40, 0x83, 0x06, 0x0C, 0x18, 0x20, 0x40,
  0x83, 0x06, 0x08, 0x10, 0x20, 0x41, 0x02, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x87, 0x8E, 0x00, 0x20, 0x90, 0x48, 0x6C, 0x36, 0x1B, 0x09, 0x04, 0x82,
  0x43, 0x61, 0xB0, 0xC0, 0x00, 0x0C, 0x08, 0x00, 0x08, 0x18, 0x00, 0x08,
  0x10, 0x00, 0x18, 0x10, 0x00, 0x10, 0x30, 0x00, 0x10, 0x20, 0x00, 0x30,
  0x20, 0x00, 0x20, 0x60, 0x00, 0x20, 0x40, 0x00, 0x60, 0x40, 0x1F, 0xC0,
  0xFF, 0x00, 0x40, 0x80, 0x00, 0xC0, 0x80, 0x00, 0x81, 0x80, 0x00, 0x81,
  0x00, 0x01, 0x81, 0x00, 0x01, 0x03, 0x00, 0x01, 0x02, 0x00, 0xFF, 0x07,
  0xF8, 0x02, 0x04, 0x00, 0x06, 0x04, 0x00, 0x06, 0x0C, 0x00, 0x04, 0x08,
  0x00, 0x0C, 0x08, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x10, 0x00, 0x08, 0x10,
  0x00, 0x18, 0x30, 0x00, 0x10, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x7F, 0xC0, 0x07, 0x19, 0xC0,
  0x30, 0x41, 0x81, 0x81, 0x03, 0x0C, 0x04, 0x08, 0x30, 0x10, 0x00, 0x80,
  0xC0, 0x02, 0x03, 0x00, 0x08, 0x08, 0x00, 0x30, 0x20, 0x00, 0xC0, 0x80,
  0x01, 0x82, 0x00, 0x03, 0x18, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x04, 0x60, 0x00, 0x10, 0x60, 0x00, 0x40, 0x80, 0x03, 0x03, 0x00, 0x08,
  0x0C, 0x00, 0x20, 0x30, 0x00, 0x80, 0xC0, 0x02, 0x03, 0x00, 0x08, 0x0C,
  0xC0, 0x60, 0x21, 0x81, 0x01, 0x83, 0x04, 0x0C, 0x07, 0x10, 0xC0, 0x03,
  0xFC, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x30, 0x18, 0x60, 0x04, 0x02, 0x02, 0x00, 0xC0,
  0x60, 0x30, 0x08, 0x04, 0x01, 0x01, 0x00, 0xC0, 0x10, 0x20, 0x0C, 0x03,
  0x06, 0x00, 0x80, 0x30, 0x40, 0x08, 0x02, 0x08, 0x00, 0x80, 0x21, 0x00,
  0x0C, 0x06, 0x30, 0x00, 0x40, 0x42, 0x00, 0x06, 0x18, 0x40, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0x84,
  0x00, 0x06, 0x20, 0x20, 0x00, 0xC4, 0x03, 0x00, 0x18, 0x40, 0x30, 0x01,
  0x0C, 0x03, 0x00, 0x20, 0xC0, 0x30, 0x06, 0x08, 0x03, 0x00, 0xC0, 0x80,
  0x20, 0x08, 0x08, 0x02, 0x01, 0x00, 0x80, 0x60, 0x30, 0x04, 0x04, 0x06,
  0x00, 0x61, 0x80, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xC1,
  0x80, 0x01, 0x80, 0x40, 0x01, 0x00, 0x60, 0x03, 0x00, 0x20, 0x03, 0x00,
  0x20, 0x03, 0x00, 0x20, 0x03, 0x00, 0x20, 0x03, 0x00, 0x20, 0x01, 0x00,
  0x60, 0x01, 0x80, 0x40, 0x00, 0x80, 0xC0, 0x00, 0xC0, 0x80, 0x01, 0xC3,
  0x00, 0x0E, 0x6C, 0x00, 0x10, 0x30, 0x00, 0x20, 0x10, 0x00, 0x60, 0x18,
  0x00, 0x40, 0x08, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x02,
  0x00, 0xC0, 0x03, 0x01, 0xC0, 0x05, 0x03, 0x40, 0x04, 0x82, 0x60, 0x08,
  0xC4, 0x20, 0x08, 0x4C, 0x18, 0x30, 0x68, 0x0F, 0xC0, 0x30, 0x25, 0xB6,
  0x92, 0xDB, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00,
  0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00,
  0x80, 0x06, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x08, 0x06, 0x01, 0xF0, 0x61, 0xF1, 0xE4, 0xF0, 0x03, 0xF8,
  0x00, 0x0E, 0x00, 0x01, 0xA0, 0x00, 0x33, 0x00, 0x06, 0x10, 0x00, 0xC1,
  0x80, 0x08, 0x08, 0x01, 0x00, 0x40, 0x30, 0x06, 0x06, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x1F, 0xFF, 0xFC, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x18, 0x70,
  0xC1, 0x86, 0x0C, 0x30, 0x60, 0x83, 0x00, 0xFF, 0xE0, 0xEF, 0xE0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x18, 0x18, 0x02, 0x00, 0xC0, 0x40, 0x06, 0x08, 0x00, 0x21, 0x80,
  0x02, 0x10, 0x00, 0x33, 0x00, 0x03, 0x20, 0x00, 0x36, 0x00, 0x03, 0x60,
  0x00, 0x34, 0x00, 0x03, 0x40, 0x00, 0x3C, 0x06, 0x03, 0xC0, 0xE0, 0x2C,
  0x06, 0x02, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0x80, 0x00, 0x68, 0x00, 0x04,
  0x80, 0x00, 0xC8, 0x00, 0x0C, 0xC0, 0x00, 0x8C, 0x00, 0x18, 0x40, 0x03,
  0x06, 0x00, 0x20, 0x20, 0x0C, 0x01, 0x81, 0x80, 0x07, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x01, 0x98, 0x00, 0x62, 0x00, 0x18, 0x40, 0x0C,
  0x08, 0x03, 0x03, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x18,
  0x1C, 0x03, 0x00, 0x60, 0x40, 0x02, 0x0C, 0x00, 0x30, 0x80, 0x03, 0x18,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x00,
  0x38, 0x1C, 0x06, 0x00, 0x60, 0xC0, 0x02, 0x08, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x1F, 0xC0, 0x02, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x80, 0x01, 0x8C,
  0x00, 0x10, 0x60, 0x02, 0x03, 0x80, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0x40, 0x00, 0x32, 0x00,
  0x01, 0x10, 0x00, 0x10, 0x80, 0x01, 0x8C, 0x00, 0x18, 0x60, 0x01, 0x83,
  0x00, 0x18, 0x10, 0x00, 0x80, 0x80, 0x0C, 0x04, 0x00, 0xC0, 0x60, 0x0C,
  0x03, 0x00, 0xC0, 0x18, 0x04, 0x00, 0x80, 0x40, 0x04, 0x06, 0x00, 0x20,
  0x60, 0x03, 0x06, 0x00, 0x18, 0x60, 0x00, 0xC3, 0xFF, 0xFF, 0xE0, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x03, 0xFF, 0xF8, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x8F,
  0xE0, 0x0D, 0x81, 0x80, 0x70, 0x02, 0x03, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x40, 0x00, 0x86, 0x00, 0x0C, 0x18,
  0x00, 0xC0, 0x38, 0x18, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x03,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x47, 0xF0, 0x36,
  0x07, 0x0A, 0x00, 0x67, 0x00, 0x09, 0x80, 0x03, 0x60, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0B,
  0x00, 0x02, 0x40, 0x01, 0x98, 0x00, 0xC2, 0x00, 0x60, 0x60, 0x60, 0x07,
  0xE0, 0x00, 0x7F, 0xFF, 0xE8, 0x00, 0x0D, 0x00, 0x03, 0x60, 0x00, 0x6C,
  0x00, 0x19, 0x80, 0x02, 0x20, 0x00, 0xC4, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x0E, 0x07, 0x00, 0xC0, 0x0C, 0x0C, 0x00, 0x20, 0xC0, 0x01,
  0x86, 0x00, 0x0C, 0x20, 0x00, 0x61, 0x00, 0x03, 0x08, 0x00, 0x10, 0x40,
  0x01, 0x83, 0x00, 0x08, 0x08, 0x00, 0x80, 0x30, 0x18, 0x00, 0x7F, 0x00,
  0x1C, 0x0E, 0x03, 0x00, 0x18, 0x30, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00,
  0x08, 0x80, 0x00, 0x4C, 0x00, 0x02, 0x60, 0x00, 0x13, 0x00, 0x01, 0x98,
  0x00, 0x0C, 0x40, 0x00, 0x43, 0x00, 0x06, 0x0C, 0x00, 0xC0, 0x38, 0x1C,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x01, 0x81, 0xC0, 0x80, 0x18, 0x40,
  0x02, 0x20, 0x00, 0xD8, 0x00, 0x14, 0x00, 0x05, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xD0, 0x00, 0x66,
  0x00, 0x28, 0xC0, 0x16, 0x18, 0x19, 0x01, 0xF8, 0xC0, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x3C,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x87, 0x8E, 0x00, 0x01, 0x80, 0xF0, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x60,
  0x18, 0x04, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x02, 0x00, 0x3F, 0xFF, 0xFA,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x08, 0x00, 0x00, 0x03, 0xF0, 0x1C, 0x0C, 0x30, 0x02, 0x60, 0x03,
  0x40, 0x01, 0xC0, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x78, 0x07, 0xE0, 0x06, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x00, 0x7E, 0x00, 0x30, 0x30, 0x0C, 0x03, 0x03, 0x00, 0x30,
  0xC0, 0x02, 0x10, 0x00, 0x46, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x26,
  0x03, 0xC4, 0x81, 0x86, 0x90, 0x60, 0x72, 0x08, 0x06, 0xC3, 0x00, 0x98,
  0x40, 0x12, 0x08, 0x02, 0x41, 0x00, 0x48, 0x60, 0x19, 0x0C, 0x03, 0x61,
  0x00, 0x4C, 0x20, 0x09, 0x86, 0x03, 0x20, 0xC0, 0xA4, 0x08, 0x1C, 0x80,
  0xFD, 0x90, 0x04, 0x03, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0B, 0x00, 0x00, 0xC8, 0x00, 0x04,
  0x40, 0x00, 0x62, 0x00, 0x02, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x06, 0x00,
  0x18, 0x10, 0x00, 0x80, 0x80, 0x0C, 0x04, 0x00, 0x40, 0x20, 0x06, 0x01,
  0x80, 0x20, 0x0C, 0x03, 0x00, 0x20, 0x10, 0x01, 0x01, 0xFF, 0xF8, 0x08,
  0x00, 0x40, 0xC0, 0x03, 0x04, 0x00, 0x18, 0x60, 0x00, 0xC2, 0x00, 0x02,
  0x30, 0x00, 0x11, 0x00, 0x00, 0x98, 0x00, 0x06, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0x80, 0x07, 0xFF, 0x80, 0x40, 0x0C, 0x04, 0x00, 0x60, 0xC0, 0x03,
  0x0C, 0x00, 0x30, 0xC0, 0x01, 0x08, 0x00, 0x10, 0x80, 0x03, 0x08, 0x00,
  0x31, 0x80, 0x03, 0x18, 0x00, 0x21, 0x80, 0x06, 0x18, 0x00, 0xC1, 0x00,
  0x18, 0x1F, 0xFE, 0x03, 0x00, 0x18, 0x30, 0x00, 0xC3, 0x00, 0x06, 0x30,
  0x00, 0x62, 0x00, 0x02, 0x20, 0x00, 0x22, 0x00, 0x06, 0x60, 0x00, 0x66,
  0x00, 0x06, 0x60, 0x00, 0x44, 0x00, 0x0C, 0x40, 0x01, 0x84, 0x00, 0x70,
  0xFF, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x30, 0x70, 0x18, 0x03, 0x06, 0x00,
  0x20, 0x80, 0x06, 0x20, 0x00, 0x4C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x44, 0x00, 0x0C,
  0xC0, 0x03, 0x08, 0x00, 0xC0, 0x80, 0x30, 0x0C, 0x1C, 0x00, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0xC0, 0x30, 0x08, 0x00, 0x80, 0x80, 0x04, 0x08, 0x00,
  0x61, 0x80, 0x02, 0x18, 0x00, 0x21, 0x80, 0x03, 0x10, 0x00, 0x31, 0x00,
  0x03, 0x10, 0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x33, 0x00, 0x03, 0x20,
  0x00, 0x22, 0x00, 0x02, 0x20, 0x00, 0x26, 0x00, 0x06, 0x60, 0x00, 0x66,
  0x00, 0x04, 0x40, 0x00, 0x44, 0x00, 0x0C, 0x40, 0x00, 0x8C, 0x00, 0x18,
  0xC0, 0x01, 0x0C, 0x00, 0x20, 0xC0, 0x04, 0x08, 0x01, 0x80, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFC, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xFF, 0xFE, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xFF, 0xFE, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x18, 0x1C, 0x03, 0x00,
  0x60, 0x60, 0x02, 0x0C, 0x00, 0x30, 0x80, 0x01, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x3F, 0xEC,
  0x00, 0x04, 0xC0, 0x00, 0x4C, 0x00, 0x04, 0xC0, 0x00, 0xC4, 0x00, 0x0C,
  0x40, 0x00, 0x84, 0x00, 0x18, 0x60, 0x01, 0x82, 0x00, 0x38, 0x30, 0x05,
  0x81, 0xC1, 0x98, 0x07, 0xE1, 0x00, 0x04, 0x00, 0x0C, 0x10, 0x00, 0x30,
  0xC0, 0x00, 0x83, 0x00, 0x02, 0x0C, 0x00, 0x08, 0x20, 0x00, 0x60, 0x80,
  0x01, 0x82, 0x00, 0x06, 0x18, 0x00, 0x10, 0x60, 0x00, 0x41, 0x80, 0x01,
  0x06, 0x00, 0x0C, 0x10, 0x00, 0x30, 0x40, 0x00, 0xC3, 0xFF, 0xFE, 0x0C,
  0x00, 0x08, 0x30, 0x00, 0x20, 0xC0, 0x01, 0x82, 0x00, 0x06, 0x08, 0x00,
  0x18, 0x60, 0x00, 0x41, 0x80, 0x01, 0x06, 0x00, 0x04, 0x18, 0x00, 0x30,
  0x40, 0x00, 0xC1, 0x00, 0x03, 0x0C, 0x00, 0x08, 0x30, 0x00, 0x20, 0xC0,
  0x01, 0x80, 0x07, 0xFF, 0xFC, 0x20, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x00, 0x84, 0x00, 0x30, 0x80, 0x04, 0x18, 0x01, 0x81,
  0x80, 0x60, 0x18, 0x18, 0x01, 0xFC, 0x00, 0x06, 0x00, 0x07, 0x06, 0x00,
  0x0C, 0x04, 0x00, 0x18, 0x04, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x0C, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x08, 0x06, 0x00, 0x08, 0x0C,
  0x00, 0x18, 0x18, 0x00, 0x18, 0x30, 0x00, 0x18, 0x60, 0x00, 0x18, 0xE0,
  0x00, 0x11, 0xB0, 0x00, 0x12, 0x10, 0x00, 0x14, 0x18, 0x00, 0x38, 0x08,
  0x00, 0x30, 0x0C, 0x00, 0x20, 0x04, 0x00, 0x20, 0x06, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x03, 0x00, 0x60, 0x01, 0x00, 0x60, 0x01, 0x80, 0x60, 0x00,
  0x80, 0x40, 0x00, 0xC0, 0x40, 0x00, 0x40, 0xC0, 0x00, 0x60, 0x04, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0x0C, 0x00, 0x0C, 0x38,
  0x00, 0x70, 0xA0, 0x01, 0xC2, 0x80, 0x0F, 0x0A, 0x00, 0x2C, 0x6C, 0x01,
  0xA1, 0x90, 0x0C, 0x84, 0x40, 0x32, 0x11, 0x01, 0x98, 0x46, 0x04, 0x61,
  0x08, 0x31, 0x8C, 0x20, 0x84, 0x30, 0xC6, 0x10, 0xC1, 0x30, 0x42, 0x04,
  0x83, 0x08, 0x16, 0x0C, 0x20, 0x70, 0x31, 0x80, 0xC0, 0x86, 0x02, 0x02,
  0x18, 0x10, 0x08, 0x40, 0x00, 0x21, 0x00, 0x01, 0x84, 0x00, 0x06, 0x30,
  0x00, 0x10, 0xC0, 0x00, 0x43, 0x00, 0x01, 0x08, 0x00, 0x04, 0x20, 0x00,
  0x30, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x1C, 0x00, 0x30, 0xF0, 0x00,
  0x83, 0x40, 0x02, 0x0D, 0x00, 0x08, 0x26, 0x00, 0x60, 0x88, 0x01, 0x82,
  0x20, 0x06, 0x18, 0xC0, 0x10, 0x61, 0x00, 0x41, 0x84, 0x01, 0x04, 0x18,
  0x0C, 0x10, 0x20, 0x30, 0x40, 0x80, 0xC3, 0x03, 0x02, 0x0C, 0x0C, 0x08,
  0x30, 0x10, 0x20, 0x80, 0x61, 0x82, 0x01, 0x86, 0x08, 0x02, 0x18, 0x60,
  0x0C, 0x41, 0x80, 0x31, 0x06, 0x00, 0x44, 0x10, 0x01, 0xB0, 0x40, 0x06,
  0xC1, 0x00, 0x0B, 0x0C, 0x00, 0x28, 0x30, 0x00, 0xE0, 0xC0, 0x01, 0x80,
  0x00, 0x7E, 0x00, 0x18, 0x18, 0x02, 0x00, 0xC0, 0x40, 0x06, 0x08, 0x00,
  0x21, 0x80, 0x02, 0x10, 0x00, 0x33, 0x00, 0x03, 0x20, 0x00, 0x36, 0x00,
  0x03, 0x60, 0x00, 0x34, 0x00, 0x03, 0x40, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0x80, 0x00, 0x68,
  0x00, 0x04, 0x80, 0x00, 0xC8, 0x00, 0x0C, 0xC0, 0x00, 0x8C, 0x00, 0x18,
  0x40, 0x03, 0x06, 0x00, 0x20, 0x20, 0x0C, 0x01, 0x81, 0x80, 0x07, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x10, 0x01, 0xC0, 0x40, 0x01, 0x01, 0x00, 0x06,
  0x0C, 0x00, 0x08, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x08,
  0x00, 0x08, 0x20, 0x00, 0x20, 0x80, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00,
  0x30, 0x60, 0x00, 0x81, 0x00, 0x0C, 0x07, 0xFF, 0xC0, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x18, 0x18, 0x02, 0x00, 0xC0, 0x40, 0x06, 0x08, 0x00, 0x21, 0x80, 0x02,
  0x10, 0x00, 0x33, 0x00, 0x03, 0x20, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00,
  0x34, 0x00, 0x03, 0x40, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x2C, 0x00,
  0x02, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0x80, 0x00, 0x68, 0x00, 0x04, 0x80,
  0x00, 0xC8, 0x00, 0x0C, 0xC0, 0x00, 0x8C, 0x00, 0x18, 0x40, 0x03, 0x06,
  0x00, 0x20, 0x20, 0x0C, 0x01, 0x81, 0x80, 0x0F, 0xE0, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x04, 0x00, 0x60, 0x80, 0x03, 0x30, 0x00, 0x16,
  0x00, 0x01, 0xC0, 0x07, 0xFF, 0xC0, 0x10, 0x01, 0xC0, 0x40, 0x01, 0x01,
  0x00, 0x06, 0x0C, 0x00, 0x08, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00,
  0x03, 0x08, 0x00, 0x08, 0x20, 0x00, 0x20, 0x80, 0x01, 0x86, 0x00, 0x06,
  0x18, 0x00, 0x30, 0x60, 0x00, 0x81, 0x00, 0x0C, 0x07, 0xFF, 0xC0, 0x10,
  0x10, 0x00, 0xC0, 0x60, 0x03, 0x01, 0x80, 0x0C, 0x02, 0x00, 0x20, 0x0C,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x60, 0x18, 0x00, 0x80, 0x60, 0x03, 0x01,
  0x80, 0x04, 0x04, 0x00, 0x18, 0x10, 0x00, 0x20, 0xC0, 0x00, 0xC0, 0x00,
  0x7F, 0xC0, 0x07, 0x01, 0xC0, 0x30, 0x01, 0x81, 0x80, 0x03, 0x04, 0x00,
  0x08, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x23, 0x80, 0x01, 0x83, 0x00,
  0x0C, 0x07, 0x00, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x18, 0x40, 0x00, 0xC6, 0x00, 0x04, 0x30,
  0x00, 0x21, 0x80, 0x01, 0x08, 0x00, 0x18, 0x40, 0x00, 0xC2, 0x00, 0x06,
  0x30, 0x00, 0x21, 0x80, 0x01, 0x0C, 0x00, 0x08, 0x40, 0x00, 0xC2, 0x00,
  0x06, 0x10, 0x00, 0x31, 0x80, 0x01, 0x0C, 0x00, 0x08, 0x60, 0x00, 0x42,
  0x00, 0x06, 0x10, 0x00, 0x30, 0x80, 0x01, 0x0C, 0x00, 0x08, 0x60, 0x00,
  0x43, 0x00, 0x06, 0x18, 0x00, 0x20, 0x40, 0x03, 0x02, 0x00, 0x10, 0x18,
  0x01, 0x80, 0x70, 0x38, 0x00, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xB0, 0x00, 0x08, 0x80, 0x00, 0xC4, 0x00, 0x04, 0x20, 0x00, 0x61,
  0x80, 0x02, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x01, 0x00, 0x18, 0x08, 0x00,
  0x80, 0x40, 0x0C, 0x02, 0x00, 0x60, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06,
  0x03, 0x00, 0x10, 0x18, 0x00, 0x80, 0x80, 0x04, 0x0C, 0x00, 0x20, 0x40,
  0x01, 0x86, 0x00, 0x0C, 0x20, 0x00, 0x23, 0x00, 0x01, 0x10, 0x00, 0x09,
  0x80, 0x00, 0x48, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x80, 0x00, 0x12, 0x00, 0x00, 0xC8, 0x00, 0x03,
  0x20, 0x00, 0x08, 0x80, 0x00, 0x22, 0x00, 0x01, 0x88, 0x00, 0x06, 0x60,
  0x00, 0x11, 0x80, 0xC0, 0x46, 0x07, 0x03, 0x18, 0x14, 0x08, 0x60, 0xD0,
  0x21, 0x82, 0x40, 0x84, 0x19, 0x06, 0x10, 0x46, 0x10, 0x41, 0x18, 0x41,
  0x0C, 0x61, 0x04, 0x21, 0x8C, 0x11, 0x82, 0x20, 0x44, 0x08, 0x81, 0x30,
  0x22, 0x0C, 0x80, 0x98, 0x36, 0x02, 0x40, 0xD0, 0x09, 0x03, 0x40, 0x34,
  0x0F, 0x00, 0xF0, 0x28, 0x03, 0x80, 0xE0, 0x06, 0x00, 0x02, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x40, 0x30, 0x00, 0x30, 0x06, 0x00, 0x18, 0x01, 0x80,
  0x0C, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x80, 0x00,
  0x60, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x18, 0x00, 0x00, 0x4C, 0x00,
  0x00, 0x1A, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x08, 0x80, 0x00, 0x04, 0x30, 0x00, 0x03,
  0x04, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0x20, 0x00, 0x60, 0x0C, 0x00,
  0x10, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x08, 0x03, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x40, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x0E, 0x80,
  0x00, 0x11, 0x80, 0x00, 0x61, 0x00, 0x01, 0x83, 0x00, 0x06, 0x02, 0x00,
  0x18, 0x06, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x18, 0x0C,
  0x00, 0x18, 0x30, 0x00, 0x30, 0x40, 0x00, 0x21, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x58, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0x80, 0x00, 0xFF, 0xC0, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x30, 0x04, 0x01, 0x00, 0x40, 0x18, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x80, 0x20,
  0x08, 0x02, 0x00, 0xC0, 0x03, 0xFF, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x40, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00,
  0x24, 0x00, 0x06, 0x60, 0x00, 0xC2, 0x00, 0x18, 0x20, 0x01, 0x03, 0x00,
  0x30, 0x10, 0x06, 0x01, 0x80, 0xC0, 0x08, 0x08, 0x00, 0xC1, 0x00, 0x04,
  0x30, 0x00, 0x46, 0x00, 0x06, 0x40, 0x00, 0x28, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x8C, 0x46, 0x23, 0x10, 0x01, 0xF8, 0x41, 0x81, 0x90, 0x80, 0x14,
  0x40, 0x05, 0x30, 0x00, 0xD8, 0x00, 0x34, 0x00, 0x09, 0x00, 0x02, 0xC0,
  0x00, 0xB0, 0x00, 0x68, 0x00, 0x1A, 0x00, 0x06, 0x80, 0x01, 0x20, 0x00,
  0x48, 0x00, 0x32, 0x00, 0x0C, 0xC0, 0x07, 0x10, 0x02, 0xC6, 0x01, 0xA0,
  0xC0, 0x88, 0x0F, 0xC3, 0xC0, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x03, 0x0F, 0xC0, 0x66, 0x0C, 0x0D, 0x00, 0x41, 0x40, 0x0C,
  0x30, 0x00, 0x86, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x66, 0x00, 0x0C,
  0x80, 0x01, 0x90, 0x00, 0x32, 0x00, 0x06, 0xC0, 0x00, 0x98, 0x00, 0x32,
  0x00, 0x06, 0x40, 0x00, 0x8C, 0x00, 0x31, 0x80, 0x0C, 0x68, 0x03, 0x0C,
  0xC1, 0xC1, 0x87, 0xE0, 0x00, 0x00, 0xFC, 0x01, 0xC1, 0xC0, 0xC0, 0x18,
  0x60, 0x02, 0x30, 0x00, 0x88, 0x00, 0x16, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x11, 0x00, 0x06, 0x40, 0x03, 0x18, 0x01, 0x83, 0x00, 0xC0,
  0x60, 0x60, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x1F, 0x86, 0x06, 0x06, 0x40, 0x80, 0x14, 0x10,
  0x01, 0x43, 0x00, 0x0C, 0x60, 0x00, 0xC4, 0x00, 0x08, 0x40, 0x00, 0x8C,
  0x00, 0x08, 0xC0, 0x00, 0x88, 0x00, 0x18, 0x80, 0x01, 0x88, 0x00, 0x10,
  0x80, 0x01, 0x08, 0x00, 0x30, 0x80, 0x03, 0x0C, 0x00, 0x70, 0x40, 0x0B,
  0x06, 0x01, 0xA0, 0x30, 0x22, 0x00, 0xFC, 0x20, 0x00, 0xFC, 0x00, 0xC0,
  0xC0, 0xC0, 0x08, 0x60, 0x03, 0x10, 0x00, 0xCC, 0x00, 0x32, 0x00, 0x0D,
  0x80, 0x02, 0x40, 0x01, 0x90, 0x01, 0x8C, 0x0F, 0x83, 0xFE, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x02, 0x40, 0x01, 0x18, 0x00,
  0xC3, 0x00, 0x60, 0x60, 0x70, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x02, 0x00, 0x80, 0x00, 0x80, 0x40, 0x00,
  0x20, 0x60, 0x00, 0x08, 0x30, 0x00, 0x03, 0x10, 0x00, 0x00, 0xC8, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFC, 0x30, 0x30, 0x32,
  0x04, 0x00, 0xA0, 0x80, 0x0A, 0x10, 0x00, 0x63, 0x00, 0x06, 0x20, 0x00,
  0x42, 0x00, 0x04, 0x60, 0x00, 0x46, 0x00, 0x04, 0x40, 0x00, 0xC4, 0x00,
  0x0C, 0x40, 0x00, 0x84, 0x00, 0x08, 0x40, 0x01, 0x84, 0x00, 0x18, 0x60,
  0x03, 0x82, 0x00, 0x58, 0x30, 0x0D, 0x01, 0x81, 0x90, 0x07, 0xE1, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40,
  0xC0, 0x0C, 0x07, 0x03, 0x00, 0x1F, 0xC0, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x02, 0x1F, 0x80, 0x98, 0x30, 0x68, 0x06, 0x1C,
  0x00, 0x87, 0x00, 0x31, 0x80, 0x0C, 0x40, 0x03, 0x10, 0x00, 0x8C, 0x00,
  0x23, 0x00, 0x08, 0xC0, 0x02, 0x20, 0x01, 0x88, 0x00, 0x62, 0x00, 0x11,
  0x80, 0x04, 0x60, 0x01, 0x10, 0x00, 0x44, 0x00, 0x31, 0x00, 0x0C, 0x40,
  0x02, 0x30, 0x00, 0x80, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x03, 0x06, 0x03, 0x03, 0x06, 0x01,
  0x06, 0x00, 0x84, 0x00, 0xCC, 0x00, 0x68, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0xC1, 0x80, 0x60, 0x60, 0x20, 0x18, 0x10, 0x06, 0x08,
  0x01, 0x84, 0x00, 0x26, 0x00, 0x0B, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC3, 0xF0, 0x06,
  0x60, 0x60, 0x34, 0x01, 0x01, 0x40, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x03,
  0x06, 0x00, 0x10, 0x30, 0x01, 0x81, 0x80, 0x18, 0x08, 0x01, 0x80, 0x40,
  0x30, 0x02, 0x1E, 0x00, 0x31, 0x80, 0x01, 0x86, 0x00, 0x0C, 0x18, 0x02,
  0x40, 0x40, 0x2A, 0x03, 0x02, 0x10, 0x08, 0x21, 0x80, 0x62, 0x0C, 0x01,
  0x60, 0x60, 0x06, 0x00, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x08, 0x03, 0x08, 0x04, 0x08, 0x18, 0x18, 0x20, 0x18, 0xC0, 0x11, 0x00,
  0x16, 0x00, 0x18, 0x00, 0x08, 0xF0, 0xF8, 0x24, 0x64, 0x30, 0xE0, 0xA0,
  0x47, 0x03, 0x01, 0x18, 0x0C, 0x04, 0x60, 0x20, 0x11, 0x00, 0x80, 0x44,
  0x02, 0x03, 0x10, 0x18, 0x0C, 0xC0, 0x60, 0x23, 0x01, 0x00, 0x88, 0x04,
  0x02, 0x20, 0x10, 0x18, 0x80, 0x40, 0x62, 0x03, 0x01, 0x98, 0x0C, 0x04,
  0x60, 0x20, 0x11, 0x00, 0x80, 0x44, 0x02, 0x03, 0x10, 0x18, 0x0C, 0xC0,
  0x60, 0x30, 0x08, 0x7E, 0x02, 0x60, 0xC1, 0xA0, 0x18, 0x70, 0x02, 0x1C,
  0x00, 0xC6, 0x00, 0x31, 0x00, 0x0C, 0x40, 0x02, 0x30, 0x00, 0x8C, 0x00,
  0x23, 0x00, 0x08, 0x80, 0x06, 0x20, 0x01, 0x88, 0x00, 0x46, 0x00, 0x11,
  0x80, 0x04, 0x40, 0x01, 0x10, 0x00, 0xC4, 0x00, 0x31, 0x00, 0x08, 0xC0,
  0x02, 0x00, 0x01, 0xFC, 0x01, 0xC1, 0xC0, 0xC0, 0x18, 0x60, 0x02, 0x30,
  0x00, 0xC8, 0x00, 0x16, 0x00, 0x05, 0x80, 0x01, 0x40, 0x00, 0x50, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0B,
  0x00, 0x06, 0x40, 0x01, 0x18, 0x00, 0xC2, 0x00, 0x60, 0x60, 0x60, 0x07,
  0xE0, 0x00, 0x0C, 0x3F, 0x00, 0xCC, 0x18, 0x0D, 0x00, 0x40, 0xA0, 0x06,
  0x0C, 0x00, 0x20, 0xC0, 0x03, 0x18, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00,
  0x31, 0x00, 0x03, 0x10, 0x00, 0x31, 0x00, 0x03, 0x30, 0x00, 0x23, 0x00,
  0x06, 0x20, 0x00, 0x62, 0x00, 0x04, 0x30, 0x00, 0xC3, 0x00, 0x18, 0x68,
  0x03, 0x06, 0x60, 0xE0, 0x61, 0xF8, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x60, 0xC0, 0xC8, 0x20, 0x05, 0x08, 0x00,
  0xA3, 0x00, 0x0C, 0xC0, 0x01, 0x90, 0x00, 0x22, 0x00, 0x04, 0xC0, 0x00,
  0x98, 0x00, 0x12, 0x00, 0x06, 0x40, 0x00, 0xC8, 0x00, 0x11, 0x00, 0x02,
  0x20, 0x00, 0xC4, 0x00, 0x18, 0xC0, 0x07, 0x08, 0x01, 0x61, 0x80, 0x68,
  0x18, 0x19, 0x00, 0xFC, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0xFF, 0x0F, 0xE0, 0x26, 0x00, 0x0D, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x30, 0x1C, 0x04, 0x00, 0x60, 0x80, 0x03,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x40, 0x00, 0x4C, 0x00, 0x0C, 0x30,
  0x01, 0x81, 0xC0, 0x70, 0x07, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xF0, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x04, 0x06, 0x01, 0x80, 0x60, 0x30, 0x06, 0x0C, 0x00, 0x41, 0x00,
  0x04, 0x60, 0x00, 0x58, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x98, 0x00,
  0x48, 0x00, 0x64, 0x00, 0x32, 0x00, 0x1B, 0x00, 0x09, 0x80, 0x04, 0xC0,
  0x02, 0x40, 0x03, 0x20, 0x01, 0x90, 0x00, 0xD8, 0x00, 0x4C, 0x00, 0x26,
  0x00, 0x32, 0x00, 0x19, 0x00, 0x0C, 0x80, 0x0E, 0x60, 0x0A, 0x10, 0x09,
  0x0E, 0x08, 0x81, 0xF8, 0xC0, 0xFE, 0x00, 0x40, 0xC0, 0x08, 0x18, 0x01,
  0x82, 0x00, 0x30, 0x40, 0x06, 0x08, 0x00, 0xC1, 0x00, 0x18, 0x60, 0x03,
  0x0C, 0x00, 0x41, 0x80, 0x08, 0x20, 0x03, 0x04, 0x00, 0x60, 0x80, 0x08,
  0x30, 0x03, 0x06, 0x00, 0xC0, 0xC0, 0x10, 0x10, 0x04, 0x02, 0x03, 0x00,
  0x40, 0xC0, 0x08, 0x60, 0x01, 0xF0, 0x00, 0x30, 0x10, 0x23, 0x01, 0x02,
  0x20, 0x10, 0x32, 0x03, 0x01, 0x20, 0x30, 0x16, 0x02, 0x01, 0x60, 0x20,
  0x16, 0x02, 0x01, 0x40, 0x20, 0x14, 0x06, 0x01, 0x40, 0x60, 0x1C, 0x04,
  0x03, 0xC0, 0x40, 0x3C, 0x04, 0x02, 0x80, 0x40, 0x28, 0x0C, 0x06, 0x81,
  0x40, 0x48, 0x14, 0x0C, 0x82, 0x40, 0x8C, 0x66, 0x30, 0x78, 0x3E, 0x00,
  0x01, 0xC0, 0x78, 0x0E, 0xC3, 0x18, 0x70, 0x8C, 0x1B, 0x01, 0x90, 0x30,
  0x01, 0x40, 0x20, 0x02, 0x80, 0x40, 0x06, 0x01, 0x80, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x30, 0x14, 0x00, 0x40, 0x28, 0x00, 0x80, 0x50,
  0x09, 0x01, 0x30, 0x3B, 0x04, 0x21, 0x82, 0x10, 0x6E, 0x03, 0xC0, 0x70,
  0x00, 0x0C, 0x00, 0x21, 0x80, 0x04, 0x20, 0x01, 0x84, 0x00, 0x30, 0x80,
  0x06, 0x30, 0x00, 0x86, 0x00, 0x10, 0xC0, 0x02, 0x10, 0x00, 0xC2, 0x00,
  0x18, 0x40, 0x03, 0x18, 0x00, 0x43, 0x00, 0x08, 0x60, 0x03, 0x08, 0x00,
  0x61, 0x00, 0x0C, 0x20, 0x03, 0x06, 0x00, 0xA0, 0x40, 0x24, 0x0E, 0x18,
  0x80, 0x7E, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x01, 0x82, 0x00, 0x60, 0x30, 0x18, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x10, 0xC1, 0xF1, 0x18, 0x01, 0xF1, 0x00, 0x06, 0x10, 0x00, 0xC3, 0x00,
  0x18, 0x30, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x08, 0x0C, 0x00, 0x81,
  0x80, 0x0C, 0x30, 0x00, 0xC7, 0x80, 0x04, 0xDF, 0xC0, 0x4C, 0x1F, 0xC4,
  0xC0, 0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x60, 0x0F, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x1F, 0xF0, 0x00, 0x02, 0x04, 0x08, 0x30, 0x60, 0xC1, 0x02, 0x04, 0x18,
  0x30, 0x60, 0x81, 0x02, 0x0C, 0x18, 0x30, 0x40, 0x81, 0x06, 0x0C, 0x18,
  0x20, 0x40, 0x83, 0x06, 0x0C, 0x10, 0x20, 0x41, 0x83, 0x06, 0x08, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xFC, 0x01, 0xC0, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0x00, 0x08, 0xC6, 0x00, 0xCC, 0x18, 0x04, 0x40, 0x40, 0x64, 0x01,
  0x02, 0x20, 0x04, 0x62, 0x00, 0x1E, 0x00,
};

const GFXglyph IBMPlexMono_ExtraLightItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 7, 29, 25, 9, -29 },
  { 27, 9, 11, 25, 10, -30 },
  { 40, 24, 29, 25, 1, -29 },
  { 127, 22, 37, 25, 1, -33 },
  { 229, 28, 29, 25, -1, -29 },
  { 331, 24, 29, 25, 0, -29 },
  { 418, 3, 11, 25, 13, -30 },
  { 423, 14, 37, 25, 9, -31 },
  { 488, 13, 37, 25, 3, -31 },
  { 549, 20, 20, 25, 3, -23 },
  { 599, 19, 19, 25, 3, -22 },
  { 645, 7, 11, 25, 6, -4 },
  { 655, 11, 1, 25, 7, -13 },
  { 657, 4, 3, 25, 9, -3 },
  { 659, 23, 37, 25, 1, -31 },
  { 766, 20, 29, 25, 3, -29 },
  { 839, 19, 29, 25, 2, -29 },
  { 908, 20, 29, 25, 2, -29 },
  { 981, 20, 29, 25, 2, -29 },
  { 1054, 21, 29, 25, 1, -29 },
  { 1131, 21, 29, 25, 2, -29 },
  { 1208, 18, 29, 25, 3, -29 },
  { 1274, 19, 29, 25, 5, -29 },
  { 1343, 21, 29, 25, 2, -29 },
  { 1420, 18, 29, 25, 4, -29 },
  { 1486, 7, 21, 25, 9, -21 },
  { 1505, 10, 28, 25, 6, -21 },
  { 1540, 19, 22, 25, 4, -24 },
  { 1593, 21, 9, 25, 2, -17 },
  { 1617, 20, 22, 25, 2, -24 },
  { 1672, 16, 29, 25, 6, -29 },
  { 1730, 19, 33, 25, 3, -29 },
  { 1809, 21, 29, 25, 0, -29 },
  { 1886, 20, 29, 25, 2, -29 },
  { 1959, 19, 29, 25, 4, -29 },
  { 2028, 20, 29, 25, 3, -29 },
  { 2101, 22, 29, 25, 2, -29 },
  { 2181, 22, 29, 25, 2, -29 },
  { 2261, 20, 29, 25, 3, -29 },
  { 2334, 22, 29, 25, 2, -29 },
  { 2414, 22, 29, 25, 2, -29 },
  { 2494, 19, 29, 25, 3, -29 },
  { 2563, 24, 29, 25, 2, -29 },
  { 2650, 16, 29, 25, 4, -29 },
  { 2708, 22, 29, 25, 2, -29 },
  { 2788, 22, 29, 25, 2, -29 },
  { 2868, 20, 29, 25, 3, -29 },
  { 2941, 22, 29, 25, 2, -29 },
  { 3021, 20, 36, 25, 3, -29 },
  { 3111, 22, 29, 25, 2, -29 },
  { 3191, 22, 29, 25, 1, -29 },
  { 3271, 22, 29, 25, 4, -29 },
  { 3351, 21, 29, 25, 3, -29 },
  { 3428, 21, 29, 25, 5, -29 },
  { 3505, 22, 29, 25, 3, -29 },
  { 3585, 26, 29, 25, 0, -29 },
  { 3680, 23, 29, 25, 4, -29 },
  { 3764, 25, 29, 25, 0, -29 },
  { 3855, 16, 37, 25, 8, -31 },
  { 3929, 10, 37, 25, 8, -31 },
  { 3976, 16, 37, 25, 1, -31 },
  { 4050, 20, 16, 25, 3, -29 },
  { 4090, 20, 1, 25, 0, 5 },
  { 4093, 4, 7, 25, 10, -31 },
  { 4097, 18, 21, 25, 3, -21 },
  { 4145, 19, 30, 25, 3, -30 },
  { 4217, 18, 21, 25, 3, -21 },
  { 4265, 20, 30, 25, 3, -30 },
  { 4340, 18, 21, 25, 3, -21 },
  { 4388, 25, 38, 25, 0, -30 },
  { 4507, 20, 29, 25, 2, -21 },
  { 4580, 18, 30, 25, 3, -30 },
  { 4648, 17, 31, 25, 4, -31 },
  { 4714, 17, 39, 25, 4, -31 },
  { 4797, 21, 30, 25, 3, -30 },
  { 4876, 16, 30, 25, 5, -30 },
  { 4936, 22, 21, 25, 1, -21 },
  { 4994, 18, 21, 25, 3, -21 },
  { 5042, 18, 21, 25, 3, -21 },
  { 5090, 20, 29, 25, 2, -21 },
  { 5163, 19, 29, 25, 3, -21 },
  { 5232, 19, 21, 25, 5, -21 },
  { 5282, 20, 21, 25, 2, -21 },
  { 5335, 20, 29, 25, 3, -29 },
  { 5408, 17, 21, 25, 4, -21 },
  { 5453, 19, 21, 25, 3, -21 },
  { 5503, 20, 21, 25, 3, -21 },
  { 5556, 23, 21, 25, 1, -21 },
  { 5617, 19, 29, 25, 2, -21 },
  { 5686, 20, 21, 25, 2, -21 },
  { 5739, 18, 37, 25, 5, -31 },
  { 5823, 7, 37, 25, 9, -31 },
  { 5856, 18, 37, 25, 2, -31 },
  { 5940, 21, 7, 25, 2, -16 },
};

const GFXfont IBMPlexMono_ExtraLightItalic41pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic41pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic41pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC41PT7B_H_
