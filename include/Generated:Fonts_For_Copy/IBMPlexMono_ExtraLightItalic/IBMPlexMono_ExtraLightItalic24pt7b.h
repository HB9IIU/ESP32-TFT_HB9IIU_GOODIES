#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC24PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x11, 0x11, 0x22, 0x22, 0x44, 0x00, 0x0C, 0xC0, 0x4A, 0x63,
  0x18, 0xC8, 0x00, 0x88, 0x02, 0x20, 0x04, 0x40, 0x08, 0x80, 0x22, 0x07,
  0xC7, 0xC0, 0x88, 0x02, 0x20, 0x04, 0x40, 0x08, 0x80, 0x21, 0x07, 0xC7,
  0xC0, 0x88, 0x02, 0x10, 0x04, 0x40, 0x10, 0x80, 0x22, 0x00, 0x01, 0x80,
  0x08, 0x01, 0xF0, 0x32, 0x62, 0x10, 0x90, 0x80, 0x84, 0x04, 0x40, 0x22,
  0x00, 0xD0, 0x01, 0xE0, 0x04, 0x80, 0x42, 0x02, 0x10, 0x10, 0x90, 0x84,
  0x84, 0x23, 0x26, 0x07, 0xC0, 0x10, 0x00, 0x80, 0x00, 0x0E, 0x03, 0x11,
  0x04, 0x20, 0x84, 0x20, 0x88, 0x20, 0x90, 0x21, 0x20, 0x23, 0x20, 0x1E,
  0x40, 0x00, 0x00, 0x00, 0x70, 0x0D, 0x88, 0x09, 0x08, 0x12, 0x08, 0x22,
  0x08, 0x42, 0x08, 0x41, 0x10, 0x80, 0xE0, 0x07, 0xC0, 0x31, 0x80, 0x82,
  0x02, 0x08, 0x08, 0x20, 0x20, 0x80, 0x82, 0x01, 0x10, 0x3F, 0x81, 0x08,
  0x04, 0x10, 0x20, 0x40, 0x80, 0x82, 0x05, 0x18, 0x14, 0x90, 0xCA, 0x3C,
  0x30, 0x6A, 0xA0, 0x01, 0x06, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40,
  0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20, 0x18,
  0x10, 0x10, 0x10, 0x20, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x81, 0x02, 0x08, 0x20, 0x82, 0x08, 0x00, 0x01, 0x00, 0x08, 0x00, 0x80,
  0x04, 0x04, 0x21, 0xDD, 0x70, 0x1C, 0x00, 0xC0, 0x09, 0x00, 0x84, 0x08,
  0x20, 0x80, 0x80, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x41, 0xFF, 0xC1,
  0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x00, 0x2D, 0x29, 0x00, 0xFE, 0xF0,
  0x00, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x00, 0x0F,
  0x83, 0x08, 0x80, 0xB0, 0x14, 0x02, 0x80, 0x60, 0x0C, 0x21, 0x84, 0x30,
  0x06, 0x00, 0xC0, 0x28, 0x05, 0x00, 0xA0, 0x22, 0x08, 0x3E, 0x00, 0x01,
  0x80, 0x50, 0x32, 0x0C, 0x83, 0x10, 0x82, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0xFF, 0xE0, 0x07,
  0xC0, 0x82, 0x10, 0x12, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0xFF,
  0xE0, 0x07, 0xC0, 0x82, 0x10, 0x12, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40,
  0xF8, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x80, 0x46,
  0x08, 0x3F, 0x00, 0x00, 0x20, 0x06, 0x00, 0xA0, 0x12, 0x02, 0x20, 0x44,
  0x08, 0x40, 0x84, 0x10, 0x42, 0x04, 0x40, 0x48, 0x08, 0xFF, 0xF0, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xF1, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x02, 0x00, 0x2F, 0x83, 0x04, 0x20, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0xC0, 0x46, 0x08, 0x1F, 0x00, 0x01, 0xC0, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x06, 0x01, 0x3C, 0x70, 0xF0, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x09, 0x06, 0x3E, 0x00, 0xFF, 0xF0, 0x06, 0x01, 0x40, 0x48, 0x08,
  0x02, 0x00, 0x40, 0x10, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40,
  0x08, 0x02, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0x83, 0x10, 0x12, 0x01, 0x20,
  0x12, 0x01, 0x20, 0x11, 0x86, 0x07, 0x83, 0x84, 0x40, 0x24, 0x02, 0x80,
  0x18, 0x02, 0x40, 0x26, 0x0C, 0x1F, 0x00, 0x0F, 0x86, 0x09, 0x80, 0xA0,
  0x18, 0x03, 0x00, 0x60, 0x0A, 0x07, 0x61, 0xC7, 0xC8, 0x02, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0xC0, 0x60, 0x00, 0x33, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0xC0, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x46, 0x21, 0x10,
  0x80, 0x00, 0x10, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0x80, 0x04,
  0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x00, 0x10, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00,
  0x80, 0x00, 0x1F, 0x0C, 0x24, 0x05, 0x01, 0x80, 0x40, 0x10, 0x08, 0x04,
  0x0E, 0x04, 0x01, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x07, 0x83, 0x08, 0xC0, 0x90, 0x14, 0x02, 0x87, 0x51, 0x1A, 0x41, 0x88,
  0x52, 0x0A, 0x41, 0x48, 0x29, 0x05, 0x13, 0xA3, 0xA4, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x1F, 0x80, 0x00, 0xC0, 0x0C, 0x01, 0x40, 0x14, 0x02, 0x40,
  0x24, 0x04, 0x20, 0x42, 0x08, 0x20, 0x82, 0x10, 0x21, 0xFE, 0x20, 0x12,
  0x01, 0x40, 0x14, 0x01, 0x80, 0x10, 0x1F, 0xC1, 0x02, 0x10, 0x12, 0x01,
  0x20, 0x12, 0x01, 0x20, 0x22, 0x04, 0x3F, 0x84, 0x06, 0x40, 0x24, 0x02,
  0x40, 0x24, 0x02, 0x40, 0x28, 0x04, 0xFF, 0x80, 0x07, 0x81, 0x84, 0x10,
  0x22, 0x02, 0x40, 0x14, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x04, 0x40, 0x86, 0x10, 0x3E, 0x00, 0x3F, 0x84,
  0x18, 0x80, 0x90, 0x14, 0x02, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x28, 0x06,
  0x00, 0xC0, 0x18, 0x05, 0x00, 0xA0, 0x24, 0x18, 0xFE, 0x00, 0x1F, 0xF8,
  0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x3F,
  0xE1, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x3F, 0xE1, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x80, 0x00, 0x07, 0x83, 0x08, 0xC0, 0x90, 0x14,
  0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x7E, 0x01, 0x40, 0x28, 0x05,
  0x00, 0xB0, 0x33, 0x0A, 0x3E, 0x80, 0x10, 0x08, 0x80, 0x48, 0x02, 0x40,
  0x22, 0x01, 0x10, 0x08, 0x80, 0x44, 0x02, 0x3F, 0xF2, 0x01, 0x10, 0x08,
  0x80, 0x44, 0x02, 0x20, 0x11, 0x00, 0x90, 0x08, 0x80, 0x40, 0x1F, 0xF8,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0xFF, 0xC0, 0x1F, 0xE0, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x09, 0x01, 0x20, 0x46, 0x10,
  0x7C, 0x00, 0x10, 0x0C, 0x40, 0x41, 0x02, 0x04, 0x10, 0x20, 0x80, 0x84,
  0x02, 0x20, 0x09, 0x80, 0x2A, 0x00, 0xC4, 0x06, 0x10, 0x10, 0x20, 0x40,
  0x81, 0x01, 0x04, 0x04, 0x10, 0x10, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x02, 0x00, 0xFF, 0xC0, 0x10, 0x09, 0x80, 0xCC, 0x06, 0x50,
  0x52, 0x87, 0x14, 0x29, 0x22, 0x48, 0x92, 0x45, 0x12, 0x28, 0x90, 0x84,
  0x88, 0x48, 0x02, 0x40, 0x12, 0x00, 0x90, 0x04, 0x80, 0x20, 0x10, 0x08,
  0xC0, 0x4A, 0x02, 0x50, 0x22, 0x41, 0x12, 0x08, 0x90, 0x44, 0x42, 0x42,
  0x12, 0x11, 0x10, 0x48, 0x82, 0x44, 0x12, 0x20, 0x52, 0x02, 0x90, 0x18,
  0x80, 0x40, 0x0F, 0x83, 0x08, 0x80, 0xB0, 0x14, 0x02, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x28, 0x05, 0x00, 0xA0, 0x22, 0x08,
  0x3E, 0x00, 0x1F, 0xE0, 0x80, 0x84, 0x02, 0x20, 0x12, 0x00, 0x90, 0x04,
  0x80, 0x44, 0x02, 0x20, 0x21, 0xFE, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x80, 0x00, 0x0F, 0x83, 0x08, 0x80, 0xB0, 0x14,
  0x02, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x28, 0x05,
  0x00, 0xA0, 0x22, 0x08, 0x3E, 0x01, 0x00, 0x11, 0x81, 0x40, 0x30, 0x1F,
  0xE0, 0x80, 0x84, 0x02, 0x20, 0x12, 0x00, 0x90, 0x04, 0x80, 0x44, 0x02,
  0x20, 0x21, 0xFE, 0x08, 0x80, 0x82, 0x04, 0x10, 0x20, 0x41, 0x02, 0x08,
  0x08, 0x80, 0x60, 0x07, 0xC0, 0xC1, 0x88, 0x02, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x03, 0x00, 0x07, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x40, 0x12, 0x00, 0x8C, 0x18, 0x1F, 0x00, 0xFF, 0xF0, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x00, 0x20, 0x12, 0x01,
  0x40, 0x24, 0x02, 0x40, 0x24, 0x02, 0x40, 0x24, 0x02, 0x80, 0x28, 0x04,
  0x80, 0x48, 0x04, 0x80, 0x48, 0x08, 0x80, 0x84, 0x10, 0x3E, 0x00, 0x80,
  0x18, 0x02, 0x80, 0x28, 0x04, 0x40, 0x44, 0x08, 0x40, 0x84, 0x10, 0x41,
  0x04, 0x20, 0x42, 0x02, 0x40, 0x24, 0x02, 0x80, 0x28, 0x02, 0x80, 0x30,
  0x00, 0x40, 0x0A, 0x00, 0x50, 0x04, 0x80, 0x28, 0x01, 0x43, 0x12, 0x18,
  0x91, 0x44, 0x8A, 0x24, 0x92, 0x24, 0x91, 0x24, 0x8A, 0x24, 0x50, 0xC3,
  0x06, 0x18, 0x30, 0x81, 0x80, 0x10, 0x06, 0x10, 0x08, 0x20, 0x20, 0x20,
  0x80, 0x42, 0x00, 0x4C, 0x00, 0x90, 0x00, 0xC0, 0x01, 0x00, 0x05, 0x00,
  0x12, 0x00, 0x22, 0x00, 0x84, 0x02, 0x04, 0x08, 0x08, 0x20, 0x08, 0xC0,
  0x10, 0xC0, 0x0D, 0x00, 0x44, 0x01, 0x08, 0x08, 0x20, 0x40, 0x42, 0x01,
  0x10, 0x02, 0x40, 0x0A, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x1F, 0xFE, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20,
  0x00, 0xFF, 0xF0, 0x1F, 0x88, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x0F, 0xC0, 0x84, 0x21, 0x08, 0x21, 0x08, 0x41, 0x08, 0x42, 0x08,
  0x42, 0x10, 0x42, 0x10, 0x80, 0x1F, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x8F, 0xC0, 0x03, 0x00, 0xA0, 0x12, 0x04, 0x41, 0x08,
  0x40, 0x88, 0x12, 0x01, 0x80, 0x20, 0xFF, 0xF0, 0xA5, 0x1F, 0x64, 0x19,
  0x01, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x24, 0x04, 0x80, 0x90, 0x33, 0x0A,
  0x1E, 0x70, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x09, 0xE2,
  0xC6, 0x60, 0x48, 0x05, 0x00, 0xA0, 0x14, 0x03, 0x00, 0xA0, 0x14, 0x04,
  0xE1, 0x93, 0xC0, 0x0F, 0x0C, 0x24, 0x05, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0xE0, 0x24, 0x30, 0xF8, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x1F, 0x42, 0x0C, 0x40, 0x48, 0x04, 0x80, 0x48, 0x04,
  0x80, 0x88, 0x08, 0x80, 0x88, 0x18, 0xC2, 0x83, 0xC8, 0x0F, 0x8C, 0x14,
  0x05, 0x01, 0x80, 0x60, 0xEF, 0xC2, 0x00, 0x80, 0xA0, 0x34, 0x18, 0xF8,
  0x00, 0x7E, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x07,
  0xFF, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x02, 0x08, 0x02,
  0x20, 0x02, 0x40, 0x02, 0x80, 0x03, 0x00, 0x00, 0x0F, 0x91, 0x06, 0x20,
  0x24, 0x02, 0x40, 0x24, 0x02, 0x40, 0x28, 0x04, 0x40, 0x44, 0x0C, 0x61,
  0x41, 0xE4, 0x00, 0x80, 0x08, 0x00, 0x8C, 0x30, 0x3E, 0x00, 0x10, 0x04,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x78, 0xA3, 0x70, 0x58, 0x14, 0x05,
  0x01, 0x40, 0x50, 0x28, 0x0A, 0x02, 0x80, 0xA0, 0x20, 0x02, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x04, 0x11, 0x08, 0x4C, 0x14, 0x06, 0x00, 0x00, 0x40, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE2, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x41, 0x08, 0x71, 0x03,
  0x20, 0x14, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x27, 0x85, 0x84, 0x60, 0x46, 0x04, 0x40, 0x44, 0x18, 0x5E, 0x08,
  0x80, 0x8C, 0x38, 0x46, 0x82, 0x88, 0x30, 0xFC, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x04, 0x8C,
  0x48, 0x58, 0x10, 0x00, 0x2E, 0x71, 0x94, 0x98, 0xC2, 0x84, 0x24, 0x21,
  0x21, 0x09, 0x08, 0x50, 0x42, 0x84, 0x14, 0x21, 0x21, 0x09, 0x08, 0x40,
  0x27, 0x8A, 0x33, 0x05, 0x81, 0x40, 0x50, 0x14, 0x05, 0x02, 0x80, 0xA0,
  0x28, 0x0A, 0x02, 0x0F, 0x06, 0x19, 0x01, 0x20, 0x28, 0x03, 0x00, 0xA0,
  0x14, 0x02, 0x80, 0x50, 0x11, 0x04, 0x1F, 0x00, 0x13, 0xC2, 0xC6, 0x30,
  0x22, 0x01, 0x20, 0x12, 0x01, 0x20, 0x14, 0x02, 0x40, 0x24, 0x04, 0x70,
  0xC4, 0xF0, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x1F, 0x24,
  0x19, 0x01, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x14, 0x04, 0x80, 0x90, 0x33,
  0x0A, 0x1E, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0xF9, 0xE1,
  0xC0, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x00, 0x0F, 0xC1, 0x02, 0x20, 0x12, 0x00, 0x20, 0x01, 0xF0,
  0x00, 0xC0, 0x02, 0x00, 0x28, 0x02, 0x60, 0x41, 0xF8, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x81, 0xFF, 0xC2, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40,
  0x08, 0x01, 0x04, 0x21, 0x84, 0xC1, 0x60, 0x18, 0x00, 0x60, 0x50, 0x14,
  0x05, 0x01, 0x40, 0x50, 0x18, 0x0A, 0x02, 0x80, 0xA0, 0xE4, 0x28, 0xE4,
  0xF0, 0x42, 0x04, 0x80, 0x90, 0x12, 0x02, 0x40, 0x88, 0x11, 0x06, 0x40,
  0x88, 0x21, 0x18, 0x3C, 0x00, 0x42, 0x24, 0x22, 0x42, 0x28, 0x41, 0x84,
  0x18, 0x41, 0x84, 0x28, 0x42, 0x84, 0x28, 0x84, 0x94, 0xCE, 0x38, 0x06,
  0x38, 0x69, 0x16, 0x28, 0x40, 0x61, 0x01, 0x04, 0x04, 0x00, 0x10, 0x20,
  0xC0, 0x83, 0x02, 0x14, 0x24, 0xD3, 0x1E, 0x30, 0x10, 0x24, 0x04, 0x80,
  0x90, 0x12, 0x02, 0x40, 0x50, 0x12, 0x02, 0x40, 0x48, 0x38, 0x85, 0x0F,
  0x60, 0x08, 0x01, 0x00, 0x66, 0x18, 0x3E, 0x00, 0x1F, 0x12, 0x0F, 0x20,
  0x24, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x84, 0x30, 0x44, 0x02, 0xBE,
  0x28, 0x3E, 0x07, 0xE0, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x01, 0x00,
  0x10, 0x02, 0x00, 0x83, 0xE0, 0x0E, 0x00, 0x40, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x03, 0xE0, 0x08, 0x84, 0x21, 0x08, 0x44,
  0x21, 0x08, 0x44, 0x21, 0x08, 0x42, 0x21, 0x08, 0x00, 0x0F, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x20, 0x04, 0x00, 0xC0, 0x07,
  0x83, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x0F, 0xC0, 0x18, 0x19, 0x20, 0x90, 0x85, 0x02, 0x48, 0x1C, 0x00,
};

const GFXglyph IBMPlexMono_ExtraLightItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 17, 14, 5, -17 },
  { 10, 5, 6, 14, 6, -18 },
  { 14, 15, 17, 14, 0, -17 },
  { 46, 13, 21, 14, 1, -19 },
  { 81, 16, 17, 14, 0, -17 },
  { 115, 14, 17, 14, 0, -17 },
  { 145, 2, 6, 14, 8, -18 },
  { 147, 8, 21, 14, 5, -18 },
  { 168, 7, 21, 14, 2, -18 },
  { 187, 13, 12, 14, 1, -13 },
  { 207, 11, 11, 14, 2, -13 },
  { 223, 3, 6, 14, 4, -2 },
  { 226, 7, 1, 14, 4, -8 },
  { 227, 2, 2, 14, 5, -2 },
  { 228, 13, 21, 14, 1, -18 },
  { 263, 11, 17, 14, 2, -17 },
  { 287, 11, 17, 14, 1, -17 },
  { 311, 12, 17, 14, 1, -17 },
  { 337, 12, 17, 14, 1, -17 },
  { 363, 12, 17, 14, 1, -17 },
  { 389, 12, 17, 14, 1, -17 },
  { 415, 10, 17, 14, 2, -17 },
  { 437, 11, 17, 14, 3, -17 },
  { 461, 12, 17, 14, 1, -17 },
  { 487, 11, 17, 14, 2, -17 },
  { 511, 4, 13, 14, 5, -13 },
  { 518, 5, 17, 14, 4, -13 },
  { 529, 12, 13, 14, 2, -14 },
  { 549, 13, 5, 14, 1, -10 },
  { 558, 12, 13, 14, 1, -14 },
  { 578, 10, 17, 14, 3, -17 },
  { 600, 11, 20, 14, 2, -17 },
  { 628, 12, 17, 14, 0, -17 },
  { 654, 12, 17, 14, 1, -17 },
  { 680, 12, 17, 14, 2, -17 },
  { 706, 11, 17, 14, 2, -17 },
  { 730, 13, 17, 14, 1, -17 },
  { 758, 13, 17, 14, 1, -17 },
  { 786, 11, 17, 14, 2, -17 },
  { 810, 13, 17, 14, 1, -17 },
  { 838, 13, 17, 14, 1, -17 },
  { 866, 11, 17, 14, 2, -17 },
  { 890, 14, 17, 14, 1, -17 },
  { 920, 10, 17, 14, 2, -17 },
  { 942, 13, 17, 14, 1, -17 },
  { 970, 13, 17, 14, 1, -17 },
  { 998, 11, 17, 14, 2, -17 },
  { 1022, 13, 17, 14, 1, -17 },
  { 1050, 11, 21, 14, 2, -17 },
  { 1079, 13, 17, 14, 1, -17 },
  { 1107, 13, 17, 14, 1, -17 },
  { 1135, 12, 17, 14, 3, -17 },
  { 1161, 12, 17, 14, 2, -17 },
  { 1187, 12, 17, 14, 3, -17 },
  { 1213, 13, 17, 14, 2, -17 },
  { 1241, 15, 17, 14, 0, -17 },
  { 1273, 14, 17, 14, 2, -17 },
  { 1303, 15, 17, 14, 0, -17 },
  { 1335, 9, 21, 14, 5, -18 },
  { 1359, 5, 21, 14, 5, -18 },
  { 1373, 9, 21, 14, 1, -18 },
  { 1397, 11, 9, 14, 2, -17 },
  { 1410, 12, 1, 14, 0, 3 },
  { 1412, 2, 4, 14, 6, -18 },
  { 1413, 11, 12, 14, 2, -12 },
  { 1430, 11, 18, 14, 2, -18 },
  { 1455, 10, 12, 14, 2, -12 },
  { 1470, 12, 18, 14, 2, -18 },
  { 1497, 10, 12, 14, 2, -12 },
  { 1512, 15, 23, 14, 0, -18 },
  { 1556, 12, 17, 14, 1, -12 },
  { 1582, 10, 18, 14, 2, -18 },
  { 1605, 10, 18, 14, 2, -18 },
  { 1628, 11, 23, 14, 2, -18 },
  { 1660, 12, 18, 14, 2, -18 },
  { 1687, 9, 18, 14, 3, -18 },
  { 1708, 13, 12, 14, 1, -12 },
  { 1728, 10, 12, 14, 2, -12 },
  { 1743, 11, 12, 14, 2, -12 },
  { 1760, 12, 17, 14, 1, -12 },
  { 1786, 11, 17, 14, 2, -12 },
  { 1810, 11, 12, 14, 3, -12 },
  { 1827, 12, 12, 14, 1, -12 },
  { 1845, 11, 17, 14, 2, -17 },
  { 1869, 10, 12, 14, 2, -12 },
  { 1884, 11, 12, 14, 2, -12 },
  { 1901, 12, 12, 14, 2, -12 },
  { 1919, 14, 12, 14, 0, -12 },
  { 1940, 11, 17, 14, 1, -12 },
  { 1964, 12, 12, 14, 1, -12 },
  { 1982, 11, 21, 14, 3, -18 },
  { 2011, 5, 21, 14, 5, -18 },
  { 2025, 11, 21, 14, 1, -18 },
  { 2054, 13, 5, 14, 1, -10 },
};

const GFXfont IBMPlexMono_ExtraLightItalic24pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic24pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic24pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC24PT7B_H_
