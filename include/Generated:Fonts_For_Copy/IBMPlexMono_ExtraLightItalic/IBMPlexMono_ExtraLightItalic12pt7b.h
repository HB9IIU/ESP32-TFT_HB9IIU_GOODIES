#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC12PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x6A, 0x82, 0xBB, 0x00, 0x14, 0x29, 0x99, 0x42, 0x99, 0xD4, 0x28,
  0x08, 0x79, 0x4A, 0x83, 0x01, 0x85, 0x52, 0x78, 0x40, 0x33, 0x52, 0x94,
  0x78, 0x2C, 0x52, 0x92, 0x8C, 0x38, 0x89, 0x11, 0x4D, 0x12, 0x22, 0xBA,
  0xE0, 0x34, 0x88, 0x88, 0x88, 0x88, 0xC0, 0x42, 0x21, 0x11, 0x22, 0x24,
  0x80, 0x20, 0x8A, 0xDC, 0x52, 0x40, 0x20, 0x82, 0x3F, 0x20, 0x84, 0x00,
  0xE8, 0xE0, 0x80, 0x02, 0x08, 0x10, 0x41, 0x02, 0x08, 0x10, 0x40, 0x82,
  0x00, 0x39, 0x18, 0x61, 0xAA, 0x28, 0x9C, 0x13, 0xB4, 0x42, 0x10, 0x9F,
  0x1C, 0x94, 0x41, 0x08, 0x46, 0x3F, 0x1C, 0x90, 0x4E, 0x0C, 0x18, 0x5E,
  0x04, 0x31, 0x5A, 0x89, 0xF8, 0x82, 0x7D, 0x08, 0x1C, 0x88, 0x28, 0x9C,
  0x19, 0x11, 0xF8, 0xC6, 0x2E, 0x7E, 0x28, 0x84, 0x20, 0x84, 0x20, 0x3B,
  0x18, 0x9C, 0xCA, 0x28, 0xBC, 0x7A, 0x28, 0x62, 0x78, 0x42, 0x10, 0x40,
  0x20, 0x20, 0x01, 0xA4, 0x04, 0x66, 0x20, 0x40, 0x81, 0x80, 0xFC, 0x0F,
  0x80, 0x83, 0x04, 0x11, 0x32, 0x00, 0x74, 0x64, 0x26, 0x40, 0x10, 0x3A,
  0x67, 0x5C, 0xE6, 0xF0, 0x70, 0x08, 0x62, 0x8A, 0x45, 0xF4, 0x61, 0x7C,
  0x63, 0xE8, 0xC6, 0x3E, 0x39, 0x28, 0x60, 0x82, 0x29, 0x18, 0x7A, 0x28,
  0x61, 0x8A, 0x28, 0xBC, 0x7E, 0x08, 0x1E, 0x82, 0x08, 0x3E, 0x7E, 0x08,
  0x1E, 0x82, 0x08, 0x20, 0x39, 0x28, 0x60, 0x9A, 0x28, 0x9E, 0x86, 0x18,
  0x7E, 0x8A, 0x28, 0xA2, 0x7C, 0x42, 0x08, 0x20, 0x84, 0x3E, 0x38, 0x42,
  0x10, 0x8A, 0x4C, 0xC6, 0x29, 0x28, 0xE2, 0x49, 0x22, 0x42, 0x11, 0x08,
  0x42, 0x1F, 0x26, 0x4D, 0xAA, 0x99, 0x50, 0xA1, 0x42, 0x47, 0x1A, 0x6A,
  0xAA, 0x69, 0xA2, 0x39, 0x18, 0x61, 0x8A, 0x28, 0x9C, 0x7A, 0x18, 0x61,
  0xFA, 0x08, 0x20, 0x39, 0x18, 0x61, 0x8A, 0x28, 0x9C, 0x28, 0x40, 0x7A,
  0x18, 0x61, 0xFA, 0x89, 0x22, 0x3C, 0x85, 0x01, 0x80, 0xC0, 0xA1, 0x3C,
  0xFE, 0x20, 0x81, 0x02, 0x04, 0x08, 0x20, 0x86, 0x18, 0x62, 0x8A, 0x28,
  0xBC, 0x86, 0x18, 0xA2, 0x51, 0x46, 0x08, 0x86, 0x1A, 0x6A, 0xDB, 0x69,
  0xA4, 0x42, 0x48, 0xA0, 0x81, 0x05, 0x12, 0x42, 0x87, 0x11, 0x22, 0x82,
  0x04, 0x08, 0x20, 0x3E, 0x04, 0x10, 0xC2, 0x08, 0x20, 0x7E, 0x3A, 0x10,
  0x84, 0x22, 0x10, 0x84, 0x38, 0x92, 0x44, 0x92, 0x24, 0x80, 0x38, 0x42,
  0x11, 0x08, 0x42, 0x10, 0xB8, 0x30, 0xC4, 0xA2, 0x8C, 0xFC, 0xC0, 0x7C,
  0x63, 0x19, 0x74, 0x42, 0x21, 0x74, 0xC6, 0x31, 0xF0, 0x74, 0x61, 0x19,
  0x30, 0x04, 0x10, 0x9E, 0x8A, 0x28, 0xA6, 0xF0, 0x7C, 0x7D, 0x08, 0xB8,
  0x0E, 0x10, 0x41, 0xF1, 0x02, 0x04, 0x08, 0xA1, 0xC0, 0x80, 0x7C, 0x63,
  0x19, 0x7A, 0x5C, 0x42, 0x11, 0x74, 0xC6, 0x31, 0x90, 0x10, 0x01, 0xC2,
  0x21, 0x2B, 0x60, 0x08, 0x00, 0xF1, 0x08, 0x42, 0x93, 0x08, 0x41, 0x08,
  0x2E, 0x4A, 0x2B, 0x6B, 0x90, 0xE1, 0x08, 0x44, 0x21, 0x2A, 0x60, 0x76,
  0x95, 0x4C, 0xA9, 0x54, 0x80, 0xBA, 0x63, 0x18, 0xC8, 0x7C, 0x63, 0x18,
  0xB8, 0x5C, 0x94, 0x51, 0xC6, 0xE8, 0x20, 0x7C, 0x63, 0x19, 0xF8, 0x42,
  0xEC, 0xC2, 0x10, 0x41, 0x00, 0x7C, 0x18, 0x38, 0xB8, 0x20, 0x8F, 0xD0,
  0x41, 0x25, 0x98, 0x8C, 0x63, 0x19, 0x38, 0xCA, 0x63, 0x19, 0x30, 0xA6,
  0x9A, 0x69, 0xAB, 0x60, 0x26, 0xB4, 0x4C, 0x89, 0x6D, 0x00, 0x45, 0x14,
  0x51, 0x48, 0xE8, 0x9C, 0x7E, 0x21, 0x18, 0x8B, 0xE0, 0x1C, 0x82, 0x08,
  0x13, 0x82, 0x08, 0x41, 0x07, 0x00, 0x5A, 0xAA, 0xA8, 0x70, 0x84, 0x44,
  0x1D, 0x88, 0x21, 0x30, 0x46, 0xA9, 0x80,
};

const GFXglyph IBMPlexMono_ExtraLightItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 8, 7, 3, -8 },
  { 3, 3, 3, 7, 3, -9 },
  { 5, 7, 8, 7, 0, -8 },
  { 12, 7, 10, 7, 0, -9 },
  { 21, 8, 8, 7, 0, -8 },
  { 29, 7, 8, 7, 0, -8 },
  { 36, 1, 3, 7, 4, -9 },
  { 37, 4, 11, 7, 3, -9 },
  { 43, 4, 11, 7, 1, -9 },
  { 49, 6, 6, 7, 1, -7 },
  { 54, 6, 7, 7, 1, -7 },
  { 60, 2, 3, 7, 2, -1 },
  { 61, 3, 1, 7, 2, -4 },
  { 62, 1, 1, 7, 3, -1 },
  { 63, 7, 11, 7, 0, -9 },
  { 73, 6, 8, 7, 1, -8 },
  { 79, 5, 8, 7, 1, -8 },
  { 84, 6, 8, 7, 0, -8 },
  { 90, 6, 8, 7, 0, -8 },
  { 96, 6, 8, 7, 0, -8 },
  { 102, 6, 8, 7, 1, -8 },
  { 108, 5, 8, 7, 1, -8 },
  { 113, 6, 8, 7, 1, -8 },
  { 119, 6, 8, 7, 1, -8 },
  { 125, 6, 8, 7, 1, -8 },
  { 131, 2, 6, 7, 3, -6 },
  { 133, 3, 8, 7, 2, -6 },
  { 136, 6, 7, 7, 1, -7 },
  { 142, 6, 3, 7, 1, -5 },
  { 145, 5, 7, 7, 1, -7 },
  { 150, 5, 8, 7, 2, -8 },
  { 155, 5, 9, 7, 1, -8 },
  { 161, 6, 8, 7, 0, -8 },
  { 167, 5, 8, 7, 1, -8 },
  { 172, 6, 8, 7, 1, -8 },
  { 178, 6, 8, 7, 1, -8 },
  { 184, 6, 8, 7, 1, -8 },
  { 190, 6, 8, 7, 1, -8 },
  { 196, 6, 8, 7, 1, -8 },
  { 202, 6, 8, 7, 1, -8 },
  { 208, 6, 8, 7, 1, -8 },
  { 214, 5, 8, 7, 1, -8 },
  { 219, 6, 8, 7, 1, -8 },
  { 225, 5, 8, 7, 1, -8 },
  { 230, 7, 8, 7, 0, -8 },
  { 237, 6, 8, 7, 1, -8 },
  { 243, 6, 8, 7, 1, -8 },
  { 249, 6, 8, 7, 1, -8 },
  { 255, 6, 10, 7, 1, -8 },
  { 263, 6, 8, 7, 1, -8 },
  { 269, 7, 8, 7, 0, -8 },
  { 276, 7, 8, 7, 1, -8 },
  { 283, 6, 8, 7, 1, -8 },
  { 289, 6, 8, 7, 1, -8 },
  { 295, 6, 8, 7, 1, -8 },
  { 301, 7, 8, 7, 0, -8 },
  { 308, 7, 8, 7, 1, -8 },
  { 315, 7, 8, 7, 0, -8 },
  { 322, 5, 11, 7, 2, -9 },
  { 329, 3, 11, 7, 2, -9 },
  { 334, 5, 11, 7, 0, -9 },
  { 341, 6, 5, 7, 1, -8 },
  { 345, 6, 1, 7, 0, 1 },
  { 346, 1, 2, 7, 3, -10 },
  { 347, 5, 6, 7, 1, -6 },
  { 351, 5, 9, 7, 1, -9 },
  { 357, 5, 6, 7, 1, -6 },
  { 361, 6, 9, 7, 1, -9 },
  { 368, 5, 6, 7, 1, -6 },
  { 372, 7, 11, 7, 0, -9 },
  { 382, 5, 8, 7, 1, -6 },
  { 387, 5, 9, 7, 1, -9 },
  { 393, 5, 9, 7, 1, -9 },
  { 399, 5, 11, 7, 1, -9 },
  { 406, 6, 9, 7, 1, -9 },
  { 413, 5, 9, 7, 1, -9 },
  { 419, 7, 6, 7, 0, -6 },
  { 425, 5, 6, 7, 1, -6 },
  { 429, 5, 6, 7, 1, -6 },
  { 433, 6, 8, 7, 0, -6 },
  { 439, 5, 8, 7, 1, -6 },
  { 444, 6, 6, 7, 1, -6 },
  { 449, 5, 6, 7, 1, -6 },
  { 453, 6, 8, 7, 1, -8 },
  { 459, 5, 6, 7, 1, -6 },
  { 463, 5, 6, 7, 1, -6 },
  { 467, 6, 6, 7, 1, -6 },
  { 472, 7, 6, 7, 0, -6 },
  { 478, 6, 8, 7, 0, -6 },
  { 484, 6, 6, 7, 1, -6 },
  { 489, 6, 11, 7, 1, -9 },
  { 498, 2, 11, 7, 3, -9 },
  { 501, 5, 11, 7, 1, -9 },
  { 508, 6, 3, 7, 1, -5 },
};

const GFXfont IBMPlexMono_ExtraLightItalic12pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic12pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC12PT7B_H_
