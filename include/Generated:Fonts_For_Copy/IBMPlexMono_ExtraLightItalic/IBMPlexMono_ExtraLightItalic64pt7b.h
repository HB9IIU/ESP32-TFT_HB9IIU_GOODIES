#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC64PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E,
  0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x1F, 0x83, 0xF0,
  0x7C, 0x07, 0x00, 0x18, 0x0C, 0xE0, 0x33, 0x81, 0xCC, 0x07, 0x30, 0x18,
  0xC0, 0x63, 0x01, 0x9C, 0x06, 0x70, 0x39, 0x80, 0xE6, 0x03, 0x18, 0x0C,
  0x60, 0x33, 0x80, 0xCE, 0x07, 0x30, 0x18, 0x00, 0x00, 0x0C, 0x01, 0xC0,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x03, 0x80, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x20, 0x0C, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x38, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xC3, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x1C,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x00, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0x0C, 0x7E, 0x00, 0x1E, 0x03, 0x03, 0xC0,
  0x0E, 0x00, 0xC0, 0x38, 0x07, 0x00, 0x30, 0x07, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0xE0, 0x02, 0x00, 0x20, 0x30, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x70, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x01,
  0xC0, 0x30, 0x00, 0x00, 0x3C, 0x08, 0x00, 0x00, 0x07, 0xE6, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x06, 0x3E, 0x00, 0x00, 0x03, 0x03, 0xC0, 0x00, 0x00, 0xC0,
  0x38, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00,
  0x18, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x38, 0x00, 0x01, 0x80, 0x0E, 0x00,
  0x00, 0x60, 0x03, 0x80, 0x00, 0x18, 0x00, 0xC1, 0x00, 0x0C, 0x00, 0x70,
  0xE0, 0x03, 0x00, 0x1C, 0x1C, 0x00, 0xC0, 0x0E, 0x07, 0x80, 0x30, 0x03,
  0x00, 0xF0, 0x0C, 0x03, 0xC0, 0x0E, 0x03, 0x01, 0xE0, 0x01, 0xF1, 0x83,
  0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x60, 0x03,
  0xC1, 0xC0, 0x00, 0x38, 0x01, 0xC0, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x07,
  0x00, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x30, 0x01,
  0xC0, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x03, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x00, 0x30, 0x0E, 0x00, 0x0C, 0x00,
  0x0C, 0x03, 0x00, 0x03, 0x00, 0x07, 0x01, 0x80, 0x00, 0xC0, 0x01, 0x80,
  0xC0, 0x00, 0x30, 0x00, 0x60, 0x70, 0x00, 0x0C, 0x00, 0x30, 0x18, 0x00,
  0x03, 0x80, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x0E, 0x06, 0x00, 0x00, 0x0E,
  0x07, 0x03, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x30, 0x3C, 0x1E, 0x00, 0x00, 0x18,
  0x1C, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x30, 0x00, 0x07, 0x03, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x40,
  0x00, 0x60, 0x18, 0x00, 0x18, 0x00, 0x38, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x30,
  0x00, 0x30, 0x01, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x07,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x18, 0x00, 0x60, 0x06,
  0x00, 0x06, 0x00, 0x30, 0x03, 0x00, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x00,
  0x38, 0x1C, 0x00, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x38, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0x3F, 0x03, 0x80, 0x00, 0x0F, 0x9C, 0xF0, 0x00,
  0x01, 0xE0, 0x7E, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0x1E, 0x00,
  0x2C, 0x00, 0x00, 0xB0, 0x03, 0xE0, 0x00, 0x05, 0xC0, 0x3B, 0x00, 0x00,
  0x66, 0x01, 0x9C, 0x00, 0x02, 0x18, 0x18, 0x60, 0x00, 0x30, 0xE1, 0xC3,
  0x80, 0x03, 0x03, 0x0C, 0x0E, 0x00, 0x38, 0x1C, 0xE0, 0x3C, 0x07, 0x80,
  0x66, 0x00, 0xFF, 0xF0, 0x01, 0xE0, 0x01, 0xFE, 0x00, 0x0E, 0x00, 0x1C,
  0x61, 0x86, 0x38, 0xE3, 0x0C, 0x30, 0xC7, 0x1C, 0x61, 0x86, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x40, 0x01, 0xC0, 0x03, 0xF8, 0x01, 0x80,
  0x1F, 0x3F, 0x01, 0x80, 0xFC, 0x07, 0xE1, 0x8F, 0xE0, 0x00, 0xFD, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x38, 0x60,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x01, 0xC0, 0x18,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xC1, 0xE0,
  0x78, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xC0,
  0x70, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7B, 0xFF, 0xFE, 0x70, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x06, 0x03, 0x80, 0x00,
  0x0E, 0x06, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x30, 0xE0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x01,
  0x8E, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x0C,
  0xE0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x00, 0xDC, 0x00, 0x70, 0x01, 0xB8, 0x01, 0xE0, 0x03, 0x70,
  0x03, 0xC0, 0x0E, 0xC0, 0x07, 0x80, 0x1D, 0x80, 0x00, 0x00, 0x3B, 0x00,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x03, 0x98, 0x00,
  0x00, 0x07, 0x30, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x71, 0x80, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0xE0, 0x30, 0x00, 0x03, 0x80, 0x70, 0x00, 0x06, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x60, 0x00, 0x00, 0x79, 0x80, 0x00, 0x03, 0xC6, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0F, 0x03, 0x00, 0x00,
  0x70, 0x0C, 0x00, 0x07, 0x80, 0x30, 0x00, 0x3C, 0x00, 0xC0, 0x01, 0xE0,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x01, 0x80, 0x70, 0x00, 0x03, 0x80, 0xC0, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0C, 0x14, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xF8, 0x07,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03,
  0x80, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0xFC, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0E,
  0x60, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x07,
  0x03, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x18, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x03,
  0x80, 0x06, 0x00, 0x01, 0x80, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x70, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x01, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x0F, 0xF8, 0x00, 0x06, 0x3F,
  0xFE, 0x00, 0x0E, 0xF0, 0x0F, 0x80, 0x0D, 0xC0, 0x03, 0xC0, 0x0F, 0x00,
  0x01, 0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x1F, 0x80,
  0x7C, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0C, 0x0F, 0xF0, 0x01, 0xC7, 0xFF, 0xE0, 0x18, 0xF0, 0x1F, 0x03,
  0xB8, 0x00, 0x38, 0x37, 0x00, 0x01, 0xC3, 0x40, 0x00, 0x0E, 0x68, 0x00,
  0x00, 0x67, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x01, 0xC6, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x03, 0x80, 0x00,
  0xE0, 0x1C, 0x00, 0x1C, 0x00, 0xF0, 0x0F, 0x80, 0x07, 0xFF, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF8, 0xC0,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x03, 0x81, 0x80, 0x00, 0x06, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x07, 0x06, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x07, 0x06, 0x00,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0E, 0x06, 0x00,
  0x00, 0x0C, 0x07, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x70, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0x80,
  0x01, 0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0x30, 0x70, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x18, 0xE0, 0x00,
  0x00, 0x18, 0xE0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x38, 0xC0, 0x00,
  0x00, 0x38, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7E, 0x03,
  0xE0, 0x07, 0x80, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x30,
  0x70, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x03, 0xB0, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x1C, 0xC0,
  0x00, 0x01, 0xE7, 0x00, 0x00, 0x1E, 0x18, 0x00, 0x01, 0xB0, 0xE0, 0x00,
  0x1B, 0x83, 0xC0, 0x03, 0x98, 0x0F, 0x80, 0x78, 0xC0, 0x1F, 0xFF, 0x0C,
  0x00, 0x3F, 0xC0, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x0F,
  0xC3, 0xF0, 0xF8, 0x1C, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01,
  0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03,
  0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE0, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x3C, 0x03, 0xE0, 0x1C, 0x00, 0x3C, 0x0E,
  0x00, 0x03, 0x07, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x19, 0xC0, 0x00, 0x07,
  0x60, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x34, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xE0, 0x3E,
  0x00, 0x1E, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x30, 0x03, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x1C,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x0C, 0x30, 0x01, 0xF8, 0x20, 0xC0, 0x1F, 0xF9, 0x86, 0x00, 0xF0,
  0x76, 0x18, 0x07, 0x00, 0x58, 0x60, 0x38, 0x01, 0x63, 0x80, 0xC0, 0x03,
  0x8C, 0x07, 0x00, 0x0E, 0x30, 0x18, 0x00, 0x30, 0xC0, 0x60, 0x00, 0xC3,
  0x03, 0x80, 0x03, 0x1C, 0x0C, 0x00, 0x0C, 0x60, 0x30, 0x00, 0x31, 0x80,
  0xC0, 0x01, 0xC6, 0x03, 0x00, 0x06, 0x18, 0x1C, 0x00, 0x18, 0x60, 0x60,
  0x00, 0x63, 0x81, 0x80, 0x01, 0x8E, 0x06, 0x00, 0x0E, 0x30, 0x18, 0x00,
  0x38, 0xC0, 0x60, 0x00, 0xC3, 0x00, 0xC0, 0x07, 0x0C, 0x03, 0x00, 0x3C,
  0x30, 0x0C, 0x01, 0xB0, 0xC0, 0x18, 0x0C, 0xC3, 0x00, 0x7C, 0xE3, 0x0C,
  0x00, 0xFF, 0x18, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0x31,
  0xC0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x06,
  0x03, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00,
  0xC0, 0x07, 0x00, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00,
  0x0E, 0x18, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x00, 0xCE, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0x38, 0x01, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x18, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x30,
  0x70, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x06, 0x0E, 0x00,
  0x00, 0x38, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x07, 0x03, 0x00, 0x00,
  0x38, 0x0C, 0x00, 0x07, 0x80, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0,
  0x06, 0x00, 0x00, 0xF0, 0x18, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x06,
  0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x0E, 0x0C,
  0x00, 0x01, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x20, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x78,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x3C, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x70,
  0x01, 0x80, 0x00, 0x38, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0E,
  0x18, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x1C,
  0x18, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x70,
  0x30, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x80, 0x60, 0x00, 0x07, 0x00,
  0x60, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x78, 0x07, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x03, 0x80,
  0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x06, 0x07,
  0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x08, 0x38, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0xF1, 0x80, 0x07, 0xFF,
  0xC7, 0x00, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x06,
  0x38, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x61,
  0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x01, 0x83, 0x00, 0x00, 0x07, 0x06,
  0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x70, 0x18,
  0x00, 0x01, 0x60, 0x38, 0x00, 0x06, 0xC0, 0x38, 0x00, 0x19, 0x80, 0x38,
  0x00, 0x67, 0x00, 0x3C, 0x07, 0x8C, 0x00, 0x3F, 0xFE, 0x18, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00, 0xE0, 0x30, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x03, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x1C, 0x06,
  0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x60,
  0x38, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x0E, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0x0C, 0x07, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x60, 0x00,
  0x00, 0x70, 0x18, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x38, 0x0C,
  0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x07,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x01, 0x80, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x30, 0x1C, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x18, 0x00, 0x00, 0x1C, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0x70, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x70, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x38, 0x00, 0x00, 0x60, 0x07,
  0x00, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x0C, 0x0F, 0x80, 0x00,
  0x00, 0xC3, 0x98, 0x00, 0x00, 0x0C, 0x71, 0xC0, 0x00, 0x01, 0xCE, 0x0C,
  0x00, 0x00, 0x1D, 0xC0, 0xE0, 0x00, 0x01, 0xB8, 0x06, 0x00, 0x00, 0x1F,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x60, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x1B, 0x00, 0x00, 0x1E, 0x01, 0xB0, 0x00, 0x03, 0xE0, 0x1B, 0x00, 0x00,
  0x76, 0x01, 0x98, 0x00, 0x06, 0x60, 0x19, 0x80, 0x00, 0xEE, 0x03, 0x98,
  0x00, 0x0C, 0xE0, 0x31, 0x80, 0x01, 0xCC, 0x03, 0x0C, 0x00, 0x38, 0xC0,
  0x30, 0xC0, 0x03, 0x0C, 0x03, 0x0C, 0x00, 0x70, 0xC0, 0x30, 0xE0, 0x06,
  0x0C, 0x07, 0x06, 0x00, 0xE1, 0xC0, 0x60, 0x60, 0x1C, 0x18, 0x06, 0x06,
  0x01, 0x81, 0x80, 0x60, 0x30, 0x38, 0x18, 0x06, 0x03, 0x03, 0x01, 0x80,
  0x60, 0x30, 0x60, 0x18, 0x0E, 0x03, 0x0E, 0x03, 0x80, 0xC0, 0x18, 0xC0,
  0x30, 0x0C, 0x01, 0x9C, 0x03, 0x00, 0xC0, 0x19, 0x80, 0x30, 0x0C, 0x01,
  0xB0, 0x03, 0x00, 0xC0, 0x0F, 0x00, 0x30, 0x1C, 0x00, 0xE0, 0x07, 0x01,
  0xC0, 0x0E, 0x00, 0x60, 0x18, 0x00, 0x40, 0x06, 0x01, 0x80, 0x08, 0x00,
  0x60, 0x18, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x60, 0x38, 0x00,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x70, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x00, 0x18, 0x06, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x7C, 0x00, 0x00, 0x30, 0x1F, 0x00, 0x00, 0x1C, 0x06, 0xC0,
  0x00, 0x07, 0x01, 0xB8, 0x00, 0x01, 0x80, 0x66, 0x00, 0x00, 0x60, 0x19,
  0x80, 0x00, 0x18, 0x0E, 0x70, 0x00, 0x06, 0x03, 0x0C, 0x00, 0x03, 0x80,
  0xC3, 0x00, 0x00, 0xE0, 0x30, 0xE0, 0x00, 0x30, 0x0C, 0x38, 0x00, 0x0C,
  0x03, 0x06, 0x00, 0x03, 0x01, 0xC1, 0x80, 0x00, 0xC0, 0x60, 0x70, 0x00,
  0x70, 0x18, 0x0C, 0x00, 0x1C, 0x06, 0x03, 0x00, 0x06, 0x01, 0x80, 0xE0,
  0x01, 0x80, 0x60, 0x18, 0x00, 0x60, 0x38, 0x06, 0x00, 0x18, 0x0E, 0x01,
  0xC0, 0x0E, 0x03, 0x00, 0x30, 0x03, 0x80, 0xC0, 0x0C, 0x00, 0xC0, 0x30,
  0x03, 0x80, 0x30, 0x0C, 0x00, 0x60, 0x0C, 0x07, 0x00, 0x18, 0x03, 0x01,
  0xC0, 0x07, 0x01, 0xC0, 0x60, 0x00, 0xC0, 0x70, 0x18, 0x00, 0x30, 0x18,
  0x06, 0x00, 0x0E, 0x06, 0x01, 0x80, 0x01, 0x81, 0x80, 0xE0, 0x00, 0x60,
  0x60, 0x38, 0x00, 0x1C, 0x18, 0x0C, 0x00, 0x03, 0x0E, 0x03, 0x00, 0x00,
  0xC3, 0x00, 0xC0, 0x00, 0x30, 0xC0, 0x30, 0x00, 0x0E, 0x30, 0x1C, 0x00,
  0x01, 0x8C, 0x07, 0x00, 0x00, 0x63, 0x01, 0x80, 0x00, 0x1D, 0xC0, 0x60,
  0x00, 0x03, 0x60, 0x18, 0x00, 0x00, 0xD8, 0x06, 0x00, 0x00, 0x3E, 0x03,
  0x80, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x06,
  0x03, 0x80, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0xC7,
  0x00, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x07, 0x30,
  0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0x03, 0x70, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x00, 0x3B, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x03, 0x98, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0x71, 0x80, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03,
  0x86, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x03, 0x80, 0x70, 0x00, 0x06, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x78, 0x0F, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x0F, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x18, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x03, 0x81, 0x80, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0x38, 0x30, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0x03, 0x80,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x01, 0xC0, 0x30, 0x00, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xF8,
  0x0F, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x06, 0x03, 0x80, 0x00, 0x0E, 0x06, 0x00, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x03,
  0x98, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0xDC,
  0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x0E, 0xC0,
  0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x07, 0x30, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x71, 0x80, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x0C, 0x1C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x06, 0x00, 0x70, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0x78, 0x0F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0C, 0x1C, 0x00,
  0x00, 0x0C, 0x70, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x60, 0x00, 0x0F, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x60,
  0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x07,
  0x03, 0x00, 0x00, 0x03, 0x81, 0x80, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00,
  0x1C, 0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x03, 0x03, 0x80, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x01, 0xC0, 0x30, 0x00,
  0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x30, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x06, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x07, 0x00, 0x00, 0x60, 0x03,
  0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x70,
  0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00, 0x70, 0x18,
  0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x10, 0x00,
  0x00, 0x03, 0x0E, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0xE0, 0x78,
  0x00, 0x00, 0x30, 0x0F, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x1F, 0x80, 0x3E, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x07, 0x06, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x0E, 0x0C, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00,
  0x1C, 0x18, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00,
  0x38, 0x30, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00,
  0x70, 0x60, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03,
  0x80, 0x60, 0x00, 0x03, 0x00, 0x70, 0x00, 0x07, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x1C, 0x60, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00,
  0xE0, 0x30, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xC0,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x03, 0x80,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x1C, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x61,
  0xC0, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x70, 0x01, 0x81, 0x80,
  0x1E, 0x00, 0x30, 0x30, 0x03, 0xC0, 0x0C, 0x06, 0x00, 0xF8, 0x01, 0x80,
  0xC0, 0x19, 0x80, 0x30, 0x18, 0x03, 0x30, 0x06, 0x07, 0x00, 0xC6, 0x01,
  0x80, 0xE0, 0x18, 0xC0, 0x30, 0x18, 0x06, 0x18, 0x06, 0x03, 0x00, 0xC3,
  0x01, 0xC0, 0x60, 0x38, 0x60, 0x30, 0x0C, 0x06, 0x0C, 0x06, 0x01, 0x81,
  0xC1, 0x80, 0xC0, 0x30, 0x30, 0x18, 0x38, 0x06, 0x06, 0x03, 0x06, 0x00,
  0xC1, 0x80, 0x60, 0xC0, 0x18, 0x30, 0x0C, 0x18, 0x03, 0x0C, 0x01, 0x87,
  0x00, 0x61, 0x80, 0x30, 0xC0, 0x0C, 0x70, 0x06, 0x18, 0x03, 0x8C, 0x00,
  0xC3, 0x00, 0x73, 0x80, 0x18, 0xE0, 0x0C, 0x60, 0x01, 0x98, 0x01, 0x8C,
  0x00, 0x33, 0x00, 0x33, 0x00, 0x06, 0x60, 0x06, 0x60, 0x00, 0xDC, 0x00,
  0xD8, 0x00, 0x1B, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x03, 0xE0, 0x00, 0x6C,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00,
  0x00, 0x61, 0xC0, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x00, 0x37,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x03, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x00, 0x06, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x00, 0xEC,
  0x00, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x38, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x60, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00,
  0x00, 0xDC, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x03, 0x81, 0x80, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x03, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x60, 0x00, 0xE0, 0x01, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x18, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x18, 0x07,
  0x00, 0x00, 0x60, 0x38, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x03, 0x07, 0x00,
  0x00, 0x0C, 0x38, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x61, 0xC1, 0xC1, 0x83, 0x83, 0x07, 0x06,
  0x0E, 0x0C, 0x08, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x70, 0x0F,
  0x80, 0xE1, 0x80, 0x70, 0x00, 0xC6, 0x03, 0x80, 0x01, 0x98, 0x1C, 0x00,
  0x03, 0x60, 0xE0, 0x00, 0x07, 0x83, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0x8E, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x38, 0x18, 0x00, 0x01, 0x60,
  0x70, 0x00, 0x0D, 0x80, 0xC0, 0x00, 0x66, 0x03, 0x80, 0x03, 0x38, 0x07,
  0x00, 0x1C, 0xC0, 0x0F, 0x01, 0xC3, 0xFC, 0x1F, 0xFE, 0x07, 0xE0, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x81, 0xFE, 0x00, 0x18, 0x3F, 0xFC, 0x00, 0xC3, 0x80,
  0xF0, 0x06, 0x30, 0x01, 0xC0, 0x33, 0x00, 0x07, 0x03, 0xB0, 0x00, 0x1C,
  0x1F, 0x00, 0x00, 0x60, 0xD0, 0x00, 0x03, 0x07, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x18, 0xE0, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x07, 0x30,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x18, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x3A,
  0x00, 0x01, 0xC1, 0xD8, 0x00, 0x1C, 0x0C, 0x60, 0x01, 0xC0, 0x61, 0xC0,
  0x3C, 0x03, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x03, 0xE0, 0x3C, 0x00, 0xE0, 0x01, 0xC0, 0x38,
  0x00, 0x1C, 0x0E, 0x00, 0x01, 0x83, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x8C, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x06, 0x30, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x1C, 0x07, 0x00, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x81, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x0F, 0xF0, 0x0C, 0x00, 0x3F, 0xFC, 0x1C, 0x00, 0xF8, 0x0F, 0x18,
  0x01, 0xE0, 0x03, 0x18, 0x03, 0x80, 0x00, 0x98, 0x07, 0x00, 0x00, 0xD8,
  0x0E, 0x00, 0x00, 0x58, 0x0C, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x60,
  0xE0, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x03, 0x80,
  0x60, 0x00, 0x07, 0x80, 0x70, 0x00, 0x0D, 0x80, 0x30, 0x00, 0x09, 0x80,
  0x38, 0x00, 0x19, 0x80, 0x1C, 0x00, 0x73, 0x80, 0x0F, 0x01, 0xE3, 0x00,
  0x07, 0xFF, 0x83, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0xE0, 0x70, 0x00, 0x06, 0x06, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x07,
  0x18, 0x00, 0x00, 0x71, 0x80, 0x00, 0x07, 0x30, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x38, 0x60, 0x00, 0x0F,
  0x06, 0x00, 0x07, 0xE0, 0xE0, 0x1F, 0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x46,
  0x00, 0x00, 0x0E, 0x60, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x03, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x80, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x60, 0x00, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x18, 0x00,
  0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x06, 0x00, 0x00, 0x00, 0x03, 0x83, 0x00, 0x00, 0x00, 0x00, 0xE1,
  0x80, 0x00, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x60, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x1C, 0x01, 0xF0, 0x1E, 0x30,
  0x07, 0x80, 0x0E, 0x60, 0x1C, 0x00, 0x04, 0xC0, 0x70, 0x00, 0x0D, 0x81,
  0xC0, 0x00, 0x0B, 0x03, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x01, 0x87, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x61, 0xC0, 0x00,
  0x00, 0xC3, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x07, 0x01, 0x80, 0x00, 0x1E,
  0x03, 0x80, 0x00, 0x6C, 0x03, 0x00, 0x00, 0x98, 0x07, 0x00, 0x03, 0x30,
  0x07, 0x00, 0x1C, 0xE0, 0x07, 0x80, 0xF1, 0x80, 0x07, 0xFF, 0x83, 0x00,
  0x01, 0xFC, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x01, 0x00, 0x00, 0x30, 0x07, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x07, 0x80, 0x07, 0x80, 0x7C, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x03, 0xF8, 0x00, 0xC1, 0xFF, 0xC0, 0x38, 0xF0, 0x3C,
  0x07, 0x30, 0x01, 0xC0, 0xCC, 0x00, 0x18, 0x19, 0x00, 0x03, 0x83, 0x40,
  0x00, 0x30, 0x68, 0x00, 0x06, 0x1E, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x18,
  0x70, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x30, 0x00,
  0x01, 0x8E, 0x00, 0x00, 0x71, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC7, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x63, 0x80, 0x00, 0x1C, 0x60, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x31, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x01, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x60, 0x06,
  0x00, 0x1E, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x06, 0x00, 0xE0,
  0x00, 0xC0, 0x78, 0x00, 0x18, 0x1C, 0x00, 0x03, 0x07, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x18, 0xE0, 0x00, 0x03, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x60, 0x00, 0xC0,
  0x1E, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0E, 0x00, 0x60, 0x00, 0xE0,
  0x0C, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x0E, 0x0C, 0x00,
  0x00, 0xE1, 0x80, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x01, 0xFE,
  0x00, 0x06, 0x07, 0xFF, 0x80, 0x06, 0x1E, 0x03, 0xC0, 0x06, 0x30, 0x01,
  0xC0, 0x06, 0x60, 0x00, 0xE0, 0x0E, 0xC0, 0x00, 0x60, 0x0F, 0x80, 0x00,
  0x60, 0x0D, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x3C, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x38, 0x07, 0x80,
  0x00, 0x30, 0x3C, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x30, 0x1C, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x02, 0x70, 0x0E, 0x00,
  0x07, 0x60, 0x06, 0x00, 0x0E, 0x60, 0x03, 0x00, 0x18, 0x60, 0x03, 0x00,
  0x30, 0x60, 0x01, 0x80, 0x60, 0xE0, 0x01, 0xC0, 0xC0, 0xE0, 0x00, 0xC3,
  0x80, 0xC0, 0x00, 0xE7, 0x00, 0xC0, 0x00, 0x6E, 0x00, 0xC0, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x00, 0x03, 0x03, 0x00, 0x0E, 0x03, 0x00, 0x1C, 0x03,
  0x00, 0x38, 0x07, 0x00, 0xE0, 0x06, 0x01, 0xC0, 0x06, 0x07, 0x80, 0x06,
  0x0E, 0x00, 0x06, 0x1C, 0x00, 0x0E, 0x70, 0x00, 0x0C, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0xC7, 0xF8,
  0x3F, 0xE0, 0x77, 0x0E, 0x1C, 0x38, 0x19, 0x00, 0xCC, 0x07, 0x06, 0x80,
  0x32, 0x00, 0xC1, 0xE0, 0x0D, 0x00, 0x30, 0x70, 0x03, 0x40, 0x0C, 0x18,
  0x00, 0xE0, 0x03, 0x0E, 0x00, 0x38, 0x00, 0xC3, 0x80, 0x0C, 0x00, 0x30,
  0xC0, 0x03, 0x00, 0x0C, 0x30, 0x00, 0xC0, 0x07, 0x0C, 0x00, 0x30, 0x01,
  0x83, 0x00, 0x1C, 0x00, 0x61, 0xC0, 0x06, 0x00, 0x18, 0x60, 0x01, 0x80,
  0x06, 0x18, 0x00, 0x60, 0x01, 0x86, 0x00, 0x18, 0x00, 0xE1, 0x80, 0x06,
  0x00, 0x30, 0x60, 0x03, 0x80, 0x0C, 0x38, 0x00, 0xC0, 0x03, 0x0C, 0x00,
  0x30, 0x00, 0xC3, 0x00, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x00, 0x1C, 0x30,
  0x00, 0xC0, 0x06, 0x0C, 0x00, 0x70, 0x01, 0x87, 0x00, 0x18, 0x00, 0x61,
  0x80, 0x06, 0x00, 0x18, 0x60, 0x01, 0x80, 0x06, 0x18, 0x00, 0x60, 0x03,
  0x86, 0x00, 0x18, 0x00, 0xC1, 0x80, 0x0E, 0x00, 0x30, 0xE0, 0x03, 0x00,
  0x0C, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x60, 0xFF,
  0xE0, 0x1C, 0x78, 0x1E, 0x03, 0x18, 0x00, 0xE0, 0x66, 0x00, 0x0C, 0x0C,
  0x80, 0x01, 0xC1, 0xA0, 0x00, 0x18, 0x34, 0x00, 0x03, 0x0F, 0x00, 0x00,
  0x61, 0xC0, 0x00, 0x0C, 0x38, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x06, 0x18, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x06,
  0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x63, 0x80, 0x00, 0x1C, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x31, 0xC0, 0x00,
  0x0E, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x18,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x07, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xF8, 0x0F, 0x00,
  0x1C, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x61, 0xC0, 0x00, 0x07, 0x18, 0x00, 0x00, 0x33, 0x80, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x0E, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0xC6,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x03, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x0E, 0x01, 0xC0, 0x03, 0xC0, 0x0F, 0x80, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0x07, 0xFF, 0x80,
  0x06, 0x1C, 0x07, 0x80, 0x0C, 0x60, 0x03, 0x80, 0x19, 0x80, 0x03, 0x80,
  0x76, 0x00, 0x03, 0x80, 0xF8, 0x00, 0x03, 0x01, 0xA0, 0x00, 0x06, 0x03,
  0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x38,
  0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x06, 0x1C, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x01, 0x83, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x0C, 0x1C, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00,
  0xC0, 0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x07, 0x40, 0x00, 0x38,
  0x0E, 0xC0, 0x00, 0xE0, 0x18, 0xC0, 0x03, 0x80, 0x30, 0xE0, 0x1E, 0x00,
  0x60, 0xFF, 0xF8, 0x00, 0xC0, 0x3F, 0x80, 0x01, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x70, 0x0F, 0x80, 0xF1, 0x80, 0x78, 0x00, 0xC6, 0x03, 0x80,
  0x00, 0x98, 0x1C, 0x00, 0x03, 0x60, 0xE0, 0x00, 0x05, 0x83, 0x00, 0x00,
  0x1E, 0x1C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x01, 0xC6,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x01, 0x8E, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x07, 0x06, 0x00, 0x00, 0x38,
  0x18, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x0D, 0x80, 0xC0, 0x00, 0x26, 0x03,
  0x80, 0x01, 0x98, 0x07, 0x00, 0x1C, 0xE0, 0x0F, 0x01, 0xE3, 0x00, 0x1F,
  0xFE, 0x0C, 0x00, 0x0F, 0xE0, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x7F, 0xFC, 0x0F, 0xFE, 0xFF, 0xF8, 0x7F, 0xFE,
  0x00, 0x73, 0xC0, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00,
  0x03, 0x40, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x70, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x60,
  0x00, 0x01, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x03, 0x07, 0x80, 0x00, 0x1C, 0x0F, 0x00, 0x01, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x40,
  0x03, 0x80, 0x01, 0xC0, 0x07, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x18, 0x01, 0xC0, 0x00, 0x30, 0x0F, 0x00, 0x00, 0x60, 0x38, 0x00, 0x01,
  0xC1, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x06, 0x3C, 0x00, 0x00, 0x0C,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x8E, 0x00, 0x00,
  0x71, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x06, 0x18, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x06,
  0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x63, 0x80, 0x00, 0x1C, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x31, 0xC0, 0x00,
  0x0E, 0x38, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0E, 0x18,
  0x00, 0x02, 0xC3, 0x80, 0x00, 0x58, 0x70, 0x00, 0x17, 0x06, 0x00, 0x06,
  0xC0, 0xE0, 0x01, 0x98, 0x0E, 0x00, 0x63, 0x01, 0xE0, 0x38, 0x60, 0x0F,
  0xFE, 0x0C, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x37, 0xFE, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x70, 0x0C, 0x00, 0x01,
  0x80, 0xE0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x30, 0x38, 0x00, 0x03, 0x81, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x70, 0x18, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0x80, 0x60, 0x00, 0x1C, 0x03, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0xE0, 0x06, 0x00, 0x0E,
  0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x18, 0x00, 0xE0, 0x00,
  0xC0, 0x1E, 0x00, 0x06, 0x03, 0xE0, 0x00, 0x30, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x30, 0x04, 0x0C, 0x00,
  0x30, 0x0E, 0x0C, 0x00, 0x70, 0x06, 0x0C, 0x00, 0x60, 0x06, 0x0C, 0x00,
  0x60, 0x03, 0x0C, 0x00, 0x60, 0x03, 0x1C, 0x00, 0x60, 0x03, 0x18, 0x00,
  0x60, 0x03, 0x18, 0x00, 0xE0, 0x03, 0x18, 0x00, 0xC0, 0x03, 0x18, 0x00,
  0xC0, 0x03, 0x18, 0x00, 0xC0, 0x03, 0x38, 0x00, 0xC0, 0x03, 0x30, 0x00,
  0xC0, 0x03, 0x30, 0x01, 0xC0, 0x03, 0x30, 0x01, 0x80, 0x03, 0x30, 0x01,
  0x80, 0x03, 0x30, 0x01, 0x80, 0x03, 0x70, 0x01, 0x80, 0x03, 0x60, 0x01,
  0x80, 0x07, 0x60, 0x03, 0x80, 0x06, 0x60, 0x03, 0x00, 0x06, 0x60, 0x03,
  0x00, 0x06, 0x60, 0x03, 0x00, 0x0E, 0xE0, 0x03, 0x00, 0x0C, 0xC0, 0x07,
  0x00, 0x0C, 0xC0, 0x07, 0x00, 0x18, 0xC0, 0x0B, 0x00, 0x18, 0xC0, 0x0B,
  0x00, 0x30, 0xE0, 0x1B, 0x00, 0x70, 0x60, 0x31, 0x80, 0xE0, 0x70, 0x61,
  0xC1, 0xC0, 0x3F, 0xC0, 0xFF, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x79, 0x80, 0xF0, 0xE0,
  0x1E, 0x1C, 0x0C, 0x07, 0x07, 0x80, 0xC1, 0x80, 0x31, 0xE0, 0x0E, 0x30,
  0x03, 0x38, 0x00, 0x62, 0x00, 0x30, 0x00, 0x06, 0x60, 0x03, 0x00, 0x00,
  0x64, 0x00, 0x30, 0x00, 0x06, 0xC0, 0x03, 0x00, 0x00, 0x68, 0x00, 0x30,
  0x00, 0x02, 0x80, 0x03, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x16, 0x00, 0x00, 0xC0, 0x03, 0x20, 0x00, 0x0C,
  0x00, 0x33, 0x00, 0x04, 0xE0, 0x06, 0x30, 0x01, 0xCE, 0x00, 0x63, 0x00,
  0x78, 0x60, 0x0C, 0x38, 0x1E, 0x07, 0x01, 0x81, 0x83, 0x80, 0x78, 0x70,
  0x1C, 0xF0, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x07, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x18,
  0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x07,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x03, 0x80,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x01, 0xC0, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0xE0, 0x18, 0x00, 0x02, 0xC0, 0x38, 0x00, 0x05, 0x80, 0x70, 0x00, 0x17,
  0x00, 0x60, 0x00, 0x6E, 0x00, 0xE0, 0x01, 0x98, 0x00, 0xE0, 0x06, 0x30,
  0x01, 0xF0, 0x38, 0x60, 0x01, 0xFF, 0xE0, 0xC0, 0x00, 0x7F, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x80, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x70, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0x03,
  0xC0, 0x7E, 0x07, 0x03, 0x00, 0x0F, 0x86, 0x06, 0x00, 0x01, 0xE6, 0x06,
  0x00, 0x00, 0x7E, 0x04, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x38, 0x0C,
  0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x03, 0x80, 0x0C,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x60, 0x00, 0x70, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0x60, 0x01, 0x80, 0x00, 0x60, 0x07, 0x00, 0x00, 0x60, 0x0E,
  0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x30, 0x3C, 0x00, 0x00, 0x30, 0x7F,
  0xC0, 0x00, 0x30, 0x63, 0xFE, 0x00, 0x30, 0x60, 0x3F, 0xE0, 0x38, 0x60,
  0x01, 0xFF, 0x18, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x70,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0x81, 0xFE, 0x00, 0x00, 0xC1, 0xC3, 0x80, 0x00, 0xC1, 0xC0, 0xE0, 0x00,
  0x61, 0xC0, 0x38, 0x00, 0x70, 0xC0, 0x0E, 0x00, 0x30, 0xC0, 0x03, 0x00,
  0x38, 0x60, 0x00, 0xC0, 0x18, 0x60, 0x00, 0x70, 0x18, 0x30, 0x00, 0x1C,
  0x38, 0x18, 0x00, 0x07, 0xF8, 0x18, 0x00, 0x00, 0xF8, 0x00,
};

const GFXglyph IBMPlexMono_ExtraLightItalic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 11, 45, 38, 14, -45 },
  { 63, 14, 16, 38, 16, -47 },
  { 91, 38, 45, 38, 1, -45 },
  { 305, 34, 58, 38, 2, -51 },
  { 552, 42, 46, 38, -1, -45 },
  { 794, 37, 46, 38, 1, -45 },
  { 1007, 6, 16, 38, 20, -47 },
  { 1019, 20, 58, 38, 15, -49 },
  { 1164, 21, 58, 38, 4, -49 },
  { 1317, 32, 32, 38, 4, -35 },
  { 1445, 31, 32, 38, 4, -36 },
  { 1569, 10, 17, 38, 10, -6 },
  { 1591, 17, 2, 38, 11, -20 },
  { 1596, 6, 5, 38, 14, -5 },
  { 1600, 35, 58, 38, 2, -49 },
  { 1854, 31, 46, 38, 5, -45 },
  { 2033, 30, 45, 38, 3, -45 },
  { 2202, 31, 45, 38, 3, -45 },
  { 2377, 31, 46, 38, 3, -45 },
  { 2556, 33, 45, 38, 2, -45 },
  { 2742, 32, 46, 38, 4, -45 },
  { 2926, 28, 46, 38, 5, -45 },
  { 3087, 31, 45, 38, 7, -45 },
  { 3262, 32, 46, 38, 4, -45 },
  { 3446, 29, 45, 38, 6, -45 },
  { 3610, 10, 34, 38, 14, -34 },
  { 3653, 14, 45, 38, 10, -34 },
  { 3732, 30, 35, 38, 6, -37 },
  { 3864, 33, 13, 38, 3, -26 },
  { 3918, 31, 35, 38, 3, -37 },
  { 4054, 26, 45, 38, 9, -45 },
  { 4201, 30, 52, 38, 5, -45 },
  { 4396, 33, 45, 38, 0, -45 },
  { 4582, 30, 45, 38, 4, -45 },
  { 4751, 30, 46, 38, 6, -45 },
  { 4924, 32, 45, 38, 4, -45 },
  { 5104, 34, 45, 38, 4, -45 },
  { 5296, 34, 45, 38, 4, -45 },
  { 5488, 31, 46, 38, 5, -45 },
  { 5667, 34, 45, 38, 3, -45 },
  { 5859, 34, 45, 38, 3, -45 },
  { 6051, 31, 46, 38, 4, -45 },
  { 6230, 36, 45, 38, 4, -45 },
  { 6433, 25, 45, 38, 6, -45 },
  { 6574, 36, 45, 38, 2, -45 },
  { 6777, 34, 45, 38, 3, -45 },
  { 6969, 31, 46, 38, 5, -45 },
  { 7148, 33, 45, 38, 4, -45 },
  { 7334, 31, 56, 38, 5, -45 },
  { 7551, 33, 45, 38, 4, -45 },
  { 7737, 34, 46, 38, 2, -45 },
  { 7933, 34, 45, 38, 7, -45 },
  { 8125, 32, 46, 38, 5, -45 },
  { 8309, 32, 45, 38, 8, -45 },
  { 8489, 35, 45, 38, 5, -45 },
  { 8686, 40, 45, 38, 0, -45 },
  { 8911, 35, 45, 38, 6, -45 },
  { 9108, 39, 45, 38, 0, -45 },
  { 9328, 26, 58, 38, 12, -49 },
  { 9517, 16, 58, 38, 12, -49 },
  { 9633, 25, 58, 38, 2, -49 },
  { 9815, 30, 25, 38, 5, -45 },
  { 9909, 31, 2, 38, 0, 7 },
  { 9917, 7, 11, 38, 15, -49 },
  { 9927, 30, 35, 38, 4, -34 },
  { 10059, 29, 48, 38, 5, -47 },
  { 10233, 27, 35, 38, 5, -34 },
  { 10352, 32, 48, 38, 4, -47 },
  { 10544, 28, 35, 38, 5, -34 },
  { 10667, 41, 61, 38, -1, -47 },
  { 10980, 31, 48, 38, 3, -34 },
  { 11166, 27, 47, 38, 5, -47 },
  { 11325, 27, 48, 38, 6, -47 },
  { 11487, 27, 61, 38, 6, -47 },
  { 11693, 32, 48, 38, 5, -47 },
  { 11885, 24, 48, 38, 8, -47 },
  { 12029, 34, 34, 38, 2, -34 },
  { 12174, 27, 34, 38, 5, -34 },
  { 12289, 28, 35, 38, 5, -34 },
  { 12412, 31, 47, 38, 3, -34 },
  { 12595, 30, 47, 38, 4, -34 },
  { 12772, 31, 33, 38, 7, -33 },
  { 12900, 30, 35, 38, 4, -34 },
  { 13032, 31, 46, 38, 5, -45 },
  { 13211, 27, 34, 38, 6, -33 },
  { 13326, 29, 33, 38, 5, -33 },
  { 13446, 32, 34, 38, 4, -33 },
  { 13582, 36, 35, 38, 1, -34 },
  { 13740, 31, 47, 38, 2, -33 },
  { 13923, 32, 35, 38, 3, -34 },
  { 14063, 28, 58, 38, 8, -49 },
  { 14266, 12, 58, 38, 14, -49 },
  { 14353, 29, 58, 38, 3, -49 },
  { 14564, 33, 12, 38, 3, -25 },
};

const GFXfont IBMPlexMono_ExtraLightItalic64pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic64pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic64pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC64PT7B_H_
