#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC32PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x20, 0x82, 0x08, 0x61, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82,
  0x00, 0x00, 0x00, 0x38, 0xE3, 0x00, 0x62, 0x85, 0x1A, 0x24, 0x58, 0xA1,
  0x46, 0x00, 0x61, 0x00, 0x08, 0x20, 0x01, 0x08, 0x00, 0x41, 0x00, 0x08,
  0x20, 0x01, 0x08, 0x00, 0x41, 0x01, 0xF8, 0x3F, 0x03, 0x08, 0x00, 0x41,
  0x00, 0x08, 0x20, 0x01, 0x08, 0x00, 0x41, 0x00, 0x08, 0x60, 0x3F, 0x0F,
  0xC0, 0x41, 0x00, 0x08, 0x60, 0x01, 0x08, 0x00, 0x41, 0x00, 0x08, 0x60,
  0x03, 0x08, 0x00, 0x41, 0x00, 0x00, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x3F, 0x80, 0x62, 0x30, 0x41, 0x0C, 0x60, 0x82, 0x20, 0x40, 0x10,
  0x40, 0x08, 0x20, 0x04, 0x10, 0x03, 0x08, 0x00, 0xC4, 0x00, 0x1E, 0x00,
  0x02, 0xE0, 0x01, 0x08, 0x00, 0x82, 0x00, 0x41, 0x00, 0x20, 0x80, 0x20,
  0x40, 0x10, 0x26, 0x08, 0x31, 0x84, 0x10, 0x62, 0x30, 0x0F, 0xE0, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x03, 0xE0, 0x0C, 0x18, 0xC0, 0x60,
  0x81, 0x01, 0x02, 0x02, 0x08, 0x08, 0x08, 0x40, 0x40, 0x41, 0x01, 0x01,
  0x08, 0x02, 0x04, 0x40, 0x0C, 0x62, 0x00, 0x1F, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x00, 0x87, 0x80, 0x04, 0x61, 0x00, 0x23, 0x02, 0x01,
  0x08, 0x08, 0x04, 0x20, 0x20, 0x20, 0x80, 0x81, 0x02, 0x04, 0x08, 0x08,
  0x10, 0x20, 0x30, 0x83, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x61, 0x80,
  0x18, 0x18, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80,
  0x20, 0x30, 0x02, 0x04, 0x00, 0x61, 0x00, 0x3C, 0xC0, 0x18, 0x60, 0x06,
  0x08, 0x00, 0x80, 0x80, 0x10, 0x18, 0x06, 0x01, 0x00, 0x80, 0x10, 0x18,
  0x05, 0x0D, 0x00, 0xA1, 0x20, 0x22, 0x42, 0x0C, 0x78, 0x3E, 0x06, 0x00,
  0x2D, 0x24, 0x96, 0x00, 0x60, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x10, 0x04,
  0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x01, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00,
  0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x01, 0x00, 0xC0, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x03, 0x00, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x80, 0x81, 0xF0, 0x87, 0x1F, 0x78, 0x03, 0x80, 0x02,
  0x80, 0x06, 0xC0, 0x0C, 0x40, 0x18, 0x60, 0x10, 0x20, 0x20, 0x10, 0x40,
  0x10, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x01, 0x80, 0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x19, 0x8C, 0x46, 0x23, 0x10,
  0xFF, 0x80, 0xFF, 0x00, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x00, 0x01, 0xF8, 0x06, 0x0C, 0x0C, 0x06, 0x18, 0x02,
  0x10, 0x03, 0x20, 0x01, 0x20, 0x01, 0x60, 0x01, 0x40, 0x01, 0x40, 0x03,
  0x41, 0x83, 0x41, 0x82, 0xC0, 0x02, 0xC0, 0x02, 0x80, 0x06, 0x80, 0x04,
  0xC0, 0x04, 0x40, 0x08, 0x40, 0x08, 0x60, 0x10, 0x30, 0x60, 0x0F, 0x80,
  0x00, 0x60, 0x06, 0x80, 0x32, 0x01, 0x88, 0x18, 0x60, 0xC1, 0x02, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x03, 0xFF, 0xF0, 0x01, 0xF8, 0x03, 0x06, 0x04, 0x03, 0x08, 0x01, 0x18,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0xFF, 0xFE, 0x01,
  0xF8, 0x06, 0x06, 0x0C, 0x02, 0x08, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x03, 0xF0, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0xC0,
  0x04, 0x40, 0x08, 0x30, 0x30, 0x0F, 0xC0, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0A, 0x00, 0x12, 0x00, 0x22, 0x00, 0x44, 0x00, 0xC4, 0x01, 0x84, 0x01,
  0x04, 0x02, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x10, 0x08, 0x20, 0x08, 0x60,
  0x08, 0xC0, 0x08, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x0F, 0xFF, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x23, 0xE0, 0x2C,
  0x18, 0x30, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x0C, 0x80, 0x08, 0xC0, 0x10, 0x70, 0x60, 0x1F, 0xC0, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x47, 0xC0, 0xB0, 0x62, 0x80, 0x66, 0x00, 0x48,
  0x00, 0xB0, 0x01, 0xE0, 0x02, 0xC0, 0x04, 0x80, 0x09, 0x00, 0x23, 0x00,
  0xC3, 0x06, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x0A, 0x00, 0x14, 0x00,
  0x48, 0x01, 0x90, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00,
  0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x00, 0x01,
  0xF8, 0x06, 0x0E, 0x08, 0x02, 0x10, 0x03, 0x10, 0x01, 0x30, 0x01, 0x30,
  0x03, 0x10, 0x02, 0x10, 0x04, 0x0C, 0x18, 0x03, 0xE0, 0x1C, 0x18, 0x20,
  0x0C, 0x40, 0x04, 0x80, 0x06, 0x80, 0x06, 0x80, 0x06, 0x80, 0x04, 0x80,
  0x0C, 0x40, 0x18, 0x70, 0x30, 0x1F, 0xC0, 0x07, 0xE0, 0x60, 0x63, 0x00,
  0x98, 0x01, 0x40, 0x05, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00,
  0x74, 0x01, 0xCC, 0x1A, 0x1F, 0x98, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x01, 0xC0, 0x00, 0x19, 0xC6,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x9C, 0xC0, 0x06, 0x1C, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x18, 0x30,
  0x41, 0x82, 0x0C, 0x10, 0x00, 0x00, 0x02, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x10, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x80, 0x00, 0x0F,
  0xC1, 0x83, 0x10, 0x05, 0x80, 0x28, 0x01, 0x00, 0x0C, 0x00, 0x40, 0x06,
  0x00, 0x20, 0x06, 0x03, 0xC0, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x07, 0x00, 0x38, 0x00, 0x01,
  0xF8, 0x0C, 0x18, 0x30, 0x08, 0x40, 0x11, 0x00, 0x22, 0x00, 0x4C, 0x3C,
  0x90, 0xC5, 0x21, 0x06, 0x44, 0x05, 0x08, 0x0A, 0x10, 0x24, 0x40, 0x48,
  0x80, 0x91, 0x01, 0x22, 0x06, 0xC4, 0x15, 0x04, 0x32, 0x0F, 0xA6, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0F, 0xE0, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x28, 0x00, 0x68, 0x00, 0x48, 0x00, 0xC4, 0x00, 0x84,
  0x01, 0x84, 0x01, 0x04, 0x03, 0x04, 0x02, 0x04, 0x06, 0x06, 0x04, 0x02,
  0x0C, 0x02, 0x0F, 0xFE, 0x18, 0x02, 0x10, 0x02, 0x30, 0x03, 0x20, 0x01,
  0x60, 0x01, 0x40, 0x01, 0xC0, 0x01, 0x1F, 0xF8, 0x20, 0x18, 0x40, 0x08,
  0x80, 0x11, 0x00, 0x22, 0x00, 0x4C, 0x00, 0x90, 0x03, 0x20, 0x04, 0x40,
  0x30, 0xFF, 0x81, 0x00, 0xC6, 0x00, 0x48, 0x00, 0x90, 0x01, 0x20, 0x02,
  0x40, 0x04, 0x80, 0x0B, 0x00, 0x14, 0x00, 0x48, 0x03, 0x1F, 0xFC, 0x00,
  0x03, 0xF0, 0x0C, 0x30, 0x20, 0x10, 0x80, 0x32, 0x00, 0x24, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x11, 0x00, 0x13, 0x00, 0x42,
  0x01, 0x83, 0x06, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x18, 0x18, 0x10, 0x04,
  0x10, 0x02, 0x10, 0x02, 0x10, 0x03, 0x10, 0x01, 0x30, 0x01, 0x20, 0x01,
  0x20, 0x01, 0x20, 0x03, 0x20, 0x02, 0x20, 0x02, 0x60, 0x02, 0x40, 0x02,
  0x40, 0x04, 0x40, 0x04, 0x40, 0x0C, 0x40, 0x08, 0xC0, 0x10, 0x80, 0x60,
  0xFF, 0x80, 0x0F, 0xFF, 0x8C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0F,
  0xFF, 0x84, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x8C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0F, 0xFF,
  0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x00,
  0x03, 0xF0, 0x18, 0x30, 0x60, 0x10, 0x80, 0x32, 0x00, 0x2C, 0x00, 0x10,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x1F,
  0xD0, 0x01, 0xA0, 0x02, 0x40, 0x04, 0x80, 0x09, 0x00, 0x32, 0x00, 0x62,
  0x01, 0xC6, 0x0D, 0x03, 0xE2, 0x00, 0x18, 0x01, 0x88, 0x00, 0x84, 0x00,
  0x42, 0x00, 0x21, 0x00, 0x11, 0x80, 0x18, 0x80, 0x08, 0x40, 0x04, 0x20,
  0x02, 0x10, 0x01, 0x0F, 0xFF, 0x8C, 0x00, 0xC4, 0x00, 0x42, 0x00, 0x21,
  0x00, 0x10, 0x80, 0x08, 0x40, 0x04, 0x60, 0x06, 0x20, 0x02, 0x10, 0x01,
  0x08, 0x00, 0x84, 0x00, 0x40, 0x0F, 0xFF, 0xC0, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x11, 0x00, 0x23, 0x00, 0xC2, 0x01, 0x06, 0x0C, 0x03, 0xE0,
  0x00, 0x08, 0x00, 0xC6, 0x00, 0x41, 0x00, 0x20, 0x40, 0x10, 0x10, 0x08,
  0x04, 0x04, 0x01, 0x06, 0x00, 0xC3, 0x00, 0x21, 0x80, 0x08, 0xC0, 0x02,
  0x78, 0x00, 0xB2, 0x00, 0x38, 0xC0, 0x1C, 0x10, 0x04, 0x06, 0x01, 0x00,
  0x80, 0x40, 0x30, 0x10, 0x04, 0x0C, 0x01, 0x83, 0x00, 0x20, 0x80, 0x0C,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C,
  0x00, 0x7F, 0xFC, 0x0C, 0x00, 0xC3, 0x00, 0x51, 0xC0, 0x1C, 0x50, 0x0A,
  0x12, 0x04, 0x84, 0x81, 0x21, 0x20, 0x88, 0x44, 0x62, 0x31, 0x11, 0x88,
  0x48, 0x42, 0x1A, 0x10, 0x83, 0x04, 0x20, 0x81, 0x08, 0x20, 0x46, 0x00,
  0x31, 0x00, 0x08, 0x40, 0x02, 0x10, 0x00, 0x84, 0x00, 0x21, 0x00, 0x08,
  0xC0, 0x06, 0x20, 0x01, 0x00, 0x18, 0x01, 0x8E, 0x00, 0x85, 0x00, 0x42,
  0x80, 0x21, 0x60, 0x11, 0x90, 0x18, 0x88, 0x08, 0x46, 0x04, 0x21, 0x02,
  0x10, 0x81, 0x08, 0x60, 0x8C, 0x10, 0xC4, 0x08, 0x42, 0x04, 0x21, 0x01,
  0x10, 0x80, 0x88, 0x40, 0x44, 0x60, 0x16, 0x20, 0x0A, 0x10, 0x05, 0x08,
  0x01, 0x84, 0x00, 0xC0, 0x01, 0xF8, 0x06, 0x0C, 0x0C, 0x06, 0x18, 0x02,
  0x10, 0x03, 0x20, 0x01, 0x20, 0x01, 0x60, 0x01, 0x40, 0x01, 0x40, 0x03,
  0x40, 0x03, 0x40, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0x80, 0x06, 0x80, 0x04,
  0xC0, 0x04, 0x40, 0x08, 0x40, 0x08, 0x60, 0x10, 0x30, 0x60, 0x0F, 0x80,
  0x0F, 0xFC, 0x18, 0x06, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01,
  0x10, 0x01, 0x30, 0x01, 0x20, 0x03, 0x20, 0x02, 0x20, 0x0C, 0x3F, 0xF8,
  0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x01, 0xF8, 0x06, 0x0C,
  0x0C, 0x06, 0x18, 0x02, 0x10, 0x03, 0x20, 0x01, 0x20, 0x01, 0x60, 0x01,
  0x40, 0x01, 0x40, 0x03, 0x40, 0x03, 0x40, 0x02, 0xC0, 0x02, 0xC0, 0x02,
  0x80, 0x06, 0x80, 0x04, 0xC0, 0x04, 0x40, 0x08, 0x40, 0x08, 0x60, 0x10,
  0x30, 0x60, 0x0F, 0x80, 0x03, 0x00, 0x01, 0x00, 0x01, 0x86, 0x00, 0x88,
  0x00, 0x50, 0x00, 0x60, 0x0F, 0xFC, 0x18, 0x06, 0x10, 0x01, 0x10, 0x01,
  0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x30, 0x01, 0x20, 0x03, 0x20, 0x02,
  0x20, 0x0C, 0x3F, 0xF8, 0x20, 0x80, 0x60, 0x80, 0x40, 0x40, 0x40, 0x40,
  0x40, 0x20, 0x40, 0x20, 0x40, 0x10, 0xC0, 0x10, 0x80, 0x08, 0x80, 0x08,
  0x01, 0xFC, 0x03, 0x03, 0x82, 0x00, 0x63, 0x00, 0x11, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x30, 0x01, 0x8C, 0x00, 0x83, 0x01, 0x80, 0x7F, 0x00, 0xFF,
  0xFF, 0x80, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x03,
  0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x60, 0x06, 0x40, 0x04,
  0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0xC0, 0x0C, 0x80, 0x08,
  0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x18, 0x80, 0x10, 0x80, 0x10,
  0x80, 0x20, 0x60, 0xC0, 0x3F, 0x80, 0x80, 0x03, 0x80, 0x02, 0x80, 0x06,
  0xC0, 0x04, 0x40, 0x0C, 0x40, 0x08, 0x40, 0x18, 0x40, 0x10, 0x40, 0x30,
  0x60, 0x20, 0x20, 0x60, 0x20, 0x40, 0x20, 0xC0, 0x20, 0x80, 0x20, 0x80,
  0x31, 0x00, 0x11, 0x00, 0x12, 0x00, 0x12, 0x00, 0x14, 0x00, 0x14, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x48, 0x00, 0x22, 0x00, 0x08, 0x80, 0x02, 0x20,
  0x00, 0x88, 0x00, 0x46, 0x0C, 0x11, 0x83, 0x04, 0x41, 0x41, 0x10, 0x50,
  0x84, 0x24, 0x21, 0x09, 0x08, 0x44, 0x46, 0x11, 0x11, 0x04, 0xC4, 0x41,
  0x21, 0x90, 0x48, 0x2C, 0x14, 0x0A, 0x05, 0x02, 0x81, 0x80, 0xA0, 0xE0,
  0x30, 0x30, 0x0C, 0x00, 0x0C, 0x00, 0x30, 0x40, 0x06, 0x06, 0x00, 0xC0,
  0x20, 0x08, 0x03, 0x01, 0x00, 0x10, 0x20, 0x01, 0x84, 0x00, 0x08, 0xC0,
  0x00, 0xD8, 0x00, 0x05, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x90,
  0x00, 0x19, 0x00, 0x03, 0x08, 0x00, 0x60, 0x80, 0x04, 0x0C, 0x00, 0x80,
  0x40, 0x10, 0x06, 0x03, 0x00, 0x20, 0x60, 0x03, 0x0C, 0x00, 0x10, 0xC0,
  0x00, 0xD0, 0x00, 0x66, 0x00, 0x30, 0x80, 0x08, 0x20, 0x04, 0x04, 0x02,
  0x01, 0x01, 0x80, 0x20, 0xC0, 0x08, 0x20, 0x03, 0x10, 0x00, 0x48, 0x00,
  0x1E, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xF8, 0x20, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00,
  0x20, 0x01, 0xFE, 0x00, 0x80, 0x40, 0x40, 0x40, 0x40, 0x40, 0x20, 0x20,
  0x20, 0x20, 0x10, 0x10, 0x10, 0x10, 0x08, 0x08, 0x08, 0x08, 0x04, 0x04,
  0x04, 0x04, 0x04, 0x02, 0x02, 0x02, 0x02, 0x01, 0x07, 0xF8, 0x40, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01,
  0x00, 0x08, 0x00, 0x41, 0xFE, 0x00, 0x00, 0x60, 0x00, 0xA0, 0x01, 0x90,
  0x01, 0x10, 0x02, 0x18, 0x04, 0x08, 0x0C, 0x08, 0x08, 0x04, 0x10, 0x04,
  0x20, 0x02, 0x60, 0x02, 0xC0, 0x03, 0xFF, 0xFE, 0x99, 0x12, 0x07, 0xE2,
  0x18, 0x2C, 0x40, 0x31, 0x00, 0x26, 0x00, 0x48, 0x00, 0x90, 0x01, 0x60,
  0x06, 0x80, 0x09, 0x00, 0x12, 0x00, 0x24, 0x00, 0x48, 0x01, 0x88, 0x07,
  0x10, 0x14, 0x18, 0x68, 0x1F, 0x1E, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0xF8, 0x12, 0x08, 0x28,
  0x08, 0x60, 0x19, 0x80, 0x13, 0x00, 0x24, 0x00, 0x48, 0x00, 0x90, 0x01,
  0x20, 0x02, 0xC0, 0x0D, 0x00, 0x12, 0x00, 0x26, 0x00, 0x8C, 0x03, 0x16,
  0x08, 0x63, 0xE0, 0x07, 0xC0, 0xC1, 0x8C, 0x06, 0xC0, 0x14, 0x00, 0x60,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x01,
  0xC0, 0x19, 0x01, 0x8C, 0x18, 0x1F, 0x00, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x07, 0xE2, 0x0C,
  0x12, 0x10, 0x0C, 0x20, 0x04, 0x60, 0x04, 0x40, 0x04, 0x40, 0x04, 0xC0,
  0x04, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x18, 0x40,
  0x28, 0x40, 0x38, 0x30, 0xD0, 0x1F, 0x10, 0x07, 0xE0, 0xC0, 0x8C, 0x02,
  0x40, 0x14, 0x00, 0xC0, 0x06, 0x00, 0xD0, 0x38, 0xFE, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x28, 0x01, 0x40, 0x09, 0x00, 0x8C, 0x18, 0x1F, 0x00, 0x00,
  0x0F, 0xF0, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0xFF, 0xFE, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x08, 0x08, 0x00, 0xC1,
  0x80, 0x06, 0x10, 0x00, 0x31, 0x00, 0x01, 0x90, 0x00, 0x0D, 0x00, 0x00,
  0x30, 0x00, 0x03, 0xF1, 0x06, 0x09, 0x08, 0x06, 0x10, 0x02, 0x30, 0x02,
  0x20, 0x02, 0x20, 0x02, 0x60, 0x02, 0x40, 0x04, 0x40, 0x04, 0x40, 0x04,
  0x40, 0x04, 0x40, 0x0C, 0x20, 0x0C, 0x20, 0x18, 0x18, 0x68, 0x0F, 0x88,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x40, 0x20, 0xE0, 0xE0, 0x1F, 0x80,
  0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06,
  0x7C, 0x24, 0x31, 0x40, 0xCC, 0x02, 0x40, 0x16, 0x00, 0xA0, 0x05, 0x00,
  0x28, 0x03, 0x40, 0x12, 0x00, 0xB0, 0x05, 0x00, 0x28, 0x01, 0x40, 0x1A,
  0x00, 0x90, 0x04, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x42, 0x06, 0x10, 0x40,
  0x8C, 0x04, 0xC0, 0x28, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x10, 0x00, 0x40,
  0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x20, 0x20,
  0x40, 0x80, 0x82, 0x01, 0x08, 0x02, 0x60, 0x05, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x11, 0xF0, 0x12, 0x0C, 0x14, 0x04, 0x18, 0x04, 0x30, 0x04, 0x30,
  0x04, 0x20, 0x08, 0x20, 0x10, 0x20, 0xE0, 0x27, 0x00, 0x62, 0x00, 0x43,
  0x01, 0x41, 0x03, 0x40, 0x86, 0x40, 0x8C, 0x40, 0x50, 0xC0, 0x60, 0xFF,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x10,
  0x01, 0x01, 0x10, 0x21, 0x0C, 0x31, 0x82, 0x20, 0x2C, 0x03, 0x00, 0x13,
  0x87, 0x0A, 0x2C, 0xCE, 0x18, 0x26, 0x0C, 0x12, 0x04, 0x09, 0x02, 0x04,
  0x81, 0x02, 0x40, 0x83, 0x60, 0x81, 0x20, 0x40, 0x90, 0x20, 0x48, 0x10,
  0x24, 0x08, 0x12, 0x04, 0x19, 0x04, 0x09, 0x02, 0x04, 0x81, 0x02, 0x00,
  0x23, 0xE1, 0x21, 0x8A, 0x06, 0x60, 0x12, 0x00, 0xB0, 0x05, 0x00, 0x28,
  0x01, 0x40, 0x1A, 0x00, 0x90, 0x05, 0x80, 0x28, 0x01, 0x40, 0x0A, 0x00,
  0xD0, 0x04, 0x80, 0x20, 0x03, 0xE0, 0x18, 0x30, 0x40, 0x31, 0x80, 0x22,
  0x00, 0x6C, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x06, 0x80, 0x0B, 0x00,
  0x12, 0x00, 0x24, 0x00, 0x88, 0x01, 0x18, 0x04, 0x18, 0x30, 0x0F, 0x80,
  0x08, 0xF8, 0x09, 0x04, 0x0A, 0x02, 0x0C, 0x03, 0x18, 0x01, 0x18, 0x01,
  0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x30, 0x03, 0x20, 0x02,
  0x20, 0x02, 0x30, 0x04, 0x30, 0x0C, 0x2C, 0x10, 0x43, 0xE0, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x07, 0xE2,
  0x18, 0x24, 0x40, 0x31, 0x00, 0x26, 0x00, 0x48, 0x00, 0x90, 0x01, 0x60,
  0x02, 0x80, 0x09, 0x00, 0x12, 0x00, 0x24, 0x00, 0x48, 0x01, 0x88, 0x07,
  0x10, 0x0C, 0x18, 0x68, 0x1F, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0xFC, 0x7E, 0x09, 0x00, 0x1C, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x07, 0xF0, 0x18, 0x18, 0x40, 0x19, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x0E, 0x00, 0x03, 0xF0, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x50, 0x01, 0xB0, 0x02, 0x38, 0x18, 0x1F, 0xC0, 0x00, 0x80,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x7F, 0xFF, 0x82, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x04, 0x0C, 0x18, 0x08, 0x60,
  0x08, 0x80, 0x0B, 0x00, 0x0C, 0x00, 0x20, 0x0C, 0x80, 0x22, 0x00, 0x98,
  0x02, 0x40, 0x09, 0x00, 0x24, 0x01, 0x90, 0x04, 0x40, 0x13, 0x00, 0x48,
  0x01, 0x20, 0x0C, 0x80, 0x32, 0x01, 0x8C, 0x0A, 0x18, 0x48, 0x3E, 0x20,
  0xF8, 0x0C, 0x60, 0x11, 0x00, 0x44, 0x01, 0x10, 0x04, 0x40, 0x11, 0x00,
  0x44, 0x03, 0x30, 0x08, 0x80, 0x22, 0x01, 0x08, 0x04, 0x20, 0x20, 0x81,
  0x02, 0x08, 0x18, 0xC0, 0x3C, 0x00, 0x20, 0x42, 0x20, 0x41, 0x20, 0x41,
  0x20, 0x81, 0x60, 0x81, 0x40, 0x81, 0x40, 0x81, 0x40, 0x81, 0x40, 0x81,
  0x41, 0x01, 0x41, 0x01, 0x81, 0x02, 0x81, 0x02, 0x83, 0x06, 0x85, 0x04,
  0xC5, 0x88, 0x78, 0xF0, 0x07, 0x07, 0x06, 0x46, 0x26, 0x09, 0x0E, 0x02,
  0x81, 0x00, 0xE0, 0x40, 0x30, 0x30, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x02, 0x06, 0x00, 0x81, 0x80, 0x20, 0xA0, 0x68,
  0x24, 0x23, 0x11, 0x30, 0x78, 0x30, 0x00, 0x08, 0x03, 0x08, 0x02, 0x08,
  0x02, 0x18, 0x02, 0x10, 0x02, 0x10, 0x02, 0x10, 0x06, 0x10, 0x04, 0x10,
  0x04, 0x30, 0x04, 0x20, 0x04, 0x20, 0x0C, 0x20, 0x0C, 0x20, 0x18, 0x30,
  0x28, 0x18, 0x48, 0x0F, 0x88, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x80,
  0x20, 0x60, 0xC0, 0x1F, 0x00, 0x0F, 0xC2, 0x20, 0xF4, 0x80, 0x39, 0x00,
  0x22, 0x01, 0x88, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x30, 0x20, 0xC0, 0x43, 0x00, 0x88, 0x01, 0x3F, 0x01, 0x47, 0xE2, 0x80,
  0xF8, 0x01, 0xFC, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x60, 0x03, 0x03,
  0xF0, 0x00, 0x60, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00,
  0x0F, 0xF0, 0x04, 0x10, 0x82, 0x08, 0x20, 0x86, 0x10, 0x41, 0x04, 0x10,
  0xC2, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10, 0x42, 0x08, 0x20, 0x07,
  0xF0, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x0F, 0xC0, 0x70, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x07, 0xF8, 0x00, 0x1C, 0x01, 0x22, 0x01, 0x41, 0x02, 0x40, 0x86,
  0x80, 0xCC, 0x80, 0x78,
};

const GFXglyph IBMPlexMono_ExtraLightItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 6, 22, 19, 7, -22 },
  { 18, 7, 8, 19, 8, -24 },
  { 25, 19, 22, 19, 1, -22 },
  { 78, 17, 28, 19, 1, -25 },
  { 138, 22, 22, 19, -1, -22 },
  { 199, 19, 22, 19, 0, -22 },
  { 252, 3, 8, 19, 10, -24 },
  { 255, 11, 28, 19, 7, -24 },
  { 294, 10, 28, 19, 2, -24 },
  { 329, 16, 16, 19, 2, -18 },
  { 361, 16, 15, 19, 2, -17 },
  { 391, 5, 8, 19, 5, -3 },
  { 396, 9, 1, 19, 5, -10 },
  { 398, 3, 3, 19, 7, -3 },
  { 400, 17, 28, 19, 1, -24 },
  { 460, 16, 22, 19, 2, -22 },
  { 504, 14, 22, 19, 2, -22 },
  { 543, 16, 22, 19, 1, -22 },
  { 587, 16, 22, 19, 1, -22 },
  { 631, 16, 22, 19, 1, -22 },
  { 675, 16, 22, 19, 2, -22 },
  { 719, 15, 22, 19, 2, -22 },
  { 761, 15, 22, 19, 4, -22 },
  { 803, 16, 22, 19, 2, -22 },
  { 847, 14, 22, 19, 3, -22 },
  { 886, 5, 17, 19, 7, -17 },
  { 897, 7, 22, 19, 5, -17 },
  { 917, 15, 17, 19, 3, -18 },
  { 949, 16, 7, 19, 2, -13 },
  { 963, 15, 17, 19, 2, -18 },
  { 995, 13, 22, 19, 5, -22 },
  { 1031, 15, 25, 19, 2, -22 },
  { 1078, 16, 22, 19, 0, -22 },
  { 1122, 15, 22, 19, 2, -22 },
  { 1164, 15, 22, 19, 3, -22 },
  { 1206, 16, 22, 19, 2, -22 },
  { 1250, 17, 22, 19, 2, -22 },
  { 1297, 17, 22, 19, 2, -22 },
  { 1344, 15, 22, 19, 3, -22 },
  { 1386, 17, 22, 19, 2, -22 },
  { 1433, 18, 22, 19, 1, -22 },
  { 1483, 15, 22, 19, 2, -22 },
  { 1525, 18, 22, 19, 2, -22 },
  { 1575, 13, 22, 19, 3, -22 },
  { 1611, 18, 22, 19, 1, -22 },
  { 1661, 17, 22, 19, 2, -22 },
  { 1708, 16, 22, 19, 2, -22 },
  { 1752, 16, 22, 19, 2, -22 },
  { 1796, 16, 28, 19, 2, -22 },
  { 1852, 16, 22, 19, 2, -22 },
  { 1896, 17, 22, 19, 1, -22 },
  { 1943, 17, 22, 19, 3, -22 },
  { 1990, 16, 22, 19, 3, -22 },
  { 2034, 16, 22, 19, 4, -22 },
  { 2078, 18, 22, 19, 2, -22 },
  { 2128, 20, 22, 19, 0, -22 },
  { 2183, 18, 22, 19, 3, -22 },
  { 2233, 19, 22, 19, 0, -22 },
  { 2286, 13, 28, 19, 6, -24 },
  { 2332, 8, 28, 19, 6, -24 },
  { 2360, 13, 28, 19, 1, -24 },
  { 2406, 16, 12, 19, 2, -22 },
  { 2430, 15, 1, 19, 0, 4 },
  { 2432, 3, 5, 19, 8, -24 },
  { 2434, 15, 17, 19, 2, -17 },
  { 2466, 15, 24, 19, 2, -24 },
  { 2511, 13, 17, 19, 3, -17 },
  { 2539, 16, 24, 19, 2, -24 },
  { 2587, 13, 17, 19, 3, -17 },
  { 2615, 20, 30, 19, 0, -24 },
  { 2690, 16, 23, 19, 1, -17 },
  { 2736, 13, 24, 19, 3, -24 },
  { 2775, 13, 24, 19, 3, -24 },
  { 2814, 14, 30, 19, 3, -24 },
  { 2867, 16, 24, 19, 2, -24 },
  { 2915, 12, 24, 19, 4, -24 },
  { 2951, 17, 17, 19, 1, -17 },
  { 2988, 13, 17, 19, 3, -17 },
  { 3016, 15, 17, 19, 2, -17 },
  { 3048, 16, 23, 19, 1, -17 },
  { 3094, 15, 23, 19, 2, -17 },
  { 3138, 15, 17, 19, 4, -17 },
  { 3170, 15, 17, 19, 2, -17 },
  { 3202, 16, 22, 19, 2, -22 },
  { 3246, 14, 17, 19, 3, -17 },
  { 3276, 14, 17, 19, 3, -17 },
  { 3306, 16, 17, 19, 2, -17 },
  { 3340, 18, 17, 19, 1, -17 },
  { 3379, 16, 23, 19, 1, -17 },
  { 3425, 15, 17, 19, 2, -17 },
  { 3457, 14, 28, 19, 4, -24 },
  { 3506, 6, 28, 19, 7, -24 },
  { 3527, 15, 28, 19, 1, -24 },
  { 3580, 16, 6, 19, 2, -13 },
};

const GFXfont IBMPlexMono_ExtraLightItalic32pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic32pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic32pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC32PT7B_H_
