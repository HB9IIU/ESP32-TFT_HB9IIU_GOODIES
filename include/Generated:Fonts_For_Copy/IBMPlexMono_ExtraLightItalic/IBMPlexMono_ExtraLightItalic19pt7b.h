#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC19PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x92, 0x92, 0x00, 0x6C, 0x99, 0x9A, 0xA0, 0x02, 0x40, 0x44,
  0x04, 0x80, 0x48, 0x38, 0xF0, 0x90, 0x09, 0x01, 0x10, 0xF1, 0xC1, 0x20,
  0x22, 0x02, 0x40, 0x24, 0x00, 0x02, 0x01, 0x01, 0xF0, 0x92, 0x44, 0x51,
  0x04, 0x40, 0xE0, 0x1E, 0x02, 0x40, 0x88, 0x22, 0x90, 0xB4, 0x43, 0xE0,
  0x40, 0x10, 0x00, 0x1C, 0x12, 0x22, 0x42, 0x44, 0x24, 0x44, 0x83, 0x90,
  0x00, 0x01, 0x9C, 0x12, 0x42, 0x42, 0x44, 0x48, 0x44, 0x83, 0x80, 0x0F,
  0x02, 0x10, 0x42, 0x08, 0x41, 0x08, 0x12, 0x0F, 0x82, 0x20, 0x84, 0x10,
  0x42, 0x0C, 0xA2, 0xA7, 0x8C, 0xEA, 0x80, 0x06, 0x10, 0x41, 0x04, 0x08,
  0x10, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x10, 0x10, 0x30, 0x10, 0x20,
  0x81, 0x04, 0x10, 0x41, 0x04, 0x10, 0x42, 0x08, 0x41, 0x08, 0xC0, 0x04,
  0x01, 0x00, 0x42, 0x21, 0x7B, 0x83, 0x01, 0x40, 0x88, 0x42, 0x00, 0x04,
  0x02, 0x02, 0x01, 0x0F, 0xF8, 0x40, 0x20, 0x10, 0x08, 0x00, 0x29, 0x48,
  0xF8, 0xF0, 0x00, 0x40, 0x20, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10,
  0x08, 0x02, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x00,
  0x0F, 0x04, 0x22, 0x09, 0x01, 0x40, 0x60, 0x28, 0xCA, 0x02, 0x80, 0xA0,
  0x28, 0x11, 0x08, 0x3C, 0x00, 0x06, 0x05, 0x05, 0x0C, 0x84, 0x40, 0x20,
  0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x0F, 0xF8, 0x0F, 0x08, 0x48, 0x28,
  0x10, 0x08, 0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x0F, 0xF0, 0x0F,
  0x18, 0x50, 0x20, 0x10, 0x10, 0xF0, 0x0C, 0x02, 0x01, 0x00, 0xA0, 0x58,
  0x43, 0xC0, 0x01, 0x81, 0x81, 0x41, 0x21, 0x10, 0x88, 0x84, 0x84, 0x82,
  0x7F, 0xC0, 0x80, 0x40, 0x20, 0x1F, 0xC8, 0x02, 0x00, 0x80, 0x40, 0x17,
  0x86, 0x10, 0x02, 0x00, 0x80, 0x48, 0x11, 0x0C, 0x3C, 0x00, 0x03, 0x02,
  0x02, 0x02, 0x02, 0x02, 0xF1, 0x84, 0x81, 0x80, 0xC0, 0x60, 0x48, 0x63,
  0xC0, 0x7F, 0xC0, 0x60, 0x50, 0x40, 0x20, 0x20, 0x20, 0x10, 0x10, 0x08,
  0x08, 0x08, 0x04, 0x00, 0x0F, 0x0C, 0x22, 0x05, 0x01, 0x40, 0x88, 0x61,
  0xE1, 0xC4, 0x80, 0xA0, 0x28, 0x0B, 0x04, 0x3E, 0x00, 0x3E, 0x41, 0x81,
  0x81, 0x81, 0x81, 0xC3, 0x7E, 0x02, 0x04, 0x08, 0x10, 0x60, 0x24, 0x00,
  0x00, 0x1B, 0x00, 0x11, 0x00, 0x00, 0x00, 0x02, 0x44, 0x88, 0x00, 0x81,
  0x83, 0x06, 0x0C, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x40, 0x18, 0x03, 0x00, 0x40, 0x18, 0x08, 0x18, 0x30,
  0x20, 0x60, 0x00, 0x3C, 0x86, 0x0C, 0x10, 0x20, 0x8E, 0x10, 0x40, 0x00,
  0x02, 0x04, 0x00, 0x0F, 0x08, 0x48, 0x24, 0x14, 0x7A, 0x45, 0x43, 0x21,
  0x91, 0x48, 0xA3, 0xD0, 0x08, 0x02, 0x00, 0xF8, 0x03, 0x00, 0xC0, 0x50,
  0x14, 0x09, 0x04, 0x41, 0x08, 0x82, 0x3F, 0x88, 0x24, 0x09, 0x02, 0x80,
  0x40, 0x3F, 0x10, 0x48, 0x28, 0x14, 0x0A, 0x09, 0xF8, 0x82, 0x40, 0xC0,
  0x60, 0x30, 0x2F, 0xE0, 0x1E, 0x10, 0x90, 0x50, 0x18, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x41, 0x20, 0xD8, 0x87, 0x80, 0x3F, 0x08, 0x22, 0x08, 0x81,
  0x40, 0x50, 0x14, 0x09, 0x02, 0x40, 0xA0, 0x28, 0x12, 0x08, 0xFC, 0x00,
  0x3F, 0xC8, 0x02, 0x01, 0x00, 0x40, 0x10, 0x07, 0xF9, 0x00, 0x40, 0x20,
  0x08, 0x02, 0x00, 0xFF, 0x00, 0x3F, 0xC8, 0x02, 0x01, 0x00, 0x40, 0x10,
  0x07, 0xF9, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x00, 0x1E, 0x10,
  0x90, 0x50, 0x18, 0x04, 0x02, 0x01, 0x1E, 0x81, 0x40, 0xA0, 0x90, 0xC7,
  0xA0, 0x20, 0x48, 0x14, 0x05, 0x02, 0x40, 0x90, 0x27, 0xF9, 0x02, 0x80,
  0xA0, 0x48, 0x12, 0x04, 0x81, 0x00, 0x3F, 0xC1, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0xFF, 0x00, 0x1F,
  0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xA0, 0x88,
  0xC3, 0xC0, 0x20, 0x64, 0x10, 0x84, 0x21, 0x04, 0x40, 0x90, 0x16, 0x03,
  0x20, 0x44, 0x10, 0x42, 0x08, 0x40, 0x88, 0x18, 0x20, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x0F, 0xE0, 0x20, 0x58, 0x35, 0x15,
  0x45, 0x52, 0x94, 0xA8, 0xCA, 0x22, 0x88, 0xA0, 0x28, 0x12, 0x04, 0x81,
  0x00, 0x20, 0x4C, 0x15, 0x05, 0x42, 0x48, 0x92, 0x24, 0x89, 0x12, 0x84,
  0xA1, 0x48, 0x32, 0x0C, 0x81, 0x00, 0x0F, 0x04, 0x22, 0x09, 0x01, 0x40,
  0x60, 0x28, 0x0A, 0x02, 0x80, 0xA0, 0x28, 0x11, 0x08, 0x3C, 0x00, 0x3F,
  0x88, 0x32, 0x04, 0x81, 0x40, 0x50, 0x14, 0x09, 0xFC, 0x40, 0x10, 0x08,
  0x02, 0x00, 0x80, 0x00, 0x0F, 0x04, 0x22, 0x09, 0x01, 0x40, 0x60, 0x28,
  0x0A, 0x02, 0x80, 0xA0, 0x28, 0x11, 0x08, 0x3C, 0x02, 0x20, 0x50, 0x18,
  0x3F, 0x88, 0x32, 0x04, 0x81, 0x40, 0x50, 0x14, 0x09, 0xFC, 0x44, 0x11,
  0x08, 0x22, 0x08, 0x81, 0x00, 0x1F, 0x08, 0x24, 0x05, 0x00, 0x40, 0x0C,
  0x00, 0xE0, 0x04, 0x00, 0x80, 0x28, 0x0B, 0x04, 0x3E, 0x00, 0xFF, 0xC2,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x80, 0x20, 0x00, 0x40, 0xA0, 0x60, 0x30, 0x28, 0x14, 0x0A, 0x05, 0x02,
  0x81, 0x41, 0x20, 0x90, 0x87, 0x80, 0x80, 0x60, 0x28, 0x09, 0x04, 0x41,
  0x10, 0x84, 0x21, 0x10, 0x44, 0x0A, 0x02, 0x80, 0xC0, 0x30, 0x00, 0x40,
  0x28, 0x09, 0x01, 0x20, 0x24, 0x44, 0x99, 0x15, 0x24, 0xA4, 0x94, 0x94,
  0xA2, 0x8C, 0x61, 0x8C, 0x20, 0x20, 0x31, 0x02, 0x10, 0x40, 0x88, 0x09,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x09, 0x01, 0x10, 0x20, 0x84, 0x08, 0x80,
  0x40, 0x80, 0x60, 0x24, 0x11, 0x04, 0x22, 0x09, 0x01, 0x80, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x80, 0x20, 0x00, 0x1F, 0xE0, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x0F, 0xFC,
  0x3E, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0xF0, 0x88, 0x88, 0x84, 0x44, 0x44, 0x22, 0x22, 0x11, 0x10,
  0x1F, 0x01, 0x01, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04,
  0x04, 0x04, 0x04, 0x08, 0xF8, 0x06, 0x05, 0x02, 0x42, 0x22, 0x12, 0x07,
  0x02, 0xFF, 0x80, 0xAC, 0x1E, 0x90, 0xD0, 0x30, 0x28, 0x14, 0x0A, 0x05,
  0x02, 0x47, 0x1C, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0xF1, 0x8C, 0x82,
  0x81, 0x40, 0xA0, 0x50, 0x28, 0x2C, 0x35, 0xE0, 0x3C, 0x42, 0x82, 0x81,
  0x80, 0x80, 0x82, 0x82, 0x84, 0x78, 0x00, 0x40, 0x20, 0x08, 0x02, 0x1E,
  0x88, 0x64, 0x0A, 0x04, 0x81, 0x20, 0x48, 0x12, 0x04, 0x47, 0x0E, 0x80,
  0x3E, 0x41, 0x81, 0x86, 0xF8, 0x80, 0x82, 0x82, 0x84, 0x78, 0x01, 0xF0,
  0x20, 0x02, 0x00, 0x20, 0x1F, 0xE2, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x88, 0x04, 0x80, 0x28, 0x01,
  0x80, 0x1E, 0x90, 0xD0, 0x30, 0x28, 0x14, 0x0A, 0x05, 0x02, 0x47, 0x1D,
  0x00, 0x80, 0x48, 0x43, 0xC0, 0x60, 0x40, 0x40, 0x40, 0x5E, 0x62, 0x41,
  0x81, 0x82, 0x82, 0x82, 0x82, 0x82, 0x82, 0x08, 0x00, 0x00, 0x00, 0xF0,
  0x10, 0x10, 0x10, 0x20, 0x20, 0x23, 0x24, 0x38, 0x30, 0x01, 0x02, 0x00,
  0x00, 0x7E, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x88,
  0x48, 0x28, 0x18, 0x20, 0x08, 0x02, 0x00, 0x80, 0x2F, 0x0C, 0x26, 0x09,
  0x04, 0x42, 0x17, 0x04, 0x85, 0x22, 0x85, 0x20, 0x80, 0xF8, 0x08, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x23, 0x24, 0x58, 0x20, 0x59,
  0x99, 0x94, 0x46, 0x11, 0x88, 0xA2, 0x28, 0x8A, 0x22, 0x88, 0xA4, 0x20,
  0x5E, 0x62, 0x41, 0x81, 0x82, 0x82, 0x82, 0x82, 0x82, 0x82, 0x1E, 0x10,
  0x90, 0x28, 0x18, 0x0C, 0x06, 0x03, 0x02, 0x42, 0x1E, 0x00, 0x2F, 0x28,
  0xC8, 0x28, 0x14, 0x0A, 0x05, 0x02, 0x82, 0xC3, 0x5E, 0x20, 0x10, 0x08,
  0x04, 0x00, 0x1E, 0x90, 0xD0, 0x30, 0x28, 0x14, 0x0A, 0x05, 0x02, 0x47,
  0x1D, 0x00, 0x80, 0x40, 0x20, 0x10, 0xF3, 0x8E, 0x04, 0x02, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x00, 0x1F, 0x10, 0x50, 0x08, 0x03, 0xC0,
  0x18, 0x04, 0x02, 0xC1, 0x1F, 0x00, 0x08, 0x02, 0x00, 0x81, 0xFF, 0x88,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x22, 0x30, 0xB0, 0x10, 0x00, 0x41,
  0x81, 0x82, 0x82, 0x82, 0x82, 0x82, 0x86, 0x8C, 0x74, 0xE1, 0x41, 0x41,
  0x41, 0x41, 0x41, 0x42, 0x84, 0x88, 0x70, 0x44, 0x91, 0x14, 0x45, 0x11,
  0x88, 0x62, 0x18, 0x8A, 0x22, 0x99, 0x99, 0xC0, 0x08, 0xC6, 0xA7, 0x18,
  0x81, 0x10, 0x40, 0x08, 0x21, 0x04, 0x62, 0x8A, 0xAE, 0x60, 0x20, 0xA0,
  0x50, 0x48, 0x24, 0x12, 0x09, 0x04, 0x86, 0x46, 0x1D, 0x00, 0x80, 0x48,
  0x43, 0xC0, 0x3E, 0xA1, 0xD0, 0x40, 0x40, 0x40, 0xC0, 0x84, 0x82, 0xF9,
  0x47, 0x80, 0x0F, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x10, 0x10, 0xF0,
  0x0C, 0x02, 0x02, 0x02, 0x01, 0x00, 0x80, 0x80, 0x3C, 0x00, 0x12, 0x22,
  0x22, 0x24, 0x44, 0x44, 0x48, 0x88, 0x80, 0x1E, 0x02, 0x02, 0x04, 0x04,
  0x08, 0x10, 0x08, 0x07, 0x18, 0x10, 0x10, 0x10, 0x08, 0x08, 0x08, 0xF0,
  0x30, 0x52, 0x28, 0x4A, 0x0C,
};

const GFXglyph IBMPlexMono_ExtraLightItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 13, 11, 4, -13 },
  { 6, 4, 5, 11, 5, -14 },
  { 9, 12, 13, 11, 0, -13 },
  { 29, 10, 17, 11, 1, -15 },
  { 51, 12, 13, 11, 0, -13 },
  { 71, 11, 13, 11, 0, -13 },
  { 89, 2, 5, 11, 6, -14 },
  { 91, 7, 17, 11, 4, -14 },
  { 106, 6, 17, 11, 1, -14 },
  { 119, 10, 9, 11, 1, -10 },
  { 131, 9, 9, 11, 1, -10 },
  { 142, 3, 5, 11, 3, -2 },
  { 144, 5, 1, 11, 3, -6 },
  { 145, 2, 2, 11, 4, -2 },
  { 146, 10, 17, 11, 1, -14 },
  { 168, 10, 13, 11, 1, -13 },
  { 185, 9, 13, 11, 1, -13 },
  { 200, 9, 13, 11, 1, -13 },
  { 215, 9, 13, 11, 1, -13 },
  { 230, 9, 13, 11, 1, -13 },
  { 245, 10, 13, 11, 1, -13 },
  { 262, 9, 13, 11, 1, -13 },
  { 277, 9, 13, 11, 2, -13 },
  { 292, 10, 13, 11, 1, -13 },
  { 309, 8, 13, 11, 2, -13 },
  { 322, 3, 11, 11, 4, -11 },
  { 327, 4, 14, 11, 3, -11 },
  { 334, 9, 10, 11, 2, -11 },
  { 346, 10, 4, 11, 1, -8 },
  { 351, 9, 10, 11, 1, -11 },
  { 363, 7, 13, 11, 3, -13 },
  { 375, 9, 15, 11, 1, -13 },
  { 392, 10, 13, 11, 0, -13 },
  { 409, 9, 13, 11, 1, -13 },
  { 424, 9, 13, 11, 2, -13 },
  { 439, 10, 13, 11, 1, -13 },
  { 456, 10, 13, 11, 1, -13 },
  { 473, 10, 13, 11, 1, -13 },
  { 490, 9, 13, 11, 2, -13 },
  { 505, 10, 13, 11, 1, -13 },
  { 522, 10, 13, 11, 1, -13 },
  { 539, 9, 13, 11, 1, -13 },
  { 554, 11, 13, 11, 1, -13 },
  { 572, 7, 13, 11, 2, -13 },
  { 584, 10, 13, 11, 1, -13 },
  { 601, 10, 13, 11, 1, -13 },
  { 618, 10, 13, 11, 1, -13 },
  { 635, 10, 13, 11, 1, -13 },
  { 652, 10, 16, 11, 1, -13 },
  { 672, 10, 13, 11, 1, -13 },
  { 689, 10, 13, 11, 1, -13 },
  { 706, 10, 13, 11, 2, -13 },
  { 723, 9, 13, 11, 2, -13 },
  { 738, 10, 13, 11, 2, -13 },
  { 755, 11, 13, 11, 1, -13 },
  { 773, 12, 13, 11, 0, -13 },
  { 793, 10, 13, 11, 2, -13 },
  { 810, 11, 13, 11, 0, -13 },
  { 828, 7, 17, 11, 4, -14 },
  { 843, 4, 17, 11, 4, -14 },
  { 852, 8, 17, 11, 0, -14 },
  { 869, 9, 7, 11, 1, -13 },
  { 877, 9, 1, 11, 0, 2 },
  { 879, 2, 3, 11, 5, -15 },
  { 880, 9, 10, 11, 1, -10 },
  { 892, 9, 14, 11, 1, -14 },
  { 908, 8, 10, 11, 2, -10 },
  { 918, 10, 14, 11, 1, -14 },
  { 936, 8, 10, 11, 2, -10 },
  { 946, 12, 18, 11, 0, -14 },
  { 973, 9, 14, 11, 1, -10 },
  { 989, 8, 14, 11, 2, -14 },
  { 1003, 8, 14, 11, 2, -14 },
  { 1017, 8, 18, 11, 2, -14 },
  { 1035, 10, 14, 11, 1, -14 },
  { 1053, 8, 14, 11, 2, -14 },
  { 1067, 10, 10, 11, 1, -10 },
  { 1080, 8, 10, 11, 2, -10 },
  { 1090, 9, 10, 11, 1, -10 },
  { 1102, 9, 14, 11, 1, -10 },
  { 1118, 9, 14, 11, 1, -10 },
  { 1134, 9, 10, 11, 2, -10 },
  { 1146, 9, 10, 11, 1, -10 },
  { 1158, 10, 13, 11, 1, -13 },
  { 1175, 8, 10, 11, 2, -10 },
  { 1185, 8, 10, 11, 2, -10 },
  { 1195, 10, 10, 11, 1, -10 },
  { 1208, 11, 10, 11, 0, -10 },
  { 1222, 9, 14, 11, 1, -10 },
  { 1238, 9, 10, 11, 1, -10 },
  { 1250, 9, 17, 11, 2, -14 },
  { 1270, 4, 17, 11, 4, -14 },
  { 1279, 8, 17, 11, 1, -14 },
  { 1296, 10, 4, 11, 1, -8 },
};

const GFXfont IBMPlexMono_ExtraLightItalic19pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic19pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic19pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC19PT7B_H_
