#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/IBMPlexMono_ExtraLightItalic
// Headers: 67

#include "IBMPlexMono_ExtraLightItalic6pt7b.h"
#include "IBMPlexMono_ExtraLightItalic7pt7b.h"
#include "IBMPlexMono_ExtraLightItalic8pt7b.h"
#include "IBMPlexMono_ExtraLightItalic9pt7b.h"
#include "IBMPlexMono_ExtraLightItalic10pt7b.h"
#include "IBMPlexMono_ExtraLightItalic11pt7b.h"
#include "IBMPlexMono_ExtraLightItalic12pt7b.h"
#include "IBMPlexMono_ExtraLightItalic13pt7b.h"
#include "IBMPlexMono_ExtraLightItalic14pt7b.h"
#include "IBMPlexMono_ExtraLightItalic15pt7b.h"
#include "IBMPlexMono_ExtraLightItalic16pt7b.h"
#include "IBMPlexMono_ExtraLightItalic17pt7b.h"
#include "IBMPlexMono_ExtraLightItalic18pt7b.h"
#include "IBMPlexMono_ExtraLightItalic19pt7b.h"
#include "IBMPlexMono_ExtraLightItalic20pt7b.h"
#include "IBMPlexMono_ExtraLightItalic21pt7b.h"
#include "IBMPlexMono_ExtraLightItalic22pt7b.h"
#include "IBMPlexMono_ExtraLightItalic23pt7b.h"
#include "IBMPlexMono_ExtraLightItalic24pt7b.h"
#include "IBMPlexMono_ExtraLightItalic25pt7b.h"
#include "IBMPlexMono_ExtraLightItalic26pt7b.h"
#include "IBMPlexMono_ExtraLightItalic27pt7b.h"
#include "IBMPlexMono_ExtraLightItalic28pt7b.h"
#include "IBMPlexMono_ExtraLightItalic29pt7b.h"
#include "IBMPlexMono_ExtraLightItalic30pt7b.h"
#include "IBMPlexMono_ExtraLightItalic31pt7b.h"
#include "IBMPlexMono_ExtraLightItalic32pt7b.h"
#include "IBMPlexMono_ExtraLightItalic33pt7b.h"
#include "IBMPlexMono_ExtraLightItalic34pt7b.h"
#include "IBMPlexMono_ExtraLightItalic35pt7b.h"
#include "IBMPlexMono_ExtraLightItalic36pt7b.h"
#include "IBMPlexMono_ExtraLightItalic37pt7b.h"
#include "IBMPlexMono_ExtraLightItalic38pt7b.h"
#include "IBMPlexMono_ExtraLightItalic39pt7b.h"
#include "IBMPlexMono_ExtraLightItalic40pt7b.h"
#include "IBMPlexMono_ExtraLightItalic41pt7b.h"
#include "IBMPlexMono_ExtraLightItalic42pt7b.h"
#include "IBMPlexMono_ExtraLightItalic43pt7b.h"
#include "IBMPlexMono_ExtraLightItalic44pt7b.h"
#include "IBMPlexMono_ExtraLightItalic45pt7b.h"
#include "IBMPlexMono_ExtraLightItalic46pt7b.h"
#include "IBMPlexMono_ExtraLightItalic47pt7b.h"
#include "IBMPlexMono_ExtraLightItalic48pt7b.h"
#include "IBMPlexMono_ExtraLightItalic49pt7b.h"
#include "IBMPlexMono_ExtraLightItalic50pt7b.h"
#include "IBMPlexMono_ExtraLightItalic51pt7b.h"
#include "IBMPlexMono_ExtraLightItalic52pt7b.h"
#include "IBMPlexMono_ExtraLightItalic53pt7b.h"
#include "IBMPlexMono_ExtraLightItalic54pt7b.h"
#include "IBMPlexMono_ExtraLightItalic55pt7b.h"
#include "IBMPlexMono_ExtraLightItalic56pt7b.h"
#include "IBMPlexMono_ExtraLightItalic57pt7b.h"
#include "IBMPlexMono_ExtraLightItalic58pt7b.h"
#include "IBMPlexMono_ExtraLightItalic59pt7b.h"
#include "IBMPlexMono_ExtraLightItalic60pt7b.h"
#include "IBMPlexMono_ExtraLightItalic61pt7b.h"
#include "IBMPlexMono_ExtraLightItalic62pt7b.h"
#include "IBMPlexMono_ExtraLightItalic63pt7b.h"
#include "IBMPlexMono_ExtraLightItalic64pt7b.h"
#include "IBMPlexMono_ExtraLightItalic65pt7b.h"
#include "IBMPlexMono_ExtraLightItalic66pt7b.h"
#include "IBMPlexMono_ExtraLightItalic67pt7b.h"
#include "IBMPlexMono_ExtraLightItalic68pt7b.h"
#include "IBMPlexMono_ExtraLightItalic69pt7b.h"
#include "IBMPlexMono_ExtraLightItalic70pt7b.h"
#include "IBMPlexMono_ExtraLightItalic71pt7b.h"
#include "IBMPlexMono_ExtraLightItalic72pt7b.h"
