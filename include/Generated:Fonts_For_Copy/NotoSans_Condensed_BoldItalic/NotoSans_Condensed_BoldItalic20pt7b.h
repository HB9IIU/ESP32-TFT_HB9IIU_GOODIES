#ifndef _NOTOSANS_CONDENSED_BOLDITALIC20PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x63, 0x8E, 0x38, 0xC3, 0x0C, 0x70, 0x00, 0x18, 0xE3, 0x80,
  0x6F, 0xDF, 0xB6, 0x6C, 0xC0, 0x06, 0xC1, 0x98, 0x33, 0x06, 0xC3, 0xFE,
  0xFF, 0xC6, 0xC0, 0xD8, 0xFF, 0xDF, 0xF8, 0xD8, 0x33, 0x06, 0x60, 0xD8,
  0x00, 0x02, 0x01, 0xC1, 0xFC, 0xFE, 0x34, 0x0F, 0x03, 0xC0, 0x78, 0x0F,
  0x03, 0xC0, 0xBB, 0x3C, 0xFF, 0x3F, 0x81, 0x00, 0x40, 0x3C, 0x33, 0x63,
  0x1B, 0x31, 0x99, 0x8C, 0xD8, 0x6E, 0xDB, 0x6D, 0xFE, 0xDB, 0x06, 0xD8,
  0x66, 0xC7, 0x66, 0x33, 0x33, 0x1F, 0x38, 0x70, 0x0F, 0x83, 0xF0, 0x66,
  0x0C, 0xC1, 0xB8, 0x3E, 0x07, 0x99, 0xF7, 0x76, 0xFC, 0xFB, 0x8E, 0x73,
  0xCF, 0xFC, 0xFB, 0x80, 0x7F, 0xEC, 0x0E, 0x18, 0x61, 0xC3, 0x06, 0x1C,
  0x30, 0x60, 0xC1, 0x87, 0x0E, 0x1C, 0x18, 0x30, 0x70, 0x0C, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x38, 0x60, 0xC3, 0x86, 0x1C, 0x31,
  0xC0, 0x1C, 0x98, 0xF9, 0xFF, 0x3F, 0x78, 0xEC, 0x4C, 0x18, 0x0C, 0x06,
  0x03, 0x0F, 0xFF, 0xFC, 0x60, 0x30, 0x18, 0x0C, 0x00, 0x3B, 0x9C, 0xCE,
  0x60, 0x7D, 0xEF, 0x80, 0x7F, 0x80, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x07,
  0x01, 0x80, 0xE0, 0x30, 0x1C, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x00,
  0x0F, 0x8F, 0xCE, 0x66, 0x37, 0x1B, 0x8D, 0xCE, 0xC7, 0x63, 0xF1, 0xB9,
  0xCC, 0xC7, 0xE3, 0xE0, 0x0E, 0x79, 0xF7, 0xE5, 0xC3, 0x86, 0x1C, 0x38,
  0x70, 0xC1, 0x87, 0x0E, 0x00, 0x0F, 0xC7, 0xF1, 0x9C, 0x03, 0x01, 0xC0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC2, 0x7F, 0x3F, 0xC0, 0x1F,
  0x9F, 0xC4, 0x60, 0x30, 0x38, 0x38, 0x70, 0x3E, 0x07, 0x01, 0x81, 0xD1,
  0xEF, 0xE7, 0xE0, 0x03, 0x81, 0xC1, 0xE1, 0xF1, 0xB0, 0xD8, 0xDC, 0xCE,
  0x67, 0x7F, 0xFF, 0xE1, 0xC0, 0xE0, 0x70, 0x1F, 0xC7, 0xE1, 0x80, 0xE0,
  0x30, 0x0F, 0x87, 0xF0, 0x9C, 0x03, 0x00, 0xC0, 0x72, 0x3C, 0xFE, 0x3F,
  0x00, 0x02, 0x07, 0xC7, 0xC7, 0x07, 0x03, 0x03, 0xF9, 0xFE, 0xE7, 0x73,
  0xB1, 0xD8, 0xCE, 0xE7, 0xE1, 0xE0, 0x7F, 0xBF, 0xC0, 0xC0, 0xE0, 0x60,
  0x70, 0x30, 0x38, 0x18, 0x1C, 0x1C, 0x0E, 0x0E, 0x07, 0x00, 0x1F, 0x8F,
  0xE3, 0x9C, 0xE6, 0x3B, 0x87, 0xC1, 0xE0, 0xFC, 0x77, 0x38, 0xCE, 0x33,
  0x9C, 0xFF, 0x1F, 0x80, 0x02, 0x0F, 0x8F, 0xE7, 0x77, 0x1B, 0x9D, 0xCE,
  0xEF, 0x7F, 0x9D, 0x81, 0xC0, 0xE0, 0xE7, 0xE3, 0xE0, 0x39, 0xCE, 0x00,
  0x00, 0x00, 0x67, 0x38, 0x1C, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x31, 0xC7,
  0x18, 0xE3, 0x00, 0x01, 0x83, 0xC7, 0xCF, 0x8F, 0x07, 0x80, 0xF8, 0x1F,
  0x03, 0x80, 0x40, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x80, 0x70,
  0x3E, 0x03, 0xC0, 0x78, 0x7C, 0xF9, 0xF0, 0xC0, 0x40, 0x00, 0x7E, 0xFD,
  0x18, 0x30, 0xE3, 0x8E, 0x38, 0x60, 0x00, 0x07, 0x0E, 0x18, 0x00, 0x07,
  0xE0, 0xE3, 0x8C, 0x06, 0xE7, 0x36, 0x7D, 0xE6, 0x6F, 0x26, 0x7B, 0x33,
  0xD9, 0x94, 0xDD, 0xA7, 0xF9, 0x99, 0x8C, 0x00, 0x70, 0x41, 0xFE, 0x03,
  0xC0, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0xC3, 0x71, 0xDC, 0x67, 0x3F,
  0xCF, 0xF7, 0x1D, 0xC7, 0xE1, 0xF8, 0x70, 0x1F, 0x87, 0xF1, 0x8C, 0xE3,
  0x39, 0xCF, 0xE3, 0xF1, 0xFE, 0x71, 0x9C, 0x66, 0x39, 0x8E, 0xFF, 0x3F,
  0x80, 0x0F, 0xCF, 0xE3, 0x89, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0xC8, 0x7E, 0x1F, 0x80, 0x1F, 0x83, 0xF8, 0x67, 0x9C,
  0x73, 0x8E, 0x71, 0xCC, 0x3B, 0x87, 0x71, 0xCE, 0x39, 0xCE, 0x33, 0xCF,
  0xF1, 0xF8, 0x00, 0x1F, 0xC7, 0xE1, 0x80, 0xE0, 0x38, 0x0F, 0xC3, 0xF1,
  0xFC, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xE1,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0xF1, 0xFC, 0x70, 0x1C, 0x07, 0x01, 0x80,
  0xE0, 0x38, 0x00, 0x0F, 0xE3, 0xF8, 0xE1, 0x38, 0x07, 0x01, 0xC0, 0x39,
  0xF7, 0x3E, 0xE1, 0x9C, 0x73, 0x8E, 0x79, 0xC7, 0xF8, 0x7E, 0x00, 0x1C,
  0x71, 0xC7, 0x18, 0x73, 0x86, 0x38, 0xE3, 0xFE, 0x3F, 0xE7, 0xFC, 0x70,
  0xC7, 0x1C, 0x71, 0xC6, 0x1C, 0xE1, 0x8E, 0x38, 0x1F, 0x87, 0x83, 0x81,
  0xC0, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0C, 0x06, 0x07, 0x07, 0xC7, 0xE0,
  0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x03,
  0x81, 0x80, 0xC0, 0xE0, 0x70, 0x78, 0xF8, 0x78, 0x00, 0x1C, 0xF1, 0x8E,
  0x19, 0xC3, 0xB8, 0x3B, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x77, 0x07, 0x70,
  0x77, 0x06, 0x30, 0xE3, 0x8E, 0x38, 0x1C, 0x30, 0x61, 0xC3, 0x87, 0x0C,
  0x38, 0x70, 0xE1, 0xC3, 0x0F, 0xFF, 0xC0, 0x1E, 0x1F, 0x1E, 0x1E, 0x1E,
  0x1E, 0x3E, 0x3E, 0x3E, 0x3C, 0x36, 0x6C, 0x36, 0x6C, 0x76, 0xDC, 0x76,
  0xDC, 0x77, 0xD8, 0x67, 0x98, 0x67, 0xB8, 0xE7, 0x38, 0xE7, 0x38, 0x1C,
  0x38, 0xF1, 0x87, 0x8C, 0x7C, 0x63, 0x67, 0x1B, 0x38, 0xDD, 0x8E, 0xEC,
  0x73, 0x63, 0x9F, 0x18, 0xF8, 0xC7, 0x8E, 0x1C, 0x70, 0xE0, 0x02, 0x03,
  0xF0, 0xFF, 0x1C, 0xF7, 0x0E, 0xE1, 0xF8, 0x3F, 0x07, 0xE1, 0xDC, 0x3B,
  0x87, 0x71, 0xCE, 0x78, 0xFE, 0x1F, 0x80, 0x1F, 0xC3, 0xF8, 0x63, 0x9C,
  0x73, 0x8E, 0x73, 0x8C, 0xF3, 0xFC, 0x7E, 0x0E, 0x01, 0xC0, 0x30, 0x0E,
  0x01, 0xC0, 0x00, 0x02, 0x01, 0xF0, 0xFF, 0x1C, 0xF7, 0x0E, 0xE1, 0xF8,
  0x3F, 0x07, 0xE1, 0xDC, 0x3B, 0x87, 0x71, 0xCE, 0x78, 0xFE, 0x1F, 0x80,
  0x70, 0x0E, 0x00, 0xE0, 0x1F, 0x87, 0xF1, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0xF9, 0xFC, 0x76, 0x1D, 0xC7, 0x71, 0x8C, 0xE3, 0xB8, 0xE0, 0x1F, 0xCF,
  0xE3, 0x88, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x78, 0x07, 0x01, 0xC0, 0x73,
  0x3C, 0xFE, 0x3F, 0x00, 0xFF, 0xFF, 0x38, 0x38, 0x38, 0x30, 0x70, 0x70,
  0x70, 0x60, 0x60, 0xE0, 0xE0, 0xE0, 0x38, 0xE6, 0x1D, 0xC3, 0x38, 0xE7,
  0x1C, 0xE3, 0x98, 0x67, 0x0C, 0xE3, 0x9C, 0x73, 0x8E, 0x73, 0x8F, 0xF0,
  0xF8, 0x00, 0xC1, 0xF0, 0xEC, 0x3B, 0x1C, 0xC7, 0x31, 0x8E, 0xE3, 0xB0,
  0xFC, 0x36, 0x0D, 0x83, 0xC0, 0xF0, 0x3C, 0x00, 0xC3, 0x8F, 0x8E, 0x1B,
  0x1C, 0x76, 0x38, 0xCC, 0xF3, 0x99, 0xE7, 0x37, 0xCC, 0x6D, 0xB8, 0xDB,
  0x61, 0xE7, 0xC3, 0xCF, 0x87, 0x9E, 0x0E, 0x3C, 0x1C, 0x70, 0x00, 0x1C,
  0x70, 0xCE, 0x0C, 0xE0, 0xFC, 0x0F, 0x80, 0xF8, 0x07, 0x00, 0xF0, 0x1F,
  0x01, 0xF0, 0x3B, 0x87, 0x38, 0x73, 0x8E, 0x1C, 0xE3, 0xF3, 0xB9, 0x9D,
  0xC6, 0xC3, 0xE1, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x00,
  0x1F, 0xE3, 0xFC, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x1C,
  0x07, 0x00, 0xE0, 0x38, 0x47, 0xF1, 0xFE, 0x00, 0x0F, 0x0F, 0x1C, 0x1C,
  0x18, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60, 0x78,
  0xF8, 0xCE, 0xE6, 0x66, 0x66, 0x77, 0x33, 0x33, 0x1F, 0x1E, 0x06, 0x0E,
  0x0E, 0x0C, 0x0C, 0x0C, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x38, 0x30, 0xF0,
  0xF0, 0x06, 0x07, 0x03, 0xC3, 0x61, 0xB1, 0x99, 0xC7, 0xC3, 0xFE, 0xE6,
  0x30, 0x3D, 0xBF, 0xDD, 0xFC, 0x6E, 0x77, 0x3B, 0x1D, 0x8C, 0xCE, 0x7F,
  0x3D, 0x80, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x3F, 0x8F, 0xE3, 0x98, 0xC7,
  0x71, 0x9C, 0x67, 0x39, 0x8E, 0x77, 0x3F, 0xCD, 0xE0, 0x1F, 0x7E, 0x72,
  0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xE4, 0xFC, 0x78, 0x01, 0xC0, 0x70, 0x18,
  0x06, 0x3F, 0x9F, 0xE7, 0x7B, 0x8C, 0xE7, 0x31, 0xCC, 0x73, 0x18, 0xCE,
  0x3F, 0x8F, 0x60, 0x1E, 0x3F, 0x73, 0xE7, 0xEE, 0xFC, 0xC0, 0xC0, 0xC2,
  0xFC, 0x7C, 0x03, 0xC1, 0xF0, 0x70, 0x18, 0x0F, 0x87, 0xE0, 0xE0, 0x38,
  0x0C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x3C,
  0x0F, 0x03, 0x80, 0x1E, 0xCF, 0xF3, 0xBD, 0xC6, 0x73, 0x9C, 0xE6, 0x3B,
  0x8C, 0x67, 0x1F, 0xC7, 0xF0, 0x1C, 0x06, 0x37, 0x8F, 0xC1, 0xE0, 0x1C,
  0x0C, 0x06, 0x07, 0x03, 0xF9, 0xFC, 0xE6, 0x63, 0x71, 0xB9, 0xDC, 0xEC,
  0x76, 0x37, 0x3B, 0x9C, 0x1C, 0x71, 0x80, 0x38, 0xE3, 0x0C, 0x71, 0xC7,
  0x18, 0x63, 0x8E, 0x00, 0x03, 0x81, 0xC0, 0xC0, 0x00, 0x70, 0x38, 0x1C,
  0x0C, 0x0E, 0x07, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x7C,
  0x3E, 0x1C, 0x00, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x39, 0xCE, 0xE3, 0x30,
  0xDC, 0x7E, 0x1F, 0x87, 0xE1, 0x98, 0x67, 0x39, 0xCE, 0x70, 0x1C, 0x71,
  0x8E, 0x38, 0xE3, 0x0C, 0x71, 0xC7, 0x18, 0x63, 0x8E, 0x00, 0x37, 0xBC,
  0xFF, 0xF3, 0xBD, 0xCC, 0x63, 0x73, 0x9D, 0xCE, 0x77, 0x39, 0xD8, 0xC6,
  0x63, 0x1B, 0x9C, 0xEE, 0x73, 0x80, 0x37, 0x9F, 0xCE, 0x66, 0x37, 0x1B,
  0x9D, 0xCE, 0xC7, 0x63, 0x73, 0xB9, 0xC0, 0x1E, 0x7F, 0x77, 0xE3, 0xE3,
  0xC7, 0xC7, 0xC7, 0xCE, 0xFE, 0x78, 0x1B, 0xC3, 0xF8, 0x73, 0x0C, 0x73,
  0x8C, 0x71, 0x8E, 0x71, 0x8E, 0x3B, 0x8F, 0xF1, 0xFC, 0x38, 0x06, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0x1E, 0xCF, 0xF3, 0xBD, 0xC6, 0x71, 0x98, 0xE6,
  0x3B, 0x8C, 0x67, 0x1F, 0xC7, 0xF0, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x38,
  0x37, 0x37, 0x3E, 0x38, 0x70, 0x70, 0x70, 0x60, 0x60, 0xE0, 0xE0, 0x1F,
  0x3F, 0x72, 0x70, 0x78, 0x3C, 0x1E, 0x0E, 0x8E, 0xFC, 0xF8, 0x38, 0xC7,
  0xFF, 0x71, 0x86, 0x38, 0xE3, 0x8C, 0x3C, 0xF0, 0x73, 0xB9, 0xD8, 0xCC,
  0x6E, 0x77, 0x3B, 0x1D, 0x8C, 0xCE, 0x7F, 0x3D, 0x80, 0xE3, 0xF3, 0xB9,
  0xDC, 0xCE, 0xE7, 0x61, 0xF0, 0xF0, 0x78, 0x38, 0x1C, 0x00, 0xE7, 0x1F,
  0x39, 0xFB, 0xCD, 0xDE, 0xEE, 0xF6, 0x7D, 0xB3, 0xEF, 0x9E, 0x78, 0xF3,
  0xC7, 0x9C, 0x38, 0xE0, 0x38, 0xE3, 0xB8, 0x7E, 0x0F, 0x80, 0xF0, 0x1C,
  0x07, 0x81, 0xF8, 0x37, 0x0E, 0xE3, 0x8E, 0x00, 0x38, 0xE7, 0x38, 0xE7,
  0x1C, 0xC1, 0xB8, 0x36, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0C,
  0x03, 0x81, 0xE0, 0x3C, 0x06, 0x00, 0x1F, 0x8F, 0xC9, 0xC0, 0xE0, 0xE0,
  0xE0, 0x60, 0x70, 0x70, 0x3F, 0x3F, 0x80, 0x07, 0x0F, 0x0C, 0x1C, 0x1C,
  0x18, 0x18, 0x78, 0xE0, 0x70, 0x30, 0x30, 0x70, 0x70, 0x70, 0x78, 0x38,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x1E, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C,
  0x0F, 0x06, 0x1E, 0x18, 0x38, 0x38, 0x30, 0x70, 0xF0, 0xE0, 0x60, 0xFF,
  0xE7, 0xF0, 0xC0,
};

const GFXglyph NotoSans_Condensed_BoldItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 6, 14, 5, 0, -14 },
  { 12, 7, 5, 8, 2, -14 },
  { 17, 11, 14, 11, 0, -14 },
  { 37, 10, 16, 9, 0, -15 },
  { 57, 13, 14, 15, 1, -14 },
  { 80, 11, 14, 11, 0, -14 },
  { 100, 3, 5, 5, 2, -14 },
  { 102, 7, 17, 6, 0, -14 },
  { 117, 7, 18, 6, -2, -15 },
  { 133, 8, 8, 9, 2, -15 },
  { 141, 9, 10, 10, 1, -12 },
  { 153, 5, 6, 5, -1, -3 },
  { 157, 6, 3, 6, 0, -7 },
  { 160, 3, 3, 5, 0, -3 },
  { 162, 10, 14, 8, -1, -14 },
  { 180, 9, 14, 9, 0, -14 },
  { 196, 7, 14, 9, 2, -14 },
  { 209, 10, 14, 9, -1, -14 },
  { 227, 9, 14, 9, 0, -14 },
  { 243, 9, 14, 9, 0, -14 },
  { 259, 10, 14, 9, 0, -14 },
  { 277, 9, 15, 9, 1, -15 },
  { 294, 9, 14, 9, 1, -14 },
  { 310, 10, 14, 9, 0, -14 },
  { 328, 9, 15, 9, 0, -15 },
  { 345, 5, 11, 5, 0, -11 },
  { 352, 6, 14, 5, -1, -11 },
  { 363, 9, 10, 10, 1, -12 },
  { 375, 9, 6, 10, 1, -10 },
  { 382, 9, 10, 10, 1, -12 },
  { 394, 7, 14, 7, 1, -14 },
  { 407, 13, 16, 14, 1, -14 },
  { 433, 10, 14, 10, -1, -14 },
  { 451, 10, 14, 10, 0, -14 },
  { 469, 10, 14, 10, 1, -14 },
  { 487, 11, 14, 11, 0, -14 },
  { 507, 10, 14, 9, 0, -14 },
  { 525, 10, 14, 9, 0, -14 },
  { 543, 11, 14, 12, 1, -14 },
  { 563, 12, 14, 12, 0, -14 },
  { 584, 9, 14, 7, -1, -14 },
  { 600, 9, 18, 5, -3, -14 },
  { 621, 12, 14, 10, 0, -14 },
  { 642, 7, 14, 9, 0, -14 },
  { 655, 16, 14, 15, 0, -14 },
  { 683, 13, 14, 12, 0, -14 },
  { 706, 11, 15, 12, 1, -15 },
  { 727, 11, 14, 10, 0, -14 },
  { 747, 11, 18, 12, 1, -15 },
  { 772, 10, 14, 10, 0, -14 },
  { 790, 10, 14, 9, 0, -14 },
  { 808, 8, 14, 9, 2, -14 },
  { 822, 11, 14, 11, 1, -14 },
  { 842, 10, 14, 10, 2, -14 },
  { 860, 15, 14, 15, 2, -14 },
  { 887, 12, 14, 10, -1, -14 },
  { 908, 9, 14, 9, 2, -14 },
  { 924, 11, 14, 9, -1, -14 },
  { 944, 8, 17, 6, -1, -14 },
  { 961, 4, 14, 8, 2, -14 },
  { 968, 8, 17, 6, -1, -14 },
  { 985, 9, 8, 9, 0, -14 },
  { 994, 7, 1, 7, -2, 2 },
  { 995, 4, 3, 6, 3, -15 },
  { 997, 9, 11, 10, 1, -11 },
  { 1010, 10, 15, 10, 0, -15 },
  { 1029, 8, 11, 8, 1, -11 },
  { 1040, 10, 15, 10, 1, -15 },
  { 1059, 8, 11, 9, 1, -11 },
  { 1070, 10, 20, 6, -2, -15 },
  { 1095, 10, 16, 10, 0, -11 },
  { 1115, 9, 15, 10, 0, -15 },
  { 1132, 6, 15, 5, 0, -15 },
  { 1144, 9, 20, 5, -3, -15 },
  { 1167, 10, 15, 9, 0, -15 },
  { 1186, 6, 15, 5, 0, -15 },
  { 1198, 14, 11, 15, 0, -11 },
  { 1218, 9, 11, 10, 0, -11 },
  { 1231, 8, 11, 10, 1, -11 },
  { 1242, 11, 16, 10, -1, -11 },
  { 1264, 10, 16, 10, 0, -11 },
  { 1284, 8, 11, 7, 0, -11 },
  { 1295, 8, 11, 8, 0, -11 },
  { 1306, 6, 13, 7, 1, -13 },
  { 1316, 9, 11, 10, 1, -11 },
  { 1329, 9, 11, 9, 1, -11 },
  { 1342, 13, 11, 13, 1, -11 },
  { 1360, 11, 11, 9, -1, -11 },
  { 1376, 11, 16, 9, -1, -11 },
  { 1398, 9, 11, 8, -1, -11 },
  { 1411, 8, 17, 7, 0, -14 },
  { 1428, 2, 20, 9, 3, -15 },
  { 1433, 8, 17, 7, -1, -14 },
  { 1450, 9, 4, 10, 1, -9 },
};

const GFXfont NotoSans_Condensed_BoldItalic20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic20pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC20PT7B_H_
