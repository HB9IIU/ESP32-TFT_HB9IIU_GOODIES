#ifndef _NOTOSANS_CONDENSED_BOLDITALIC61PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F,
  0xF8, 0x01, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x3F, 0xC7, 0xFC, 0xFF, 0x1F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xE1, 0xFE, 0x3F, 0x87, 0xF1, 0xFE, 0x1F, 0xC7,
  0xF0, 0x7F, 0x1F, 0xC3, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xE0,
  0xFE, 0x1F, 0x83, 0xF0, 0xFE, 0x0F, 0xC3, 0xF8, 0x3F, 0x0F, 0xC1, 0xFC,
  0x3F, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x1F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x3F, 0x07, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x7C, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xE0,
  0x00, 0x07, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0xE0, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xF8, 0x3F, 0x00,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xF8,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF8, 0x03, 0xFE, 0xFF, 0xC0, 0x3F, 0xCE, 0x1C, 0x01, 0xFE, 0x70,
  0x20, 0x0F, 0xE3, 0x80, 0x00, 0x7F, 0x1C, 0x00, 0x03, 0xFC, 0xE0, 0x00,
  0x1F, 0xEE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xBF, 0xE0, 0x00,
  0x1D, 0xFF, 0x00, 0x01, 0xC7, 0xF8, 0x00, 0x0E, 0x3F, 0xC1, 0x00, 0x71,
  0xFE, 0x1C, 0x03, 0x9F, 0xE0, 0xF8, 0x1D, 0xFF, 0x07, 0xFD, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0xFF,
  0xE0, 0x01, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0xFC, 0x00, 0x7F, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x7E, 0x00,
  0x3F, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x83,
  0xF0, 0x3F, 0x00, 0x1F, 0xC3, 0xF8, 0x3F, 0x80, 0x0F, 0xC1, 0xFC, 0x1F,
  0x80, 0x07, 0xE0, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x0F, 0xC0, 0x01,
  0xF8, 0x3F, 0x0F, 0xC0, 0x01, 0xFC, 0x1F, 0x8F, 0xE0, 0x00, 0xFC, 0x1F,
  0xC7, 0xE0, 0x00, 0x7E, 0x0F, 0xC7, 0xE0, 0x78, 0x3F, 0x07, 0xE3, 0xF0,
  0xFF, 0x1F, 0x87, 0xE3, 0xF1, 0xFF, 0xCF, 0xC7, 0xF3, 0xF9, 0xFF, 0xF7,
  0xF7, 0xF1, 0xF8, 0xFF, 0xF9, 0xFF, 0xF9, 0xF8, 0xFF, 0xFE, 0xFF, 0xF8,
  0xFC, 0xFE, 0x7F, 0x3F, 0xF8, 0xFC, 0x7E, 0x1F, 0x9F, 0xF8, 0xFE, 0x7F,
  0x0F, 0xC3, 0xF0, 0x7E, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x1F, 0x83, 0xF0,
  0x00, 0x3F, 0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0x0F, 0xC1, 0xFC, 0x00, 0x3F,
  0x87, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x7E, 0x00, 0x1F, 0x81, 0xF8,
  0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0xFE, 0x1F, 0x80,
  0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x0F, 0xE0, 0x07, 0xE0,
  0x1F, 0xC7, 0xE0, 0x03, 0xF0, 0x07, 0xE7, 0xF0, 0x03, 0xF0, 0x03, 0xFF,
  0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x7F, 0xF8, 0x01,
  0xF8, 0x00, 0x3F, 0xF8, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x03, 0xFC,
  0x3F, 0xC0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x01,
  0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0x00,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x03, 0xFD, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xE0, 0x3F, 0xC0, 0x7F, 0xFC, 0x0F, 0xF0, 0x1F, 0xFF, 0xC1, 0xFE,
  0x07, 0xFF, 0xF8, 0x7F, 0x81, 0xFF, 0xFF, 0x8F, 0xF0, 0x7F, 0xCF, 0xF1,
  0xFC, 0x1F, 0xF1, 0xFF, 0x7F, 0x83, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0x83,
  0xFF, 0xFC, 0x1F, 0xE0, 0x7F, 0xFF, 0x03, 0xFC, 0x07, 0xFF, 0xE0, 0x7F,
  0x80, 0xFF, 0xF8, 0x0F, 0xF0, 0x0F, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0xC0,
  0x7F, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xCF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0xFF, 0x80, 0x3F, 0xFF, 0x1F, 0xF8, 0x03,
  0xFF, 0x81, 0xFF, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0xCF, 0xF3, 0xFC,
  0xFF, 0x3F, 0x9F, 0xE7, 0xF9, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xF8, 0xFE,
  0x3F, 0x8F, 0xE3, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x20, 0x3F,
  0x80, 0x38, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x7F, 0x3F, 0x00, 0x7F, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x1F, 0xEF, 0xC0, 0x3F, 0xEF, 0xC0, 0x7F, 0xCF, 0xE0, 0x3F, 0x87,
  0xF0, 0x1F, 0x87, 0xF0, 0x0F, 0x07, 0xF8, 0x06, 0x03, 0xE0, 0x02, 0x03,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFE, 0x0F, 0xF0,
  0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0,
  0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1F, 0x8F, 0xF7,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x7F, 0x06, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xF9, 0xFF, 0x03, 0xFE, 0x1F,
  0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0xFF,
  0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC7, 0xFC, 0x07, 0xF8, 0xFF, 0x00, 0xFF,
  0x1F, 0xE0, 0x1F, 0xE7, 0xFC, 0x03, 0xFC, 0xFF, 0x80, 0x7F, 0x9F, 0xE0,
  0x0F, 0xF3, 0xFC, 0x03, 0xFE, 0x7F, 0x80, 0x7F, 0xDF, 0xF0, 0x0F, 0xF3,
  0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xCF, 0xF0, 0x0F, 0xF9, 0xFE, 0x01,
  0xFF, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x07, 0xF9, 0xFE, 0x01, 0xFF, 0x3F,
  0xC0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF8, 0xFF, 0x01, 0xFF, 0x1F, 0xE0, 0x3F,
  0xC3, 0xFC, 0x0F, 0xF8, 0x3F, 0xC3, 0xFE, 0x07, 0xF8, 0x7F, 0xC0, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFF, 0xBF, 0x8F, 0xFB, 0xFC,
  0x3F, 0x9F, 0xE0, 0xF0, 0xFF, 0x07, 0x07, 0xF8, 0x10, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xC3, 0xFF, 0x00, 0x7E, 0x07, 0xFC, 0x01, 0xE0, 0x0F, 0xF0,
  0x03, 0x00, 0x3F, 0xC0, 0x08, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0x03, 0xFF,
  0x00, 0x60, 0x0F, 0xF8, 0x02, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE1, 0x00, 0x03, 0xFE, 0x0E, 0x00, 0x7F, 0xF0, 0x7F, 0x1F, 0xFF,
  0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3F, 0x7F, 0x80, 0x00, 0xFD, 0xFE, 0x00,
  0x07, 0xE7, 0xF8, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0xFC, 0xFF, 0x00, 0x07,
  0xE3, 0xFC, 0x00, 0x3F, 0x0F, 0xF0, 0x01, 0xFC, 0x3F, 0xC0, 0x07, 0xE0,
  0xFE, 0x00, 0x3F, 0x07, 0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x07, 0xE0, 0x7F,
  0x80, 0x3F, 0x01, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0,
  0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00,
  0x7C, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x20, 0x00, 0x7F, 0xC1, 0x80, 0x07, 0xFE, 0x0F, 0x00,
  0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x2D, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFC, 0x02,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC7, 0xF8, 0x03, 0xFC, 0xFF, 0xC0, 0x3F,
  0xDF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0xFF, 0xC0, 0xFF, 0x8F,
  0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x0F, 0xF8, 0xFF, 0x00,
  0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0,
  0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0,
  0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x07, 0xFC, 0x7F, 0xE0, 0x3F, 0xC1, 0xFF,
  0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x07,
  0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xF0,
  0x3F, 0xC0, 0x7F, 0xC3, 0xFC, 0x01, 0xFF, 0x7F, 0xE0, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xEF, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF,
  0x03, 0xFC, 0x07, 0xF8, 0x3F, 0xE0, 0x3F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F,
  0xF0, 0x07, 0xF8, 0xFF, 0x80, 0x3F, 0xC7, 0xFC, 0x01, 0xFE, 0x3F, 0xE0,
  0x1F, 0xE1, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF,
  0x81, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xF8, 0x1F, 0xE1, 0xFF, 0x03,
  0xFC, 0x3F, 0xC0, 0x7F, 0x8F, 0xF8, 0x0F, 0xF1, 0xFE, 0x01, 0xFE, 0x3F,
  0xC0, 0x3F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x3F, 0xE0, 0x3F,
  0xE7, 0xFC, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0x9F, 0xF0, 0x3F, 0xF3, 0xFE,
  0x0F, 0xFC, 0x3F, 0xE3, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFD, 0xFE, 0x01, 0xFE,
  0x3F, 0xC0, 0x06, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x01, 0xF1, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x01, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x81, 0xFE, 0x03, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF,
  0x80, 0xFE, 0x00, 0x60, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xF0, 0x03, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xC0, 0xFF, 0x0C, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x7E, 0x01,
  0xFF, 0xC1, 0xF8, 0x3F, 0x01, 0xFF, 0xF0, 0xFC, 0x3F, 0x03, 0xFF, 0xF8,
  0x7E, 0x1F, 0x83, 0xFF, 0xFC, 0x3F, 0x1F, 0x83, 0xFE, 0xFE, 0x1F, 0x8F,
  0x81, 0xF8, 0x3E, 0x0F, 0xCF, 0xC1, 0xF8, 0x3F, 0x07, 0xE7, 0xE0, 0xFC,
  0x1F, 0x83, 0xF3, 0xE0, 0xFC, 0x0F, 0xC1, 0xFB, 0xF0, 0x7E, 0x07, 0xC0,
  0xF9, 0xF8, 0x7E, 0x07, 0xE0, 0x7C, 0xF8, 0x3F, 0x03, 0xF0, 0x3E, 0x7C,
  0x1F, 0x81, 0xF8, 0x3F, 0x7E, 0x1F, 0x80, 0xFC, 0x1F, 0xBF, 0x0F, 0xC0,
  0xFC, 0x0F, 0x9F, 0x87, 0xE0, 0x7E, 0x0F, 0xCF, 0xC3, 0xF0, 0x3F, 0x07,
  0xC7, 0xC1, 0xF8, 0x3F, 0x87, 0xE3, 0xE0, 0xFC, 0x1F, 0x83, 0xE1, 0xF0,
  0x7E, 0x1F, 0xE3, 0xF0, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7C, 0x0F, 0xFE,
  0xFF, 0xF0, 0x3F, 0x07, 0xFF, 0x7F, 0xF0, 0x1F, 0x81, 0xFF, 0x1F, 0xF0,
  0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0C, 0x00,
  0x03, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFE,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF8, 0xFE,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0x80, 0xFE,
  0x00, 0x7F, 0x80, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xF8, 0x01, 0xFE,
  0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFF,
  0x1F, 0xF0, 0x01, 0xFF, 0x1F, 0xE0, 0x01, 0xFF, 0x3F, 0xE0, 0x01, 0xFF,
  0x3F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x07, 0xFF,
  0x00, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xFC,
  0x03, 0xFC, 0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xE0, 0x0F, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xF0, 0x3F, 0xC0, 0x1F, 0xF0,
  0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x7C, 0x03, 0xFF, 0x00, 0x60, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x01, 0x00, 0xFF, 0xE0, 0x3C, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0x03, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x07,
  0xF8, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x1F, 0xF0,
  0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xE0, 0x03, 0xFE,
  0x0F, 0xF0, 0x01, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xC0, 0x1F,
  0xF8, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFC, 0x1F, 0xFE, 0x03, 0xFC, 0x7F, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xC1, 0xFC, 0x03, 0xFF, 0x80, 0x1C, 0x03, 0xFF,
  0x80, 0x02, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xFF, 0x87, 0xFC, 0x0F, 0xFF, 0xC7,
  0xFC, 0x07, 0xFF, 0xE3, 0xFE, 0x03, 0xFF, 0xF1, 0xFF, 0x01, 0xFF, 0xF0,
  0xFF, 0x81, 0xFF, 0xF8, 0x7F, 0xC0, 0xFF, 0xFC, 0x3F, 0xE0, 0x7F, 0xFE,
  0x1F, 0xE0, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F,
  0xF0, 0x7F, 0xC0, 0x0F, 0xF0, 0x3F, 0xE0, 0x07, 0xF8, 0x1F, 0xF8, 0x03,
  0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x0C, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x1F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x7F,
  0xC0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF,
  0x03, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xC3, 0xFE, 0x00,
  0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x00, 0xFF, 0x1F,
  0xF0, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x03,
  0xFC, 0xFF, 0x80, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x80,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x7F,
  0x80, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0xFF, 0x80, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x3F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x1F,
  0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x01,
  0xFD, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07,
  0xEF, 0xF0, 0x07, 0xF7, 0xF0, 0x1F, 0xDF, 0xE0, 0x0F, 0xEF, 0xE0, 0x3F,
  0xBF, 0x80, 0x1F, 0xCF, 0xC0, 0xFE, 0xFF, 0x00, 0x7F, 0x9F, 0x81, 0xFD,
  0xFE, 0x00, 0xFF, 0x3F, 0x07, 0xF3, 0xFC, 0x01, 0xFC, 0x7E, 0x0F, 0xE7,
  0xF8, 0x03, 0xF8, 0xFC, 0x3F, 0x8F, 0xE0, 0x0F, 0xF1, 0xF8, 0x7F, 0x3F,
  0xC0, 0x1F, 0xE3, 0xF1, 0xFC, 0x7F, 0x80, 0x3F, 0xC7, 0xE3, 0xF8, 0xFF,
  0x00, 0x7F, 0x0F, 0xCF, 0xE1, 0xFE, 0x00, 0xFE, 0x1F, 0x9F, 0xC3, 0xF8,
  0x03, 0xFC, 0x3F, 0x3F, 0x0F, 0xF0, 0x07, 0xF8, 0x7E, 0xFE, 0x1F, 0xE0,
  0x0F, 0xF0, 0xFF, 0xF8, 0x3F, 0xC0, 0x1F, 0xC1, 0xFF, 0xF0, 0x7F, 0x00,
  0x3F, 0x83, 0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0x07, 0xFF, 0x83, 0xFC, 0x01,
  0xFE, 0x0F, 0xFF, 0x07, 0xF8, 0x03, 0xF8, 0x1F, 0xFC, 0x0F, 0xF0, 0x07,
  0xF0, 0x3F, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0xE0, 0x7F, 0x80, 0x3F,
  0xC0, 0xFF, 0xC0, 0xFF, 0x00, 0x7F, 0x81, 0xFF, 0x01, 0xFE, 0x00, 0xFE,
  0x03, 0xFE, 0x03, 0xFC, 0x01, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0xFF,
  0xC0, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x03, 0xFF, 0x00, 0x0F,
  0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0x80, 0x3F,
  0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0xF8, 0x03,
  0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xE0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xFF, 0x80,
  0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFC, 0x01, 0xFE, 0xFE, 0x07, 0xF8, 0x03,
  0xF9, 0xFC, 0x0F, 0xF0, 0x07, 0xF3, 0xFC, 0x1F, 0xE0, 0x0F, 0xE7, 0xF8,
  0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x7F, 0x00, 0x7F, 0x8F, 0xE1, 0xFE, 0x00,
  0xFF, 0x1F, 0xC3, 0xFC, 0x01, 0xFC, 0x3F, 0xC7, 0xF8, 0x03, 0xF8, 0x7F,
  0x8F, 0xE0, 0x0F, 0xF0, 0x7F, 0x1F, 0xC0, 0x1F, 0xE0, 0xFE, 0x7F, 0x80,
  0x3F, 0xC1, 0xFE, 0xFF, 0x00, 0x7F, 0x03, 0xFD, 0xFE, 0x00, 0xFE, 0x03,
  0xFB, 0xF8, 0x03, 0xFC, 0x07, 0xF7, 0xF0, 0x07, 0xF8, 0x0F, 0xEF, 0xE0,
  0x0F, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0x80,
  0x3F, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xF8,
  0x03, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xE0,
  0x03, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xFE,
  0x00, 0xFE, 0x00, 0x1F, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x07, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x0F,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x83, 0xFF, 0x00,
  0x3F, 0xC1, 0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x80,
  0x07, 0xFC, 0xFF, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0x3F, 0xE0,
  0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x3F, 0xEF, 0xF8,
  0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x0F, 0xFB, 0xFE,
  0x00, 0x07, 0xFD, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0x7F,
  0xC0, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x7F, 0xCF,
  0xF0, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x1F, 0xF1,
  0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xC0, 0x0F, 0xF8,
  0x3F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE,
  0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x01, 0xFF, 0x00,
  0x7F, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC,
  0x07, 0xFC, 0x01, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xC1, 0xFF, 0x00,
  0x1F, 0xF1, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80,
  0x03, 0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0xBF, 0xE0,
  0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x1F, 0xE7, 0xFC,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x07, 0xFD, 0xFF,
  0x00, 0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x3F,
  0xE0, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x7F, 0xC7,
  0xF8, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xFC,
  0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F,
  0x87, 0xFF, 0x00, 0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x07, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x03,
  0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F,
  0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0xFF, 0x03, 0xFE, 0x01, 0xFE,
  0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0,
  0x1F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xE0, 0xFF, 0x00,
  0x7F, 0xC1, 0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFB, 0xF8, 0x03, 0xFF, 0x00, 0xE0, 0x0F, 0xF8, 0x01, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x04, 0x00, 0x1F, 0xF0, 0x38, 0x00, 0xFF,
  0x80, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x7F, 0x81, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x1F,
  0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xFE, 0x07, 0xF8, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF0,
  0x3F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xFE,
  0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F,
  0xF0, 0x7F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x07,
  0xFC, 0x0F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x07, 0xFC, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xE0, 0x3F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0x40, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x00, 0x07, 0xFD,
  0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x7F, 0x8F,
  0xF0, 0x01, 0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF8, 0x7F,
  0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x03, 0xFC,
  0x01, 0xFE, 0x07, 0xF8, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x03,
  0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F,
  0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x7F, 0x8F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFE, 0x7F, 0x80,
  0x03, 0xFC, 0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x07, 0xF7, 0xF8, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x7E, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xFB, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF7, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0x9F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFC,
  0x7F, 0x80, 0x3F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xE1,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xC3, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0x87,
  0xF8, 0x0F, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xFE, 0x03, 0xFC, 0x1F,
  0xE0, 0x3F, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F,
  0x81, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0x01, 0xFE,
  0x0F, 0xFF, 0xC1, 0xFE, 0x03, 0xFC, 0x1F, 0xBF, 0x87, 0xF8, 0x07, 0xF8,
  0x7F, 0x7F, 0x0F, 0xF0, 0x0F, 0xF0, 0xFE, 0xFE, 0x1F, 0xE0, 0x1F, 0xE3,
  0xF9, 0xFC, 0x7F, 0x80, 0x3F, 0xC7, 0xF3, 0xF8, 0xFF, 0x00, 0x7F, 0x8F,
  0xC7, 0xF3, 0xFC, 0x00, 0xFF, 0x3F, 0x8F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F,
  0x1F, 0xCF, 0xF0, 0x03, 0xFD, 0xFC, 0x3F, 0xBF, 0xC0, 0x07, 0xF3, 0xF8,
  0x7E, 0x7F, 0x80, 0x0F, 0xE7, 0xE0, 0xFC, 0xFE, 0x00, 0x1F, 0xDF, 0xC1,
  0xFB, 0xFC, 0x00, 0x3F, 0xBF, 0x83, 0xF7, 0xF8, 0x00, 0x7F, 0xFE, 0x07,
  0xEF, 0xE0, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0,
  0x01, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xF0,
  0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x03, 0xFE, 0x00,
  0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0xE3,
  0xFE, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00,
  0x07, 0xFB, 0xFE, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x7F, 0x80,
  0x00, 0x07, 0xFD, 0xFE, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0xFF,
  0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x00, 0xFF, 0x83, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xFB, 0xFC,
  0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xFC, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x03,
  0xFE, 0x3F, 0xC0, 0x3F, 0xE1, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0x7F,
  0x87, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0x9F,
  0xE0, 0x03, 0xFD, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x04,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0xFE, 0x07, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x7F, 0x3F, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC1, 0xF8, 0x01, 0xFC,
  0x1F, 0x80, 0x3F, 0x81, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC,
  0x0F, 0xE0, 0x0F, 0xC0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8,
  0x00, 0x7E, 0x3F, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xF0, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x8F, 0xF8, 0x7F, 0x87, 0xFC, 0x3F, 0xC1, 0xFC, 0x1F, 0xE0, 0xFE,
  0x07, 0xE0, 0x7F, 0x00, 0x1F, 0x00, 0x08, 0x03, 0xFE, 0x3F, 0x80, 0x7F,
  0xF9, 0xFC, 0x07, 0xFF, 0xCF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0x9F, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0,
  0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0x87, 0xFC,
  0x03, 0xFC, 0x3F, 0xE0, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x0F,
  0xF0, 0xFF, 0x80, 0x7F, 0x87, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1,
  0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x83, 0xFC,
  0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF, 0x01, 0xFF, 0x07, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE1, 0xFF, 0x81, 0xFF, 0xBF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xF7, 0xF0, 0x0F, 0xFF, 0x3F, 0x80, 0x3F,
  0xF1, 0xFC, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE1, 0xF0, 0x00, 0xFF, 0x3F,
  0xE0, 0x07, 0xFB, 0xFF, 0x80, 0x7F, 0xBF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x1F, 0xF0, 0x7F,
  0xE0, 0xFF, 0x83, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00,
  0xFF, 0x07, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFE,
  0x1F, 0xE0, 0x1F, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x7F,
  0x80, 0x3F, 0xC3, 0xFC, 0x03, 0xFE, 0x1F, 0xE0, 0x1F, 0xF0, 0xFF, 0x00,
  0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE, 0x03, 0xFC,
  0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xFE, 0x3F, 0xF0, 0x7F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFC, 0xFF,
  0xF8, 0x0F, 0xE3, 0xFF, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFC,
  0x18, 0x1F, 0xF8, 0x08, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x20, 0xFF, 0x80, 0xC0, 0xFF, 0xE7,
  0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xF0, 0x7F,
  0x80, 0x0F, 0xF9, 0xFE, 0x00, 0x7F, 0xFB, 0xFC, 0x01, 0xFF, 0xF7, 0xF8,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80,
  0x7F, 0xC3, 0xFF, 0x01, 0xFF, 0x07, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x0F,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF,
  0x80, 0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFC, 0x0F, 0xF8,
  0x07, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80,
  0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03,
  0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x3F, 0xC0, 0xFF, 0x80, 0x7F, 0xC3, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFB, 0xF0, 0x03, 0xFF, 0xEF, 0xE0,
  0x03, 0xFF, 0x9F, 0xC0, 0x03, 0xFE, 0x3F, 0x80, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xF1, 0xFE, 0x1F,
  0xE0, 0x7F, 0x1F, 0xE0, 0x3F, 0x8F, 0xF0, 0x1F, 0xCF, 0xF0, 0x0F, 0xE7,
  0xF8, 0x0F, 0xF7, 0xF8, 0x0F, 0xFB, 0xFC, 0x0F, 0xF9, 0xFE, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x04, 0x1F, 0xF0, 0x0E, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x88,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x40, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x01, 0x00,
  0x0F, 0xF8, 0xFE, 0x00, 0x3F, 0xFC, 0xFE, 0x00, 0x7F, 0xFC, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0x0F, 0xFC, 0x03, 0xFE, 0x0F, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x07,
  0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x0F,
  0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x7F, 0xE0, 0x1F,
  0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0x7F, 0x80, 0x07, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x00,
  0x40, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x80, 0x03, 0xFE, 0x00, 0xE0,
  0x03, 0xFE, 0x00, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE1, 0xF0, 0x00, 0xFF,
  0x3F, 0xE0, 0x07, 0xF3, 0xFF, 0x80, 0x7F, 0xBF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF,
  0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0xC0, 0x7F, 0x83, 0xFC, 0x03,
  0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0,
  0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF,
  0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x03,
  0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0,
  0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF,
  0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x07, 0xF8, 0x01, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x33, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0x01, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x07,
  0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x1F,
  0xF0, 0x03, 0xFC, 0x3F, 0xE0, 0x03, 0xF8, 0x7F, 0xC0, 0x07, 0xF8, 0x7F,
  0x80, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x07, 0xF3, 0xFE,
  0x00, 0x07, 0xF7, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x3F, 0x81, 0xFE,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x7F, 0x81, 0xFF,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x80, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3F, 0x0F, 0xF8, 0x1F, 0xF0,
  0x07, 0xE7, 0xFF, 0x8F, 0xFF, 0x01, 0xFD, 0xFF, 0xF3, 0xFF, 0xF0, 0x3F,
  0xBF, 0xFF, 0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0xFF, 0xF1, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xE0, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0x83, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x1F,
  0xE0, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC,
  0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x00, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC1, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0xFE, 0x01, 0xFE,
  0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0x0F,
  0xE0, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x83,
  0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xC3, 0xFE, 0x00,
  0x7E, 0x3F, 0xF8, 0x03, 0xF3, 0xFF, 0xE0, 0x3F, 0xBF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xE1, 0xFF, 0x07, 0xFE, 0x0F,
  0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0,
  0x7F, 0x80, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE,
  0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x07,
  0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0,
  0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE,
  0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x07,
  0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0,
  0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xE3, 0xFE, 0x1F, 0xF0,
  0x7F, 0xCF, 0xF8, 0x0F, 0xF3, 0xFE, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x7F,
  0xC0, 0x3F, 0xDF, 0xE0, 0x0F, 0xF7, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xFB, 0xFC, 0x01,
  0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x3F, 0xEF, 0xF0, 0x0F, 0xF3, 0xFC,
  0x03, 0xFC, 0xFF, 0x01, 0xFF, 0x3F, 0xC0, 0xFF, 0x8F, 0xF8, 0x3F, 0xE3,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x0F, 0xF8, 0x00, 0x3F,
  0x1F, 0xFC, 0x00, 0x3F, 0x3F, 0xFC, 0x00, 0x7F, 0x7F, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0xFF,
  0xC1, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFC,
  0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFC,
  0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC,
  0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x0F, 0xF8, 0x07, 0xFC,
  0x1F, 0xF0, 0x0F, 0xFE, 0x3F, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xEF, 0xFF, 0xC0, 0x0F, 0xEF, 0xFF, 0x80, 0x1F, 0xE7,
  0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x1F, 0xE0, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x08, 0x03, 0xFE,
  0x1F, 0x80, 0x3F, 0xF9, 0xFC, 0x03, 0xFF, 0xEF, 0xE0, 0x3F, 0xFF, 0x7F,
  0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0x0F, 0xFC, 0x1F,
  0xF0, 0x7F, 0xE0, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0x7F, 0x80,
  0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0xFF,
  0x0F, 0xF0, 0x07, 0xF0, 0xFF, 0x80, 0x3F, 0x87, 0xF8, 0x03, 0xFC, 0x3F,
  0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x80,
  0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x01, 0xFF,
  0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x81, 0xFF, 0x9F, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xF7, 0xF0, 0x0F, 0xFF,
  0x7F, 0x80, 0x3F, 0xF3, 0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xC1, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x04, 0x1F, 0x01, 0xF8, 0x7F, 0x01, 0xF8,
  0xFF, 0x03, 0xF9, 0xFE, 0x03, 0xFB, 0xFE, 0x03, 0xFB, 0xFE, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xF8, 0x1C, 0x0F, 0xF0,
  0x04, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x80, 0x0F, 0xF8, 0xC0, 0x1F, 0xF0, 0xF8, 0x3F, 0xF0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC,
  0x00, 0x7F, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x40, 0xFF, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x03,
  0x00, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x0F, 0xF0, 0x0F,
  0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x1F,
  0xE0, 0x1F, 0xE1, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xC1, 0xFE, 0x03,
  0xFC, 0x1F, 0xC0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3,
  0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0x83, 0xF8, 0x07, 0xF8, 0x7F, 0x80,
  0x7F, 0x87, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0,
  0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0,
  0x1F, 0xE0, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x7F, 0xE0, 0xFF, 0x8F, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xDF, 0xC0, 0x7F,
  0xFD, 0xFC, 0x03, 0xFF, 0x9F, 0xC0, 0x1F, 0xE1, 0xF8, 0x00, 0x78, 0x00,
  0x00, 0xFF, 0x00, 0x3F, 0xEF, 0xE0, 0x07, 0xF9, 0xFC, 0x01, 0xFE, 0x3F,
  0x80, 0x3F, 0xC7, 0xF0, 0x0F, 0xF0, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x7F,
  0x83, 0xF8, 0x0F, 0xF0, 0x7F, 0x01, 0xFE, 0x0F, 0xE0, 0x7F, 0x81, 0xFC,
  0x0F, 0xF0, 0x3F, 0x83, 0xFC, 0x07, 0xF0, 0x7F, 0x80, 0xFE, 0x1F, 0xE0,
  0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x00, 0x7F, 0x9F, 0xE0, 0x0F, 0xF3,
  0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x7E, 0xFE, 0x00, 0x0F, 0xDF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0x01, 0xFE, 0xFE, 0x03, 0xFF, 0x01, 0xFE, 0xFE, 0x03, 0xFF, 0x03,
  0xFC, 0xFE, 0x07, 0xFF, 0x03, 0xFC, 0xFE, 0x07, 0xFF, 0x03, 0xF8, 0xFE,
  0x07, 0xFF, 0x07, 0xF8, 0xFE, 0x0F, 0xFF, 0x07, 0xF0, 0xFE, 0x0F, 0xFF,
  0x0F, 0xF0, 0xFE, 0x1F, 0xBF, 0x0F, 0xF0, 0xFE, 0x1F, 0xBF, 0x0F, 0xE0,
  0xFE, 0x1F, 0xBF, 0x1F, 0xE0, 0xFE, 0x3F, 0x3F, 0x1F, 0xC0, 0xFE, 0x3F,
  0x7F, 0x3F, 0xC0, 0xFE, 0x7F, 0x7F, 0x3F, 0xC0, 0xFE, 0x7E, 0x7F, 0x3F,
  0x80, 0xFE, 0x7E, 0x7E, 0x7F, 0x80, 0xFE, 0xFC, 0x7E, 0x7F, 0x00, 0xFE,
  0xFC, 0x7E, 0x7F, 0x00, 0xFE, 0xFC, 0x7E, 0xFE, 0x00, 0xFF, 0xF8, 0x7E,
  0xFE, 0x00, 0xFF, 0xF8, 0x7E, 0xFE, 0x00, 0xFF, 0xF8, 0x7F, 0xFC, 0x00,
  0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0xFF, 0xE0,
  0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0,
  0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xFF,
  0x80, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x3F,
  0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0xC0, 0x03,
  0xFC, 0x7F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x3F, 0xC0, 0x00,
  0x3F, 0xDF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x03, 0xFD, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0x7F,
  0x80, 0x03, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x07,
  0xF8, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xC3, 0xFC, 0x00,
  0x03, 0xF8, 0x7F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x0F, 0xE3, 0xFC,
  0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x43, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x05, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x02, 0x7F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x20, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x4F, 0xFC, 0x00, 0x17, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xA0, 0x00, 0xFF, 0x88, 0x00, 0x00, 0x00,
};

const GFXglyph NotoSans_Condensed_BoldItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 18, 45, 16, 0, -44 },
  { 103, 22, 16, 25, 6, -44 },
  { 147, 34, 44, 32, 0, -44 },
  { 334, 29, 50, 28, 0, -46 },
  { 516, 41, 45, 46, 3, -44 },
  { 747, 35, 45, 35, 0, -44 },
  { 944, 10, 16, 15, 6, -44 },
  { 964, 21, 54, 18, 1, -44 },
  { 1106, 22, 54, 18, -5, -44 },
  { 1255, 24, 27, 28, 5, -47 },
  { 1336, 26, 29, 30, 3, -36 },
  { 1431, 14, 16, 15, -3, -8 },
  { 1459, 16, 7, 18, 1, -20 },
  { 1473, 10, 10, 15, 0, -9 },
  { 1486, 32, 44, 24, -3, -44 },
  { 1662, 27, 45, 28, 1, -44 },
  { 1814, 21, 44, 29, 6, -44 },
  { 1930, 30, 44, 28, -2, -44 },
  { 2095, 29, 45, 28, 0, -44 },
  { 2259, 30, 44, 29, -1, -44 },
  { 2424, 29, 45, 28, 0, -44 },
  { 2588, 28, 45, 28, 2, -44 },
  { 2746, 30, 44, 28, 2, -44 },
  { 2911, 29, 45, 28, 0, -44 },
  { 3075, 27, 45, 28, 1, -44 },
  { 3227, 15, 35, 16, 0, -34 },
  { 3293, 18, 42, 16, -3, -34 },
  { 3388, 26, 30, 30, 3, -37 },
  { 3486, 26, 19, 30, 3, -31 },
  { 3548, 26, 30, 30, 3, -37 },
  { 3646, 23, 45, 23, 2, -44 },
  { 3776, 41, 49, 43, 2, -44 },
  { 4028, 32, 44, 32, -4, -44 },
  { 4204, 32, 44, 32, 0, -44 },
  { 4380, 30, 45, 30, 3, -44 },
  { 4549, 33, 44, 34, 0, -44 },
  { 4731, 30, 44, 27, 0, -44 },
  { 4896, 30, 44, 26, 0, -44 },
  { 5061, 33, 45, 35, 3, -44 },
  { 5247, 37, 44, 36, 0, -44 },
  { 5451, 27, 44, 21, -2, -44 },
  { 5600, 27, 57, 17, -9, -44 },
  { 5793, 37, 44, 31, 0, -44 },
  { 5997, 22, 44, 26, 0, -44 },
  { 6118, 47, 44, 46, 0, -44 },
  { 6377, 39, 44, 38, 0, -44 },
  { 6592, 33, 45, 37, 3, -44 },
  { 6778, 33, 44, 31, 0, -44 },
  { 6960, 33, 54, 37, 3, -44 },
  { 7183, 31, 44, 31, 0, -44 },
  { 7354, 30, 45, 27, 0, -44 },
  { 7523, 26, 44, 27, 5, -44 },
  { 7666, 33, 45, 35, 3, -44 },
  { 7852, 31, 44, 31, 5, -44 },
  { 8023, 47, 44, 46, 5, -44 },
  { 8282, 38, 44, 30, -4, -44 },
  { 8491, 29, 44, 28, 5, -44 },
  { 8651, 32, 44, 26, -2, -44 },
  { 8827, 25, 54, 18, -2, -44 },
  { 8996, 13, 44, 24, 6, -44 },
  { 9068, 24, 54, 18, -4, -44 },
  { 9230, 28, 27, 29, 0, -44 },
  { 9325, 22, 4, 21, -6, 5 },
  { 9336, 12, 10, 19, 9, -47 },
  { 9351, 29, 35, 31, 2, -34 },
  { 9478, 29, 47, 31, 0, -46 },
  { 9649, 24, 35, 25, 2, -34 },
  { 9754, 31, 47, 31, 2, -46 },
  { 9937, 25, 35, 28, 2, -34 },
  { 10047, 33, 62, 19, -7, -47 },
  { 10303, 32, 49, 31, -1, -34 },
  { 10499, 29, 46, 31, 0, -46 },
  { 10666, 18, 46, 15, 0, -46 },
  { 10770, 26, 61, 15, -8, -46 },
  { 10969, 32, 46, 29, 0, -46 },
  { 11153, 18, 46, 15, 0, -46 },
  { 11257, 43, 34, 45, 0, -34 },
  { 11440, 29, 34, 31, 0, -34 },
  { 11564, 26, 35, 30, 2, -34 },
  { 11678, 32, 49, 31, -3, -34 },
  { 11874, 29, 49, 31, 2, -34 },
  { 12052, 24, 34, 21, 0, -34 },
  { 12154, 24, 35, 24, 0, -34 },
  { 12259, 20, 41, 20, 2, -40 },
  { 12362, 28, 34, 30, 2, -33 },
  { 12481, 27, 33, 26, 3, -33 },
  { 12593, 40, 33, 41, 4, -33 },
  { 12758, 33, 33, 27, -3, -33 },
  { 12895, 35, 48, 27, -5, -33 },
  { 13105, 27, 33, 23, -2, -33 },
  { 13217, 25, 54, 21, 0, -44 },
  { 13386, 7, 61, 26, 9, -47 },
  { 13440, 23, 54, 21, -3, -44 },
  { 13596, 26, 11, 30, 3, -27 },
};

const GFXfont NotoSans_Condensed_BoldItalic61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic61pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC61PT7B_H_
