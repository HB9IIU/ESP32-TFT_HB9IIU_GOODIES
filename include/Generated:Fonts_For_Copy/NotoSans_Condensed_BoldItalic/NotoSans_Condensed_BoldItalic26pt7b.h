#ifndef _NOTOSANS_CONDENSED_BOLDITALIC26PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x3C, 0x3C, 0x38, 0x38,
  0x38, 0x38, 0x00, 0x00, 0x70, 0xF0, 0xF0, 0xF0, 0x7B, 0xDE, 0xE7, 0x39,
  0xCE, 0x73, 0x98, 0xCE, 0x70, 0x03, 0x9C, 0x0E, 0x60, 0x33, 0x80, 0xCE,
  0x07, 0x30, 0x18, 0xC3, 0xFF, 0xCF, 0xFF, 0x0E, 0x60, 0x33, 0x81, 0xCE,
  0x3F, 0xFE, 0xFF, 0xFB, 0xFF, 0xC3, 0x98, 0x0C, 0xE0, 0x33, 0x81, 0xCC,
  0x07, 0x70, 0x00, 0x00, 0x80, 0x04, 0x00, 0xF8, 0x1F, 0xF1, 0xFF, 0x0E,
  0xB0, 0xF4, 0x07, 0xA0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E,
  0x03, 0xF2, 0x13, 0x8C, 0xBC, 0xFF, 0xC7, 0xFC, 0x0F, 0xC0, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x0E, 0x07, 0x07, 0xC1, 0x83, 0xF0, 0xE1, 0xCC, 0x70,
  0x73, 0x18, 0x19, 0xCE, 0x0E, 0x73, 0x03, 0x9D, 0xC0, 0xE6, 0xEF, 0xBF,
  0xB3, 0xE7, 0xDD, 0xDC, 0xE6, 0x67, 0x03, 0xB9, 0xC1, 0xCE, 0x60, 0x63,
  0x98, 0x38, 0xCE, 0x0C, 0x3B, 0x07, 0x0F, 0xC3, 0x81, 0xE0, 0x01, 0xC0,
  0x0F, 0xE0, 0x3F, 0xC0, 0x73, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0xB8, 0x07,
  0xF0, 0x0F, 0x80, 0x3E, 0x3C, 0xFE, 0x73, 0xDD, 0xE7, 0x3F, 0x9E, 0x3F,
  0x3C, 0x7C, 0x78, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0, 0xFD, 0xE0, 0xFF, 0xEE,
  0xEE, 0xC0, 0x07, 0x83, 0x83, 0x83, 0x81, 0xC1, 0xC0, 0xE0, 0xF0, 0x70,
  0x38, 0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x01, 0xC0, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x0F,
  0x07, 0x07, 0x83, 0x83, 0x83, 0xC0, 0x07, 0x00, 0xC1, 0x38, 0x37, 0x0F,
  0xFC, 0xFF, 0xC7, 0xF9, 0xF8, 0x7F, 0x0E, 0x70, 0x8C, 0x00, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0x3D, 0xE7, 0x9C, 0xF3, 0x80, 0x7E, 0xFD, 0xFF, 0xF0,
  0x7F, 0xFF, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0x07, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E,
  0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x00, 0x07, 0x81, 0xF8,
  0x7F, 0x9E, 0xF3, 0x8E, 0xF1, 0xDC, 0x3B, 0x87, 0xF1, 0xFE, 0x3F, 0x87,
  0xF0, 0xEE, 0x3D, 0xC7, 0xB8, 0xE7, 0x3C, 0xFF, 0x1F, 0xC1, 0xF0, 0x00,
  0x03, 0x83, 0xC3, 0xE3, 0xF7, 0xFF, 0xB9, 0x9C, 0x9E, 0x0F, 0x07, 0x03,
  0x81, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x1E, 0x0F, 0x00, 0x01, 0xE0,
  0x3F, 0x87, 0xFE, 0x1C, 0xF0, 0xC7, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00,
  0x7F, 0xE7, 0xFF, 0x3F, 0xF0, 0x07, 0xC1, 0xFE, 0x1F, 0xF0, 0xCF, 0x00,
  0x70, 0x07, 0x00, 0xF0, 0x1E, 0x0F, 0xC0, 0xF0, 0x1F, 0xC0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE8, 0x3C, 0xFF, 0xCF, 0xF8, 0xFE, 0x00, 0x00, 0x70,
  0x0F, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x7E, 0x0E, 0xE0, 0xDE, 0x1D, 0xE3,
  0x9C, 0x31, 0xC7, 0x1C, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0x38, 0x03, 0x80,
  0x78, 0x07, 0x00, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFF, 0x1C, 0x01, 0xC0,
  0x1C, 0x03, 0xF0, 0x3F, 0xC3, 0xFE, 0x13, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xC8, 0x3C, 0xFF, 0xCF, 0xF8, 0xFE, 0x00, 0x01, 0xF0, 0x7F, 0x0F,
  0xE1, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x78, 0x7F, 0xCF, 0xFC, 0xF1,
  0xCF, 0x1C, 0xE1, 0xCE, 0x1C, 0xE3, 0xCE, 0x38, 0xFF, 0x87, 0xF0, 0x3E,
  0x00, 0x3F, 0xF3, 0xFF, 0x3F, 0xF7, 0xFF, 0x00, 0xE0, 0x1E, 0x01, 0xC0,
  0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03,
  0x80, 0x78, 0x07, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0xFF, 0x1F, 0xF1, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0xF1, 0xFE, 0x0F, 0xC0, 0xF8, 0x3F, 0xC7, 0x9C,
  0x71, 0xEF, 0x0E, 0xF0, 0xEF, 0x1E, 0xFF, 0xC7, 0xF8, 0x3F, 0x00, 0x03,
  0xC0, 0xFE, 0x1F, 0xF1, 0xEF, 0x3C, 0xF3, 0x87, 0x38, 0xF7, 0x8F, 0x78,
  0xF3, 0xFF, 0x3F, 0xE3, 0xEE, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0xFF,
  0x8F, 0xF0, 0xFC, 0x00, 0x1C, 0x7C, 0xF0, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC7, 0x8F, 0x1E, 0x00, 0x0E, 0x1F, 0x1E, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x78, 0x70, 0x70, 0xE0, 0xE0, 0x00, 0x20,
  0x0C, 0x07, 0x83, 0xF1, 0xF8, 0xFC, 0x3C, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0x80, 0x70, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x1C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x78, 0x1F, 0x1F, 0xCF, 0xE3, 0xE0, 0x70, 0x08, 0x00, 0x0F, 0x0F, 0xE7,
  0xFC, 0x8F, 0x03, 0xC0, 0xE0, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xE0,
  0x70, 0x00, 0x00, 0x01, 0x80, 0xF0, 0x3C, 0x0E, 0x00, 0x00, 0x78, 0x01,
  0xFF, 0x01, 0xF3, 0xC1, 0xC0, 0x71, 0xC0, 0x39, 0xC7, 0x8C, 0xC7, 0xE6,
  0xE7, 0x73, 0x67, 0x39, 0xF3, 0x18, 0xFB, 0x8C, 0xF9, 0xCE, 0x7C, 0xE7,
  0x36, 0x77, 0xBB, 0x3E, 0xF9, 0x8F, 0x78, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x0C, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3B, 0x80, 0xEE, 0x07, 0x38, 0x1C, 0xF0,
  0xF3, 0xC3, 0xFF, 0x1F, 0xFC, 0x7F, 0xF3, 0xC3, 0xCF, 0x0F, 0x38, 0x3D,
  0xE0, 0xFF, 0x03, 0xC0, 0x0F, 0x80, 0x3F, 0xC0, 0xFF, 0x87, 0x9F, 0x1E,
  0x3C, 0x70, 0xE1, 0xC3, 0x87, 0x1E, 0x3F, 0xF0, 0xFF, 0x03, 0xFE, 0x0E,
  0x3C, 0x38, 0x71, 0xE1, 0xC7, 0x8F, 0x1C, 0x7C, 0x7F, 0xE3, 0xFF, 0x0F,
  0xF0, 0x00, 0x01, 0xE0, 0x3F, 0xC3, 0xFE, 0x3E, 0x63, 0xE0, 0x1E, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1F, 0x08, 0x7F, 0xC3, 0xFE, 0x0F, 0xE0, 0x0F, 0x80, 0x3F,
  0xC0, 0xFF, 0x87, 0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xC3, 0xC7, 0x0F, 0x3C,
  0x3C, 0xF0, 0xF3, 0xC3, 0xCE, 0x0F, 0x38, 0x79, 0xE1, 0xE7, 0x8F, 0x1E,
  0x7C, 0x7F, 0xE3, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0x83, 0xFC,
  0x3F, 0xE1, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3F, 0xE1, 0xFE, 0x0F,
  0xF0, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x7F, 0x87, 0xFC,
  0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xE1, 0xE0, 0x0F, 0x00,
  0x70, 0x03, 0x80, 0x3F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0x80, 0x3C,
  0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x00, 0x01, 0xF0, 0x1F,
  0xF0, 0xFF, 0xC7, 0xC6, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x70,
  0x03, 0xC7, 0xEF, 0x1F, 0xBC, 0x7E, 0xF0, 0x73, 0xC1, 0xCF, 0x0F, 0x3E,
  0x3C, 0x7F, 0xF0, 0xFF, 0x81, 0xFC, 0x00, 0x0F, 0x0F, 0x0E, 0x0F, 0x0E,
  0x0E, 0x1E, 0x0E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1E, 0x1C, 0x1C, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x38, 0x38, 0x38, 0x38, 0x78, 0x78, 0x78,
  0x78, 0x78, 0x78, 0x70, 0x70, 0xF0, 0x70, 0xF0, 0xF0, 0x0F, 0xF0, 0xFE,
  0x0F, 0xE0, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3E, 0x0F, 0xF0,
  0xFF, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x0F, 0xE0, 0xFC,
  0x0F, 0xC0, 0x0F, 0x0F, 0x0E, 0x1E, 0x0E, 0x3C, 0x1E, 0x78, 0x1E, 0x78,
  0x1C, 0xF0, 0x1D, 0xE0, 0x1D, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3B, 0xC0, 0x79, 0xC0, 0x79, 0xE0, 0x71, 0xE0, 0x71, 0xE0,
  0xF0, 0xE0, 0xF0, 0xF0, 0x0F, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x70,
  0x38, 0x3C, 0x1E, 0x0F, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x83, 0xF1, 0xF8, 0x3F,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x86, 0xE1, 0xF8, 0xFE, 0x3F, 0x8F,
  0xC3, 0xB9, 0xDC, 0x3B, 0x9D, 0xC3, 0xBB, 0x9C, 0x3B, 0xBB, 0xC7, 0xBF,
  0x38, 0x73, 0xF3, 0x87, 0x3E, 0x38, 0x73, 0xE7, 0x8F, 0x3C, 0x78, 0xE1,
  0xC7, 0x00, 0x0F, 0x07, 0x87, 0x83, 0xC3, 0xC1, 0xC3, 0xF0, 0xE1, 0xF8,
  0x70, 0xFC, 0x78, 0x7E, 0x38, 0x3F, 0x9C, 0x3D, 0xCE, 0x1C, 0xE7, 0x0E,
  0x77, 0x87, 0x3B, 0x83, 0x9F, 0xC3, 0xC7, 0xE1, 0xC3, 0xF0, 0xE1, 0xF8,
  0x70, 0xF8, 0x78, 0x3C, 0x38, 0x1E, 0x00, 0x01, 0xE0, 0x1F, 0xE0, 0xFF,
  0x87, 0xDF, 0x3C, 0x3C, 0xF0, 0xF7, 0x83, 0xDE, 0x0F, 0x70, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7B, 0xC1, 0xEF, 0x0F, 0x3C, 0x7C, 0x7F,
  0xE1, 0xFF, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0xC0, 0xFF, 0x87, 0xFF,
  0x1E, 0x3C, 0x78, 0xF1, 0xC3, 0xC7, 0x0F, 0x3C, 0x78, 0xFF, 0xE3, 0xFF,
  0x0F, 0xF0, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0xE0, 0xFF, 0x87, 0xDF, 0x3C, 0x3C,
  0xF0, 0xF7, 0x83, 0xDE, 0x0F, 0x70, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x7B, 0xC1, 0xEF, 0x0F, 0x3C, 0x7C, 0x7F, 0xE1, 0xFF, 0x03, 0xF8,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x7F, 0x83,
  0xFE, 0x3D, 0xF1, 0xE3, 0x8E, 0x1C, 0x71, 0xE3, 0x8F, 0x3C, 0xF1, 0xFF,
  0x8F, 0xF8, 0x7F, 0x83, 0xBC, 0x3C, 0xE1, 0xE7, 0x0E, 0x3C, 0x71, 0xE7,
  0x87, 0x3C, 0x3C, 0x03, 0xE0, 0x7F, 0xC7, 0xFC, 0x3E, 0xE3, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x07, 0x80, 0x3C,
  0x00, 0xE0, 0x07, 0x18, 0x78, 0xFF, 0x87, 0xFC, 0x3F, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF1, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0,
  0x00, 0x1E, 0x1E, 0x38, 0x38, 0x70, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x87,
  0x0E, 0x0E, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0xF1, 0xC1, 0xC3, 0x83, 0x8F,
  0x0F, 0x1E, 0x1E, 0x3C, 0x38, 0x78, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0xFC,
  0x00, 0xF0, 0x3F, 0x83, 0xFC, 0x1D, 0xE1, 0xEF, 0x0F, 0x38, 0x71, 0xC7,
  0x8E, 0x38, 0x73, 0xC3, 0x9C, 0x1D, 0xE0, 0xEE, 0x07, 0x70, 0x3F, 0x01,
  0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x70, 0xFF, 0x0F,
  0x0F, 0xF0, 0xF0, 0xEF, 0x1F, 0x1E, 0xF1, 0xF1, 0xCF, 0x1F, 0x1C, 0xF3,
  0xF3, 0xCE, 0x3F, 0x38, 0xE7, 0x77, 0x8E, 0x77, 0x70, 0xE6, 0x67, 0x0E,
  0xE6, 0xF0, 0xEE, 0x6E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7C, 0x0F, 0x87, 0xC0,
  0xF8, 0x7C, 0x0F, 0x87, 0x80, 0xF0, 0x78, 0x00, 0x07, 0x07, 0x83, 0xC7,
  0x81, 0xE3, 0x80, 0xF3, 0xC0, 0x3B, 0xC0, 0x1D, 0xC0, 0x0F, 0xE0, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x7F, 0x80, 0x79, 0xC0, 0x38, 0xE0, 0x3C, 0x78, 0x3C, 0x3C, 0x3E, 0x1E,
  0x00, 0xF0, 0x77, 0x0F, 0x70, 0xE7, 0x1E, 0x71, 0xC7, 0x3C, 0x7F, 0x83,
  0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x78, 0x07, 0x80, 0x70, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x84,
  0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00,
  0x70, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x7F, 0xE3,
  0xFF, 0x0F, 0xFC, 0x00, 0x07, 0xE0, 0xF8, 0x1F, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xF8, 0x3F, 0x00,
  0xE7, 0x39, 0xCE, 0x73, 0xCE, 0x73, 0x9C, 0xE7, 0x38, 0xE7, 0x39, 0xCE,
  0x07, 0xE0, 0xF8, 0x3F, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x0F, 0x01, 0xC1, 0xF8, 0x3F, 0x00, 0x01, 0x80, 0x18, 0x03,
  0xC0, 0x7C, 0x07, 0xC0, 0xEC, 0x1C, 0xE1, 0xCE, 0x38, 0xE7, 0x06, 0x70,
  0x7E, 0x07, 0xFF, 0xFF, 0xC0, 0xF7, 0x9C, 0x70, 0x1F, 0x73, 0xFF, 0x7F,
  0xE7, 0x9E, 0x71, 0xEF, 0x1E, 0xF1, 0xEE, 0x1C, 0xE1, 0xCE, 0x3C, 0xE3,
  0xCF, 0xFC, 0xFF, 0x87, 0xB8, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E,
  0x01, 0xC0, 0x1D, 0xE1, 0xFF, 0x3F, 0xF3, 0xC7, 0x38, 0x73, 0x87, 0x38,
  0x77, 0x8F, 0x78, 0xF7, 0x8E, 0x79, 0xE7, 0xFC, 0xEF, 0xCE, 0xF8, 0x1F,
  0xCF, 0xF3, 0xF9, 0xE0, 0x70, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0F,
  0x13, 0xFC, 0xFF, 0x1F, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x00, 0x38, 0x7D, 0xC7, 0xFE, 0x3F, 0xE3, 0xCF, 0x1C, 0x79, 0xE3,
  0xCF, 0x1E, 0x70, 0xE3, 0x87, 0x1C, 0x38, 0xE3, 0xC7, 0xFE, 0x3F, 0xE0,
  0xF7, 0x00, 0x0F, 0xC7, 0xF8, 0xF7, 0xBC, 0xF7, 0x1D, 0xEF, 0xBF, 0xE7,
  0xF0, 0xE0, 0x1C, 0x03, 0x80, 0x79, 0xC7, 0xF8, 0x7E, 0x00, 0x00, 0x78,
  0x03, 0xF0, 0x1F, 0x80, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x7F, 0x03, 0xFC,
  0x0F, 0xF0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70,
  0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0xB8, 0xFD, 0xC7,
  0xFC, 0x79, 0xE3, 0x8F, 0x3C, 0x79, 0xE3, 0xCE, 0x1C, 0x70, 0xE3, 0x8F,
  0x1C, 0x78, 0xFF, 0xC7, 0xFC, 0x1E, 0xE0, 0x0F, 0x00, 0x78, 0x83, 0x87,
  0xFC, 0x3F, 0xC1, 0xFC, 0x00, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E,
  0x01, 0xC0, 0x1D, 0xE1, 0xFF, 0x3F, 0xF3, 0xC7, 0x3C, 0x73, 0x8F, 0x38,
  0xF7, 0x8E, 0x78, 0xE7, 0x0E, 0x71, 0xE7, 0x1E, 0xF1, 0xCF, 0x1C, 0x06,
  0x0F, 0x0E, 0x0E, 0x00, 0x02, 0x1C, 0x1C, 0x3C, 0x3C, 0x3C, 0x38, 0x38,
  0x78, 0x78, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0x00, 0xC0, 0x3C, 0x07, 0x00,
  0xE0, 0x00, 0x00, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80,
  0x70, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xC0,
  0x38, 0x0F, 0x07, 0xE0, 0xF8, 0x1E, 0x00, 0x0F, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x71, 0xE3, 0x9E, 0x3C, 0xE1, 0xEE, 0x0E,
  0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x0E, 0x70, 0x73, 0xC3, 0x9E,
  0x3C, 0x71, 0xC3, 0xC0, 0x0F, 0x0E, 0x0E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C,
  0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x78, 0x78, 0x70, 0x70, 0x70, 0xF0, 0xF0,
  0x1D, 0xE7, 0xC6, 0xFF, 0xF3, 0xFF, 0xFC, 0xF1, 0xE7, 0x3C, 0xF1, 0xCE,
  0x3C, 0x73, 0x8E, 0x1D, 0xE3, 0x8F, 0x78, 0xE3, 0x9C, 0x78, 0xE7, 0x1E,
  0x39, 0xC7, 0x1E, 0xF1, 0xC7, 0xB8, 0x71, 0xC0, 0x1D, 0xE1, 0xBF, 0x3F,
  0xF3, 0xC7, 0x3C, 0x73, 0x8F, 0x38, 0xF7, 0x8E, 0x78, 0xE7, 0x0E, 0x71,
  0xE7, 0x1E, 0xF1, 0xCF, 0x1C, 0x1F, 0x87, 0xF9, 0xFF, 0xBC, 0xF7, 0x0F,
  0xE3, 0xF8, 0x7F, 0x0F, 0xE1, 0xDC, 0x3B, 0x8F, 0x7F, 0xC7, 0xF0, 0x7C,
  0x00, 0x0E, 0xF0, 0x7F, 0xC7, 0xDE, 0x3C, 0x71, 0xC3, 0x8E, 0x1C, 0x70,
  0xE7, 0x8F, 0x3C, 0x79, 0xE3, 0x8F, 0x3C, 0x7F, 0xC7, 0xFE, 0x3B, 0xE1,
  0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x00, 0x1F, 0x73,
  0xFF, 0x3F, 0xE7, 0x9E, 0x70, 0xEF, 0x1E, 0xF1, 0xEE, 0x1C, 0xE1, 0xCE,
  0x1C, 0xE3, 0xCF, 0xFC, 0xFF, 0x87, 0xB8, 0x07, 0x80, 0x78, 0x07, 0x00,
  0x70, 0x07, 0x00, 0xF0, 0x1D, 0xC7, 0xF3, 0xFC, 0xF8, 0x3C, 0x0E, 0x03,
  0x81, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x00, 0x1F, 0xCF,
  0xF3, 0xC8, 0xE0, 0x38, 0x0F, 0x83, 0xF0, 0x7C, 0x07, 0x81, 0xE8, 0x7B,
  0xFC, 0xFF, 0x3F, 0x80, 0x0C, 0x1C, 0x1C, 0x7F, 0xFF, 0xFF, 0x38, 0x78,
  0x70, 0x70, 0x70, 0xF0, 0xF0, 0xE0, 0xFC, 0xFC, 0x7C, 0x38, 0xF3, 0x8F,
  0x78, 0xE7, 0x8E, 0x70, 0xE7, 0x1E, 0x71, 0xEF, 0x1C, 0xE1, 0xCE, 0x3C,
  0xE3, 0xCF, 0xF8, 0xFF, 0x87, 0xB8, 0xF0, 0xF7, 0x1E, 0x71, 0xC7, 0x1C,
  0x73, 0x87, 0x38, 0x77, 0x07, 0x70, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xC0,
  0x7C, 0x07, 0x80, 0xE3, 0xC7, 0xF1, 0xE3, 0xB9, 0xF3, 0xDC, 0xF9, 0xCE,
  0xFD, 0xE7, 0x7E, 0xE3, 0xB7, 0x71, 0xFB, 0xF0, 0xF9, 0xF8, 0x7C, 0xFC,
  0x3E, 0x7C, 0x1E, 0x3E, 0x0F, 0x1E, 0x07, 0x0F, 0x00, 0x1E, 0x7C, 0x79,
  0xE0, 0xEF, 0x03, 0xB8, 0x0F, 0xC0, 0x3F, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x80, 0x7F, 0x03, 0xDC, 0x1E, 0x70, 0x71, 0xC3, 0xC7, 0x80, 0x0E, 0x1E,
  0x1C, 0x78, 0x38, 0xE0, 0x71, 0xC0, 0xE7, 0x81, 0xCE, 0x03, 0xBC, 0x07,
  0x70, 0x0E, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x00,
  0x1F, 0xE3, 0xFC, 0x7F, 0x81, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0x70, 0x1E,
  0x07, 0x80, 0xE0, 0x3F, 0xCF, 0xF9, 0xFF, 0x00, 0x00, 0x20, 0x7C, 0x1F,
  0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC1, 0xF0, 0x38,
  0x0F, 0x80, 0x70, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x03,
  0xC0, 0x78, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x08, 0x03, 0xC1, 0xF0, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x3C,
  0x0F, 0x03, 0xC0, 0x7C, 0x0E, 0x0F, 0x87, 0xC1, 0xE0, 0x70, 0x1C, 0x0F,
  0x03, 0x80, 0xE0, 0xF8, 0x3C, 0x0E, 0x00, 0x7C, 0x3F, 0xFF, 0xFF, 0xC1,
  0xE0,
};

const GFXglyph NotoSans_Condensed_BoldItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 8, 19, 7, 0, -19 },
  { 20, 10, 7, 11, 2, -19 },
  { 29, 14, 19, 14, 0, -19 },
  { 63, 13, 22, 12, 0, -20 },
  { 99, 18, 19, 20, 1, -19 },
  { 142, 15, 19, 15, 0, -19 },
  { 178, 4, 7, 6, 3, -19 },
  { 182, 9, 23, 8, 1, -19 },
  { 208, 9, 23, 8, -2, -19 },
  { 234, 11, 11, 12, 2, -20 },
  { 250, 11, 12, 13, 1, -15 },
  { 267, 6, 6, 7, -1, -3 },
  { 272, 7, 4, 8, 0, -9 },
  { 276, 4, 4, 7, 0, -4 },
  { 278, 13, 19, 10, -1, -19 },
  { 309, 11, 19, 12, 1, -19 },
  { 336, 9, 19, 12, 2, -19 },
  { 358, 13, 19, 12, -1, -19 },
  { 389, 12, 19, 12, 0, -19 },
  { 418, 12, 19, 12, 0, -19 },
  { 447, 12, 19, 12, 0, -19 },
  { 476, 12, 19, 12, 1, -19 },
  { 505, 12, 19, 12, 1, -19 },
  { 534, 12, 19, 12, 0, -19 },
  { 563, 12, 19, 12, 0, -19 },
  { 592, 7, 14, 7, 0, -14 },
  { 605, 8, 17, 7, -1, -14 },
  { 622, 11, 13, 13, 1, -16 },
  { 640, 11, 8, 13, 1, -13 },
  { 651, 11, 13, 13, 1, -16 },
  { 669, 10, 19, 10, 1, -19 },
  { 693, 17, 21, 18, 1, -19 },
  { 738, 14, 19, 13, -2, -19 },
  { 772, 14, 19, 14, 0, -19 },
  { 806, 13, 19, 13, 1, -19 },
  { 837, 14, 19, 15, 0, -19 },
  { 871, 13, 19, 11, 0, -19 },
  { 902, 13, 19, 11, 0, -19 },
  { 933, 14, 19, 15, 1, -19 },
  { 967, 16, 19, 15, 0, -19 },
  { 1005, 12, 19, 9, -1, -19 },
  { 1034, 12, 24, 7, -4, -19 },
  { 1070, 16, 19, 13, 0, -19 },
  { 1108, 9, 19, 11, 0, -19 },
  { 1130, 20, 19, 20, 0, -19 },
  { 1178, 17, 19, 16, 0, -19 },
  { 1219, 14, 19, 16, 1, -19 },
  { 1253, 14, 19, 13, 0, -19 },
  { 1287, 14, 23, 16, 1, -19 },
  { 1328, 13, 19, 13, 0, -19 },
  { 1359, 13, 19, 12, 0, -19 },
  { 1390, 11, 19, 11, 2, -19 },
  { 1417, 15, 19, 15, 1, -19 },
  { 1453, 13, 19, 13, 2, -19 },
  { 1484, 20, 19, 20, 2, -19 },
  { 1532, 17, 19, 13, -2, -19 },
  { 1573, 12, 19, 12, 2, -19 },
  { 1602, 14, 19, 11, -1, -19 },
  { 1636, 11, 23, 8, -1, -19 },
  { 1668, 5, 19, 10, 3, -19 },
  { 1680, 11, 23, 8, -2, -19 },
  { 1712, 12, 12, 12, 0, -19 },
  { 1730, 9, 2, 9, -2, 2 },
  { 1733, 5, 4, 8, 4, -20 },
  { 1736, 12, 14, 13, 1, -14 },
  { 1757, 12, 20, 13, 0, -20 },
  { 1787, 10, 14, 10, 1, -14 },
  { 1805, 13, 20, 13, 1, -20 },
  { 1838, 11, 14, 12, 1, -14 },
  { 1858, 14, 26, 8, -3, -20 },
  { 1904, 13, 20, 13, 0, -14 },
  { 1937, 12, 20, 13, 0, -20 },
  { 1967, 8, 20, 7, 0, -20 },
  { 1987, 11, 26, 7, -3, -20 },
  { 2023, 13, 20, 12, 0, -20 },
  { 2056, 8, 20, 6, 0, -20 },
  { 2076, 18, 14, 19, 0, -14 },
  { 2108, 12, 14, 13, 0, -14 },
  { 2129, 11, 14, 13, 1, -14 },
  { 2149, 13, 20, 13, -1, -14 },
  { 2182, 12, 20, 13, 1, -14 },
  { 2212, 10, 14, 9, 0, -14 },
  { 2230, 10, 14, 10, 0, -14 },
  { 2248, 8, 17, 9, 1, -17 },
  { 2265, 12, 14, 13, 1, -14 },
  { 2286, 12, 14, 11, 1, -14 },
  { 2307, 17, 14, 17, 2, -14 },
  { 2337, 14, 14, 12, -1, -14 },
  { 2362, 15, 20, 11, -2, -14 },
  { 2400, 11, 14, 10, -1, -14 },
  { 2420, 11, 23, 9, 0, -19 },
  { 2452, 3, 26, 11, 4, -20 },
  { 2462, 10, 23, 9, -1, -19 },
  { 2491, 11, 4, 13, 1, -11 },
};

const GFXfont NotoSans_Condensed_BoldItalic26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic26pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC26PT7B_H_
