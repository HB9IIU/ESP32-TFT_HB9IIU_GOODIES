#ifndef _NOTOSANS_CONDENSED_BOLDITALIC6PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic6pt7bBitmaps[] PROGMEM = {
  0x00, 0x6A, 0xC0, 0x7F, 0xE0, 0x2D, 0x3C, 0xDF, 0x75, 0x6B, 0xF0, 0x80,
  0x6A, 0x80, 0x56, 0x80, 0x5D, 0x80, 0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x6A,
  0x40, 0x76, 0xE0, 0xEA, 0xE5, 0x60, 0xE8, 0xE0, 0x6B, 0xA0, 0x78, 0xE0,
  0x7A, 0xE0, 0x69, 0x40, 0x6A, 0xE0, 0xF5, 0xE0, 0xC8, 0xCA, 0x39, 0x80,
  0xFC, 0x8F, 0x00, 0xDA, 0x7F, 0xF8, 0x60, 0x6F, 0xD0, 0x6E, 0xE0, 0x72,
  0x60, 0x76, 0xE0, 0x6A, 0x60, 0x7A, 0x40, 0x78, 0xAE, 0x56, 0xAA, 0x5B,
  0x29, 0x2C, 0x74, 0xCA, 0x6B, 0x5A, 0xBD, 0xA0, 0x5D, 0xAA, 0x69, 0xAE,
  0x77, 0x40, 0x69, 0xAE, 0x20, 0x77, 0x50, 0x69, 0x60, 0xE9, 0x20, 0x7A,
  0xAE, 0xFA, 0x40, 0xAD, 0x9D, 0xE0, 0x69, 0x50, 0xEA, 0x6A, 0x60, 0x6A,
  0x80, 0xF0, 0x56, 0x80, 0x54, 0xE0, 0x80, 0xF7, 0x00, 0x4A, 0xDC, 0xF3,
  0x00, 0x27, 0xDC, 0xFB, 0x00, 0x32, 0x64, 0x4C, 0xF7, 0x60, 0x4A, 0xDA,
  0x5A, 0x80, 0x25, 0x25, 0x80, 0x4A, 0xEC, 0x5A, 0x80, 0xFB, 0xD0, 0x76,
  0x80, 0xF7, 0x00, 0xF7, 0x40, 0xF7, 0x20, 0x68, 0xDC, 0x6B, 0xB7, 0x00,
  0xB9, 0x00, 0xBF, 0xA0, 0xEB, 0x00, 0xB9, 0x40, 0xDC, 0x5A, 0x80, 0xFC,
  0x56, 0x80, 0xE0,
};

const GFXglyph NotoSans_Condensed_BoldItalic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 2, 4, 2, 0, -4 },
  { 2, 2, 1, 2, 1, -4 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 4, 4, 5, 0, -4 },
  { 9, 3, 4, 3, 0, -4 },
  { 11, 1, 1, 1, 1, -4 },
  { 12, 2, 5, 2, 0, -4 },
  { 14, 2, 5, 2, 0, -4 },
  { 16, 3, 3, 3, 0, -5 },
  { 18, 3, 3, 3, 0, -4 },
  { 20, 1, 2, 2, 0, -1 },
  { 21, 2, 1, 2, 0, -2 },
  { 22, 1, 1, 2, 0, -1 },
  { 23, 3, 4, 2, 0, -4 },
  { 25, 3, 4, 3, 0, -4 },
  { 27, 2, 4, 3, 1, -4 },
  { 28, 3, 4, 3, 0, -4 },
  { 30, 3, 4, 3, 0, -4 },
  { 32, 3, 4, 3, 0, -4 },
  { 34, 3, 4, 3, 0, -4 },
  { 36, 3, 4, 3, 0, -4 },
  { 38, 3, 4, 3, 0, -4 },
  { 40, 3, 4, 3, 0, -4 },
  { 42, 3, 4, 3, 0, -4 },
  { 44, 2, 3, 2, 0, -3 },
  { 45, 2, 4, 2, 0, -3 },
  { 46, 3, 3, 3, 0, -4 },
  { 48, 3, 2, 3, 0, -3 },
  { 49, 3, 3, 3, 0, -4 },
  { 51, 2, 4, 2, 0, -4 },
  { 52, 4, 5, 4, 0, -4 },
  { 55, 3, 4, 3, 0, -4 },
  { 57, 3, 4, 3, 0, -4 },
  { 59, 3, 4, 3, 0, -4 },
  { 61, 3, 4, 3, 0, -4 },
  { 63, 3, 4, 3, 0, -4 },
  { 65, 3, 4, 3, 0, -4 },
  { 67, 4, 4, 3, 0, -4 },
  { 69, 4, 4, 3, 0, -4 },
  { 71, 2, 4, 2, 0, -4 },
  { 72, 3, 5, 2, -1, -4 },
  { 74, 4, 4, 3, 0, -4 },
  { 76, 2, 4, 3, 0, -4 },
  { 77, 5, 4, 5, 0, -4 },
  { 80, 4, 4, 4, 0, -4 },
  { 82, 4, 4, 4, 0, -4 },
  { 84, 3, 4, 3, 0, -4 },
  { 86, 4, 5, 4, 0, -4 },
  { 89, 3, 4, 3, 0, -4 },
  { 91, 3, 4, 3, 0, -4 },
  { 93, 3, 4, 3, 0, -4 },
  { 95, 4, 4, 3, 0, -4 },
  { 97, 3, 4, 3, 1, -4 },
  { 99, 5, 4, 5, 0, -4 },
  { 102, 3, 4, 3, 0, -4 },
  { 104, 2, 4, 3, 1, -4 },
  { 105, 3, 4, 3, 0, -4 },
  { 107, 2, 5, 2, 0, -4 },
  { 109, 1, 4, 2, 1, -4 },
  { 110, 2, 5, 2, 0, -4 },
  { 112, 3, 2, 3, 0, -4 },
  { 113, 3, 1, 2, -1, 0 },
  { 114, 1, 1, 2, 1, -5 },
  { 115, 3, 3, 3, 0, -3 },
  { 117, 3, 5, 3, 0, -5 },
  { 119, 3, 3, 2, 0, -3 },
  { 121, 3, 5, 3, 0, -5 },
  { 123, 3, 3, 3, 0, -3 },
  { 125, 4, 6, 2, -1, -5 },
  { 128, 3, 4, 3, 0, -3 },
  { 130, 3, 5, 3, 0, -5 },
  { 132, 2, 5, 2, 0, -5 },
  { 134, 3, 6, 2, -1, -5 },
  { 137, 3, 5, 3, 0, -5 },
  { 139, 2, 5, 1, 0, -5 },
  { 141, 4, 3, 4, 0, -3 },
  { 143, 3, 3, 3, 0, -3 },
  { 145, 3, 3, 3, 0, -3 },
  { 147, 3, 4, 3, 0, -3 },
  { 149, 3, 4, 3, 0, -3 },
  { 151, 2, 3, 2, 0, -3 },
  { 152, 2, 3, 2, 0, -3 },
  { 153, 2, 4, 2, 0, -4 },
  { 154, 3, 3, 3, 0, -3 },
  { 156, 3, 3, 3, 0, -3 },
  { 158, 4, 3, 4, 0, -3 },
  { 160, 3, 3, 3, 0, -3 },
  { 162, 3, 4, 3, 0, -3 },
  { 164, 2, 3, 2, 0, -3 },
  { 165, 2, 5, 2, 0, -4 },
  { 167, 1, 6, 3, 1, -5 },
  { 168, 2, 5, 2, 0, -4 },
  { 170, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_Condensed_BoldItalic6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic6pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC6PT7B_H_
