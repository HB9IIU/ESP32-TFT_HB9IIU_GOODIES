#ifndef _NOTOSANS_CONDENSED_BOLDITALIC56PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x3F, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x00,
  0xFC, 0x00, 0x18, 0x00, 0x00, 0x3F, 0xC7, 0xF3, 0xF8, 0x7F, 0x3F, 0x87,
  0xF3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF0, 0xFE, 0x3F, 0x0F, 0xC7, 0xF0,
  0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7C,
  0x1F, 0x8F, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC3, 0xF0,
  0x00, 0x1F, 0x87, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x3E, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0xFC, 0x3E, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFE, 0xE7, 0xC0, 0x3F, 0x9C, 0x30, 0x0F,
  0xE3, 0x80, 0x01, 0xFC, 0x60, 0x00, 0x3F, 0x9C, 0x00, 0x07, 0xFB, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xCF, 0xF0, 0x00, 0x19, 0xFE, 0x00, 0x07, 0x3F, 0xC2,
  0x00, 0xE7, 0xF8, 0x70, 0x1C, 0xFE, 0x0F, 0x83, 0x3F, 0xC1, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x01, 0xFF, 0x80, 0x07, 0xE0, 0x1F, 0xFE, 0x00, 0x7E, 0x00, 0xFF, 0xF0,
  0x03, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0x00, 0x7E, 0x7E, 0x03, 0xF0, 0x07,
  0xE3, 0xF0, 0x1F, 0x80, 0x3E, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0xFC, 0x0F,
  0x80, 0x1F, 0x87, 0xE0, 0xFC, 0x00, 0xF8, 0x3F, 0x0F, 0xC0, 0x07, 0xC1,
  0xF8, 0x7E, 0x00, 0x7E, 0x0F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x3E, 0x00,
  0x1F, 0x87, 0xE3, 0xF0, 0x00, 0xFC, 0x3F, 0x3F, 0x02, 0x07, 0xE3, 0xF1,
  0xF8, 0xFF, 0x3F, 0x1F, 0x9F, 0x8F, 0xFD, 0xF9, 0xF8, 0xF8, 0xFF, 0xEF,
  0xFF, 0xCF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFC, 0xFF, 0xFD, 0xFF, 0xC7, 0xE7,
  0xE3, 0xE7, 0xFC, 0x7E, 0x7E, 0x1F, 0x1F, 0xC3, 0xE3, 0xF0, 0xF8, 0x10,
  0x3F, 0x1F, 0x07, 0xC0, 0x03, 0xF1, 0xF8, 0x3E, 0x00, 0x1F, 0x8F, 0xC3,
  0xF0, 0x01, 0xF8, 0x7E, 0x1F, 0x80, 0x0F, 0x83, 0xE0, 0xFC, 0x00, 0xFC,
  0x1F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x3E, 0x00, 0x7E, 0x0F, 0xC3, 0xF0,
  0x07, 0xE0, 0x7E, 0x1F, 0x80, 0x3E, 0x03, 0xF1, 0xF8, 0x03, 0xF0, 0x1F,
  0x8F, 0xC0, 0x3F, 0x00, 0x7F, 0xFC, 0x01, 0xF0, 0x03, 0xFF, 0xE0, 0x1F,
  0x80, 0x1F, 0xFE, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7E,
  0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE,
  0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0x03, 0xFF, 0xE0, 0xFE, 0x07, 0xFF,
  0xE0, 0xFE, 0x0F, 0xFF, 0xF1, 0xFC, 0x1F, 0xEF, 0xF1, 0xFC, 0x3F, 0xC7,
  0xFB, 0xFC, 0x3F, 0x87, 0xFB, 0xF8, 0x7F, 0x83, 0xFF, 0xF0, 0x7F, 0x83,
  0xFF, 0xF0, 0x7F, 0x01, 0xFF, 0xE0, 0x7F, 0x01, 0xFF, 0xE0, 0xFF, 0x00,
  0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0x83,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xDF, 0xF0, 0x1F, 0xFF, 0x8F, 0xF0, 0x07, 0xFE,
  0x0F, 0xF8, 0x00, 0x40, 0x00, 0x00, 0x3F, 0xCF, 0xF3, 0xF8, 0xFE, 0x3F,
  0x8F, 0xE3, 0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x3F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x01, 0x81, 0xF8, 0x07, 0x87, 0xE0, 0x1F, 0x9F, 0x00,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0xFF, 0xFC, 0x07, 0xF9, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x1F, 0xC0,
  0x78, 0x3F, 0x80, 0x40, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x3F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x81,
  0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x00, 0x7F, 0xFE,
  0xFF, 0xF9, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x80, 0x04, 0x1F,
  0x9F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x07, 0xF8, 0xFF,
  0x07, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xC3, 0xFC, 0x0F, 0xE1, 0xFE, 0x07,
  0xF0, 0xFE, 0x03, 0xF8, 0xFF, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80,
  0xFF, 0x3F, 0xC0, 0x7F, 0x9F, 0xE0, 0x3F, 0xCF, 0xE0, 0x1F, 0xEF, 0xF0,
  0x0F, 0xE7, 0xF8, 0x07, 0xF3, 0xFC, 0x07, 0xF9, 0xFC, 0x03, 0xFC, 0xFE,
  0x01, 0xFE, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0xFF, 0x3F, 0xC0, 0x7F, 0x9F,
  0xE0, 0x3F, 0xCF, 0xF0, 0x1F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xF1,
  0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x87, 0xF8, 0x1F, 0xE7, 0xF8,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xFC,
  0xFF, 0xBF, 0x87, 0xF3, 0xF8, 0x3E, 0x3F, 0x83, 0xC7, 0xF8, 0x18, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xE1, 0xFF, 0x00, 0xF8, 0x0F, 0xF0, 0x07,
  0x00, 0xFF, 0x00, 0x60, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x07, 0x83, 0xFE, 0x00, 0xC0, 0x3F, 0xE0, 0x10, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x80, 0x03, 0xFC, 0x10, 0x00, 0xFF, 0x83, 0xC0, 0x7F,
  0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xDF, 0xC0, 0x01, 0xFB, 0xF8, 0x00, 0x7E, 0x7F,
  0x00, 0x0F, 0x9F, 0xC0, 0x03, 0xF3, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x1F,
  0x0F, 0xE0, 0x07, 0xE3, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x7E, 0x0F, 0xE0,
  0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0x7F, 0x80, 0xFC, 0x0F, 0xE0, 0x1F, 0x81,
  0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x06, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x84, 0x00, 0x1F, 0xE0, 0xC0, 0x07, 0xFC, 0x1F, 0x03, 0xFF, 0x03, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x02, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFC,
  0x02, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x1F, 0x00, 0x3F, 0x9F, 0xF0, 0x0F, 0xEF, 0xFE, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xF9, 0xFF, 0x0F, 0xFC,
  0x3F, 0xC3, 0xFE, 0x07, 0xF0, 0xFF, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x0F,
  0xF0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0xFF,
  0x0F, 0xE0, 0x3F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFE, 0x07, 0xF8, 0x3F, 0xC3,
  0xFE, 0x0F, 0xF1, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0x9F, 0xF0, 0x1F, 0xE0, 0xFF, 0x03, 0xF8,
  0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xE0,
  0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x7F, 0x80, 0xFE, 0x0F, 0xE0, 0x1F, 0xE7,
  0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xF3, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0xFE,
  0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x07, 0xF0, 0x0F, 0xF0, 0xFE, 0x01, 0xFE,
  0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0xFE, 0x1F, 0xE0,
  0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xF7, 0xFE, 0x07, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x1F, 0xF1, 0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xF0, 0x3F,
  0xC7, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFC, 0x07, 0xF9, 0xFE, 0x03,
  0xFC, 0xFF, 0x01, 0xFE, 0x7F, 0x80, 0xFF, 0x3F, 0xC0, 0xFF, 0x9F, 0xE0,
  0x7F, 0x8F, 0xF0, 0x3F, 0xC7, 0xF8, 0x3F, 0xE3, 0xFE, 0x7F, 0xF1, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFE, 0xFE, 0x03,
  0xFE, 0xFF, 0x00, 0x7C, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xF0, 0x20, 0x1F, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0xC1, 0xFF,
  0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x0F, 0xC0, 0x7F,
  0x81, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFC, 0x07, 0xE0, 0x04,
  0x00, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE1, 0xE0, 0xFF, 0x0C,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7E,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0x07, 0xC1, 0xF8, 0x07, 0xC0, 0x3E, 0x1F, 0x80, 0xFF, 0xE1,
  0xF0, 0xF8, 0x1F, 0xFF, 0x8F, 0x8F, 0xC1, 0xFF, 0xF8, 0x7C, 0x7C, 0x1F,
  0xFF, 0xC3, 0xE7, 0xE0, 0xFC, 0x3E, 0x1F, 0x3E, 0x0F, 0xC3, 0xF0, 0xF9,
  0xF0, 0xFC, 0x1F, 0x07, 0xDF, 0x07, 0xC0, 0xF8, 0x3E, 0xF8, 0x7E, 0x07,
  0xC1, 0xF7, 0xC3, 0xE0, 0x7E, 0x0F, 0xFE, 0x1F, 0x03, 0xE0, 0xFF, 0xE0,
  0xF8, 0x1F, 0x07, 0xDF, 0x0F, 0xC1, 0xF8, 0x3E, 0xF8, 0x7E, 0x0F, 0xC1,
  0xF7, 0xC3, 0xE0, 0x7C, 0x1F, 0x3E, 0x1F, 0x07, 0xE0, 0xF9, 0xF0, 0xF8,
  0x3F, 0x0F, 0x8F, 0x87, 0xE3, 0xF8, 0xFC, 0x7C, 0x3F, 0xFF, 0xFF, 0xC3,
  0xE0, 0xFF, 0xDF, 0xFC, 0x1F, 0x07, 0xFE, 0xFF, 0xC0, 0xF8, 0x1F, 0xC3,
  0xFC, 0x07, 0xC0, 0x3C, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x02, 0x00, 0x03, 0xFC, 0x01, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0xBF, 0x00, 0x01,
  0xFD, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xE3,
  0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x87, 0xF0,
  0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x0F,
  0xF0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0xC0,
  0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F,
  0xC0, 0x1F, 0xC3, 0xFC, 0x00, 0xFE, 0x1F, 0xE0, 0x07, 0xF0, 0xFE, 0x00,
  0x3F, 0x8F, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x7F,
  0x3F, 0xC0, 0x03, 0xFB, 0xFC, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x07, 0xF8, 0x7F,
  0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81, 0xFC,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x07, 0xFC, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0x83, 0xFE, 0x01, 0xFC,
  0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x00, 0xFE, 0x07, 0xF8, 0x07,
  0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0,
  0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0x81, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x80, 0x7F, 0xF8, 0x78, 0x03, 0xFF, 0x00, 0xC0, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0xC0, 0x1F, 0xFC, 0x3E, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0x07, 0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x03, 0xFC, 0x07, 0xF8,
  0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0,
  0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0xFF, 0x07,
  0xF8, 0x03, 0xFE, 0x0F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F,
  0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xFC,
  0x01, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0,
  0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x81, 0xFE, 0x01,
  0xFE, 0x03, 0xF8, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x7F,
  0xE0, 0x3F, 0xC3, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0xFC, 0x03, 0xFF, 0x00,
  0x30, 0x0F, 0xFC, 0x00, 0x20, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x03, 0xFF, 0xE3, 0xFC, 0x07, 0xFF, 0x87, 0xF8, 0x1F, 0xFF, 0x0F,
  0xF0, 0x3F, 0xFE, 0x1F, 0xE0, 0x7F, 0xFC, 0x3F, 0xC0, 0xFF, 0xF8, 0x7F,
  0x81, 0xFF, 0xE1, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0x87, 0xF8,
  0x00, 0xFF, 0x0F, 0xF8, 0x01, 0xFC, 0x1F, 0xF0, 0x03, 0xF8, 0x1F, 0xE0,
  0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0xC0, 0x3F, 0xC0, 0xFF, 0x80,
  0x7F, 0x01, 0xFF, 0xC3, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xE0, 0x1F,
  0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xE0, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x41, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xF0, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0xFE,
  0x03, 0xFC, 0x00, 0x3F, 0x81, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07,
  0xF8, 0x3F, 0xC0, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x0F, 0xF8, 0x00,
  0x1F, 0xC3, 0xFC, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x00, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x0F, 0xEF, 0xF0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F,
  0xF3, 0xF8, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00,
  0x7F, 0x0F, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x80,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0x81, 0xFE,
  0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x3F, 0x7F, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xBF, 0x01, 0xFB,
  0xF8, 0x07, 0xF7, 0xE0, 0x7F, 0x7F, 0x00, 0xFE, 0xFC, 0x0F, 0xCF, 0xE0,
  0x1F, 0xDF, 0x83, 0xFB, 0xF8, 0x03, 0xFB, 0xF0, 0x7E, 0x7F, 0x00, 0xFE,
  0x7E, 0x0F, 0xCF, 0xE0, 0x1F, 0xCF, 0xC3, 0xF1, 0xFC, 0x03, 0xF9, 0xFC,
  0x7E, 0x3F, 0x80, 0x7F, 0x1F, 0x9F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF3, 0xF1,
  0xFC, 0x03, 0xF8, 0x7E, 0xFE, 0x3F, 0x80, 0x7F, 0x0F, 0xDF, 0x87, 0xF0,
  0x0F, 0xE1, 0xFF, 0xF1, 0xFE, 0x01, 0xFC, 0x3F, 0xFC, 0x3F, 0x80, 0x3F,
  0x07, 0xFF, 0x87, 0xF0, 0x0F, 0xE0, 0xFF, 0xE0, 0xFE, 0x01, 0xFC, 0x1F,
  0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xFF, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0xE0,
  0xFE, 0x01, 0xFC, 0x0F, 0xF8, 0x1F, 0xC0, 0x3F, 0x81, 0xFF, 0x03, 0xF8,
  0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x1F,
  0xC0, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x7F,
  0x80, 0x07, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0x00, 0xFF, 0xC0, 0x07, 0xF0,
  0x0F, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xE0, 0x0F, 0xFC, 0x00,
  0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xE0, 0x1F, 0xFE, 0x01, 0xFC, 0x01, 0xFF,
  0xE0, 0x1F, 0xC0, 0x1F, 0xFE, 0x01, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xC0,
  0x3F, 0xFF, 0x01, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0x80, 0x3F, 0xFF, 0x03,
  0xF8, 0x03, 0xF3, 0xF0, 0x3F, 0x80, 0x3F, 0x3F, 0x83, 0xF8, 0x07, 0xF3,
  0xF8, 0x3F, 0x80, 0x7F, 0x3F, 0x87, 0xF0, 0x07, 0xF1, 0xF8, 0x7F, 0x00,
  0x7F, 0x1F, 0xC7, 0xF0, 0x0F, 0xE1, 0xFC, 0x7F, 0x00, 0xFE, 0x1F, 0xC7,
  0xF0, 0x0F, 0xE1, 0xFC, 0xFE, 0x00, 0xFE, 0x0F, 0xCF, 0xE0, 0x0F, 0xE0,
  0xFE, 0xFE, 0x01, 0xFC, 0x0F, 0xEF, 0xE0, 0x1F, 0xC0, 0xFE, 0xFC, 0x01,
  0xFC, 0x0F, 0xEF, 0xC0, 0x1F, 0xC0, 0x7F, 0xFC, 0x01, 0xF8, 0x07, 0xFF,
  0xC0, 0x3F, 0x80, 0x7F, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0x80,
  0x3F, 0xF8, 0x03, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0x00, 0x3F, 0xF8, 0x07,
  0xF0, 0x03, 0xFF, 0x80, 0x7F, 0x00, 0x3F, 0xF0, 0x07, 0xF0, 0x01, 0xFF,
  0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xC7, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x07,
  0xF8, 0x1F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0xFF,
  0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xFB,
  0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F, 0x9F,
  0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x07, 0xF9, 0xFF,
  0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0x8F, 0xF0,
  0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFE, 0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0,
  0x1F, 0xF0, 0x7F, 0x80, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x8F,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0x81, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0xC0, 0xFF,
  0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0x80,
  0x7F, 0x80, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F,
  0xC0, 0x7F, 0x83, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x01, 0xFF, 0xC7, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0x9F, 0xF0, 0x00,
  0xFF, 0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0xFF, 0x00, 0x0F,
  0xFB, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F,
  0x9F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x07, 0xF9,
  0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x7F, 0x8F,
  0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFE, 0x3F, 0xE0, 0x07, 0xF8, 0x3F,
  0xC0, 0x1F, 0xF0, 0x7F, 0x80, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x81, 0xFF,
  0x8F, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF8, 0x07, 0xF8, 0xFF, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFC,
  0x0F, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF8, 0x0F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x03, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC3, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0xFF, 0x1F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0x87, 0xF8, 0x01, 0xFC,
  0x3F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F,
  0xC0, 0x3F, 0x81, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0xC1, 0xFC,
  0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFD, 0xFC, 0x03, 0xFE, 0x03,
  0x00, 0xFF, 0x80, 0x20, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0xC0, 0x07, 0xFC, 0x1E, 0x01, 0xFF,
  0x03, 0xF9, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F,
  0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFF, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0xFF,
  0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xF0,
  0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x81,
  0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x1F,
  0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xFE,
  0x00, 0x7F, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0,
  0x07, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x07,
  0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0xC0, 0x7F,
  0x80, 0x7F, 0x81, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xEF, 0xF0,
  0x01, 0xFC, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x7F,
  0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF,
  0x00, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x3F,
  0xC0, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x07, 0xF8, 0x07,
  0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x1F,
  0xE0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x3F, 0xC0, 0x07, 0xF3, 0xF8, 0x00,
  0x7F, 0x3F, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7E, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x1F, 0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xF0, 0x03, 0xFB,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xBF, 0x80,
  0x3F, 0xC0, 0x1F, 0xCF, 0xE0, 0x1F, 0xF0, 0x0F, 0xF3, 0xF8, 0x07, 0xFC,
  0x03, 0xF8, 0xFE, 0x03, 0xFF, 0x00, 0xFE, 0x3F, 0x80, 0xFF, 0xC0, 0x7F,
  0x8F, 0xE0, 0x3F, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0xFC, 0x0F, 0xF0, 0xFE,
  0x07, 0xFF, 0x03, 0xF8, 0x3F, 0x83, 0xFF, 0xC0, 0xFE, 0x0F, 0xE0, 0xFF,
  0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0xFC, 0x1F, 0xC0, 0xFE, 0x1F, 0xBF, 0x0F,
  0xF0, 0x3F, 0x87, 0xEF, 0xC3, 0xF8, 0x0F, 0xE3, 0xFB, 0xF0, 0xFE, 0x03,
  0xF8, 0xFC, 0xFC, 0x7F, 0x80, 0xFE, 0x3F, 0x3F, 0x1F, 0xC0, 0x3F, 0x9F,
  0x8F, 0xC7, 0xF0, 0x0F, 0xE7, 0xE3, 0xF3, 0xF8, 0x03, 0xFB, 0xF8, 0xFC,
  0xFE, 0x00, 0xFC, 0xFC, 0x3F, 0x7F, 0x80, 0x3F, 0x3F, 0x0F, 0xDF, 0xC0,
  0x0F, 0xDF, 0x83, 0xF7, 0xF0, 0x03, 0xF7, 0xE0, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x3F, 0xE0,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x1F,
  0xE0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0x7F,
  0xBF, 0xC0, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xBF, 0x80, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF8,
  0x3F, 0x80, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F,
  0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xF9, 0xFC, 0x03, 0xFC, 0x7F, 0x00,
  0xFF, 0x1F, 0xC0, 0x7F, 0x87, 0xF0, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xF8, 0x0F, 0xE1, 0xFE, 0x03, 0xF8, 0xFF, 0x00, 0xFE, 0x3F, 0x80,
  0x3F, 0x9F, 0xE0, 0x0F, 0xE7, 0xF0, 0x03, 0xFB, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x10, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFC, 0x0F,
  0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x83,
  0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xC1,
  0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xEF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0xFC,
  0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x87, 0xE0, 0x0F, 0xC1, 0xFC, 0x07,
  0xE0, 0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0xFE,
  0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x07, 0xE7, 0xF0, 0x01, 0xF9, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xC3, 0xFC, 0x3F, 0x83,
  0xF0, 0x7F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x1F, 0xF1, 0xFC, 0x07,
  0xFF, 0x3F, 0x81, 0xFF, 0xF7, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0x3F, 0xF0, 0x7F, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0x83, 0xFC,
  0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xF8,
  0x7F, 0x00, 0xFE, 0x1F, 0xE0, 0x1F, 0xC3, 0xFC, 0x03, 0xF8, 0x7F, 0x80,
  0xFF, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0xFF, 0x0F,
  0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x3F,
  0xE0, 0x7F, 0x87, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFE, 0xFC, 0x03, 0xFF, 0x9F, 0x80, 0x3F, 0xE3, 0xF0, 0x03, 0xF8, 0x7E,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC7, 0xC0,
  0x07, 0xF3, 0xFE, 0x00, 0xFE, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x7F, 0x81, 0xFE, 0x0F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0x7F, 0x00,
  0xFF, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x0F,
  0xE0, 0x1F, 0xE1, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x87, 0xF0, 0x0F,
  0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x1F, 0xE0, 0xFF,
  0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xFE, 0x1F, 0xE0, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x03, 0xF7, 0xFF, 0xC0, 0x7E, 0xFF, 0xF0, 0x1F, 0x8F,
  0xFC, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC1, 0xFF, 0x8F, 0x07, 0xF8, 0x08, 0x3F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x20, 0xFF, 0x83, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0x0F, 0xE0, 0x03, 0xFF, 0x3F, 0x80, 0x1F, 0xFD, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0x8F, 0xFC,
  0x03, 0xFC, 0x1F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x01,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80,
  0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0xFF, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0,
  0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x87, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFD, 0xF8, 0x00, 0x7F,
  0xE7, 0xE0, 0x00, 0xFF, 0x1F, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE1, 0xFF, 0xFF, 0xC7, 0xF8, 0x3F, 0x8F, 0xE0, 0x7F, 0x3F, 0xC0, 0xFE,
  0x7F, 0x01, 0xFD, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xE7, 0xF0, 0x7F, 0xCF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0x81, 0xFF,
  0xF8, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x61, 0xFF, 0x07,
  0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xF6, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF,
  0xFE, 0x00, 0x08, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x02, 0x3F, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xC1, 0xF8, 0x01, 0xFF, 0x9F, 0xC0, 0x1F, 0xFC, 0xFE, 0x01,
  0xFF, 0xF7, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC,
  0xFF, 0xC0, 0x7F, 0x83, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF,
  0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x07,
  0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0x03, 0xFC, 0x03, 0xF8, 0x1F, 0xE0,
  0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0xFF,
  0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x07,
  0xF8, 0x3F, 0xE0, 0x1F, 0xE3, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xEF, 0xE0, 0x07, 0xFE, 0x7F,
  0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x08, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x08, 0x00,
  0x7F, 0x80, 0x78, 0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x7E, 0x00, 0xFE,
  0x7F, 0xC0, 0x3F, 0xBF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF0, 0x7F, 0xF7, 0xFC, 0x1F, 0xF0, 0xFF, 0x07, 0xF8, 0x1F,
  0xC1, 0xFE, 0x07, 0xF0, 0xFF, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x0F, 0xF0,
  0x3F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x7F, 0x80, 0xFE, 0x1F,
  0xC0, 0x7F, 0x87, 0xF0, 0x1F, 0xE1, 0xFC, 0x07, 0xF0, 0xFF, 0x01, 0xFC,
  0x3F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0xC3, 0xF8, 0x0F, 0xF0, 0xFE, 0x03,
  0xF8, 0x7F, 0x80, 0xFE, 0x1F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xE1, 0xFC,
  0x07, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x0F, 0xF0, 0x3F, 0xC0,
  0x00, 0x0C, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8,
  0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x01, 0x0F,
  0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x81, 0xFC, 0x07, 0xF8, 0x0F, 0xE0,
  0x7F, 0x80, 0x7F, 0x03, 0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC,
  0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x03,
  0xF9, 0xFE, 0x00, 0x3F, 0x9F, 0xE0, 0x01, 0xFD, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x07,
  0xFD, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1,
  0xFE, 0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0x80, 0x3F, 0x81, 0xFE,
  0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0x01, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x3F, 0x80,
  0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x00, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x03, 0xF1, 0xFF, 0x07,
  0xFC, 0x03, 0xF3, 0xFF, 0x9F, 0xFE, 0x03, 0xF7, 0xFF, 0x9F, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFE, 0x3F,
  0xF9, 0xFF, 0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0xFF,
  0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x7F,
  0x01, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0xFC, 0x7F, 0xC0, 0x3F, 0x3F, 0xF8,
  0x0F, 0xDF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xF3,
  0xFC, 0x1F, 0xF0, 0xFF, 0x07, 0xF8, 0x1F, 0xC1, 0xFE, 0x07, 0xF0, 0xFF,
  0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0xC3, 0xF8, 0x0F, 0xE0,
  0xFE, 0x03, 0xF8, 0x7F, 0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x1F,
  0xE1, 0xFC, 0x07, 0xF0, 0xFF, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x0F, 0xE0,
  0x3F, 0xC3, 0xF8, 0x0F, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x80, 0xFE, 0x1F,
  0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xE1, 0xFC, 0x07, 0xF8, 0x7F, 0x01, 0xFC,
  0x3F, 0xC0, 0x7F, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x1F, 0xF1, 0xFE, 0x1F, 0xE0, 0xFE, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0,
  0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFC, 0xFE, 0x03,
  0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x07, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x01,
  0xF8, 0xFF, 0x80, 0x07, 0xE7, 0xFF, 0x00, 0x1F, 0xBF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x7F, 0x80, 0x3F, 0xC0,
  0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x00, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF8, 0x0F,
  0xE0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x01, 0xFE, 0x0F,
  0xF0, 0x0F, 0xFC, 0x7F, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xEF, 0xFE, 0x00, 0x7F, 0xBF, 0xF0, 0x01,
  0xFC, 0x7F, 0x80, 0x07, 0xF0, 0x20, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x87, 0xE0, 0x0F, 0xF8, 0xFC, 0x07,
  0xFF, 0xBF, 0x81, 0xFF, 0xF7, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x83, 0xFE, 0x3F, 0xF0, 0x7F, 0x83, 0xFE, 0x1F, 0xE0, 0x7F, 0x83, 0xFC,
  0x0F, 0xF0, 0x7F, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xF8, 0x07, 0xF8,
  0x7F, 0x00, 0xFE, 0x1F, 0xE0, 0x1F, 0xC3, 0xFC, 0x03, 0xF8, 0x7F, 0x00,
  0x7F, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x0F,
  0xF0, 0x0F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x87, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x03, 0xFF, 0xBF, 0x80, 0x3F, 0xE7, 0xF0, 0x03, 0xF9, 0xFE,
  0x00, 0x08, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x7C,
  0x0F, 0xC7, 0xF0, 0x3F, 0x3F, 0xC0, 0xFD, 0xFE, 0x03, 0xF7, 0xF8, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0x07, 0x07, 0xF8, 0x04, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x20, 0x07, 0xF8, 0xE0, 0x3F, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0x80,
  0x00, 0x60, 0x00, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x3F, 0xFF, 0x3F, 0xFF, 0xDF,
  0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0,
  0x3F, 0xF0, 0x00, 0x80, 0x00, 0x0F, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xF0,
  0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x0F,
  0xE1, 0xFC, 0x07, 0xF8, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x0F, 0xF0,
  0x1F, 0xC3, 0xF8, 0x0F, 0xF0, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0xFE, 0x0F,
  0xE0, 0x3F, 0x87, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF8, 0x7F, 0x01, 0xFC,
  0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFE, 0x03,
  0xFC, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x7F, 0x83, 0xF8, 0x3F, 0xE0, 0xFF,
  0x0F, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xEF, 0xC0,
  0x7F, 0xF3, 0xF0, 0x1F, 0xFC, 0xFC, 0x03, 0xFC, 0x3E, 0x00, 0x0C, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0xFE, 0x01,
  0xFE, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xFC, 0x7E, 0x03, 0xF8, 0x7E, 0x03,
  0xF8, 0x7E, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0x7F, 0x0F,
  0xE0, 0x7F, 0x1F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0x3F, 0xC0, 0x7F, 0x3F,
  0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x01,
  0xFE, 0x03, 0xFB, 0xF0, 0x1F, 0xF0, 0x1F, 0xDF, 0x80, 0xFF, 0x81, 0xFC,
  0xFC, 0x0F, 0xFC, 0x0F, 0xE7, 0xE0, 0x7F, 0xE0, 0xFE, 0x3F, 0x03, 0xFF,
  0x07, 0xF1, 0xF8, 0x3F, 0xF8, 0x3F, 0x8F, 0xC1, 0xFF, 0x83, 0xF8, 0xFE,
  0x1F, 0xFC, 0x1F, 0xC7, 0xF0, 0xFF, 0xE1, 0xFC, 0x3F, 0x87, 0xDF, 0x0F,
  0xE1, 0xFC, 0x7E, 0xF8, 0x7F, 0x0F, 0xE3, 0xF7, 0xC7, 0xF0, 0x7F, 0x3F,
  0x3E, 0x3F, 0x83, 0xF9, 0xF9, 0xF3, 0xF8, 0x1F, 0xCF, 0x8F, 0x9F, 0xC0,
  0xFE, 0xFC, 0x7C, 0xFC, 0x07, 0xF7, 0xE3, 0xEF, 0xE0, 0x3F, 0xBE, 0x3F,
  0x7F, 0x01, 0xFF, 0xF1, 0xFB, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0x80, 0x7F,
  0xF8, 0x7F, 0xF8, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xF0,
  0x3F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0x83,
  0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF1, 0xFC,
  0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xDF, 0xC0,
  0x01, 0xFE, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0xC7, 0xF8, 0x01,
  0xFE, 0x1F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0xC0, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x03, 0xFC, 0x00,
  0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0xFE, 0x1F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00,
  0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0x7E, 0x7F, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x05, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x01,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0xBF, 0xFE, 0x00, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFD, 0x80, 0x0F, 0xFC, 0x80,
  0x01, 0xF8, 0x00,
};

const GFXglyph NotoSans_Condensed_BoldItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 17, 41, 15, 0, -40 },
  { 89, 20, 14, 23, 5, -40 },
  { 124, 31, 40, 30, 0, -40 },
  { 279, 27, 46, 26, 0, -43 },
  { 435, 37, 42, 42, 3, -41 },
  { 630, 32, 42, 32, 0, -41 },
  { 798, 10, 14, 14, 5, -40 },
  { 816, 20, 49, 16, 1, -40 },
  { 939, 19, 50, 16, -4, -41 },
  { 1058, 22, 24, 25, 5, -43 },
  { 1124, 25, 27, 28, 2, -33 },
  { 1209, 13, 15, 14, -3, -7 },
  { 1234, 15, 6, 17, 1, -18 },
  { 1246, 9, 10, 14, 0, -9 },
  { 1258, 29, 40, 22, -3, -40 },
  { 1403, 25, 42, 26, 1, -41 },
  { 1535, 20, 40, 26, 5, -40 },
  { 1635, 28, 41, 26, -2, -41 },
  { 1779, 27, 42, 26, 0, -41 },
  { 1921, 27, 40, 26, -1, -40 },
  { 2056, 27, 41, 26, 0, -40 },
  { 2195, 26, 42, 26, 2, -41 },
  { 2332, 27, 40, 26, 2, -40 },
  { 2467, 27, 42, 26, 0, -41 },
  { 2609, 25, 42, 26, 1, -41 },
  { 2741, 14, 32, 14, 0, -31 },
  { 2797, 17, 39, 14, -3, -31 },
  { 2880, 25, 28, 28, 2, -34 },
  { 2968, 25, 17, 28, 2, -28 },
  { 3022, 25, 28, 28, 2, -34 },
  { 3110, 21, 42, 21, 2, -41 },
  { 3221, 37, 45, 40, 2, -40 },
  { 3430, 29, 40, 29, -3, -40 },
  { 3575, 29, 40, 29, 0, -40 },
  { 3720, 29, 42, 27, 2, -41 },
  { 3873, 31, 40, 31, 0, -40 },
  { 4028, 27, 40, 25, 0, -40 },
  { 4163, 27, 40, 24, 0, -40 },
  { 4298, 31, 42, 32, 2, -41 },
  { 4461, 34, 40, 33, 0, -40 },
  { 4631, 25, 40, 19, -2, -40 },
  { 4756, 26, 52, 15, -9, -40 },
  { 4925, 34, 40, 28, 0, -40 },
  { 5095, 20, 40, 24, 0, -40 },
  { 5195, 43, 40, 42, 0, -40 },
  { 5410, 36, 40, 35, 0, -40 },
  { 5590, 31, 42, 34, 2, -41 },
  { 5753, 30, 40, 28, 0, -40 },
  { 5903, 31, 51, 34, 2, -41 },
  { 6101, 29, 40, 29, 0, -40 },
  { 6246, 27, 42, 25, 0, -41 },
  { 6388, 25, 40, 24, 4, -40 },
  { 6513, 31, 41, 32, 2, -40 },
  { 6672, 28, 40, 28, 5, -40 },
  { 6812, 42, 40, 42, 5, -40 },
  { 7022, 35, 40, 27, -3, -40 },
  { 7197, 26, 40, 26, 5, -40 },
  { 7327, 30, 40, 24, -2, -40 },
  { 7477, 23, 49, 17, -2, -40 },
  { 7618, 12, 40, 22, 6, -40 },
  { 7678, 23, 49, 17, -4, -40 },
  { 7819, 26, 25, 26, 0, -40 },
  { 7901, 20, 4, 19, -5, 5 },
  { 7911, 11, 9, 17, 8, -43 },
  { 7924, 27, 32, 28, 1, -31 },
  { 8032, 27, 44, 28, 0, -43 },
  { 8181, 22, 32, 23, 2, -31 },
  { 8269, 30, 44, 28, 1, -43 },
  { 8434, 23, 32, 26, 2, -31 },
  { 8526, 30, 56, 17, -6, -43 },
  { 8736, 29, 44, 28, -1, -31 },
  { 8896, 26, 43, 28, 0, -43 },
  { 9036, 16, 43, 14, 0, -43 },
  { 9122, 23, 56, 14, -7, -43 },
  { 9283, 29, 43, 26, 0, -43 },
  { 9439, 17, 43, 14, 0, -43 },
  { 9531, 40, 31, 42, 0, -31 },
  { 9686, 26, 31, 28, 0, -31 },
  { 9787, 24, 32, 27, 2, -31 },
  { 9883, 30, 44, 28, -3, -31 },
  { 10048, 27, 44, 28, 1, -31 },
  { 10197, 22, 31, 20, 0, -31 },
  { 10283, 22, 32, 22, 0, -31 },
  { 10371, 18, 38, 18, 2, -37 },
  { 10457, 26, 32, 28, 2, -31 },
  { 10561, 24, 31, 24, 3, -31 },
  { 10654, 37, 31, 37, 3, -31 },
  { 10798, 30, 31, 25, -3, -31 },
  { 10915, 32, 44, 24, -4, -31 },
  { 11091, 25, 31, 21, -2, -31 },
  { 11188, 23, 49, 19, 0, -40 },
  { 11329, 6, 56, 24, 9, -43 },
  { 11371, 22, 49, 19, -3, -40 },
  { 11506, 25, 9, 28, 2, -24 },
};

const GFXfont NotoSans_Condensed_BoldItalic56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic56pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC56PT7B_H_
