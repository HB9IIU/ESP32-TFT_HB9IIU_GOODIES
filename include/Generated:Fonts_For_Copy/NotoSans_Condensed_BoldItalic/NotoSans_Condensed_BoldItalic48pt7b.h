#ifndef _NOTOSANS_CONDENSED_BOLDITALIC48PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x01, 0xF0,
  0x01, 0x00, 0x00, 0x7F, 0x3F, 0xBF, 0x1F, 0x9F, 0x8F, 0xCF, 0xC7, 0xE7,
  0xC3, 0xE3, 0xE3, 0xF3, 0xF1, 0xF9, 0xF8, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E,
  0x3E, 0x1F, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC3, 0xE0,
  0x01, 0xF0, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x87,
  0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x7C, 0x3C, 0x03, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF0, 0x0F, 0x0F, 0x80, 0x07, 0xC3, 0xC0, 0x01, 0xF1, 0xF0,
  0x00, 0x78, 0x7C, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x8F, 0x80, 0x7F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x0F,
  0x87, 0xC0, 0x03, 0xE1, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x3C, 0x3E, 0x00,
  0x1F, 0x0F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0xF8, 0x78,
  0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xCC,
  0x70, 0x1F, 0x98, 0x40, 0x3F, 0x30, 0x00, 0xFE, 0xE0, 0x01, 0xFD, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x19, 0xF8, 0x00, 0x33, 0xF0, 0x00, 0x67, 0xE1, 0x81,
  0xCF, 0xC3, 0x83, 0xBF, 0x87, 0xF7, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xF0, 0x0F, 0xF8, 0x03,
  0xE0, 0x1F, 0xFC, 0x03, 0xE0, 0x3F, 0xFC, 0x07, 0xC0, 0x3E, 0x7C, 0x07,
  0x80, 0x7C, 0x7C, 0x0F, 0x80, 0x7C, 0x7C, 0x1F, 0x00, 0x78, 0x7C, 0x1F,
  0x00, 0xF8, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x7C, 0x00, 0xF8, 0x7C, 0x7C,
  0x00, 0xF8, 0xF8, 0xF8, 0x00, 0xF0, 0xF8, 0xF8, 0x00, 0xF0, 0xF9, 0xF1,
  0xF8, 0xF1, 0xF3, 0xE3, 0xFC, 0xF1, 0xF3, 0xE7, 0xFE, 0xFF, 0xE7, 0xCF,
  0xFE, 0xFF, 0xE7, 0xDF, 0xBE, 0x7F, 0xCF, 0x9F, 0x1F, 0x7F, 0x9F, 0x1E,
  0x1F, 0x0E, 0x1F, 0x3E, 0x1F, 0x00, 0x3E, 0x3E, 0x1E, 0x00, 0x3E, 0x3E,
  0x3E, 0x00, 0x7C, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x3E, 0x00, 0xF8, 0x7C,
  0x3E, 0x01, 0xF0, 0x7C, 0x3C, 0x01, 0xF0, 0x7C, 0x7C, 0x03, 0xE0, 0x7C,
  0x7C, 0x07, 0xC0, 0x7C, 0xF8, 0x07, 0xC0, 0x7F, 0xF8, 0x0F, 0x80, 0x3F,
  0xF0, 0x0F, 0x80, 0x3F, 0xE0, 0x1F, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xF9, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0,
  0x01, 0xF8, 0x7C, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC,
  0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0xFC, 0x1F, 0xFC,
  0x3F, 0x87, 0xFF, 0xC7, 0xE1, 0xFF, 0xF8, 0xFC, 0x7F, 0x3F, 0xBF, 0x0F,
  0xC7, 0xF7, 0xE3, 0xF8, 0x7F, 0xF8, 0x7E, 0x0F, 0xFF, 0x0F, 0xC0, 0xFF,
  0xC3, 0xF8, 0x1F, 0xF8, 0x7F, 0x01, 0xFE, 0x0F, 0xE0, 0x7F, 0x80, 0xFE,
  0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0xCF, 0xE0, 0x3F, 0xE1, 0xFE, 0x00, 0x7F, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7C, 0x7C, 0xFC, 0xFC, 0xF8, 0xF8, 0xF8, 0x00, 0x3F, 0x80, 0x1F,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x02, 0x0F, 0x80, 0xE1, 0xF0,
  0x1F, 0x3E, 0x03, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0x81, 0xFF, 0xF0, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFB, 0xF0,
  0x7F, 0x3E, 0x07, 0xC7, 0xE0, 0x70, 0xFC, 0x06, 0x0E, 0x00, 0x01, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x07, 0xE1, 0xFC, 0x3F, 0x87, 0xE1, 0xFC, 0x3F, 0x07,
  0xE1, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x7E, 0x00, 0x7F, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3E, 0x7F, 0x7F, 0xFF, 0xFF, 0xFE, 0x7C,
  0x10, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xC7, 0xE1, 0xFC, 0x3F,
  0x0F, 0xC1, 0xF8, 0xFE, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF3, 0xF8,
  0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xEF, 0xE0, 0x7F, 0x7F, 0x03, 0xFB,
  0xF0, 0x1F, 0xDF, 0x80, 0xFC, 0xFC, 0x07, 0xEF, 0xE0, 0x7F, 0x7F, 0x03,
  0xFB, 0xF8, 0x1F, 0xDF, 0x80, 0xFC, 0xFC, 0x0F, 0xE7, 0xE0, 0x7E, 0x3F,
  0x07, 0xF1, 0xF8, 0x3F, 0x8F, 0xE3, 0xF8, 0x7F, 0x3F, 0xC1, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x1F, 0xFE, 0x3F,
  0xFE, 0x7F, 0xFC, 0xFF, 0xFC, 0xFC, 0xFC, 0x79, 0xFC, 0x71, 0xFC, 0x21,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x01, 0xF8, 0x7F, 0x00, 0xE0, 0x7F, 0x00, 0xC0, 0x3F, 0x00, 0x80,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x70, 0x7F,
  0x80, 0x80, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x08, 0x01, 0xFE, 0x1E, 0x07, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x3E, 0xFC, 0x00, 0x3D, 0xF8, 0x00, 0x7D, 0xF8, 0x00, 0xF9, 0xF8,
  0x01, 0xF1, 0xF8, 0x01, 0xF3, 0xF8, 0x03, 0xE3, 0xF0, 0x07, 0xC3, 0xF0,
  0x07, 0xC3, 0xF0, 0x0F, 0x83, 0xF0, 0x1F, 0x07, 0xE0, 0x3F, 0x07, 0xE0,
  0x3E, 0x07, 0xE0, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0xC0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x10, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x86, 0x00, 0xFF, 0x0F,
  0x87, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x0F, 0xDF, 0xF0,
  0x1F, 0xBF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE1, 0xFF, 0x1F, 0xC3,
  0xFC, 0x3F, 0x87, 0xF0, 0x3F, 0x0F, 0xE0, 0x7E, 0x1F, 0x81, 0xFC, 0x7F,
  0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xC3, 0xF8, 0x3F, 0x83, 0xF0,
  0x7F, 0x07, 0xE1, 0xFC, 0x0F, 0xE7, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0x3F, 0xC1, 0xFC, 0x3F,
  0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x83, 0xF0,
  0x3F, 0x07, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x7F, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x7F,
  0xFE, 0x01, 0xFE, 0xFE, 0x07, 0xF0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x81,
  0xF8, 0x7E, 0x03, 0xF1, 0xFC, 0x07, 0xE3, 0xF8, 0x0F, 0xC7, 0xF0, 0x1F,
  0x8F, 0xE0, 0x7F, 0x1F, 0xE1, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF,
  0xFC, 0x3F, 0x8F, 0xE3, 0xF8, 0x3F, 0x1F, 0x81, 0xF9, 0xFC, 0x0F, 0xCF,
  0xE0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x3F, 0x9F, 0x81, 0xFC, 0xFC, 0x0F,
  0xE7, 0xE0, 0xFF, 0x3F, 0x87, 0xF9, 0xFE, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFB, 0xF0, 0x1F, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x40, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x07,
  0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x00, 0xC0, 0x3E, 0x07, 0xF0, 0x7F, 0x0F,
  0xF0, 0xFF, 0x0F, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x7C, 0x01, 0x00, 0x00,
  0x18, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80,
  0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0,
  0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xC0, 0x00,
  0x78, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xFF,
  0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xF1, 0xC1, 0xFC,
  0x40, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFE,
  0x3F, 0xC0, 0x07, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x07, 0x83, 0xE0,
  0x7F, 0xE3, 0xE1, 0xF0, 0x7F, 0xF1, 0xF1, 0xF0, 0x7F, 0xF8, 0xF8, 0xF8,
  0x7E, 0x7C, 0x7C, 0xF8, 0x7C, 0x3C, 0x3E, 0x7C, 0x3C, 0x1E, 0x1F, 0x3C,
  0x3E, 0x1F, 0x0F, 0xBE, 0x1E, 0x0F, 0x87, 0x9F, 0x1F, 0x07, 0x83, 0xCF,
  0x0F, 0x83, 0xC1, 0xE7, 0x87, 0x83, 0xE1, 0xF3, 0xC3, 0xC1, 0xF0, 0xF1,
  0xE3, 0xE0, 0xF0, 0x79, 0xF1, 0xF0, 0xF8, 0x7C, 0xF8, 0xF8, 0x7C, 0x7C,
  0x7C, 0x3E, 0x7E, 0x3C, 0x3E, 0x1F, 0xF7, 0xFE, 0x1F, 0x0F, 0xFB, 0xFE,
  0x07, 0x83, 0xF9, 0xFE, 0x03, 0xC0, 0x70, 0x38, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x02,
  0x00, 0x07, 0xF0, 0x0F, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x07, 0xE7, 0xE0,
  0x03, 0xF3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xFC, 0x7E,
  0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07,
  0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xF0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8,
  0x07, 0xF1, 0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0xFE,
  0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x1F, 0xC3, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF0,
  0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0x7E,
  0x07, 0xF0, 0x3F, 0x1F, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xF8, 0x3F, 0x81,
  0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x7F, 0x01, 0xF8,
  0x3F, 0x80, 0xFC, 0x1F, 0x80, 0xFE, 0x0F, 0xC0, 0x7F, 0x07, 0xE0, 0x7F,
  0x07, 0xF0, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x07, 0xFC, 0x1C, 0x0F, 0xF8, 0x04, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0xC0, 0x7F,
  0xCF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0xFE, 0x7F,
  0xE0, 0x3F, 0x83, 0xFC, 0x0F, 0xE0, 0xFF, 0x03, 0xF0, 0x1F, 0xC1, 0xFC,
  0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xE0, 0x1F, 0xC1,
  0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F,
  0xC3, 0xF0, 0x07, 0xF0, 0xFC, 0x03, 0xFC, 0x7F, 0x00, 0xFE, 0x1F, 0xC0,
  0x3F, 0x87, 0xF0, 0x1F, 0xE1, 0xF8, 0x07, 0xF0, 0xFE, 0x03, 0xFC, 0x3F,
  0x80, 0xFE, 0x0F, 0xE0, 0x7F, 0x83, 0xF8, 0x3F, 0xC0, 0xFC, 0x1F, 0xE0,
  0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0xF0, 0x1F,
  0xE0, 0x04, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x07, 0xFF, 0x1F, 0xC1, 0xFF, 0xCF, 0xE0,
  0x7F, 0xF3, 0xF8, 0x1F, 0xF8, 0xFE, 0x0F, 0xFE, 0x3F, 0x80, 0x3F, 0x8F,
  0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFC, 0x3F, 0x80, 0x3F,
  0x0F, 0xE0, 0x1F, 0xC3, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xF0,
  0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0,
  0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7F,
  0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03,
  0xF0, 0x07, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0,
  0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0,
  0x1F, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F,
  0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x07,
  0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xC0,
  0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0x7E, 0x03, 0xF8, 0x03,
  0xF0, 0x3F, 0x80, 0x1F, 0x83, 0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xC1,
  0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0,
  0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x03,
  0xF7, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFE, 0xFC, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x7E, 0x3F, 0x80, 0x07,
  0xF1, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1,
  0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x81, 0xF8,
  0x01, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x7F, 0x00, 0x7E, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF8,
  0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x1F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFC, 0x01,
  0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F,
  0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFE, 0x03, 0xEF,
  0xC0, 0x7F, 0xF0, 0x3F, 0xFE, 0x03, 0xEF, 0xC1, 0xF7, 0xE0, 0x3F, 0x7E,
  0x1F, 0xBF, 0x01, 0xFB, 0xF0, 0xF9, 0xF8, 0x0F, 0xDF, 0x87, 0xCF, 0xC0,
  0x7E, 0x7C, 0x7C, 0xFC, 0x03, 0xF3, 0xE3, 0xE7, 0xE0, 0x3F, 0x1F, 0x3F,
  0x3F, 0x01, 0xF8, 0xF9, 0xF1, 0xF8, 0x0F, 0xC7, 0xDF, 0x9F, 0xC0, 0x7E,
  0x3E, 0xF8, 0xFC, 0x07, 0xE1, 0xFF, 0xC7, 0xE0, 0x3F, 0x0F, 0xFC, 0x3F,
  0x01, 0xF8, 0x7F, 0xE1, 0xF8, 0x0F, 0xC3, 0xFE, 0x1F, 0xC0, 0x7E, 0x1F,
  0xF0, 0xFC, 0x07, 0xE0, 0xFF, 0x07, 0xE0, 0x3F, 0x07, 0xF8, 0x3F, 0x01,
  0xF8, 0x3F, 0x81, 0xF8, 0x0F, 0xC1, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0,
  0xFC, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x7E, 0x03,
  0xFC, 0x00, 0xFC, 0x07, 0xF8, 0x03, 0xF0, 0x0F, 0xF8, 0x07, 0xE0, 0x1F,
  0xF0, 0x0F, 0xC0, 0x7F, 0xE0, 0x1F, 0x80, 0xFF, 0xC0, 0x7E, 0x01, 0xFF,
  0xC0, 0xFC, 0x03, 0xFF, 0x81, 0xF8, 0x0F, 0xFF, 0x03, 0xF0, 0x1F, 0xFE,
  0x07, 0xE0, 0x3F, 0x7C, 0x1F, 0x80, 0x7E, 0xFC, 0x3F, 0x00, 0xF9, 0xF8,
  0x7E, 0x03, 0xF3, 0xF0, 0xFC, 0x07, 0xE7, 0xE1, 0xF8, 0x0F, 0xC7, 0xE7,
  0xE0, 0x1F, 0x8F, 0xCF, 0xC0, 0x3E, 0x1F, 0x9F, 0x80, 0xFC, 0x3F, 0x3F,
  0x01, 0xF8, 0x3E, 0x7E, 0x03, 0xF0, 0x7F, 0xF8, 0x07, 0xE0, 0xFF, 0xF0,
  0x1F, 0x81, 0xFF, 0xE0, 0x3F, 0x03, 0xFF, 0xC0, 0x7E, 0x03, 0xFF, 0x00,
  0xFC, 0x07, 0xFE, 0x01, 0xF8, 0x0F, 0xFC, 0x07, 0xE0, 0x1F, 0xF8, 0x0F,
  0xC0, 0x3F, 0xF0, 0x1F, 0x80, 0x3F, 0xC0, 0x3F, 0x00, 0x7F, 0x80, 0x7E,
  0x00, 0xFF, 0x01, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0x7F, 0xC7, 0xF8, 0x3F, 0xC0, 0xFF, 0x0F, 0xE0, 0x1F,
  0xC7, 0xF8, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0xFF, 0x00, 0x7F, 0x3F, 0x80,
  0x1F, 0xCF, 0xE0, 0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x7F,
  0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE,
  0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x07, 0xF3, 0xF8, 0x01,
  0xFC, 0xFE, 0x00, 0xFF, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x1F, 0xE3, 0xF8,
  0x07, 0xF0, 0x7F, 0x03, 0xFC, 0x1F, 0xF3, 0xFE, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0xFE, 0x3F, 0xE0, 0x3F, 0x83, 0xF8,
  0x0F, 0xC0, 0x7F, 0x03, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x01,
  0xF8, 0x1F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x81, 0xF8, 0x0F, 0xE0, 0xFE,
  0x07, 0xF0, 0x3F, 0x83, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x7F, 0xC7, 0xF8, 0x3F, 0xC0, 0xFF, 0x0F, 0xE0, 0x1F, 0xC7, 0xF8, 0x07,
  0xF1, 0xFC, 0x01, 0xFC, 0xFF, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0,
  0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF,
  0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F,
  0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00,
  0xFF, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x1F, 0xE3, 0xF8, 0x07, 0xF0, 0x7F,
  0x03, 0xFC, 0x1F, 0xF7, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x03, 0xF8, 0xFF, 0x03, 0xF0, 0x7F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x3F, 0x07, 0xF0, 0x3F, 0x07, 0xE0, 0x7F,
  0x07, 0xE0, 0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xE1, 0xFE, 0x0F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x1F, 0x8F, 0xC0, 0x1F, 0x8F, 0xC0, 0x3F, 0x8F, 0xE0,
  0x3F, 0x8F, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xF0, 0x3F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x7E, 0x03, 0xF8, 0x7E, 0x03, 0xF8,
  0x7E, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81,
  0xFF, 0x1E, 0x03, 0xF8, 0x0C, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x84,
  0x00, 0x7F, 0x0E, 0x01, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF0, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xF8,
  0x1F, 0x80, 0x7F, 0x03, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0,
  0x3F, 0x03, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83,
  0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xF8, 0x07,
  0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF0, 0x3F,
  0x00, 0xFE, 0x07, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7E,
  0x07, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0,
  0x0F, 0xE0, 0xFE, 0x01, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x0F, 0xF9, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF8,
  0x7E, 0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0x80,
  0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x7F, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xE0,
  0x0F, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0x01, 0xFD, 0xF8, 0x07, 0xF0, 0x0F,
  0xCF, 0xC0, 0x3F, 0x80, 0xFE, 0x7E, 0x03, 0xFC, 0x07, 0xE3, 0xF0, 0x1F,
  0xE0, 0x3F, 0x1F, 0x81, 0xFF, 0x03, 0xF8, 0xFC, 0x0F, 0xF8, 0x1F, 0x87,
  0xE0, 0x7F, 0xC1, 0xFC, 0x3F, 0x07, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0xF0,
  0x7E, 0x0F, 0xC3, 0xFF, 0x87, 0xF0, 0x7E, 0x1F, 0x7C, 0x3F, 0x03, 0xF0,
  0xFB, 0xE3, 0xF8, 0x1F, 0x8F, 0xDF, 0x1F, 0x80, 0xFC, 0x7C, 0xF8, 0xFC,
  0x07, 0xE7, 0xE7, 0xCF, 0xC0, 0x3F, 0x3E, 0x3E, 0x7E, 0x01, 0xF9, 0xF1,
  0xF7, 0xF0, 0x0F, 0xDF, 0x8F, 0xBF, 0x00, 0x7E, 0xF8, 0x7D, 0xF8, 0x03,
  0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF,
  0xE0, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF,
  0x81, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0x1F, 0x81, 0xFC, 0x00,
  0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7F,
  0x7E, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7F, 0x1F,
  0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x7F, 0x03, 0xF0,
  0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03,
  0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFE, 0xFC, 0x03, 0xF9, 0xF8, 0x0F,
  0xE3, 0xF0, 0x1F, 0xC7, 0xE0, 0x7F, 0x0F, 0xE0, 0xFC, 0x1F, 0xC3, 0xF8,
  0x1F, 0x87, 0xE0, 0x3F, 0x1F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC, 0xFC, 0x01,
  0xFB, 0xF8, 0x03, 0xF7, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x1F, 0x07, 0xC1, 0xF0, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x07, 0xC1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0x7C, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7E, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xEF, 0x80, 0x1F, 0x3F,
  0x00, 0xF8, 0x7C, 0x07, 0xE1, 0xF0, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x87,
  0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0xFC, 0x03, 0xE7, 0xE0, 0x0F, 0xDF, 0x00,
  0x1F, 0xFC, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE,
  0x7F, 0x1F, 0xC7, 0xE3, 0xF0, 0xFC, 0x3E, 0x1F, 0x00, 0x30, 0x00, 0x03,
  0xFC, 0xFC, 0x0F, 0xF9, 0xF8, 0x3F, 0xFB, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x87, 0xF8, 0xFF, 0x0F, 0xE1, 0xFE, 0x3F, 0x81, 0xF8, 0x7F, 0x03,
  0xF0, 0xFC, 0x07, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7E,
  0x1F, 0x80, 0xFC, 0x7F, 0x01, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE3,
  0xF8, 0x1F, 0x87, 0xF0, 0x7F, 0x0F, 0xE1, 0xFE, 0x1F, 0xE7, 0xFC, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xDF, 0x80, 0x7E,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE1, 0x80, 0x1F, 0xDF, 0xC0, 0x3F, 0x7F,
  0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xF8, 0x7F,
  0x0F, 0xE0, 0xFE, 0x1F, 0x81, 0xFC, 0x3F, 0x03, 0xF8, 0xFE, 0x07, 0xF1,
  0xF8, 0x0F, 0xE3, 0xF0, 0x1F, 0xC7, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x3F,
  0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFC, 0x07, 0xE1, 0xF8, 0x1F, 0xC3, 0xF0,
  0x3F, 0x8F, 0xF0, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC0, 0xFB, 0xFF, 0x83, 0xF7, 0xFE, 0x07, 0xC7, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF,
  0x87, 0xF8, 0x20, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x20,
  0xFE, 0x1C, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x18, 0x3F, 0x00, 0x7F,
  0x9F, 0x80, 0x7F, 0xEF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x3F, 0x87, 0xF8, 0x1F, 0xC3, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F,
  0xE0, 0x7E, 0x07, 0xE0, 0x3F, 0x07, 0xF0, 0x1F, 0x83, 0xF8, 0x1F, 0xC1,
  0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x7F, 0x01, 0xF8,
  0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x7F,
  0x03, 0xF8, 0x7F, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFB,
  0xE0, 0x0F, 0xF9, 0xF0, 0x03, 0xF8, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x07,
  0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xF1, 0xF8,
  0x7F, 0x07, 0xE3, 0xF0, 0x3E, 0x3F, 0x81, 0xF1, 0xF8, 0x1F, 0x8F, 0xC1,
  0xFC, 0xFE, 0x7F, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F,
  0xFF, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0xC1, 0xFF, 0x7E, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xCF, 0xC0,
  0x3F, 0xF7, 0xE0, 0x3F, 0xFB, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x1F, 0xE3, 0xFC, 0x0F, 0xE1, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x3F,
  0x03, 0xF0, 0x1F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07,
  0xE0, 0x7E, 0x03, 0xF0, 0x7F, 0x01, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x7F, 0x81, 0xFE,
  0x7F, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFB, 0xF0, 0x07,
  0xFD, 0xF8, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x81, 0x00, 0x3F, 0x80, 0xE0, 0x3F, 0xC0,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE3, 0xC0,
  0x1F, 0xDF, 0xE0, 0x3F, 0x7F, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x87, 0xF8, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xF8, 0x3F,
  0x03, 0xF0, 0x7E, 0x07, 0xE1, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x87, 0xE0,
  0x7F, 0x0F, 0xC0, 0xFC, 0x3F, 0x81, 0xF8, 0x7F, 0x03, 0xF0, 0xFC, 0x0F,
  0xE1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x0F, 0xE0, 0x7E, 0x1F, 0xC0, 0xFC,
  0x3F, 0x03, 0xF8, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC3, 0xF8, 0x1F, 0x87,
  0xE0, 0x7F, 0x00, 0x00, 0x20, 0x03, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xE0, 0x1F, 0x80, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC,
  0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x3E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F,
  0xC0, 0x7E, 0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x1F, 0x8F, 0xE0, 0x1F, 0xCF,
  0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xF7,
  0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xE7, 0xE0, 0x07,
  0xE3, 0xF0, 0x03, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xF8, 0x3F, 0x00,
  0xFC, 0x1F, 0xC0, 0x7E, 0x0F, 0xE0, 0x3F, 0x07, 0xF0, 0x3F, 0x81, 0xF8,
  0x1F, 0x80, 0xFE, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x01, 0xC0, 0x0C, 0x01,
  0xF1, 0xFC, 0x1F, 0xC0, 0x7C, 0xFF, 0x8F, 0xF8, 0x1F, 0x7F, 0xF7, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x0F, 0xF1,
  0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x0F, 0xE0, 0xFE, 0x0F, 0xC3, 0xF0, 0x3F,
  0x03, 0xF1, 0xFC, 0x0F, 0xC1, 0xFC, 0x7F, 0x07, 0xF0, 0x7E, 0x1F, 0x81,
  0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x81, 0xF8, 0xFE,
  0x0F, 0xE0, 0xFE, 0x3F, 0x03, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x0F, 0xC3,
  0xF0, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC0, 0xFC, 0x7F, 0x07, 0xF0, 0x7F,
  0x1F, 0x81, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x81,
  0xF8, 0x7E, 0x07, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0x3F, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0x00, 0x00, 0xC0, 0x0F, 0x8F, 0xF0, 0x1F, 0x3F, 0xE0, 0x3E,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFC, 0x3F, 0x87, 0xF0,
  0x7F, 0x0F, 0xE0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0xFE, 0x07,
  0xE1, 0xF8, 0x1F, 0xC3, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x1F, 0xC0, 0xFC,
  0x3F, 0x81, 0xF8, 0x7E, 0x07, 0xF0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x87,
  0xF0, 0x3F, 0x0F, 0xE0, 0x7E, 0x1F, 0x81, 0xFC, 0x3F, 0x03, 0xF0, 0x7E,
  0x07, 0xE1, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x80, 0x00, 0x1E, 0x00, 0x07,
  0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x7F, 0x0F, 0xE3, 0xF8, 0x3F, 0x3F, 0x81, 0xF9, 0xF8, 0x0F, 0xDF, 0xC0,
  0x7E, 0xFE, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x01, 0xFD, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7E, 0xFE, 0x03, 0xF7, 0xF0, 0x3F, 0xBF, 0x81, 0xFD, 0xFC, 0x1F,
  0xCF, 0xE0, 0xFE, 0x3F, 0x8F, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0xF8, 0xFE, 0x00, 0x7C, 0xFF, 0x80, 0x3E, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x0F, 0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0x03,
  0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC, 0x07, 0xF0,
  0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0xC0, 0xFE,
  0x0F, 0xE0, 0x7F, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x1F,
  0xC1, 0xFE, 0x1F, 0xC0, 0xFF, 0x1F, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0x9F, 0xF0, 0x0F, 0xC7, 0xE0, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xFC, 0x7C, 0x0F, 0xFD, 0xF8, 0x3F, 0xFB, 0xE0, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x87, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x3F, 0x81, 0xF8, 0x7F,
  0x03, 0xF0, 0xFC, 0x07, 0xE3, 0xF8, 0x0F, 0xC7, 0xF0, 0x3F, 0x8F, 0xC0,
  0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0xFE, 0x03, 0xF1, 0xFC, 0x0F,
  0xE3, 0xF8, 0x1F, 0x87, 0xF0, 0x3F, 0x0F, 0xE0, 0xFE, 0x1F, 0xE3, 0xFC,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xDF, 0x80,
  0x7E, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0xFC, 0xFC, 0x1F, 0xBF, 0x83, 0xEF, 0xE0,
  0x7D, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xC0, 0x0F, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xF0,
  0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xCF, 0x87, 0xF0, 0x20,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x88, 0x07, 0xF1, 0xC1, 0xFE, 0x3F,
  0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x07,
  0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFB, 0xFF, 0xF0, 0xFC, 0x01, 0xF8,
  0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xE0,
  0x1F, 0xC0, 0xFC, 0x7E, 0x07, 0xF1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x3F,
  0x81, 0xF8, 0xFC, 0x0F, 0xE3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03,
  0xF1, 0xFC, 0x0F, 0xC7, 0xE0, 0x7F, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1,
  0xF8, 0x1F, 0x8F, 0xE0, 0xFE, 0x3F, 0x03, 0xF8, 0xFC, 0x0F, 0xC3, 0xF0,
  0x3F, 0x0F, 0xC1, 0xFC, 0x3F, 0x0F, 0xF0, 0xFC, 0x3F, 0x83, 0xFF, 0xFE,
  0x0F, 0xFE, 0xF8, 0x3F, 0xFB, 0xE0, 0x7F, 0xCF, 0x80, 0xFE, 0x7C, 0x00,
  0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xEF, 0xC0, 0xFE, 0xFC, 0x0F,
  0xCF, 0xC1, 0xFC, 0xFC, 0x1F, 0x8F, 0xC3, 0xF8, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0xFC, 0x07, 0xCF, 0xC0, 0x7D,
  0xF8, 0x07, 0xDF, 0x80, 0x7D, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x7F, 0xF8, 0x3F, 0xC0,
  0xFF, 0xF0, 0x7F, 0x83, 0xF7, 0xE0, 0xFF, 0x07, 0xEF, 0xC3, 0xFE, 0x1F,
  0x9F, 0x87, 0xFC, 0x3F, 0x3F, 0x1F, 0xF8, 0x7E, 0x7E, 0x3F, 0xF1, 0xF8,
  0xFC, 0x7F, 0xE3, 0xF1, 0xF9, 0xF7, 0xCF, 0xC3, 0xF3, 0xEF, 0x9F, 0x87,
  0xEF, 0x9F, 0x3E, 0x0F, 0xDF, 0x3E, 0xFC, 0x1F, 0xBE, 0x7D, 0xF8, 0x3F,
  0xF8, 0xFB, 0xE0, 0x7D, 0xF1, 0xFF, 0xC0, 0xFB, 0xC3, 0xDF, 0x01, 0xFF,
  0x87, 0xBE, 0x03, 0xFF, 0x0F, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8,
  0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFF, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0x3F, 0xC0, 0xFC, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE3, 0xF8, 0x01,
  0xF8, 0xFC, 0x00, 0x7E, 0x7F, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7E, 0xFC, 0x00,
  0x3F, 0xBF, 0x00, 0x1F, 0xCF, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF8, 0x7E,
  0x01, 0xFC, 0x1F, 0x80, 0x7F, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x00, 0x01,
  0xF8, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x81,
  0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x83, 0xF8, 0x01, 0xF8, 0x3F, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0xF8,
  0xFC, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0xF9, 0xFC, 0x00, 0x0F, 0x9F, 0x80,
  0x00, 0xF9, 0xF8, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x1F,
  0xF0, 0x07, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x18, 0x00, 0x00, 0x1F, 0x00,
  0x0B, 0xFF, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0x00, 0xFF, 0xD0, 0x01, 0xF8,
};

const GFXglyph NotoSans_Condensed_BoldItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 14, 35, 13, 0, -34 },
  { 63, 17, 12, 20, 5, -34 },
  { 89, 26, 34, 25, 0, -34 },
  { 200, 23, 39, 22, 0, -36 },
  { 313, 32, 35, 36, 3, -35 },
  { 453, 27, 35, 28, 0, -35 },
  { 572, 8, 12, 12, 5, -34 },
  { 584, 17, 42, 14, 1, -34 },
  { 674, 17, 43, 14, -4, -35 },
  { 766, 19, 21, 22, 4, -37 },
  { 816, 21, 24, 24, 2, -29 },
  { 879, 11, 12, 12, -3, -6 },
  { 896, 12, 6, 14, 1, -16 },
  { 905, 8, 8, 12, 0, -7 },
  { 913, 25, 35, 19, -2, -35 },
  { 1023, 21, 35, 22, 1, -35 },
  { 1115, 16, 34, 23, 5, -34 },
  { 1183, 24, 35, 22, -2, -35 },
  { 1288, 23, 35, 22, 0, -35 },
  { 1389, 24, 34, 23, -1, -34 },
  { 1491, 23, 34, 22, 0, -34 },
  { 1589, 23, 35, 22, 1, -35 },
  { 1690, 24, 34, 22, 1, -34 },
  { 1792, 23, 35, 22, 0, -35 },
  { 1893, 21, 35, 22, 1, -35 },
  { 1985, 12, 28, 12, 0, -27 },
  { 2027, 15, 33, 12, -3, -27 },
  { 2089, 21, 24, 24, 2, -29 },
  { 2152, 21, 14, 24, 2, -24 },
  { 2189, 21, 24, 24, 2, -29 },
  { 2252, 18, 36, 18, 2, -35 },
  { 2333, 33, 39, 34, 1, -35 },
  { 2494, 25, 34, 25, -3, -34 },
  { 2601, 25, 34, 25, 0, -34 },
  { 2708, 24, 35, 24, 2, -35 },
  { 2813, 26, 34, 27, 0, -34 },
  { 2924, 23, 34, 21, 0, -34 },
  { 3022, 23, 34, 21, 0, -34 },
  { 3120, 26, 35, 28, 2, -35 },
  { 3234, 29, 34, 28, 0, -34 },
  { 3358, 21, 34, 16, -2, -34 },
  { 3448, 21, 44, 13, -7, -34 },
  { 3564, 29, 34, 24, 0, -34 },
  { 3688, 17, 34, 20, 0, -34 },
  { 3761, 37, 34, 36, 0, -34 },
  { 3919, 31, 34, 30, 0, -34 },
  { 4051, 26, 35, 29, 2, -35 },
  { 4165, 26, 34, 24, 0, -34 },
  { 4276, 26, 43, 29, 2, -35 },
  { 4416, 24, 34, 24, 0, -34 },
  { 4518, 23, 35, 21, 0, -35 },
  { 4619, 21, 34, 21, 4, -34 },
  { 4709, 27, 34, 27, 2, -34 },
  { 4824, 24, 34, 24, 4, -34 },
  { 4926, 37, 34, 36, 4, -34 },
  { 5084, 30, 34, 23, -3, -34 },
  { 5212, 23, 34, 22, 4, -34 },
  { 5310, 26, 34, 21, -2, -34 },
  { 5421, 20, 42, 14, -2, -34 },
  { 5526, 10, 35, 19, 5, -35 },
  { 5570, 19, 42, 14, -3, -34 },
  { 5670, 22, 21, 23, 0, -34 },
  { 5728, 17, 3, 17, -4, 4 },
  { 5735, 9, 8, 15, 7, -37 },
  { 5744, 23, 27, 24, 1, -27 },
  { 5822, 23, 36, 24, 0, -36 },
  { 5926, 19, 27, 19, 1, -27 },
  { 5991, 25, 36, 24, 1, -36 },
  { 6104, 21, 27, 22, 1, -27 },
  { 6175, 25, 49, 15, -5, -37 },
  { 6329, 25, 39, 24, -1, -27 },
  { 6451, 23, 36, 24, 0, -36 },
  { 6555, 14, 37, 12, 0, -37 },
  { 6620, 20, 49, 12, -6, -37 },
  { 6743, 25, 36, 22, 0, -36 },
  { 6856, 14, 36, 12, 0, -36 },
  { 6919, 34, 27, 36, 0, -27 },
  { 7034, 23, 27, 24, 0, -27 },
  { 7112, 21, 28, 23, 1, -27 },
  { 7186, 25, 38, 24, -2, -27 },
  { 7305, 23, 39, 24, 1, -27 },
  { 7418, 19, 27, 17, 0, -27 },
  { 7483, 19, 27, 19, 0, -27 },
  { 7548, 15, 32, 16, 2, -32 },
  { 7608, 22, 26, 24, 2, -26 },
  { 7680, 20, 26, 21, 3, -26 },
  { 7745, 31, 26, 32, 3, -26 },
  { 7846, 26, 26, 21, -2, -26 },
  { 7931, 28, 38, 21, -4, -26 },
  { 8064, 21, 26, 18, -2, -26 },
  { 8133, 20, 42, 17, 0, -34 },
  { 8238, 6, 48, 20, 7, -37 },
  { 8274, 19, 42, 16, -3, -34 },
  { 8374, 21, 8, 24, 2, -21 },
};

const GFXfont NotoSans_Condensed_BoldItalic48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic48pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC48PT7B_H_
