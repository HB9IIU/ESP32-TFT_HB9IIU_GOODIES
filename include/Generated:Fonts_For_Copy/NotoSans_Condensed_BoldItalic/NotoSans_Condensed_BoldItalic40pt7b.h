#ifndef _NOTOSANS_CONDENSED_BOLDITALIC40PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0,
  0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x7C, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0x78, 0x00, 0x7E, 0x7D, 0xF1,
  0xF7, 0xCF, 0x9F, 0x3E, 0x78, 0xF9, 0xE3, 0xEF, 0x8F, 0x3E, 0x3C, 0xF0,
  0xF3, 0xC7, 0xCF, 0x1E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x07,
  0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x03, 0xC3, 0x80, 0x0F, 0x1E,
  0x00, 0x3C, 0x78, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x01, 0xE3,
  0xC0, 0x07, 0x8F, 0x01, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xE0, 0x38, 0x70, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E,
  0x3C, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x78, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x7F, 0xE0, 0x3F,
  0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x7E, 0xDE, 0x0F, 0x98, 0x81, 0xF6,
  0x00, 0x3E, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x6F,
  0xC0, 0x0C, 0xF8, 0x81, 0x9F, 0x18, 0x37, 0xE3, 0xC7, 0xF8, 0x7F, 0xFF,
  0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x0F, 0x01, 0xFC, 0x03, 0xC0,
  0x7F, 0xC0, 0x78, 0x1F, 0xF8, 0x1E, 0x03, 0xCF, 0x03, 0xC0, 0xF9, 0xE0,
  0xF0, 0x1E, 0x3C, 0x3C, 0x03, 0xC7, 0x87, 0x80, 0x78, 0xF1, 0xE0, 0x1E,
  0x1E, 0x3C, 0x03, 0xC7, 0xCF, 0x00, 0x78, 0xF3, 0xC1, 0x0F, 0x1E, 0x79,
  0xF9, 0xE7, 0x9E, 0x7F, 0xBF, 0xF7, 0xDF, 0xF3, 0xFC, 0xF3, 0xCF, 0x7F,
  0x3C, 0xF1, 0xE3, 0xC7, 0x9E, 0x3C, 0x01, 0xE7, 0xC7, 0x80, 0x7C, 0xF0,
  0xF0, 0x0F, 0x1E, 0x3C, 0x03, 0xC3, 0xC7, 0x80, 0x78, 0x78, 0xF0, 0x1E,
  0x0F, 0x3E, 0x07, 0xC1, 0xE7, 0x80, 0xF0, 0x3D, 0xF0, 0x3C, 0x07, 0xFC,
  0x07, 0x80, 0xFF, 0x01, 0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C,
  0x00, 0xF8, 0xF8, 0x01, 0xE1, 0xF0, 0x03, 0xE7, 0xC0, 0x07, 0xDF, 0x80,
  0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x1F, 0x87, 0xFE, 0x3E, 0x1F, 0xFC, 0x7C, 0x7E, 0xFD, 0xF1, 0xF9,
  0xFB, 0xE3, 0xE1, 0xFF, 0x87, 0xC3, 0xFF, 0x1F, 0x83, 0xFC, 0x3F, 0x07,
  0xF0, 0x7E, 0x0F, 0xE0, 0xFE, 0x3F, 0xC0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x81, 0xFF, 0xDF, 0x81, 0xFE, 0x3F, 0x80, 0x7E, 0xF9, 0xF3, 0xE7, 0xCF,
  0x1E, 0x7C, 0xF9, 0xE3, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x78,
  0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x78, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01,
  0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x01, 0x80, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x21, 0xE0, 0x79, 0xE0, 0x7F, 0xEF, 0xFF,
  0xFF, 0x3F, 0xFF, 0x07, 0xFF, 0x07, 0xE1, 0x1F, 0xF0, 0x3F, 0xF0, 0x7E,
  0xF8, 0x3C, 0x78, 0x1C, 0x7C, 0x08, 0x70, 0x00, 0x40, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x1F, 0x8F, 0xC7, 0xC7, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0x78,
  0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0x3C, 0xFB, 0xFF,
  0xEF, 0xCF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7F,
  0xC0, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x83, 0xE3, 0xE1, 0xF8, 0xFC,
  0x7C, 0x3F, 0x3F, 0x0F, 0xCF, 0x83, 0xF3, 0xE0, 0xF9, 0xF8, 0x3E, 0x7C,
  0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xFB, 0xF0, 0x7E, 0xFC, 0x1F, 0xBE, 0x07,
  0xCF, 0x81, 0xF3, 0xE0, 0xFC, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x87, 0xE3,
  0xE3, 0xF0, 0xFD, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x1F,
  0xC0, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x3F, 0x81, 0xFE, 0x0F, 0xF8, 0x7F,
  0xC7, 0xFF, 0x3F, 0xFC, 0xFD, 0xF1, 0xCF, 0xC2, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x03, 0xFF,
  0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7C, 0x3F, 0x03, 0x03, 0xF0, 0x20,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x3F,
  0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x06, 0x0F, 0xC0, 0x81, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x3F,
  0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xC4, 0x01, 0xF8, 0xF0, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0xC0, 0x0F, 0x7C, 0x01, 0xE7, 0xC0, 0x1E, 0xFC, 0x03, 0xCF, 0x80,
  0x78, 0xF8, 0x07, 0x8F, 0x80, 0xF0, 0xF8, 0x1E, 0x1F, 0x03, 0xE1, 0xF0,
  0x3C, 0x1F, 0x07, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF,
  0xC8, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81,
  0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x3F,
  0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC4, 0x03,
  0xF8, 0xF1, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F,
  0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x40, 0x1F, 0x7F, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF,
  0xC3, 0xF8, 0xF8, 0x7E, 0x1F, 0x1F, 0x83, 0xE3, 0xF0, 0x7C, 0x7E, 0x0F,
  0x8F, 0x81, 0xF1, 0xF0, 0x7E, 0x3E, 0x0F, 0xC7, 0xE3, 0xF0, 0x7E, 0xFE,
  0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0x7E, 0x7E, 0x1F,
  0x87, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0xF8, 0x3F,
  0x3F, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F,
  0xF0, 0x1F, 0xFF, 0x07, 0xE7, 0xE1, 0xF8, 0x7E, 0x3E, 0x0F, 0xCF, 0xC0,
  0xF9, 0xF8, 0x1F, 0x3F, 0x07, 0xE7, 0xE0, 0xF8, 0xFC, 0x3F, 0x0F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x3F,
  0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0x8F, 0x87, 0xE1,
  0xF0, 0xF8, 0x3F, 0x1F, 0x07, 0xE7, 0xE0, 0xF8, 0xFC, 0x1F, 0x1F, 0x87,
  0xE3, 0xF0, 0xFC, 0x7E, 0x3F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF,
  0x81, 0xFD, 0xF0, 0x1E, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0xC1, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0,
  0x7F, 0xF0, 0x0F, 0xF8, 0x00, 0x07, 0x83, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x1F, 0x0F, 0xE3, 0xF0, 0xFC, 0x3E, 0x00, 0x01, 0xE0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0x80,
  0xF8, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x70,
  0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xC0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x83, 0xFF, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x30,
  0x00, 0x00, 0x07, 0xE0, 0x3F, 0xF1, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC6,
  0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xBF, 0xC0, 0x1F,
  0x00, 0x7C, 0x07, 0xC0, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x0F,
  0x0F, 0x07, 0xF1, 0xE3, 0xC3, 0xFF, 0x3C, 0x70, 0xFF, 0xE3, 0x9E, 0x3E,
  0x38, 0x73, 0xC7, 0x8F, 0x1E, 0xF1, 0xE1, 0xE3, 0xDE, 0x3C, 0x3C, 0x7B,
  0xCF, 0x0F, 0x0F, 0x71, 0xE1, 0xE1, 0xDE, 0x3C, 0x3C, 0x7B, 0xC7, 0x87,
  0x8F, 0x78, 0xF1, 0xE1, 0xCF, 0x1E, 0x3C, 0x79, 0xE3, 0xFF, 0xFE, 0x3C,
  0x7F, 0xFF, 0x87, 0x87, 0xE7, 0xE0, 0x70, 0x10, 0x20, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x10, 0x03, 0xF0, 0x0C, 0x00, 0x3F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE,
  0x00, 0x3D, 0xE0, 0x07, 0xDE, 0x00, 0x7D, 0xE0, 0x0F, 0x9F, 0x00, 0xF9,
  0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x03, 0xE1, 0xF0, 0x3E,
  0x1F, 0x07, 0xE1, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0x01, 0xF3, 0xF0, 0x1F, 0x3E, 0x01, 0xF7,
  0xE0, 0x1F, 0x7C, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xF0, 0x03, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83,
  0xF0, 0xFC, 0x1F, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x7E, 0x0F,
  0x83, 0xE0, 0xFC, 0x1F, 0x0F, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0x0F, 0xC0, 0xF8, 0x3E, 0x0F, 0xC1, 0xF8,
  0x7E, 0x0F, 0xC3, 0xE0, 0x7E, 0x1F, 0x03, 0xF0, 0xF8, 0x3F, 0x0F, 0xC1,
  0xF8, 0x7C, 0x7F, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0xFE, 0x0C, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x40, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0x8F, 0xE0, 0x7E, 0x1F, 0xC1,
  0xF0, 0x3F, 0x07, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xE0,
  0x3F, 0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3E,
  0x1F, 0x01, 0xF8, 0x7C, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0xFC, 0x3F,
  0x03, 0xF0, 0xF8, 0x1F, 0x83, 0xE0, 0xFE, 0x1F, 0x87, 0xF0, 0x7F, 0xFF,
  0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFE,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x40, 0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC0,
  0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0xFC, 0x0F,
  0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0x81, 0xC1, 0xFC,
  0x01, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x7F, 0xCF, 0xC3, 0xFF, 0x3F,
  0x0F, 0xF8, 0xFC, 0x3F, 0xE3, 0xF0, 0xFF, 0x8F, 0xC0, 0x7E, 0x3E, 0x01,
  0xF0, 0xFC, 0x07, 0xC3, 0xF0, 0x1F, 0x0F, 0xC0, 0xFC, 0x3F, 0x83, 0xF0,
  0x7F, 0xBF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0x03, 0xF0, 0x1F, 0x03, 0xF0, 0x1F, 0x03, 0xE0, 0x3F, 0x03,
  0xE0, 0x3F, 0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x07,
  0xC0, 0x7E, 0x07, 0xC0, 0x7E, 0x0F, 0xC0, 0x7C, 0x0F, 0xC0, 0x7C, 0x0F,
  0x80, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0x01, 0xF8, 0x3F, 0x01, 0xF0, 0x3F,
  0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xF0, 0x3E, 0x03, 0xF0, 0x7E,
  0x03, 0xE0, 0x7E, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xE0, 0x7C,
  0x07, 0xE0, 0xFC, 0x07, 0xC0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFE, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x07, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0xCF,
  0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x03, 0xE0, 0xFC, 0x03, 0xE0, 0xFC, 0x07,
  0xE1, 0xF8, 0x07, 0xE3, 0xF0, 0x07, 0xC3, 0xF0, 0x07, 0xC7, 0xE0, 0x07,
  0xCF, 0xC0, 0x0F, 0xDF, 0x80, 0x0F, 0x9F, 0x80, 0x0F, 0xBF, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xBE, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x3F, 0x00, 0x3E,
  0x3F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7E, 0x1F, 0x80, 0x7E,
  0x1F, 0x80, 0x7C, 0x1F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F,
  0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7F, 0xFD, 0xFF, 0xF7,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x03,
  0xFC, 0x0F, 0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F,
  0xC0, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x7B, 0xE0,
  0x7F, 0xE1, 0xF7, 0xC0, 0xFF, 0xC3, 0xFF, 0x01, 0xE7, 0x87, 0xBE, 0x07,
  0xCF, 0x1F, 0x7C, 0x0F, 0x9E, 0x3C, 0xF8, 0x1F, 0x3C, 0xF9, 0xF0, 0x3E,
  0x79, 0xE7, 0xC0, 0xF8, 0xF7, 0xCF, 0x81, 0xF1, 0xEF, 0x1F, 0x03, 0xE3,
  0xFE, 0x3E, 0x07, 0xC7, 0xF8, 0xFC, 0x0F, 0x8F, 0xF1, 0xF0, 0x3E, 0x1F,
  0xC3, 0xE0, 0x7C, 0x3F, 0x87, 0xC0, 0xF8, 0x7E, 0x0F, 0x81, 0xF0, 0xFC,
  0x3E, 0x03, 0xC1, 0xF8, 0x7C, 0x0F, 0x83, 0xE0, 0xF8, 0x00, 0x03, 0xF0,
  0x07, 0xC0, 0xFE, 0x01, 0xF0, 0x3F, 0x80, 0xF8, 0x0F, 0xE0, 0x3E, 0x07,
  0xF8, 0x0F, 0x81, 0xFE, 0x03, 0xE0, 0x7F, 0xC1, 0xF0, 0x1F, 0xF0, 0x7C,
  0x07, 0xFC, 0x1F, 0x03, 0xFF, 0x07, 0xC0, 0xFB, 0xE1, 0xF0, 0x3E, 0xF8,
  0xF8, 0x0F, 0xBE, 0x3E, 0x03, 0xCF, 0x8F, 0x81, 0xF1, 0xE3, 0xE0, 0x7C,
  0x7C, 0xF8, 0x1F, 0x1F, 0x7C, 0x07, 0xC7, 0xDF, 0x03, 0xE1, 0xF7, 0xC0,
  0xF8, 0x3F, 0xF0, 0x3E, 0x0F, 0xFC, 0x0F, 0x83, 0xFE, 0x03, 0xE0, 0xFF,
  0x81, 0xF0, 0x1F, 0xE0, 0x7C, 0x07, 0xF8, 0x1F, 0x01, 0xFC, 0x07, 0xC0,
  0x7F, 0x01, 0xE0, 0x1F, 0xC0, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xF0,
  0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x1F, 0x3F, 0x00, 0xF9, 0xF8, 0x07, 0xDF,
  0x80, 0x3E, 0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xBE, 0x00, 0xFD, 0xF0,
  0x07, 0xEF, 0x80, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x3F, 0x1F, 0x83, 0xF8,
  0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x7F, 0xFF, 0x83, 0xF1, 0xFC, 0x1F, 0x07, 0xE0, 0xF8, 0x1F, 0x07,
  0xC0, 0xF8, 0x7E, 0x07, 0xC3, 0xF0, 0x7E, 0x1F, 0x03, 0xF0, 0xF8, 0x3F,
  0x07, 0xC3, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF,
  0xF8, 0x0F, 0xFE, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xF1, 0xFC, 0x7E,
  0x07, 0xE3, 0xF0, 0x1F, 0x3F, 0x00, 0xF9, 0xF8, 0x07, 0xDF, 0x80, 0x3E,
  0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xBE, 0x00, 0xFD, 0xF0, 0x07, 0xEF,
  0x80, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x3F, 0x1F, 0x83, 0xF8, 0xFF, 0xFF,
  0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xF0, 0x7E, 0x3F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xFC, 0x1F, 0x0F, 0x83, 0xF0, 0xF8, 0x3F,
  0x0F, 0x87, 0xE0, 0xFB, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFE,
  0x01, 0xFF, 0xE0, 0x3F, 0x3E, 0x03, 0xF3, 0xE0, 0x3E, 0x3F, 0x03, 0xE1,
  0xF0, 0x3E, 0x1F, 0x07, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF8, 0x7C,
  0x0F, 0x87, 0xC0, 0xFC, 0xFC, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0xFC,
  0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xC3, 0x83, 0xF0, 0x10,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x20,
  0x0F, 0xC6, 0x03, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F,
  0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x3E, 0x03, 0xF0,
  0xF8, 0x0F, 0x87, 0xE0, 0x3E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF0,
  0x1F, 0x87, 0xC0, 0x7C, 0x3F, 0x01, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F,
  0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xE1, 0xF8, 0x0F, 0x87, 0xE0, 0x7E, 0x1F,
  0x01, 0xF8, 0x7C, 0x07, 0xC3, 0xF0, 0x1F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03,
  0xF0, 0xF8, 0x0F, 0xC3, 0xE0, 0x3E, 0x0F, 0x81, 0xF8, 0x3F, 0x0F, 0xE0,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0x3E, 0xF8, 0x07, 0xEF, 0x80, 0x7C,
  0xF8, 0x0F, 0xCF, 0x80, 0xF8, 0xF8, 0x1F, 0x8F, 0x81, 0xF0, 0xF8, 0x1F,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xE0, 0xF8, 0x7C, 0x0F, 0x8F,
  0xC0, 0xF8, 0xF8, 0x0F, 0x9F, 0x80, 0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0xFB,
  0xE0, 0x0F, 0xBE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x7E, 0xF8, 0x0F, 0x80, 0xF9, 0xF0,
  0x1F, 0x01, 0xF3, 0xE0, 0x7E, 0x07, 0xE7, 0xC0, 0xFC, 0x0F, 0x8F, 0x83,
  0xF8, 0x1F, 0x3F, 0x07, 0xF0, 0x7C, 0x7E, 0x0F, 0xE0, 0xF8, 0xFC, 0x3F,
  0xC3, 0xF1, 0xF0, 0x7F, 0x87, 0xC3, 0xE1, 0xFF, 0x0F, 0x87, 0xC3, 0xDE,
  0x3E, 0x0F, 0x8F, 0xFC, 0x7C, 0x1F, 0x1E, 0xF9, 0xF8, 0x3E, 0x3D, 0xF3,
  0xE0, 0x7C, 0xFB, 0xE7, 0xC0, 0xF9, 0xE7, 0xDF, 0x01, 0xF7, 0xCF, 0xBE,
  0x03, 0xEF, 0x1F, 0xFC, 0x07, 0xDE, 0x3F, 0xF0, 0x0F, 0xFC, 0x7F, 0xE0,
  0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0x83, 0xFE, 0x00,
  0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x07,
  0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0x81,
  0xF8, 0x1F, 0x80, 0x7C, 0x0F, 0x80, 0x3E, 0x0F, 0xC0, 0x1F, 0x8F, 0xC0,
  0x0F, 0xC7, 0xC0, 0x03, 0xE7, 0xE0, 0x01, 0xF3, 0xE0, 0x00, 0xFB, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x7E,
  0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F,
  0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x1F, 0x81, 0xF0, 0x0F, 0x80, 0xFC, 0x0F,
  0xC0, 0x7E, 0x00, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFB, 0xE0, 0x7C,
  0xFC, 0x3F, 0x3F, 0x0F, 0x87, 0xC7, 0xE1, 0xF1, 0xF0, 0x7C, 0xFC, 0x1F,
  0x3E, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0xF8, 0x7C, 0x3E, 0x0F, 0x07, 0x83, 0xC1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x07, 0x83, 0xC1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x07, 0x83, 0xC1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x07, 0x83, 0xC1, 0xE0, 0xF8, 0x00, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x7F,
  0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x07,
  0xFC, 0x03, 0xCF, 0x01, 0xF3, 0xC0, 0x78, 0xF8, 0x3E, 0x3E, 0x1F, 0x07,
  0x87, 0x81, 0xE3, 0xE0, 0x7C, 0xF0, 0x1F, 0x7C, 0x03, 0xFE, 0x00, 0xF0,
  0x7F, 0xFF, 0xFF, 0xF8, 0xFD, 0xF9, 0xF3, 0xF3, 0xE3, 0xC3, 0x80, 0x03,
  0xF3, 0xE0, 0xFF, 0x7C, 0x3F, 0xEF, 0x8F, 0xFF, 0xE1, 0xF9, 0xFC, 0x7E,
  0x1F, 0x8F, 0xC3, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0x8F, 0x81, 0xF1, 0xF0,
  0x3E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF1, 0xF8, 0x3E, 0x3F, 0x0F, 0xC7, 0xE1,
  0xF8, 0xFC, 0x7F, 0x1F, 0x9F, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFB,
  0xE0, 0x7E, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xDF, 0x81, 0xF7, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFE, 0x7E, 0x3F,
  0x0F, 0xC7, 0xE1, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0xFC, 0xF8,
  0x1F, 0x9F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x1F, 0x8F, 0x83, 0xF3, 0xF0,
  0x7C, 0x7E, 0x1F, 0x8F, 0xE7, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xBF,
  0xC1, 0xE3, 0xF0, 0x00, 0x01, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE,
  0x1F, 0xCC, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x08, 0xFE, 0x30, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xF3, 0xE0,
  0x3F, 0xDF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xF9, 0xFC, 0x1F, 0x87,
  0xE0, 0xF8, 0x3F, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0x83, 0xE0, 0x7C, 0x1F,
  0x03, 0xE1, 0xF8, 0x1F, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0x83, 0xE0, 0x7C,
  0x1F, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE3, 0xF0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFC, 0x07, 0xFB, 0xE0, 0x1F, 0x9F, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x83,
  0xFF, 0xC1, 0xFF, 0xF1, 0xF8, 0xF9, 0xF8, 0x7C, 0xF8, 0x3E, 0xFC, 0x3F,
  0x7C, 0x3F, 0x3F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFC, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x06, 0x1F, 0xFF, 0x0F,
  0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFC, 0xF8, 0x0F, 0xF7, 0xC0,
  0xFF, 0xBE, 0x0F, 0xFF, 0xE0, 0x7E, 0x7F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F,
  0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x7E,
  0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x83, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8,
  0x3F, 0x1F, 0xC1, 0xF9, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFE,
  0xF8, 0x07, 0xEF, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x38, 0x1F, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC,
  0x01, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xDF, 0x81, 0xF7, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFE,
  0xFE, 0x1F, 0x8F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x07, 0xC3, 0xE0,
  0xF8, 0xFC, 0x1F, 0x1F, 0x83, 0xE3, 0xE0, 0xFC, 0x7C, 0x1F, 0x0F, 0x83,
  0xE3, 0xF0, 0x7C, 0x7C, 0x1F, 0x8F, 0x83, 0xF1, 0xF0, 0x7C, 0x3E, 0x0F,
  0x8F, 0xC1, 0xF1, 0xF0, 0x7E, 0x00, 0x01, 0xE0, 0x3F, 0x03, 0xF0, 0x3E,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8,
  0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xF0,
  0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0xFC, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xF8, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC1, 0xF8, 0x7E, 0x1F, 0x83, 0xE1, 0xF8, 0x1F, 0x1F, 0x80,
  0xF8, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x03, 0xEF, 0xC0, 0x1F, 0xFC,
  0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xF9, 0xF0, 0x0F, 0x8F, 0xC0, 0x7C, 0x7E, 0x03, 0xE1, 0xF0,
  0x1F, 0x0F, 0x80, 0xF8, 0x7E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0xC0, 0x03,
  0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x1F,
  0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0x80, 0x07, 0x9F, 0x87, 0xE0,
  0xFB, 0xFC, 0xFF, 0x0F, 0x7F, 0xDF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xEF,
  0xFB, 0xF0, 0xFC, 0x7F, 0x1F, 0x1F, 0x87, 0xE1, 0xF1, 0xF8, 0x7C, 0x1F,
  0x1F, 0x07, 0xC1, 0xF1, 0xF0, 0x7C, 0x1F, 0x3F, 0x0F, 0xC3, 0xF3, 0xE0,
  0xF8, 0x3E, 0x3E, 0x0F, 0x83, 0xE3, 0xE0, 0xF8, 0x3E, 0x3E, 0x0F, 0x83,
  0xE7, 0xE1, 0xF8, 0x7E, 0x7C, 0x1F, 0x07, 0xC7, 0xC1, 0xF0, 0x7C, 0x7C,
  0x1F, 0x07, 0xC7, 0xC1, 0xF0, 0xFC, 0xF8, 0x3E, 0x0F, 0x8F, 0x83, 0xE0,
  0xF8, 0x07, 0x8F, 0x81, 0xE7, 0xF8, 0x3D, 0xFF, 0x07, 0xBF, 0xF0, 0xFE,
  0x7E, 0x1F, 0x8F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x07, 0xC3, 0xE0,
  0xF8, 0xFC, 0x1F, 0x1F, 0x83, 0xE3, 0xE0, 0xFC, 0x7C, 0x1F, 0x0F, 0x83,
  0xE3, 0xF0, 0x7C, 0x7C, 0x0F, 0x8F, 0x83, 0xF1, 0xF0, 0x7C, 0x3E, 0x0F,
  0x8F, 0xC1, 0xF1, 0xF0, 0x7E, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF,
  0xC3, 0xFF, 0xF1, 0xF9, 0xF9, 0xF8, 0x7C, 0xF8, 0x3E, 0xFC, 0x1F, 0x7C,
  0x0F, 0xBE, 0x07, 0xDF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xE0, 0x7D, 0xF0, 0x7E, 0xFC, 0x3F, 0x7E, 0x3F, 0x1F, 0xFF, 0x0F, 0xFF,
  0x83, 0xFF, 0x80, 0xFF, 0x00, 0x01, 0xE7, 0xE0, 0x1F, 0x7F, 0x80, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0x9F, 0x81, 0xF0, 0xFC, 0x1F, 0x83, 0xE0,
  0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x0F, 0xC3, 0xE0, 0x7E, 0x1F, 0x03,
  0xE0, 0xF8, 0x1F, 0x07, 0xC1, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F,
  0x87, 0xE0, 0xFE, 0x7E, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xEF, 0xF0,
  0x1F, 0x3F, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF1, 0xE0, 0xFF, 0x7C, 0x3F, 0xFF,
  0x8F, 0xFF, 0xE1, 0xF9, 0xFC, 0x7E, 0x1F, 0x8F, 0x83, 0xF3, 0xF0, 0x7C,
  0x7E, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x7E, 0x07, 0xCF, 0xC1, 0xF1,
  0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC1, 0xF8, 0xFC, 0x3F, 0x1F, 0x8F, 0xC3,
  0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFB, 0xE0, 0x7E, 0xFC, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x07, 0x9F, 0x0F,
  0xBF, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xF2, 0x1F, 0xC0, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xFF, 0x0F, 0xFE, 0x1F,
  0xFE, 0x1F, 0x0C, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFC, 0x80, 0xF8, 0xE1, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F,
  0xC0, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x1F, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x88, 0xFF, 0x8F,
  0xF8, 0xFF, 0x87, 0xF8, 0x1F, 0x83, 0xE3, 0xE0, 0xFC, 0x7C, 0x1F, 0x0F,
  0x83, 0xE1, 0xF0, 0x7C, 0x7E, 0x0F, 0x8F, 0x83, 0xF1, 0xF0, 0x7C, 0x3E,
  0x0F, 0x87, 0xC1, 0xF1, 0xF8, 0x3E, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8,
  0x3E, 0x1F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xFF,
  0xF8, 0x3F, 0xFF, 0x07, 0xFB, 0xE0, 0x7E, 0x78, 0x00, 0xF8, 0x0F, 0xFC,
  0x0F, 0xFE, 0x07, 0xDF, 0x03, 0xE7, 0x83, 0xE3, 0xC1, 0xF1, 0xE1, 0xF0,
  0xF0, 0xF8, 0x7C, 0xFC, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0xBE, 0x07, 0xDF,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x1F, 0x07, 0xFF,
  0x07, 0xE0, 0xFB, 0xE0, 0xFC, 0x1F, 0x7C, 0x3F, 0x87, 0xCF, 0x87, 0xF0,
  0xF9, 0xF1, 0xFE, 0x3E, 0x3E, 0x3F, 0xC7, 0xC7, 0xC7, 0xF8, 0xF8, 0xF9,
  0xEF, 0x3E, 0x1F, 0x3D, 0xE7, 0xC3, 0xEF, 0xBD, 0xF0, 0x7D, 0xE7, 0xBE,
  0x0F, 0xBC, 0xF7, 0x81, 0xFF, 0x1F, 0xF0, 0x3F, 0xE3, 0xFE, 0x07, 0xFC,
  0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFC, 0x03, 0xFC, 0x3F, 0x80,
  0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x07,
  0xE1, 0xFC, 0x1F, 0x87, 0xE0, 0x3E, 0x3F, 0x00, 0xF8, 0xF8, 0x03, 0xE7,
  0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xBF, 0x00, 0x7E, 0x7C,
  0x03, 0xF1, 0xF0, 0x0F, 0x87, 0xC0, 0x7E, 0x1F, 0x83, 0xF0, 0x7E, 0x00,
  0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xF8, 0x0F, 0x83, 0xF0, 0x1F, 0x07, 0xC0,
  0x3E, 0x1F, 0x80, 0x7C, 0x3E, 0x00, 0xF8, 0xFC, 0x01, 0xF1, 0xF0, 0x03,
  0xE7, 0xE0, 0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x7C, 0x00, 0x3E,
  0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x07, 0xFF, 0x87, 0xFF,
  0xC3, 0xFF, 0xE1, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0xFF,
  0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7E, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x03,
  0xF8, 0x0F, 0xF0, 0x3F, 0x80, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x7F,
  0x80, 0xFE, 0x01, 0xFC, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC, 0x03, 0xF0,
};

const GFXglyph NotoSans_Condensed_BoldItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 12, 29, 10, 0, -29 },
  { 45, 14, 11, 16, 4, -29 },
  { 65, 22, 29, 21, 0, -29 },
  { 145, 19, 32, 18, 0, -30 },
  { 221, 27, 29, 30, 2, -29 },
  { 319, 23, 29, 23, 0, -29 },
  { 403, 7, 11, 10, 4, -29 },
  { 413, 14, 35, 12, 1, -29 },
  { 475, 14, 35, 12, -3, -29 },
  { 537, 16, 18, 18, 3, -31 },
  { 573, 17, 19, 20, 2, -24 },
  { 614, 9, 10, 10, -2, -5 },
  { 626, 10, 5, 12, 1, -13 },
  { 633, 7, 6, 10, 0, -6 },
  { 639, 21, 29, 16, -2, -29 },
  { 716, 18, 29, 18, 1, -29 },
  { 782, 14, 29, 19, 4, -29 },
  { 833, 20, 29, 18, -1, -29 },
  { 906, 19, 29, 18, 0, -29 },
  { 975, 20, 29, 19, -1, -29 },
  { 1048, 19, 29, 18, 0, -29 },
  { 1117, 19, 29, 18, 1, -29 },
  { 1186, 20, 29, 18, 1, -29 },
  { 1259, 19, 29, 18, 0, -29 },
  { 1328, 19, 29, 18, 0, -29 },
  { 1397, 10, 22, 10, 0, -22 },
  { 1425, 12, 27, 10, -2, -22 },
  { 1466, 17, 19, 20, 2, -24 },
  { 1507, 17, 12, 20, 2, -20 },
  { 1533, 17, 19, 20, 2, -24 },
  { 1574, 15, 29, 15, 2, -29 },
  { 1629, 27, 32, 28, 1, -29 },
  { 1737, 20, 29, 21, -2, -29 },
  { 1810, 21, 29, 21, 0, -29 },
  { 1887, 20, 29, 20, 2, -29 },
  { 1960, 22, 29, 22, 0, -29 },
  { 2040, 19, 29, 18, 0, -29 },
  { 2109, 19, 29, 17, 0, -29 },
  { 2178, 22, 29, 23, 2, -29 },
  { 2258, 24, 29, 23, 0, -29 },
  { 2345, 18, 29, 13, -2, -29 },
  { 2411, 18, 37, 11, -6, -29 },
  { 2495, 24, 29, 20, 0, -29 },
  { 2582, 14, 29, 17, 0, -29 },
  { 2633, 31, 29, 30, 0, -29 },
  { 2746, 26, 29, 25, 0, -29 },
  { 2841, 21, 29, 24, 2, -29 },
  { 2918, 21, 29, 20, 0, -29 },
  { 2995, 21, 36, 24, 2, -29 },
  { 3090, 20, 29, 20, 0, -29 },
  { 3163, 19, 29, 18, 0, -29 },
  { 3232, 17, 29, 17, 3, -29 },
  { 3294, 22, 29, 23, 2, -29 },
  { 3374, 20, 29, 20, 4, -29 },
  { 3447, 31, 29, 30, 3, -29 },
  { 3560, 25, 29, 20, -2, -29 },
  { 3651, 18, 29, 19, 4, -29 },
  { 3717, 21, 29, 17, -1, -29 },
  { 3794, 16, 35, 12, -1, -29 },
  { 3864, 9, 29, 16, 4, -29 },
  { 3897, 16, 35, 12, -3, -29 },
  { 3967, 18, 18, 19, 0, -29 },
  { 4008, 15, 2, 14, -4, 4 },
  { 4012, 7, 7, 12, 6, -31 },
  { 4019, 19, 22, 20, 1, -22 },
  { 4072, 19, 30, 20, 0, -30 },
  { 4144, 16, 22, 16, 1, -22 },
  { 4188, 21, 30, 20, 1, -30 },
  { 4267, 17, 22, 19, 1, -22 },
  { 4314, 21, 41, 12, -4, -31 },
  { 4422, 21, 32, 20, -1, -22 },
  { 4506, 19, 30, 20, 0, -30 },
  { 4578, 12, 30, 10, 0, -30 },
  { 4623, 17, 40, 10, -5, -30 },
  { 4708, 21, 30, 19, 0, -30 },
  { 4787, 12, 30, 10, 0, -30 },
  { 4832, 28, 22, 30, 0, -22 },
  { 4909, 19, 22, 20, 0, -22 },
  { 4962, 17, 22, 20, 1, -22 },
  { 5009, 21, 32, 20, -2, -22 },
  { 5093, 19, 32, 20, 1, -22 },
  { 5169, 16, 22, 14, 0, -22 },
  { 5213, 16, 22, 16, 0, -22 },
  { 5257, 12, 26, 13, 2, -26 },
  { 5296, 19, 22, 20, 1, -22 },
  { 5349, 17, 22, 17, 2, -22 },
  { 5396, 27, 22, 27, 2, -22 },
  { 5471, 22, 22, 18, -2, -22 },
  { 5532, 23, 32, 17, -3, -22 },
  { 5624, 17, 22, 15, -1, -22 },
  { 5671, 16, 35, 14, 0, -29 },
  { 5741, 4, 40, 17, 6, -31 },
  { 5761, 15, 35, 14, -2, -29 },
  { 5827, 17, 6, 20, 2, -17 },
};

const GFXfont NotoSans_Condensed_BoldItalic40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic40pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC40PT7B_H_
