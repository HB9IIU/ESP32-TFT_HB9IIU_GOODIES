#ifndef _NOTOSANS_CONDENSED_BOLDITALIC66PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x01, 0xC0,
  0x00, 0x1F, 0xE1, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0xE1, 0xFE, 0x3F, 0xC1,
  0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0x83,
  0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x83, 0xF8, 0x7F, 0x83, 0xF8, 0x7F, 0x07,
  0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0x7E, 0x07,
  0xE0, 0xFE, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x00,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F,
  0x83, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFE,
  0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00,
  0xFE, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0xC0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x00, 0x7F, 0xCE, 0x1E, 0x00, 0xFF, 0x1C, 0x18, 0x03, 0xFE,
  0x78, 0x00, 0x07, 0xF8, 0xE0, 0x00, 0x0F, 0xF9, 0xC0, 0x00, 0x1F, 0xF3,
  0x80, 0x00, 0x3F, 0xF7, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x03, 0xBF, 0xF0, 0x00, 0x07, 0x7F, 0xE0, 0x00, 0x0E, 0x7F, 0xC0,
  0x00, 0x3C, 0xFF, 0x80, 0x00, 0x71, 0xFF, 0x04, 0x00, 0xE3, 0xFE, 0x0C,
  0x01, 0xC7, 0xFC, 0x3E, 0x03, 0x9F, 0xF0, 0x7F, 0xCF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xFF,
  0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x7E,
  0x00, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0xC0,
  0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x3F,
  0x80, 0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xF8, 0x1F, 0x80,
  0x01, 0xFC, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0x00,
  0x7E, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF0, 0x3F, 0x0F, 0xE0, 0x00, 0x1F,
  0x83, 0xF8, 0x7E, 0x00, 0x01, 0xFC, 0x1F, 0xC7, 0xF0, 0x7E, 0x0F, 0xE0,
  0xFC, 0x7F, 0x0F, 0xFC, 0x3F, 0x0F, 0xE3, 0xF8, 0xFF, 0xF1, 0xF8, 0x7F,
  0x3F, 0x8F, 0xFF, 0x8F, 0xE7, 0xF1, 0xF8, 0xFF, 0xFE, 0x7F, 0xFF, 0x1F,
  0xCF, 0xFF, 0xF3, 0xFF, 0xF9, 0xFC, 0x7F, 0x3F, 0x8F, 0xFF, 0x8F, 0xE7,
  0xF0, 0xFC, 0x7F, 0xF8, 0xFE, 0x3F, 0x87, 0xE0, 0xFF, 0x87, 0xE3, 0xF8,
  0x3F, 0x81, 0xE0, 0x7F, 0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x0F,
  0xC0, 0x00, 0x3F, 0x87, 0xE0, 0x7E, 0x00, 0x03, 0xF8, 0x7F, 0x07, 0xF0,
  0x00, 0x1F, 0x83, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC1, 0xFC, 0x00,
  0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x7E, 0x00, 0x0F,
  0xE0, 0x3F, 0x07, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x3F, 0x80, 0x07, 0xF0,
  0x0F, 0xC1, 0xF8, 0x00, 0x7F, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF8, 0x03,
  0xF1, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xDF, 0xE0, 0x01, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x07,
  0xFB, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xF0, 0x7F,
  0xFF, 0x81, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xE1, 0xFF, 0xFF, 0xC3, 0xFE,
  0x1F, 0xF7, 0xFE, 0x3F, 0xC3, 0xFE, 0x3F, 0xE7, 0xFC, 0x7F, 0xC3, 0xFF,
  0x7F, 0x87, 0xFC, 0x1F, 0xFF, 0xF8, 0xFF, 0x81, 0xFF, 0xFF, 0x0F, 0xF8,
  0x0F, 0xFF, 0xF0, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xF8, 0x07, 0xFF, 0xE0,
  0xFF, 0x00, 0x7F, 0xFC, 0x0F, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x3F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x3F, 0xF0, 0x1F, 0xFF, 0xC3,
  0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF1, 0xFE, 0x1F, 0xE3, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F,
  0x83, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x04, 0x03, 0xF0, 0x01, 0xE0, 0xFE, 0x00, 0x3F,
  0x1F, 0xC0, 0x07, 0xFB, 0xF8, 0x05, 0xFF, 0xFE, 0x1F, 0xBF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xEF, 0xF0, 0x0F, 0xF8,
  0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xC3, 0xFC, 0x00, 0xF0, 0x3F, 0xC0,
  0x0C, 0x07, 0xE0, 0x00, 0x80, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x01, 0xFE,
  0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0xFF,
  0xDF, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0xFF, 0xCF,
  0xFF, 0xF3, 0xFF, 0xFC, 0x0F, 0x87, 0xF9, 0xFF, 0xBF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFE, 0x7F, 0x8F, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0x03, 0xFF, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0x81, 0xFF, 0x03, 0xFE,
  0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x7F,
  0xC0, 0x3F, 0xE3, 0xFE, 0x01, 0xFF, 0x1F, 0xF0, 0x0F, 0xF9, 0xFF, 0x00,
  0x7F, 0xCF, 0xF8, 0x03, 0xFC, 0x7F, 0xC0, 0x1F, 0xE7, 0xFC, 0x01, 0xFF,
  0x3F, 0xE0, 0x0F, 0xF9, 0xFF, 0x00, 0x7F, 0xCF, 0xF8, 0x03, 0xFE, 0x7F,
  0xC0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x3F, 0xE0, 0x0F, 0xF9, 0xFF, 0x00,
  0x7F, 0xCF, 0xF8, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xF3, 0xFE, 0x01, 0xFF,
  0x1F, 0xE0, 0x0F, 0xF8, 0xFF, 0x00, 0x7F, 0xC7, 0xF8, 0x07, 0xFC, 0x3F,
  0xC0, 0x3F, 0xE1, 0xFE, 0x03, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0x81,
  0xFF, 0x83, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0xC0, 0xFF, 0x8F, 0xFC,
  0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFE, 0xFF, 0x0F, 0xF1, 0xFE, 0x0F, 0xC7,
  0xFC, 0x0F, 0x0F, 0xF8, 0x1C, 0x1F, 0xE0, 0x10, 0x3F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xC3, 0xFF, 0x80,
  0x3F, 0x80, 0xFF, 0xC0, 0x0F, 0x00, 0x7F, 0xE0, 0x07, 0x00, 0x1F, 0xF0,
  0x01, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x3F, 0x07, 0xFF, 0x00, 0x38, 0x03, 0xFF, 0x00, 0x10, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x80, 0x00, 0x7F, 0xE0, 0xE0, 0x00, 0xFF, 0xE0, 0xFC, 0x03, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFB, 0xFC, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x03, 0xF7, 0xF8, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x0F, 0xE7, 0xF8,
  0x00, 0x0F, 0xCF, 0xF8, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x3F, 0x8F, 0xF0,
  0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x7E, 0x1F, 0xF0, 0x00, 0xFE, 0x1F, 0xF0,
  0x01, 0xFC, 0x1F, 0xE0, 0x01, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x3F, 0xE0,
  0x07, 0xF0, 0x3F, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0, 0x0F, 0xE0, 0x3F, 0xC0,
  0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF9,
  0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x02, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x10, 0x00, 0x1F, 0xF8, 0x38, 0x00, 0x7F, 0xF0, 0x7E,
  0x07, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFA, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x08, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0xE0, 0x00, 0x7F, 0x8F, 0xF8, 0x00,
  0xFF, 0x3F, 0xF8, 0x03, 0xFE, 0xFF, 0xF8, 0x07, 0xFB, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xF0, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x0F, 0xFC,
  0x03, 0xFE, 0x1F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0,
  0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xC1, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x01,
  0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF0, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xC7, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xC7, 0xFE,
  0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFF,
  0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x01, 0xFE,
  0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFF, 0x07, 0xFC,
  0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x7F, 0xC0,
  0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0x80, 0x1F, 0xF0,
  0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0,
  0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0,
  0x7F, 0xFB, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x83, 0xFE, 0x01, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xC0, 0x1F,
  0xF1, 0xFF, 0x00, 0x7F, 0xC7, 0xFC, 0x01, 0xFF, 0x1F, 0xF0, 0x0F, 0xF8,
  0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x87, 0xF8, 0x07, 0xFE, 0x1F,
  0xE0, 0x1F, 0xF8, 0x7F, 0xC0, 0x7F, 0xE1, 0xFF, 0x03, 0xFF, 0x87, 0xFE,
  0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xDF, 0xE0, 0x0F, 0xFE, 0xFF,
  0x80, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x3F, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF8, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x03,
  0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF0, 0x07, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0x01, 0xFF, 0x0C,
  0x00, 0xFF, 0x08, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xF8, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x01, 0xFC, 0x01, 0xFF, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0xFF, 0x0F, 0xC0,
  0xFC, 0x07, 0xFF, 0xF8, 0x7E, 0x0F, 0xE0, 0x7F, 0xFF, 0xC3, 0xF0, 0x7E,
  0x07, 0xFF, 0xFE, 0x0F, 0xC7, 0xF0, 0x3F, 0x87, 0xE0, 0x7E, 0x3F, 0x03,
  0xF8, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x81, 0xF8, 0x3F, 0x1F, 0x81, 0xF8,
  0x1F, 0xC1, 0xF8, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xC7, 0xE0, 0xFC, 0x07,
  0xE0, 0x7E, 0x7E, 0x0F, 0xE0, 0x3F, 0x03, 0xF3, 0xF0, 0x7E, 0x03, 0xF8,
  0x1F, 0x9F, 0x83, 0xF0, 0x1F, 0x81, 0xF8, 0xFC, 0x1F, 0x80, 0xFC, 0x0F,
  0xCF, 0xE1, 0xFC, 0x0F, 0xE0, 0x7E, 0x7E, 0x0F, 0xE0, 0x7F, 0x07, 0xE3,
  0xF0, 0x7E, 0x03, 0xF0, 0x3F, 0x1F, 0x83, 0xF0, 0x3F, 0x81, 0xF8, 0xFC,
  0x1F, 0x81, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0xE1, 0xFC, 0x3F, 0x07,
  0xF0, 0xFF, 0x0F, 0xC1, 0xF8, 0x3F, 0xDF, 0xFD, 0xFC, 0x0F, 0xC0, 0xFF,
  0xF7, 0xFF, 0xE0, 0x7E, 0x07, 0xFF, 0xBF, 0xFE, 0x03, 0xF0, 0x1F, 0xF8,
  0xFF, 0xE0, 0x1F, 0xC0, 0x7F, 0x83, 0xFC, 0x00, 0xFE, 0x00, 0xE0, 0x0F,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x30, 0x00, 0x01,
  0xFF, 0x80, 0x1F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x03, 0xFD,
  0xFE, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x01,
  0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xE1, 0xFE, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFF, 0x07, 0xF8,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F,
  0xE0, 0x07, 0xFC, 0x07, 0xF8, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xE0, 0x01, 0xFF,
  0x1F, 0xF0, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x07,
  0xFC, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xDF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0x1F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F,
  0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x3F,
  0xE0, 0x0F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xE0, 0x7F, 0xF0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x80,
  0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x7F,
  0xC0, 0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xC0,
  0x7F, 0xC0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x7C, 0x01, 0xFF, 0xE0,
  0x0E, 0x00, 0xFF, 0xE0, 0x01, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x04,
  0x00, 0xFF, 0xE0, 0x0E, 0x00, 0x7F, 0xFC, 0x7F, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x2F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0xE0,
  0x0F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xF8, 0x03,
  0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xF8, 0x03, 0xFF, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x1F, 0xF0, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x03,
  0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x03, 0xFF, 0x03, 0xFE,
  0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x7F, 0xC0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x07,
  0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xF8,
  0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x81,
  0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xE0,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x1F, 0x80,
  0x1F, 0xFE, 0x00, 0x38, 0x03, 0xFF, 0x80, 0x01, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0xF8, 0x7F, 0xE0,
  0x3F, 0xFF, 0x87, 0xFC, 0x03, 0xFF, 0xF8, 0x7F, 0xC0, 0x7F, 0xFF, 0x0F,
  0xFC, 0x07, 0xFF, 0xF0, 0xFF, 0xC0, 0x7F, 0xFF, 0x0F, 0xFC, 0x07, 0xFF,
  0xF0, 0xFF, 0xC0, 0x7F, 0xFF, 0x0F, 0xF8, 0x08, 0x3F, 0xE0, 0xFF, 0x80,
  0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x0F,
  0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x7F,
  0xC0, 0xFF, 0xC0, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xE0,
  0x0F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x3F, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x80,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07,
  0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x41, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x1F,
  0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x00, 0x7F, 0x81,
  0xFF, 0x80, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0xFF, 0x83, 0xFF, 0x00,
  0x00, 0xFF, 0x87, 0xFE, 0x00, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x7F, 0xE0, 0x00, 0x03,
  0xFE, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x00,
  0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0xF0,
  0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xF7, 0xF0,
  0x07, 0xF7, 0xF8, 0x01, 0xFE, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xDF,
  0xC0, 0x3F, 0xBF, 0xC0, 0x0F, 0xF3, 0xF8, 0x0F, 0xF7, 0xF8, 0x01, 0xFE,
  0x7F, 0x01, 0xFC, 0xFF, 0x00, 0x3F, 0xCF, 0xE0, 0x7F, 0xBF, 0xE0, 0x07,
  0xF9, 0xFC, 0x0F, 0xE7, 0xFC, 0x00, 0xFF, 0x3F, 0x83, 0xFC, 0xFF, 0x00,
  0x3F, 0xE7, 0xF0, 0x7F, 0x1F, 0xE0, 0x07, 0xF8, 0xFE, 0x0F, 0xE3, 0xFC,
  0x00, 0xFF, 0x1F, 0xC3, 0xF8, 0xFF, 0x80, 0x1F, 0xE3, 0xF8, 0x7F, 0x1F,
  0xE0, 0x03, 0xFC, 0x7F, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x0F, 0xE3, 0xF8,
  0x7F, 0x80, 0x1F, 0xE1, 0xFC, 0xFF, 0x1F, 0xF0, 0x03, 0xFC, 0x3F, 0x9F,
  0xC3, 0xFE, 0x00, 0x7F, 0x87, 0xF7, 0xF8, 0x7F, 0x80, 0x1F, 0xF0, 0xFE,
  0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xFF, 0xC1, 0xFE, 0x00, 0x7F, 0x83,
  0xFF, 0xF0, 0x7F, 0xC0, 0x0F, 0xF0, 0x7F, 0xFE, 0x0F, 0xF8, 0x01, 0xFE,
  0x0F, 0xFF, 0x81, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0xF0, 0x3F, 0xC0, 0x0F,
  0xF0, 0x3F, 0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0x00,
  0x3F, 0xC0, 0xFF, 0xE0, 0x3F, 0xE0, 0x07, 0xF8, 0x1F, 0xFC, 0x07, 0xF8,
  0x01, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0xE0, 0x1F,
  0xE0, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x1F, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0x80, 0x0F, 0xFF, 0xE0, 0x0F, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFE,
  0x00, 0x7F, 0xBF, 0xC0, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x0F, 0xF0, 0x01,
  0xFE, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xDF, 0xE0, 0x3F, 0xC0, 0x0F, 0xF3,
  0xFC, 0x0F, 0xF8, 0x01, 0xFE, 0x3F, 0xC1, 0xFE, 0x00, 0x3F, 0xC7, 0xF8,
  0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x1F, 0xE1, 0xFF,
  0x00, 0x3F, 0xE1, 0xFE, 0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xC7, 0xF8, 0x00,
  0xFF, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0x03, 0xFC,
  0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xE0, 0x3F,
  0xDF, 0xE0, 0x03, 0xFC, 0x07, 0xFB, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x7F,
  0x80, 0x1F, 0xF0, 0x1F, 0xFF, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xF0, 0x01,
  0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFF,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xE1, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x7F, 0xE0, 0x03, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x03,
  0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xF8,
  0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x3F, 0xF3,
  0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x03,
  0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x07, 0xFE, 0x7F, 0xC0,
  0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xEF,
  0xFC, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x0F,
  0xFC, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF8, 0xFF, 0x80,
  0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x03, 0xFF, 0x0F,
  0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xFD,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE,
  0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF8, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFE, 0x0F,
  0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x3F,
  0xF1, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xF3, 0xFF, 0x00,
  0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x03, 0xFF, 0x7F,
  0xE0, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xEF, 0xFC, 0x00,
  0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x07, 0xFC, 0xFF,
  0xC0, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00, 0xFF,
  0x8F, 0xF8, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x01, 0xFF, 0x8F, 0xF8, 0x00,
  0x3F, 0xF0, 0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0xFF,
  0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x1F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xFD, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0x81, 0xFF, 0x80, 0x3F, 0xE0,
  0x3F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xE0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x07, 0xFE,
  0x00, 0xFF, 0x9F, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFE,
  0x3F, 0xE0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F,
  0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x00,
  0x7F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x1E, 0x00, 0x7F, 0xE0, 0x02,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x01,
  0x00, 0x03, 0xFF, 0x01, 0xC0, 0x03, 0xFF, 0x00, 0xF8, 0x03, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF0,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x7F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xC0,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F,
  0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x80,
  0x1F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x1F,
  0xF0, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFF,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x7F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x7F,
  0xC0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xFC,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0xFF,
  0x80, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x0F, 0xFF, 0xBF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xBF, 0xE0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x7F, 0xCF, 0xF8, 0x00,
  0x3F, 0xE7, 0xFC, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x1F, 0xF1, 0xFF, 0x00,
  0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xE0,
  0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xFC,
  0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F,
  0xF0, 0x3F, 0xE0, 0x07, 0xF8, 0x1F, 0xF0, 0x03, 0xFC, 0x1F, 0xF0, 0x01,
  0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x87, 0xFC, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x0F, 0xF1, 0xFE, 0x00,
  0x07, 0xF9, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x80,
  0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x3F, 0xEF, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF9, 0xFE, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFF,
  0xC0, 0x0F, 0xF8, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x1F, 0xE0, 0x07,
  0xFF, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x7F, 0x80,
  0x1F, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xC1, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x3F, 0xC0, 0x3F, 0xFC, 0x01, 0xFE, 0x07,
  0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xC0, 0x7F, 0x81, 0xFF, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xFF, 0x03,
  0xFE, 0x01, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0x80, 0x3F, 0xC1, 0xFD, 0xFC,
  0x1F, 0xF0, 0x07, 0xF8, 0x3F, 0xBF, 0x83, 0xFE, 0x00, 0xFF, 0x0F, 0xF7,
  0xF0, 0x7F, 0x80, 0x1F, 0xE1, 0xFC, 0xFE, 0x1F, 0xF0, 0x03, 0xFC, 0x7F,
  0x9F, 0xC3, 0xFC, 0x00, 0x7F, 0x8F, 0xE3, 0xF8, 0xFF, 0x80, 0x0F, 0xF1,
  0xFC, 0x7F, 0x1F, 0xF0, 0x01, 0xFE, 0x7F, 0x8F, 0xE3, 0xFC, 0x00, 0x3F,
  0xCF, 0xE1, 0xFC, 0xFF, 0x80, 0x07, 0xFB, 0xFC, 0x3F, 0x9F, 0xE0, 0x00,
  0xFE, 0x7F, 0x07, 0xF7, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0xFE, 0xFF, 0x80,
  0x03, 0xFB, 0xF8, 0x1F, 0xDF, 0xE0, 0x00, 0x7F, 0x7F, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x00, 0x3F, 0xCF,
  0xF8, 0x00, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xDF, 0xF0, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x3F, 0xE7, 0xFC,
  0x00, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0xFF, 0xC7,
  0xF8, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F,
  0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x81, 0xFF, 0x00, 0xFF,
  0x07, 0xFC, 0x01, 0xFE, 0x0F, 0xF8, 0x03, 0xFC, 0x3F, 0xE0, 0x07, 0xFC,
  0x7F, 0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x1F, 0xEF,
  0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x04, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x10, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFE, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x3F, 0xDF, 0xC0, 0x00, 0xFE, 0x7F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x3F,
  0xC3, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xC0,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x1F,
  0xE0, 0xFF, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8,
  0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0x8F, 0xFC, 0xFF, 0xC7, 0xFC, 0x7F, 0xC3, 0xFE,
  0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7F, 0xC3, 0xFC, 0x01, 0xFF, 0xC7, 0xF8, 0x0F, 0xFF, 0xCF, 0xF0,
  0x1F, 0xFF, 0xBF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0x7F, 0xE0, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0x87, 0xFC,
  0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0,
  0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0x87, 0xFC, 0x01,
  0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F,
  0xF8, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0xFF,
  0x83, 0xFE, 0x03, 0xFF, 0x07, 0xFC, 0x0F, 0xFE, 0x0F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFD, 0xFE, 0x00, 0xFF, 0xF3, 0xFC, 0x00,
  0xFF, 0xC7, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0xF0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFF,
  0x9F, 0xF8, 0x01, 0xFF, 0x7F, 0xF8, 0x03, 0xFD, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xF0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x03,
  0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F,
  0xF0, 0x7F, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0xFF,
  0x87, 0xF8, 0x01, 0xFF, 0x0F, 0xF0, 0x03, 0xFE, 0x3F, 0xE0, 0x0F, 0xF8,
  0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x83,
  0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xF8, 0x0F, 0xF8, 0x3F,
  0xF0, 0x1F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0xE1, 0xFF, 0x83, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xDF,
  0xFF, 0xC0, 0x3F, 0x9F, 0xFF, 0x00, 0xFE, 0x3F, 0xFC, 0x01, 0xFC, 0x1F,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFE, 0x06, 0x03,
  0xFF, 0x00, 0x81, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x40, 0xFF, 0xC0, 0x30, 0x3F, 0xF8, 0x3C, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xC0, 0xFF, 0x80, 0x03, 0xFE,
  0x3F, 0xE0, 0x01, 0xFF, 0xCF, 0xF8, 0x00, 0xFF, 0xFB, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x80,
  0x7F, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x07, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0x7F, 0x80, 0xFF, 0x80, 0x1F, 0xE0, 0x3F, 0xE0, 0x07, 0xF8, 0x0F, 0xF8,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x3F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF8,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xF7, 0xF0, 0x00, 0xFF, 0xF9, 0xFC, 0x00, 0x1F, 0xFC,
  0x7F, 0x00, 0x03, 0xFE, 0x1F, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xE1, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x1F, 0xF0,
  0x0F, 0xF1, 0xFE, 0x01, 0xFE, 0x3F, 0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xFE,
  0x7F, 0xC0, 0x7F, 0xC7, 0xFC, 0x1F, 0xFC, 0x7F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x02, 0x0F, 0xFC, 0x00, 0xC0, 0x7F, 0xE0, 0x7C, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x08, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0xFF,
  0xE3, 0xFC, 0x00, 0x7F, 0xFC, 0xFF, 0x00, 0x3F, 0xFF, 0x7F, 0x80, 0x1F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xC7, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xF0,
  0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0xE0,
  0x0F, 0xF0, 0x1F, 0xF0, 0x07, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xE0,
  0x1F, 0xF0, 0x3F, 0xF0, 0x07, 0xFE, 0x3F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xF7,
  0xF8, 0x00, 0x7F, 0xFB, 0xFE, 0x00, 0x1F, 0xFC, 0xFF, 0x80, 0x01, 0xFE,
  0x3F, 0xE0, 0x00, 0x08, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x02, 0x00, 0x07, 0xFE, 0x00, 0xF0, 0x03, 0xFF, 0x00,
  0x3F, 0xEF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0xF0, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0xFF, 0xBF,
  0xFC, 0x01, 0xFE, 0xFF, 0xFC, 0x03, 0xFD, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x07, 0xFE, 0x03, 0xFE,
  0x0F, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xE0,
  0x7F, 0x80, 0x3F, 0xC1, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x07,
  0xFC, 0x03, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xF0, 0x7F,
  0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x83, 0xFC,
  0x01, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0,
  0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x83, 0xFE, 0x01,
  0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xE0, 0x0F,
  0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x3F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xFC, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x80,
  0x1F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x0F, 0xF1, 0xFF,
  0x00, 0x07, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0x9F,
  0xF0, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0xC0,
  0x03, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xC0, 0xFF,
  0x80, 0x0F, 0xF0, 0x3F, 0xE0, 0x03, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8,
  0x07, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x3F,
  0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x03, 0x80, 0x01, 0xF8, 0x3F, 0xC0, 0x3F, 0xE0, 0x07, 0xF1, 0xFF,
  0xE1, 0xFF, 0xE0, 0x0F, 0xE7, 0xFF, 0xC7, 0xFF, 0xE0, 0x1F, 0xDF, 0xFF,
  0xDF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xBF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x87, 0xFF,
  0x87, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xFC,
  0x0F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0,
  0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x81, 0xFF, 0x01, 0xFF, 0x00,
  0xFF, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xF8, 0x07,
  0xFC, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xE0, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xC1, 0xFF, 0x00, 0xFF, 0x80, 0xFF,
  0x83, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFE,
  0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0,
  0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xC1,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x07,
  0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x3F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0x81, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x07, 0xFC,
  0x03, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x01, 0xF8, 0x3F, 0xE0, 0x07, 0xF0, 0xFF, 0xE0, 0x0F,
  0xE3, 0xFF, 0xE0, 0x1F, 0xCF, 0xFF, 0xC0, 0x3F, 0xBF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x87, 0xFE, 0x07, 0xFE,
  0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF0, 0x7F, 0xE0,
  0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x01,
  0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F,
  0xF0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x83, 0xFE, 0x01, 0xFF,
  0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0,
  0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x83,
  0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F,
  0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFC, 0x3F, 0xF1, 0xFF, 0x81, 0xFF, 0x1F, 0xF0,
  0x1F, 0xF3, 0xFF, 0x00, 0xFF, 0x3F, 0xE0, 0x0F, 0xF3, 0xFE, 0x00, 0xFF,
  0x7F, 0xC0, 0x0F, 0xF7, 0xFC, 0x00, 0xFF, 0x7F, 0xC0, 0x0F, 0xF7, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF,
  0x80, 0x3F, 0xEF, 0xF8, 0x07, 0xFC, 0xFF, 0x80, 0x7F, 0xCF, 0xF8, 0x0F,
  0xFC, 0xFF, 0x81, 0xFF, 0x8F, 0xFC, 0x3F, 0xF8, 0x7F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0xFF, 0x00, 0x03, 0xF8, 0xFF,
  0xF0, 0x00, 0xFE, 0x7F, 0xFC, 0x00, 0x3F, 0xBF, 0xFF, 0x80, 0x0F, 0xEF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xF0, 0x7F, 0xC0, 0x1F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x7F, 0x80, 0x1F, 0xF0, 0x1F, 0xE0, 0x07, 0xFC, 0x07, 0xF8, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xE0,
  0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF8, 0x07,
  0xFE, 0x07, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFD, 0xFF, 0xF8,
  0x00, 0xFF, 0x7F, 0xFC, 0x00, 0x7F, 0xCF, 0xFE, 0x00, 0x1F, 0xF1, 0xFF,
  0x00, 0x07, 0xFC, 0x1C, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x7F, 0xC1, 0xFC, 0x01, 0xFF, 0xE7, 0xF8, 0x07, 0xFF,
  0xCF, 0xF0, 0x1F, 0xFF, 0xDF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xF0, 0x7F, 0xC0, 0x7F, 0xE0, 0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x00, 0xFF,
  0x87, 0xFC, 0x01, 0xFE, 0x0F, 0xF8, 0x03, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8,
  0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE1, 0xFE, 0x00, 0x7F, 0x87,
  0xFC, 0x00, 0xFF, 0x0F, 0xF8, 0x01, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x3F,
  0xE0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xE0, 0xFF, 0x80, 0x3F, 0xC1, 0xFF,
  0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFD, 0xFE, 0x00, 0xFF, 0xF3,
  0xFC, 0x01, 0xFF, 0xCF, 0xF8, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x70, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x3F, 0x87, 0xF0, 0x1F, 0xE7, 0xFC, 0x07, 0xF1,
  0xFF, 0x01, 0xFC, 0xFF, 0x80, 0x7F, 0x7F, 0xE0, 0x3F, 0xDF, 0xF8, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0xC0, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8,
  0x3F, 0xF8, 0xFC, 0x0F, 0xF8, 0x07, 0x03, 0xFE, 0x00, 0x80, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0xC0, 0x07, 0xFC, 0x3C,
  0x03, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x80, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x81, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8,
  0x00, 0x38, 0x00, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC,
  0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0xC1,
  0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F,
  0xF0, 0x07, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF,
  0x80, 0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFE, 0x0F, 0xF8,
  0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80,
  0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x03,
  0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F,
  0xE0, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0xFE,
  0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xBF, 0x80, 0x7F, 0xFF, 0x7F, 0x00,
  0xFF, 0xFC, 0xFE, 0x00, 0xFF, 0xF1, 0xF8, 0x00, 0xFF, 0x83, 0xF0, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFE, 0xFF,
  0x00, 0x3F, 0xEF, 0xF0, 0x03, 0xFE, 0xFF, 0x00, 0x7F, 0xCF, 0xF0, 0x07,
  0xFC, 0xFF, 0x00, 0xFF, 0x8F, 0xF0, 0x0F, 0xF8, 0xFF, 0x01, 0xFF, 0x0F,
  0xF0, 0x1F, 0xF0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x03,
  0xFC, 0x07, 0xF0, 0x7F, 0xC0, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0xFF, 0x80,
  0x7F, 0x0F, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xF9,
  0xFE, 0x00, 0x7F, 0x3F, 0xC0, 0x07, 0xF3, 0xFC, 0x00, 0x7F, 0x7F, 0x80,
  0x07, 0xF7, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0x7F, 0x80, 0xFF, 0xE0, 0x3F, 0xEF, 0xF0, 0x1F, 0xFC, 0x07,
  0xF9, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0x3F, 0xC0, 0xFF, 0xF0, 0x3F, 0xE7,
  0xF8, 0x1F, 0xFE, 0x07, 0xF8, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0x1F, 0xE0,
  0xFF, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xBF, 0x07, 0xF8, 0x7F, 0x87, 0xFF,
  0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0xFC, 0x3F, 0xC1, 0xFE, 0x3F, 0xBF, 0x8F,
  0xF8, 0x3F, 0xC7, 0xF7, 0xF1, 0xFE, 0x07, 0xF8, 0xFC, 0xFE, 0x3F, 0xC0,
  0xFF, 0x3F, 0x9F, 0xCF, 0xF0, 0x1F, 0xE7, 0xF3, 0xF9, 0xFE, 0x03, 0xFC,
  0xFC, 0x7F, 0x3F, 0xC0, 0x7F, 0xBF, 0x8F, 0xEF, 0xF0, 0x0F, 0xF7, 0xE1,
  0xFD, 0xFE, 0x01, 0xFF, 0xFC, 0x3F, 0xBF, 0x80, 0x3F, 0xFF, 0x87, 0xEF,
  0xF0, 0x07, 0xF7, 0xE0, 0xFD, 0xFC, 0x00, 0xFF, 0xFC, 0x1F, 0xBF, 0x80,
  0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x03,
  0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xFF,
  0x87, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x01, 0xFE, 0x3F, 0xE0, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x01, 0xFF,
  0x3F, 0xE0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x03,
  0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0,
  0x0F, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x07,
  0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xFC,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x01, 0xFE, 0x3F,
  0xC0, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x01,
  0xFC, 0xFF, 0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0x7F, 0x7F, 0x80,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x08, 0xFF, 0xC0, 0x00, 0xDF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF6, 0x00, 0x1F, 0xFE, 0x20,
  0x00, 0x1F, 0xE0,
};

const GFXglyph NotoSans_Condensed_BoldItalic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 20, 48, 17, 0, -47 },
  { 121, 24, 17, 27, 6, -47 },
  { 172, 36, 47, 35, 0, -47 },
  { 384, 31, 54, 30, 1, -50 },
  { 594, 45, 49, 50, 3, -48 },
  { 870, 36, 49, 38, 1, -48 },
  { 1091, 12, 17, 16, 6, -47 },
  { 1117, 23, 57, 19, 1, -47 },
  { 1281, 23, 58, 19, -5, -48 },
  { 1448, 27, 29, 30, 5, -51 },
  { 1546, 28, 32, 33, 3, -39 },
  { 1658, 15, 17, 17, -3, -8 },
  { 1690, 18, 8, 20, 1, -22 },
  { 1708, 11, 11, 17, 0, -10 },
  { 1724, 34, 48, 26, -3, -48 },
  { 1928, 29, 49, 30, 2, -48 },
  { 2106, 23, 47, 31, 6, -47 },
  { 2242, 33, 48, 30, -2, -48 },
  { 2440, 32, 49, 30, -1, -48 },
  { 2636, 32, 47, 31, -1, -47 },
  { 2824, 31, 48, 30, 0, -47 },
  { 3010, 31, 49, 30, 2, -48 },
  { 3200, 32, 47, 30, 2, -47 },
  { 3388, 32, 49, 30, 0, -48 },
  { 3584, 30, 49, 30, 1, -48 },
  { 3768, 17, 38, 17, 0, -37 },
  { 3849, 21, 46, 17, -4, -37 },
  { 3970, 28, 32, 33, 3, -40 },
  { 4082, 28, 20, 33, 3, -33 },
  { 4152, 29, 32, 33, 3, -40 },
  { 4268, 24, 49, 25, 3, -48 },
  { 4415, 45, 53, 47, 2, -48 },
  { 4714, 34, 47, 34, -4, -47 },
  { 4914, 35, 47, 34, 0, -47 },
  { 5120, 33, 49, 32, 3, -48 },
  { 5323, 36, 47, 37, 0, -47 },
  { 5535, 32, 47, 29, 0, -47 },
  { 5723, 32, 47, 28, 0, -47 },
  { 5911, 36, 49, 38, 3, -48 },
  { 6132, 40, 47, 38, 0, -47 },
  { 6367, 30, 47, 22, -3, -47 },
  { 6544, 30, 61, 18, -10, -47 },
  { 6773, 40, 47, 33, 0, -47 },
  { 7008, 24, 47, 28, 0, -47 },
  { 7149, 51, 47, 50, 0, -47 },
  { 7449, 43, 47, 41, 0, -47 },
  { 7702, 36, 49, 40, 3, -48 },
  { 7923, 35, 47, 33, 0, -47 },
  { 8129, 36, 59, 40, 3, -48 },
  { 8395, 34, 47, 34, 0, -47 },
  { 8595, 33, 49, 30, -1, -48 },
  { 8798, 29, 47, 29, 5, -47 },
  { 8969, 36, 48, 38, 3, -47 },
  { 9185, 33, 47, 33, 6, -47 },
  { 9379, 51, 47, 50, 5, -47 },
  { 9679, 41, 47, 32, -4, -47 },
  { 9920, 31, 47, 31, 6, -47 },
  { 10103, 35, 47, 29, -2, -47 },
  { 10309, 26, 58, 20, -2, -47 },
  { 10498, 14, 48, 26, 7, -48 },
  { 10582, 27, 58, 20, -5, -47 },
  { 10778, 30, 29, 31, 0, -47 },
  { 10887, 24, 4, 23, -6, 6 },
  { 10899, 12, 11, 20, 10, -51 },
  { 10916, 31, 38, 33, 2, -37 },
  { 11064, 31, 51, 33, 0, -50 },
  { 11262, 26, 38, 27, 2, -37 },
  { 11386, 34, 51, 33, 2, -50 },
  { 11603, 28, 38, 31, 2, -37 },
  { 11736, 35, 66, 20, -7, -50 },
  { 12025, 34, 53, 33, -1, -37 },
  { 12251, 31, 50, 33, 0, -50 },
  { 12445, 19, 50, 17, 0, -50 },
  { 12564, 27, 66, 17, -8, -50 },
  { 12787, 34, 50, 31, 0, -50 },
  { 13000, 20, 50, 16, 0, -50 },
  { 13125, 47, 37, 49, 0, -37 },
  { 13343, 31, 37, 33, 0, -37 },
  { 13487, 28, 38, 32, 2, -37 },
  { 13620, 34, 53, 33, -3, -37 },
  { 13846, 31, 53, 33, 2, -37 },
  { 14052, 26, 37, 23, 0, -37 },
  { 14173, 26, 38, 26, 0, -37 },
  { 14297, 21, 45, 22, 3, -44 },
  { 14416, 31, 37, 33, 2, -36 },
  { 14560, 28, 36, 29, 4, -36 },
  { 14686, 43, 36, 44, 4, -36 },
  { 14880, 35, 36, 29, -3, -36 },
  { 15038, 37, 52, 29, -5, -36 },
  { 15279, 29, 36, 25, -2, -36 },
  { 15410, 26, 57, 23, 1, -47 },
  { 15596, 7, 65, 28, 10, -50 },
  { 15653, 26, 57, 23, -4, -47 },
  { 15839, 29, 11, 33, 3, -29 },
};

const GFXfont NotoSans_Condensed_BoldItalic66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic66pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC66PT7B_H_
