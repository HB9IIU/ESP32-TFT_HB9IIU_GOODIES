#ifndef _NOTOSANS_CONDENSED_BOLDITALIC45PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x0F, 0x80, 0x10, 0x00, 0x3F, 0x3F, 0x3E, 0x3F, 0x3E,
  0x3F, 0x7E, 0x3E, 0x7E, 0x3E, 0x7C, 0x3E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x78, 0x7C, 0xF8, 0x78, 0x00, 0x1F, 0x1E, 0x00, 0x0F, 0x0F, 0x00,
  0x0F, 0x8F, 0x80, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE3, 0xE0,
  0x01, 0xF1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x07, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x0F, 0x0F,
  0x00, 0x07, 0x87, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xC0, 0x01, 0xE1,
  0xE0, 0x00, 0xF0, 0xF0, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xE0, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x0F,
  0x8F, 0x80, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE3, 0xE0, 0x01,
  0xF1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xF8, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFD, 0xF0, 0x1F, 0x31,
  0x80, 0xFC, 0xC0, 0x03, 0xF3, 0x00, 0x0F, 0xCC, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0x7E,
  0x00, 0x19, 0xF8, 0x40, 0x67, 0xE1, 0x81, 0x9F, 0x87, 0x86, 0xFE, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0x80, 0xFF,
  0x80, 0x3C, 0x03, 0xFF, 0x01, 0xF0, 0x1F, 0xFC, 0x07, 0x80, 0xF9, 0xF0,
  0x3E, 0x03, 0xE3, 0xC1, 0xF0, 0x0F, 0x0F, 0x07, 0x80, 0x7C, 0x7C, 0x3E,
  0x01, 0xF1, 0xF0, 0xF0, 0x07, 0x87, 0xC7, 0xC0, 0x1E, 0x1E, 0x3E, 0x00,
  0xF8, 0x78, 0xF0, 0x03, 0xE3, 0xE7, 0xC3, 0x8F, 0x8F, 0x9E, 0x3F, 0xBE,
  0x7C, 0xF9, 0xFF, 0x7F, 0xF7, 0xCF, 0xFD, 0xFF, 0x9E, 0x7D, 0xF7, 0xFC,
  0xF9, 0xE3, 0xCF, 0xE7, 0xCF, 0x8F, 0x06, 0x1E, 0x3C, 0x3C, 0x00, 0xF8,
  0xF0, 0xF0, 0x03, 0xC7, 0xC3, 0xC0, 0x1F, 0x1F, 0x1F, 0x00, 0xF8, 0x78,
  0x7C, 0x03, 0xC1, 0xE1, 0xF0, 0x1F, 0x07, 0x87, 0x80, 0x78, 0x1E, 0x3E,
  0x03, 0xE0, 0x78, 0xF0, 0x1F, 0x01, 0xFF, 0xC0, 0x78, 0x07, 0xFE, 0x03,
  0xE0, 0x0F, 0xF0, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x7E, 0x7E, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x03, 0xF1, 0xF8,
  0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x0F, 0xC1, 0xFF, 0x87, 0xE0, 0xFF, 0xF1, 0xF8, 0x7E, 0xFC, 0xFC,
  0x3F, 0x3F, 0xBF, 0x1F, 0x87, 0xFF, 0x87, 0xE1, 0xFF, 0xE1, 0xF8, 0x3F,
  0xF0, 0xFC, 0x0F, 0xF8, 0x3F, 0x01, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x3F, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xF3, 0xF0, 0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0x3F, 0x3E, 0x3E, 0x7E,
  0x7E, 0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xF0,
  0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x01, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80,
  0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0x01,
  0x00, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x41, 0xF0, 0x1C, 0x7C,
  0x07, 0xDE, 0x03, 0xFF, 0x9F, 0xFF, 0xFF, 0xDF, 0xFF, 0xF0, 0xFF, 0xFC,
  0x1F, 0xFF, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x83, 0xF9, 0xF0, 0x3C,
  0x7C, 0x07, 0x1F, 0x80, 0x83, 0xC0, 0x00, 0xC0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC7, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC3, 0xE1, 0xF8, 0x7C,
  0x1F, 0x0F, 0x83, 0xE0, 0x7F, 0xFF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF,
  0xFE, 0x1C, 0xFD, 0xFF, 0xFF, 0xFF, 0xDF, 0x08, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xC0,
  0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xE3, 0xF0, 0xFC, 0x3F,
  0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF3, 0xF0, 0x3F, 0x3F, 0x03,
  0xF3, 0xF0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0,
  0x7E, 0xFE, 0x07, 0xEF, 0xC0, 0xFE, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC,
  0x0F, 0xCF, 0xC1, 0xFC, 0xFC, 0x1F, 0x8F, 0xC3, 0xF8, 0xFC, 0x3F, 0x0F,
  0xC7, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x01, 0xFE, 0x03, 0xFE, 0x07,
  0xFE, 0x0F, 0xFE, 0x3F, 0xFC, 0x7F, 0xFC, 0xFE, 0xFC, 0x7C, 0xFC, 0x38,
  0xF8, 0x31, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x01, 0x00, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0x7C, 0x3F, 0x80, 0xE0, 0x3F, 0x00, 0x80, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x07, 0xFE, 0x00,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x0E, 0x0F,
  0xE0, 0x40, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0,
  0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x20, 0x07, 0xF1, 0x80, 0x7F, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF,
  0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3D, 0xF0, 0x01, 0xF7,
  0xC0, 0x07, 0xBF, 0x00, 0x3E, 0xFC, 0x01, 0xF3, 0xF0, 0x07, 0x8F, 0x80,
  0x3C, 0x7E, 0x01, 0xF1, 0xF8, 0x0F, 0x87, 0xE0, 0x3C, 0x1F, 0x01, 0xF0,
  0xFC, 0x0F, 0x83, 0xF0, 0x3C, 0x0F, 0xC1, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF2, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0x81, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x20, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC4, 0x00, 0xFE, 0x38, 0x1F, 0xE1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF1, 0xE0, 0x1F,
  0xBF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFC, 0x7F,
  0x1F, 0xC3, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x7F, 0x07, 0xF3, 0xF0,
  0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0xFE, 0x3F, 0x07, 0xE0,
  0xFC, 0x7F, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF,
  0x80, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x06, 0x00, 0x01,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xC7,
  0xE0, 0x7E, 0x1F, 0x81, 0xF0, 0x3F, 0x0F, 0xC0, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x81, 0xF8, 0xFC, 0x07, 0xE7, 0xF0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8,
  0x07, 0xF7, 0xF0, 0x3F, 0x0F, 0xC1, 0xFC, 0x1F, 0x87, 0xE0, 0x7E, 0x1F,
  0x81, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x83,
  0xF0, 0x7F, 0xBF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F,
  0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xC7, 0xF1, 0xF8, 0x3F, 0x3F,
  0x83, 0xF3, 0xF0, 0x3F, 0x3F, 0x03, 0xF3, 0xF0, 0x3F, 0x3F, 0x07, 0xF7,
  0xF0, 0x7F, 0x7F, 0x07, 0xE7, 0xF0, 0xFE, 0x3F, 0x9F, 0xE3, 0xFF, 0xFE,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0xEF, 0xC0, 0x30, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xC0, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC1, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x3F, 0x07, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0x7C,
  0x02, 0x00, 0x00, 0x70, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x81, 0xF8,
  0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07,
  0xC0, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F,
  0x80, 0x07, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFC,
  0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x40, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF0,
  0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00,
  0x08, 0x00, 0x00, 0x00, 0xC0, 0x03, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE3,
  0xFF, 0xF1, 0xFB, 0xF8, 0x60, 0xFE, 0x40, 0x3F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x0F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xC0, 0x0F, 0x80,
  0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1E, 0x0F,
  0x81, 0xFC, 0x3C, 0x1E, 0x0F, 0xFE, 0x7C, 0x7C, 0x3F, 0xF8, 0x78, 0xF0,
  0xFF, 0xF0, 0xF3, 0xE1, 0xE1, 0xE1, 0xE7, 0x87, 0x87, 0xC3, 0xCF, 0x1F,
  0x0F, 0x0F, 0x3E, 0x3C, 0x1E, 0x1E, 0x78, 0x78, 0x3C, 0x3C, 0xF1, 0xF0,
  0xF8, 0x79, 0xE3, 0xC1, 0xE0, 0xF3, 0xC7, 0x83, 0xC3, 0xCF, 0x8F, 0x0F,
  0x87, 0x9E, 0x1E, 0x1F, 0x1E, 0x3C, 0x3C, 0x7E, 0x3C, 0x78, 0x7F, 0xFF,
  0xF0, 0xF0, 0xFF, 0xFF, 0xC1, 0xF0, 0xFE, 0x7F, 0x01, 0xE0, 0xF8, 0x7C,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x02, 0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E,
  0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x3F, 0x80, 0x7E,
  0x3F, 0x00, 0x7E, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0xFE, 0x00, 0x7F,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x03, 0xF0, 0xFE, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x7F,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFC,
  0x0F, 0xC1, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0x83, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8,
  0x3F, 0x03, 0xF8, 0x3F, 0x07, 0xF0, 0x7E, 0x0F, 0xF0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFE, 0x0E, 0x07, 0xF0, 0x08, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x02, 0x03, 0xF8, 0x18, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x1F, 0x8F, 0xF8, 0x0F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7E,
  0x07, 0xE0, 0x3F, 0x83, 0xF0, 0x1F, 0xC1, 0xF8, 0x0F, 0xE0, 0xFC, 0x07,
  0xF0, 0xFE, 0x03, 0xF8, 0x7E, 0x01, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x80,
  0x7E, 0x0F, 0xC0, 0x3F, 0x0F, 0xE0, 0x3F, 0x87, 0xE0, 0x1F, 0xC3, 0xF0,
  0x0F, 0xC1, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0x7E,
  0x03, 0xF8, 0x3F, 0x03, 0xF8, 0x1F, 0x87, 0xF8, 0x1F, 0xDF, 0xFC, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x20, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xE0, 0x38, 0x1F, 0xE0, 0x08,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x1F,
  0xFC, 0xFE, 0x0F, 0xFC, 0x7F, 0x07, 0xFE, 0x3F, 0x83, 0xFF, 0x1F, 0xC3,
  0xFF, 0x8F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8,
  0x03, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xF8, 0x3F, 0x80, 0xFC, 0x0F,
  0xF0, 0x7E, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x3F,
  0x00, 0xFC, 0x0F, 0xE0, 0x1F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x00, 0xFC,
  0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xE0,
  0x1F, 0xC0, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0,
  0xFE, 0x03, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7E, 0x01, 0xF8, 0x0F,
  0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F,
  0x81, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x81, 0xFC,
  0x07, 0xF0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0,
  0x1F, 0x80, 0x7E, 0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0x03, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F,
  0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x03,
  0xF8, 0x0F, 0xC0, 0xFE, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x07, 0xF0, 0x07,
  0xE1, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE3, 0xF8,
  0x00, 0xFC, 0xFE, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFD,
  0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xEF,
  0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xC3, 0xF0, 0x01,
  0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xFC, 0x01, 0xF8, 0x3F,
  0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xE0, 0x1F,
  0x81, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xFC, 0x07, 0xFC, 0x01, 0xFF,
  0x80, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0xFB, 0xC0, 0x7F, 0xF0, 0x1F, 0x78, 0x0F, 0xFE, 0x03, 0xEF,
  0x03, 0xEF, 0x80, 0xFD, 0xE0, 0x7D, 0xF0, 0x1F, 0xBE, 0x1F, 0x7E, 0x03,
  0xF7, 0xC3, 0xEF, 0xC0, 0x7C, 0xF8, 0xF9, 0xF8, 0x0F, 0x9F, 0x1F, 0x3E,
  0x03, 0xF3, 0xE7, 0xCF, 0xC0, 0x7E, 0x7C, 0xF9, 0xF8, 0x0F, 0x8F, 0xBF,
  0x3F, 0x01, 0xF1, 0xF7, 0xC7, 0xC0, 0x7E, 0x3E, 0xF8, 0xF8, 0x0F, 0xC7,
  0xFE, 0x3F, 0x01, 0xF8, 0xFF, 0xC7, 0xE0, 0x3E, 0x1F, 0xF0, 0xFC, 0x07,
  0xC3, 0xFE, 0x1F, 0x01, 0xF8, 0x7F, 0x83, 0xE0, 0x3F, 0x0F, 0xF0, 0xFC,
  0x07, 0xE1, 0xFC, 0x1F, 0x80, 0xF8, 0x3F, 0x83, 0xF0, 0x1F, 0x07, 0xE0,
  0x7C, 0x07, 0xE0, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x01, 0xF8, 0x0F, 0xE0,
  0x0F, 0xC0, 0xFF, 0x00, 0x7C, 0x07, 0xFC, 0x03, 0xE0, 0x3F, 0xE0, 0x3F,
  0x01, 0xFF, 0x01, 0xF8, 0x0F, 0xF8, 0x0F, 0xC0, 0xFF, 0xE0, 0x7C, 0x07,
  0xFF, 0x03, 0xE0, 0x3E, 0xF8, 0x3F, 0x01, 0xF7, 0xC1, 0xF8, 0x0F, 0xBE,
  0x0F, 0xC0, 0xFD, 0xF8, 0x7C, 0x07, 0xEF, 0xC7, 0xE0, 0x3F, 0x3E, 0x3F,
  0x01, 0xF1, 0xF1, 0xF8, 0x0F, 0x8F, 0xCF, 0x80, 0xFC, 0x7E, 0x7C, 0x07,
  0xE3, 0xF3, 0xE0, 0x3E, 0x0F, 0xBF, 0x01, 0xF0, 0x7D, 0xF8, 0x1F, 0x83,
  0xFF, 0x80, 0xFC, 0x1F, 0xFC, 0x07, 0xE0, 0x7F, 0xE0, 0x3E, 0x03, 0xFF,
  0x01, 0xF0, 0x1F, 0xF8, 0x1F, 0x80, 0xFF, 0x80, 0xFC, 0x07, 0xFC, 0x07,
  0xE0, 0x1F, 0xE0, 0x3E, 0x00, 0xFF, 0x01, 0xF0, 0x07, 0xF8, 0x1F, 0x80,
  0x3F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F,
  0xE0, 0x7F, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x3F, 0x80, 0x3F, 0x3F,
  0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0xFC,
  0x01, 0xFC, 0xFC, 0x01, 0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF0, 0x7F,
  0x0F, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xF0, 0xFF, 0x03,
  0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07,
  0xE0, 0x7F, 0x07, 0xE0, 0x7F, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0xFE, 0x0F,
  0xC1, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F,
  0xF0, 0xFF, 0x0F, 0xE0, 0x7F, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x3F,
  0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7F,
  0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC,
  0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0xFE,
  0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7E,
  0x1F, 0xC0, 0xFC, 0x3F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0,
  0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F,
  0x83, 0xF1, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80,
  0x7F, 0xFE, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x07, 0xE3, 0xF0, 0x0F,
  0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0xC1, 0xF8,
  0x3F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFE, 0x1F, 0x81,
  0xFC, 0x7E, 0x01, 0xF8, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0x07, 0x03,
  0xF8, 0x04, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC2, 0x00, 0x7F, 0x0C, 0x01, 0xF8, 0x3E, 0x1F, 0xE0, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F,
  0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x03, 0xF8, 0x7F, 0x01,
  0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0,
  0x3F, 0x87, 0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC,
  0x07, 0xF0, 0x7E, 0x03, 0xF8, 0x7F, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F,
  0x80, 0x7E, 0x0F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x07, 0xF0, 0x1F, 0x83,
  0xF0, 0x0F, 0xC1, 0xF8, 0x0F, 0xE0, 0xFC, 0x07, 0xE0, 0x7F, 0x07, 0xF0,
  0x3F, 0x87, 0xF8, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xFB, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0x1F, 0x80, 0x7E,
  0x3F, 0x01, 0xFC, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x1F, 0x83,
  0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x0F, 0x87, 0xE0, 0x1F,
  0x0F, 0xC0, 0x3E, 0x3F, 0x00, 0x7C, 0x7E, 0x00, 0xF8, 0xFC, 0x01, 0xF3,
  0xF0, 0x03, 0xE7, 0xE0, 0x07, 0xDF, 0x80, 0x0F, 0xBF, 0x00, 0x1F, 0x7C,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0x00, 0xFC, 0x07, 0xEF,
  0xC0, 0x7F, 0x01, 0xFB, 0xF0, 0x1F, 0xC0, 0x7E, 0xFC, 0x07, 0xF0, 0x3F,
  0x3F, 0x03, 0xFC, 0x0F, 0xCF, 0xC0, 0xFF, 0x07, 0xE3, 0xF0, 0x7F, 0xC1,
  0xF8, 0xFC, 0x1F, 0xE0, 0x7E, 0x3F, 0x07, 0xF8, 0x3F, 0x0F, 0xC3, 0xFE,
  0x0F, 0xC3, 0xF0, 0xF7, 0x83, 0xE0, 0xF8, 0x7D, 0xE1, 0xF8, 0x3E, 0x1F,
  0x78, 0x7E, 0x0F, 0x8F, 0x9E, 0x3F, 0x03, 0xE3, 0xEF, 0x8F, 0xC0, 0xF8,
  0xF9, 0xE3, 0xE0, 0x3E, 0x7C, 0x79, 0xF8, 0x0F, 0x9F, 0x1E, 0x7E, 0x03,
  0xEF, 0x8F, 0xBF, 0x00, 0xFB, 0xE3, 0xEF, 0xC0, 0x3E, 0xF8, 0xFB, 0xE0,
  0x0F, 0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0x83, 0xFF,
  0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFC, 0x0F,
  0xF8, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x0F, 0xE0,
  0x3F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x0F,
  0xC0, 0x7E, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x1F,
  0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE7, 0xF0, 0x00,
  0x3F, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xBF, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x7E,
  0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0x81, 0xF8,
  0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xC0, 0xFC,
  0x03, 0xFF, 0xE0, 0x1F, 0xBF, 0x81, 0xFC, 0xFC, 0x0F, 0xC7, 0xE0, 0xFC,
  0x3F, 0x07, 0xE1, 0xF8, 0x7E, 0x0F, 0xC7, 0xF0, 0x7E, 0x3F, 0x01, 0xF3,
  0xF0, 0x0F, 0xDF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xF8, 0x00, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xE3, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xE3, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xE3, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0x3E, 0x00, 0xF8, 0xF0,
  0x0F, 0x87, 0xC0, 0xFC, 0x3E, 0x07, 0xC1, 0xF0, 0x7C, 0x07, 0x83, 0xE0,
  0x3E, 0x3E, 0x01, 0xF3, 0xF0, 0x0F, 0x9F, 0x00, 0x3F, 0xF0, 0x01, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x7E, 0x3E, 0x3F, 0x1F,
  0x0F, 0x00, 0xF8, 0xFC, 0x0F, 0xF3, 0xE0, 0x7F, 0xEF, 0x83, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x7F, 0x1F, 0xE1, 0xF8, 0x7F, 0x0F, 0xE0, 0xFC, 0x3F,
  0x03, 0xF1, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07,
  0xE1, 0xF8, 0x1F, 0x8F, 0xE0, 0x7E, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3,
  0xF0, 0x7F, 0x0F, 0xC1, 0xFC, 0x3F, 0x8F, 0xF0, 0xFF, 0xFF, 0x81, 0xFF,
  0xFE, 0x07, 0xFE, 0xF8, 0x0F, 0xF3, 0xE0, 0x1F, 0x8F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x3E,
  0x01, 0xFB, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x3F,
  0xC7, 0xE1, 0xFC, 0x3F, 0x0F, 0xC1, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E,
  0x3F, 0x03, 0xF1, 0xF0, 0x1F, 0x8F, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xE0,
  0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC1, 0xF8, 0xFE, 0x0F, 0xC7,
  0xF0, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xF9, 0xFF,
  0x07, 0xC7, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFF, 0x87, 0xF8, 0xC1, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8,
  0x30, 0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0xF8, 0xFC, 0x03, 0xFD, 0xF8, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xC7, 0xF0, 0x1F, 0x87,
  0xF0, 0x3F, 0x83, 0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0x03, 0xF0, 0x7E, 0x03,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x07,
  0xE0, 0xFC, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F,
  0xC0, 0xFE, 0x1F, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0x80, 0x3F, 0xEF, 0x80, 0x1F, 0x8F, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0,
  0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0x87, 0xC7, 0xE0, 0xF9,
  0xF8, 0x1F, 0x3F, 0x07, 0xEF, 0xC1, 0xF9, 0xF9, 0xFF, 0x3F, 0xFF, 0xC7,
  0xFF, 0xF1, 0xFF, 0xF8, 0x3F, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x87, 0xF0, 0xF0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x9F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x3F, 0x00, 0xFF, 0x3E, 0x01, 0xFF, 0xBE, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x07, 0xF1, 0xFE, 0x07, 0xE1, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x1F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x07, 0xF0, 0x3F, 0x07, 0xF0, 0x3F, 0x8F, 0xF0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xF7, 0xE0, 0x07, 0xE7,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x80, 0x1F, 0x80, 0xF0, 0x7F, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x3E,
  0x01, 0xFB, 0xFC, 0x0F, 0xBF, 0xE0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x3F,
  0xCF, 0xE1, 0xFC, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC7, 0xE0, 0x7E,
  0x3F, 0x03, 0xF1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0,
  0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0xFC, 0x0F, 0xC7,
  0xE0, 0x7E, 0x3F, 0x03, 0xE1, 0xF8, 0x3F, 0x0F, 0x81, 0xF8, 0xFC, 0x0F,
  0xC7, 0xE0, 0x7E, 0x00, 0x00, 0xF0, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x04, 0xFF, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x3F, 0x0F, 0xE0, 0x7C, 0x3F,
  0x81, 0xF8, 0x7E, 0x03, 0xF1, 0xF8, 0x07, 0xE7, 0xE0, 0x0F, 0x9F, 0x80,
  0x1F, 0x7F, 0x00, 0x7E, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7E,
  0x7E, 0x00, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3,
  0xF0, 0x1F, 0x87, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F,
  0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xC7, 0xC0,
  0x78, 0x07, 0xCF, 0xF1, 0xFE, 0x07, 0xDF, 0xF3, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xF3, 0xFE, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x0F, 0xC1, 0xF8, 0x3F, 0x1F, 0xC1, 0xF8, 0x3F, 0x1F, 0x81, 0xF0,
  0x3F, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0x03, 0xF0,
  0x7E, 0x3F, 0x03, 0xF0, 0x7E, 0x3F, 0x07, 0xE0, 0x7C, 0x3F, 0x07, 0xE0,
  0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x3E, 0x07, 0xE0, 0xFC, 0x7E, 0x07, 0xC0,
  0xFC, 0x7E, 0x0F, 0xC0, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC1,
  0xF8, 0x7C, 0x0F, 0xC1, 0xF8, 0xFC, 0x0F, 0x81, 0xF8, 0xFC, 0x1F, 0x83,
  0xF0, 0x07, 0xC3, 0xC0, 0x3E, 0x7F, 0x81, 0xF7, 0xFC, 0x0F, 0x7F, 0xF0,
  0xFF, 0xFF, 0x87, 0xF9, 0xFC, 0x3F, 0x87, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1,
  0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x1F,
  0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x07, 0xE1, 0xF8, 0x3F,
  0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7C, 0x3F, 0x07, 0xE1, 0xF0,
  0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x1F, 0xF8,
  0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE1, 0xFC, 0x7E, 0x3F, 0x87,
  0xF3, 0xF0, 0x3F, 0x3F, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0,
  0x3F, 0x7E, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC,
  0x0F, 0xEF, 0xC0, 0xFC, 0xFC, 0x1F, 0xC7, 0xE3, 0xF8, 0x7F, 0xFF, 0x87,
  0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x08, 0x00,
  0x01, 0xF1, 0xF0, 0x03, 0xE7, 0xF8, 0x07, 0xDF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x7F, 0x8F, 0xC0, 0xFE, 0x1F, 0x81, 0xF8, 0x3F, 0x03,
  0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7C,
  0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0x07, 0xE0, 0xFE, 0x1F, 0xC1, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x07, 0xDF, 0xF8, 0x1F, 0xBF, 0xE0, 0x3F, 0x3F, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x7C, 0x0F,
  0xF3, 0xE0, 0x7F, 0xEF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0x1F,
  0xC1, 0xF8, 0x7F, 0x0F, 0xE0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC7,
  0xE0, 0x3E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x8F, 0xC0,
  0x7E, 0x3F, 0x01, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F,
  0xF7, 0xE0, 0x1F, 0x9F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x07,
  0xC7, 0xC1, 0xF3, 0xF0, 0x7D, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF,
  0xE0, 0xFF, 0x88, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFF,
  0xE0, 0xFF, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0xE0, 0xC1, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE3, 0x03, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x83,
  0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0,
  0x07, 0xC0, 0x3F, 0xF3, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xE1, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xC0,
  0xF8, 0x7E, 0x0F, 0xC3, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F,
  0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F,
  0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8,
  0x1F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xE0, 0xFE, 0x3F, 0x07, 0xF1,
  0xFC, 0x7F, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xBE, 0x0F, 0xF9,
  0xE0, 0x3F, 0x8F, 0x00, 0xF8, 0x07, 0xFF, 0x01, 0xFB, 0xE0, 0x3F, 0x7C,
  0x0F, 0xCF, 0x81, 0xF9, 0xF0, 0x3F, 0x3E, 0x0F, 0xC7, 0xC1, 0xF8, 0xF8,
  0x7E, 0x1F, 0x0F, 0xC3, 0xE3, 0xF0, 0x7C, 0x7E, 0x0F, 0xCF, 0x81, 0xFB,
  0xF0, 0x3F, 0x7C, 0x07, 0xDF, 0x80, 0xFB, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x1F, 0xC1, 0xFF, 0xC0, 0xFE, 0x0F, 0xFE,
  0x0F, 0xF0, 0x7D, 0xF0, 0x7F, 0x87, 0xEF, 0x83, 0xFC, 0x3F, 0x7C, 0x3F,
  0xE3, 0xF3, 0xE1, 0xFE, 0x1F, 0x9F, 0x1F, 0xF0, 0xF8, 0xF8, 0xFF, 0x8F,
  0xC7, 0xC7, 0xBC, 0x7C, 0x3E, 0x7D, 0xE7, 0xE1, 0xF3, 0xCF, 0x3F, 0x0F,
  0xBE, 0x79, 0xF0, 0x7D, 0xF3, 0xDF, 0x83, 0xEF, 0x1E, 0xF8, 0x1F, 0xF8,
  0xF7, 0xC0, 0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF,
  0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x80, 0x7F, 0x87, 0xF8, 0x03,
  0xF8, 0x3F, 0xC0, 0x1F, 0xC1, 0xFE, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x7F, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0xFE, 0x03, 0xF0, 0xFC, 0x03,
  0xF1, 0xF8, 0x01, 0xFB, 0xF8, 0x01, 0xFB, 0xF0, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xDF, 0x80, 0x0F, 0xCF, 0xC0, 0x1F,
  0x8F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x7E, 0x0F, 0xE0, 0xFE,
  0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x81, 0xF0, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0,
  0x7E, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC3, 0xF0,
  0x07, 0xE1, 0xF8, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0x3E, 0x7E, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xDF,
  0x00, 0x03, 0xEF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x02,
  0x3F, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x0F,
  0xF8, 0x01, 0xFE, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F,
  0xC0, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0,
  0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xC0, 0x00,
  0x08, 0x00, 0x17, 0xFC, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFE, 0x80, 0x7F, 0xC8, 0x00, 0xF0,
};

const GFXglyph NotoSans_Condensed_BoldItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 13, 33, 12, 0, -32 },
  { 55, 16, 11, 19, 4, -32 },
  { 77, 25, 32, 24, 0, -32 },
  { 177, 22, 37, 21, 0, -34 },
  { 279, 30, 33, 34, 2, -33 },
  { 403, 26, 33, 26, 0, -33 },
  { 511, 8, 11, 11, 4, -32 },
  { 522, 15, 39, 13, 1, -32 },
  { 596, 15, 40, 13, -3, -33 },
  { 671, 18, 20, 20, 4, -35 },
  { 716, 19, 22, 22, 2, -27 },
  { 769, 10, 12, 11, -2, -6 },
  { 784, 12, 6, 13, 1, -15 },
  { 793, 7, 8, 11, 0, -7 },
  { 800, 23, 32, 17, -2, -32 },
  { 892, 20, 33, 21, 1, -33 },
  { 975, 16, 32, 21, 4, -32 },
  { 1039, 23, 33, 21, -2, -33 },
  { 1134, 21, 33, 21, 0, -33 },
  { 1221, 22, 32, 21, -1, -32 },
  { 1309, 21, 32, 21, 0, -32 },
  { 1393, 21, 33, 21, 1, -33 },
  { 1480, 22, 32, 21, 1, -32 },
  { 1568, 22, 33, 21, 0, -33 },
  { 1659, 20, 33, 21, 1, -33 },
  { 1742, 11, 26, 12, 0, -25 },
  { 1778, 13, 31, 12, -2, -25 },
  { 1829, 19, 22, 22, 2, -27 },
  { 1882, 19, 14, 22, 2, -23 },
  { 1916, 20, 22, 22, 2, -27 },
  { 1971, 17, 34, 17, 2, -33 },
  { 2044, 31, 36, 32, 1, -32 },
  { 2184, 24, 32, 23, -3, -32 },
  { 2280, 24, 32, 23, 0, -32 },
  { 2376, 23, 33, 22, 2, -33 },
  { 2471, 25, 32, 25, 0, -32 },
  { 2571, 22, 32, 20, 0, -32 },
  { 2659, 22, 32, 19, 0, -32 },
  { 2747, 25, 33, 26, 2, -33 },
  { 2851, 27, 32, 26, 0, -32 },
  { 2959, 20, 32, 15, -2, -32 },
  { 3039, 21, 42, 12, -7, -32 },
  { 3150, 27, 32, 23, 0, -32 },
  { 3258, 16, 32, 19, 0, -32 },
  { 3322, 35, 32, 34, 0, -32 },
  { 3462, 29, 32, 28, 0, -32 },
  { 3578, 24, 33, 27, 2, -33 },
  { 3677, 24, 32, 23, 0, -32 },
  { 3773, 24, 41, 27, 2, -33 },
  { 3896, 23, 32, 23, 0, -32 },
  { 3988, 22, 33, 20, 0, -33 },
  { 4079, 19, 32, 20, 4, -32 },
  { 4155, 25, 32, 26, 2, -32 },
  { 4255, 23, 32, 23, 4, -32 },
  { 4347, 34, 32, 34, 4, -32 },
  { 4483, 28, 32, 22, -3, -32 },
  { 4595, 21, 32, 21, 4, -32 },
  { 4679, 24, 32, 19, -2, -32 },
  { 4775, 18, 39, 13, -1, -32 },
  { 4863, 9, 32, 18, 5, -32 },
  { 4899, 18, 39, 13, -3, -32 },
  { 4987, 21, 20, 21, 0, -32 },
  { 5040, 16, 3, 16, -4, 4 },
  { 5046, 8, 7, 14, 7, -34 },
  { 5053, 22, 25, 23, 1, -25 },
  { 5122, 21, 34, 23, 0, -34 },
  { 5212, 18, 25, 18, 1, -25 },
  { 5269, 24, 34, 23, 1, -34 },
  { 5371, 19, 25, 21, 1, -25 },
  { 5431, 24, 45, 14, -5, -34 },
  { 5566, 24, 36, 23, -1, -25 },
  { 5674, 21, 34, 23, 0, -34 },
  { 5764, 13, 34, 11, 0, -34 },
  { 5820, 19, 45, 11, -6, -34 },
  { 5927, 23, 34, 21, 0, -34 },
  { 6025, 13, 34, 11, 0, -34 },
  { 6081, 32, 25, 33, 0, -25 },
  { 6181, 21, 25, 23, 0, -25 },
  { 6247, 20, 26, 22, 1, -25 },
  { 6312, 23, 36, 23, -2, -25 },
  { 6416, 22, 36, 23, 1, -25 },
  { 6515, 18, 25, 16, 0, -25 },
  { 6572, 18, 25, 18, 0, -25 },
  { 6629, 14, 30, 15, 2, -30 },
  { 6682, 21, 25, 22, 1, -25 },
  { 6748, 19, 25, 19, 3, -25 },
  { 6808, 29, 25, 30, 3, -25 },
  { 6899, 24, 25, 20, -2, -25 },
  { 6974, 25, 36, 20, -3, -25 },
  { 7087, 19, 25, 17, -1, -25 },
  { 7147, 19, 39, 15, 0, -32 },
  { 7240, 5, 44, 19, 7, -34 },
  { 7268, 18, 39, 15, -3, -32 },
  { 7356, 20, 8, 22, 2, -20 },
};

const GFXfont NotoSans_Condensed_BoldItalic45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic45pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC45PT7B_H_
