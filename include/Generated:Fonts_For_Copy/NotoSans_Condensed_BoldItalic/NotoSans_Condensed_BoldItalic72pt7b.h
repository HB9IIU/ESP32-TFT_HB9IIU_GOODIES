#ifndef _NOTOSANS_CONDENSED_BOLDITALIC72PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0x9F, 0xF8, 0x7F,
  0xCF, 0xF8, 0x3F, 0xE7, 0xFC, 0x3F, 0xE3, 0xFE, 0x1F, 0xF1, 0xFE, 0x0F,
  0xF8, 0xFF, 0x07, 0xFC, 0xFF, 0x83, 0xFC, 0x7F, 0xC1, 0xFE, 0x3F, 0xC0,
  0xFF, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF0, 0x3F, 0xC3, 0xF8,
  0x1F, 0xE3, 0xFC, 0x0F, 0xE1, 0xFE, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7F,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x81, 0xFC, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xF9, 0xCF, 0xE0, 0x0F, 0xFC,
  0xF0, 0xF0, 0x03, 0xFE, 0x3C, 0x08, 0x00, 0xFF, 0x8F, 0x00, 0x00, 0x3F,
  0xE3, 0x80, 0x00, 0x0F, 0xF8, 0xE0, 0x00, 0x03, 0xFE, 0x78, 0x00, 0x00,
  0xFF, 0xDE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x0F, 0x7F, 0xF0, 0x00, 0x03, 0xDF, 0xFC, 0x00, 0x00, 0xE3, 0xFF, 0x00,
  0x00, 0x38, 0xFF, 0xC1, 0x00, 0x1E, 0x3F, 0xE0, 0x40, 0x07, 0x8F, 0xF8,
  0x1C, 0x01, 0xC7, 0xFE, 0x0F, 0xC0, 0x71, 0xFF, 0x83, 0xFE, 0x1D, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x20, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x0F,
  0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x1F,
  0xE3, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xC3, 0xFC, 0x01, 0xFC, 0x00, 0x3F,
  0xC3, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0x83, 0xFC, 0x03, 0xF8, 0x00, 0x3F,
  0x83, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x00, 0x7F,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFF, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE,
  0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFE, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0xFE,
  0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0xFE, 0x01, 0x80, 0xFE,
  0x0F, 0xF1, 0xFC, 0x1F, 0xF0, 0xFE, 0x0F, 0xE3, 0xFC, 0x3F, 0xF8, 0xFE,
  0x1F, 0xE3, 0xF8, 0x7F, 0xFC, 0xFE, 0x1F, 0xC7, 0xF0, 0xFF, 0xFE, 0xFF,
  0x7F, 0xC7, 0xF1, 0xFF, 0xFE, 0xFF, 0xFF, 0x8F, 0xE3, 0xFF, 0xFE, 0x7F,
  0xFF, 0x1F, 0xE3, 0xFC, 0xFF, 0x7F, 0xFF, 0x1F, 0xC7, 0xF8, 0xFF, 0x3F,
  0xFE, 0x3F, 0x87, 0xF0, 0x7F, 0x1F, 0xF8, 0x3F, 0x8F, 0xF0, 0x7F, 0x0F,
  0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x7F, 0x00,
  0x00, 0xFE, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0xFF, 0x00,
  0x01, 0xFC, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x00,
  0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0x81, 0xFC, 0x00,
  0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0x83, 0xFC, 0x00,
  0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x87, 0xF8, 0x00,
  0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xF1, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x00,
  0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xFE,
  0x03, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFE,
  0x0F, 0xFF, 0xFF, 0x07, 0xFC, 0x1F, 0xFD, 0xFF, 0x8F, 0xFC, 0x3F, 0xF9,
  0xFF, 0x8F, 0xF8, 0x3F, 0xF0, 0xFF, 0xDF, 0xF8, 0x7F, 0xE0, 0xFF, 0xDF,
  0xF0, 0x7F, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0,
  0x7F, 0xFF, 0x00, 0xFF, 0xFB, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0xF3, 0xFF, 0x3F, 0xF3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xC3, 0xFC,
  0x7F, 0xC7, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x0F, 0xF0,
  0xFF, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0xC0, 0x3F, 0xC0, 0x07, 0x81, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xFE,
  0x7F, 0x00, 0x1F, 0xFB, 0xF0, 0x3C, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFD, 0xFC, 0x00, 0x7F, 0xEF,
  0xF0, 0x0F, 0xFE, 0x7F, 0x80, 0x3F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0,
  0x03, 0xF0, 0x7F, 0xC0, 0x0F, 0x01, 0xFF, 0x00, 0x38, 0x0F, 0xC0, 0x00,
  0x80, 0x78, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F,
  0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF,
  0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF,
  0xFF, 0xC0, 0x07, 0xC1, 0xFE, 0x3F, 0xE7, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xE7, 0xFC, 0x7F, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xEF, 0xFE, 0x03, 0xFF, 0x07, 0xFC, 0x0F,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xE0, 0x3F, 0xE0, 0xFF,
  0x80, 0x7F, 0xC3, 0xFF, 0x00, 0xFF, 0x87, 0xFE, 0x01, 0xFF, 0x1F, 0xF8,
  0x03, 0xFE, 0x3F, 0xF0, 0x07, 0xFC, 0x7F, 0xC0, 0x0F, 0xF9, 0xFF, 0x80,
  0x1F, 0xF3, 0xFF, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0xFF, 0xCF, 0xF8, 0x01,
  0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0x7F, 0xE0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F,
  0xFD, 0xFF, 0x80, 0x1F, 0xF3, 0xFE, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0xFF,
  0xDF, 0xF8, 0x01, 0xFF, 0xBF, 0xF0, 0x03, 0xFE, 0x7F, 0xE0, 0x0F, 0xFC,
  0xFF, 0xC0, 0x1F, 0xF9, 0xFF, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0xFF, 0xC7,
  0xFC, 0x01, 0xFF, 0x8F, 0xF8, 0x03, 0xFF, 0x1F, 0xF0, 0x0F, 0xFC, 0x3F,
  0xE0, 0x1F, 0xF8, 0x7F, 0xC0, 0x7F, 0xF0, 0xFF, 0x80, 0xFF, 0xC1, 0xFF,
  0x03, 0xFF, 0x83, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x1F, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x8F,
  0xFF, 0x7F, 0xC7, 0xFF, 0x7F, 0xE1, 0xFF, 0x3F, 0xE0, 0xFF, 0x1F, 0xF0,
  0x3E, 0x0F, 0xF8, 0x0E, 0x0F, 0xFC, 0x02, 0x07, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xF3, 0xFF, 0xE0, 0x03, 0xFC, 0x0F, 0xFE, 0x00,
  0x3F, 0x00, 0x7F, 0xF0, 0x01, 0xE0, 0x07, 0xFF, 0x00, 0x1C, 0x00, 0x3F,
  0xF0, 0x00, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xC3, 0xFF, 0xE0,
  0x03, 0xC0, 0x1F, 0xFC, 0x00, 0x70, 0x03, 0xFF, 0x80, 0x08, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x10, 0x00, 0x03, 0xFF, 0x83,
  0x80, 0x00, 0xFF, 0xE0, 0x7C, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xEF, 0xF8, 0x00, 0x03,
  0xF9, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xCF, 0xF8, 0x00,
  0x07, 0xF1, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0x8F, 0xFC,
  0x00, 0x0F, 0xE1, 0xFF, 0x00, 0x03, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x07,
  0xFC, 0x00, 0x1F, 0xC1, 0xFF, 0x80, 0x07, 0xF0, 0x3F, 0xE0, 0x01, 0xFE,
  0x07, 0xFC, 0x00, 0x3F, 0x80, 0xFF, 0x80, 0x0F, 0xE0, 0x1F, 0xF0, 0x03,
  0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x1F, 0xF0,
  0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x02, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x80, 0x00, 0x7F, 0xF0, 0x38, 0x00, 0x3F, 0xFC, 0x0F, 0xC0,
  0x3F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xE8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x03, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x1F, 0xF1, 0xFF, 0xC0, 0x07, 0xFC,
  0xFF, 0xF8, 0x03, 0xFF, 0x7F, 0xFF, 0x00, 0xFF, 0xBF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xF0, 0x7F, 0xE0, 0x7F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x03, 0xFE,
  0x07, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xE0, 0x0F,
  0xF8, 0x3F, 0xF0, 0x03, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x00,
  0x7F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF0, 0x07, 0xFE, 0x0F, 0xFC,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x87, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0xFF, 0xC0,
  0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x07, 0xFC,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80,
  0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x03, 0xFF, 0x1F, 0xF8,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF3, 0xFF, 0x80, 0x7F,
  0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x03,
  0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xE0, 0x07, 0xFC,
  0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x1F,
  0xF0, 0xFF, 0xC0, 0x07, 0xFC, 0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFE, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xF8, 0x7F, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xCF, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFC, 0x01,
  0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x01,
  0xFF, 0x0F, 0xF8, 0x03, 0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0x1F, 0xF8, 0x03,
  0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0x1F, 0xF8, 0x07, 0xFF, 0x1F, 0xF8, 0x07,
  0xFF, 0x1F, 0xF8, 0x07, 0xFF, 0x1F, 0xF8, 0x0F, 0xFF, 0x1F, 0xF8, 0x1F,
  0xFE, 0x1F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xF7,
  0xFC, 0x03, 0xFF, 0xEF, 0xF8, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x7E, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0xE0, 0x0F, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x0F, 0xC0, 0xFF, 0xE1, 0xE0, 0x0F, 0xFC, 0x10, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x07,
  0xF0, 0x03, 0xFF, 0x00, 0xFC, 0x07, 0xF0, 0x07, 0xFF, 0xF8, 0x7F, 0x03,
  0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0x83, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xC3,
  0xF8, 0x0F, 0xFF, 0xFE, 0x0F, 0xE1, 0xFC, 0x0F, 0xFD, 0xFF, 0x07, 0xF0,
  0xFC, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x7F, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x7E,
  0x3F, 0x83, 0xF8, 0x07, 0xE0, 0x3F, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x1F,
  0x8F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xCF, 0xE0, 0xFE, 0x01, 0xFC, 0x0F,
  0xE7, 0xF0, 0x7F, 0x01, 0xFC, 0x07, 0xE3, 0xF8, 0x3F, 0x80, 0xFE, 0x03,
  0xF1, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0xFC, 0x1F, 0xC0, 0x3F, 0x81,
  0xFC, 0xFE, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x7F, 0x07, 0xF0, 0x1F, 0xC0,
  0xFE, 0x3F, 0x83, 0xF8, 0x1F, 0xE0, 0x7E, 0x1F, 0xC1, 0xFC, 0x0F, 0xF0,
  0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xF8, 0x3F, 0x07, 0xF0, 0x7F, 0x8F, 0xFC,
  0x3F, 0x83, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x81, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0xFE, 0x07, 0xFF, 0xCF, 0xFF, 0x80, 0x7F, 0x01, 0xFF, 0xC7,
  0xFF, 0x80, 0x3F, 0x80, 0x7F, 0xC1, 0xFF, 0x80, 0x0F, 0xC0, 0x1F, 0x80,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x40, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xBF,
  0xC0, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x01,
  0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x00, 0xFF, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x07, 0xFC,
  0x3F, 0xE0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xF8, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x3F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF8,
  0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFE, 0x07, 0xFE,
  0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFC,
  0x3F, 0xF0, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x01, 0xFF, 0x8F, 0xFC, 0x00,
  0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x03, 0xFF, 0x7F,
  0xE0, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x3F,
  0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x1F,
  0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x3F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xFF,
  0x80, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFF, 0x00,
  0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x07,
  0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x1F,
  0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x3C, 0x00, 0x7F, 0xF8, 0x00, 0x60,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x30, 0x00, 0xFF, 0xF8, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xFC,
  0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x00, 0x7F,
  0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x0F,
  0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x07, 0xFE, 0x00,
  0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xF8,
  0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFC,
  0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFF,
  0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x80, 0x1F,
  0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xF0,
  0x01, 0xFF, 0xF0, 0x00, 0x30, 0x03, 0xFF, 0xE0, 0x00, 0x10, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xF0, 0x7F, 0xF0,
  0x0F, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xFF, 0xF0, 0x7F, 0xE0, 0x1F, 0xFF,
  0xF0, 0x7F, 0xE0, 0x1F, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF, 0xE0, 0x00,
  0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0xFF, 0xE0,
  0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x7F,
  0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xFE, 0x07,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x39,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x0F, 0xF8,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x3F,
  0xF8, 0x00, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0x87, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x07, 0xFC,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x8F, 0xFE, 0x00, 0x00, 0x1F, 0xF1, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xDF, 0xFC, 0x00,
  0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xF1, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x87, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x00,
  0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x1F,
  0xEF, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0x7F,
  0x80, 0x3F, 0xDF, 0xF0, 0x01, 0xFF, 0x7F, 0x80, 0x3F, 0xDF, 0xF0, 0x01,
  0xFF, 0x7F, 0x80, 0x7F, 0xBF, 0xF0, 0x01, 0xFF, 0x7F, 0x80, 0x7F, 0xBF,
  0xE0, 0x01, 0xFE, 0x7F, 0x80, 0xFF, 0x3F, 0xE0, 0x03, 0xFE, 0x7F, 0x80,
  0xFF, 0x3F, 0xE0, 0x03, 0xFE, 0x7F, 0x81, 0xFE, 0x3F, 0xE0, 0x03, 0xFE,
  0x7F, 0x81, 0xFE, 0x7F, 0xE0, 0x03, 0xFE, 0x7F, 0x83, 0xFE, 0x7F, 0xC0,
  0x03, 0xFE, 0x7F, 0x83, 0xFC, 0x7F, 0xC0, 0x07, 0xFC, 0x7F, 0x83, 0xFC,
  0x7F, 0xC0, 0x07, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0xC0, 0x07, 0xFC, 0x7F,
  0x87, 0xF8, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0x8F, 0xF0, 0xFF, 0x80, 0x07,
  0xF8, 0x7F, 0x8F, 0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0x9F, 0xE0, 0xFF,
  0x80, 0x0F, 0xF8, 0x3F, 0x9F, 0xE1, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xBF,
  0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xBF, 0xC1, 0xFF, 0x00, 0x1F, 0xF0,
  0x3F, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0x00,
  0x1F, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xFF, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F,
  0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xFE, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x3F, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xFC, 0x07, 0xFC,
  0x00, 0x3F, 0xC0, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xF8,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xC0, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF7, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xDF,
  0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0x7F, 0xC0, 0x3F, 0xE0, 0x03, 0xFD, 0xFF,
  0x00, 0xFF, 0x80, 0x1F, 0xF3, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xCF, 0xF8,
  0x1F, 0xF0, 0x01, 0xFF, 0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xF8, 0xFF, 0x81,
  0xFF, 0x00, 0x3F, 0xE3, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0x87, 0xF8, 0x3F,
  0xE0, 0x03, 0xFE, 0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE,
  0x00, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFC, 0x3F, 0xC0,
  0x07, 0xFC, 0x0F, 0xF9, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE7, 0xFC, 0x00,
  0x7F, 0xC0, 0xFF, 0x9F, 0xF0, 0x01, 0xFE, 0x03, 0xFE, 0x7F, 0xC0, 0x0F,
  0xF8, 0x07, 0xF9, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF7, 0xF8, 0x00, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0xFF, 0xFC, 0x03, 0xFF, 0xE0,
  0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0x80,
  0x01, 0xFF, 0x87, 0xFF, 0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0,
  0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x00, 0xFF,
  0xCF, 0xFC, 0x00, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x07, 0xFF, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x00, 0x3F,
  0xF3, 0xFF, 0x00, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x01, 0xFF, 0xDF, 0xFC,
  0x00, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x0F,
  0xFC, 0xFF, 0xE0, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x00, 0x7F, 0xF3, 0xFF,
  0x00, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x07,
  0xFE, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F,
  0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE1, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xE0, 0x7F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF8,
  0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF8,
  0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xC0,
  0x7F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xF8,
  0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x01, 0xFF,
  0x87, 0xFF, 0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x3F, 0xF8,
  0x00, 0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x3F,
  0xF3, 0xFF, 0x80, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x00, 0xFF, 0xCF, 0xFC,
  0x00, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0xFF, 0xE0, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x3F, 0xF3, 0xFF,
  0x00, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x03,
  0xFF, 0xBF, 0xF8, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0xFF,
  0xE0, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x01,
  0xFF, 0xC7, 0xFE, 0x00, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x07, 0xFE, 0x1F,
  0xF8, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFF, 0x01,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE1, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x07,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x0F, 0xFE,
  0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0x87, 0xFC, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xE1, 0xFF, 0x80,
  0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x81,
  0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03,
  0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFE,
  0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x07, 0xFF, 0x03, 0xFE, 0x00,
  0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0x81, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0x00, 0x0F, 0xFE, 0x00,
  0x10, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x20, 0x00, 0x1F, 0xF8, 0x07,
  0x00, 0x03, 0xFF, 0x80, 0x7C, 0x00, 0x7F, 0xF0, 0x07, 0xF8, 0x3F, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x1F, 0xF8,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x7F, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF7, 0xFC, 0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xE7, 0xFC, 0x00,
  0x07, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x0F, 0xFC, 0x7F,
  0xC0, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x03, 0xFF, 0x07, 0xFC, 0x00,
  0x7F, 0xE0, 0x7F, 0xC0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x7F,
  0xC0, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF8,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x80,
  0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xFC, 0x3F,
  0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x3F,
  0xC7, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x3F, 0xCF, 0xFC, 0x00,
  0x03, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x03, 0xFD, 0xFF,
  0x00, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFB,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xCF, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x7F, 0xC0,
  0x07, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xE1,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0x87, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFF,
  0xF0, 0x0F, 0xFC, 0x1F, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xF0, 0x3F, 0xE0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xC0,
  0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0xFE, 0x07,
  0xFE, 0x03, 0xFE, 0x03, 0xFB, 0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x0F, 0xF7,
  0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xEF, 0xE0, 0x7F, 0xE0, 0x1F, 0xF0,
  0x3F, 0x9F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x3F, 0x83, 0xFF, 0x00,
  0x7F, 0xC1, 0xFE, 0x7F, 0x07, 0xFC, 0x00, 0xFF, 0x87, 0xF8, 0xFE, 0x0F,
  0xF8, 0x01, 0xFF, 0x0F, 0xF1, 0xFC, 0x3F, 0xF0, 0x03, 0xFE, 0x3F, 0xE3,
  0xF8, 0x7F, 0xC0, 0x07, 0xFC, 0x7F, 0x87, 0xF1, 0xFF, 0x80, 0x0F, 0xF8,
  0xFF, 0x0F, 0xE3, 0xFE, 0x00, 0x1F, 0xF3, 0xFC, 0x1F, 0xC7, 0xFC, 0x00,
  0x3F, 0xE7, 0xF8, 0x3F, 0x9F, 0xF0, 0x00, 0x7F, 0xDF, 0xE0, 0x7F, 0x3F,
  0xE0, 0x00, 0xFF, 0xBF, 0xC0, 0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0x81,
  0xFD, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x03, 0xFB, 0xFE, 0x00, 0x07, 0xFB,
  0xFC, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xF7, 0xF0, 0x1F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x03,
  0xFE, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC3, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF1,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x00, 0x07, 0xFD, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x81, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0xDF, 0xF8, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x3F,
  0xF1, 0xFF, 0x80, 0x0F, 0xFC, 0x7F, 0xE0, 0x07, 0xFE, 0x1F, 0xF8, 0x01,
  0xFF, 0x83, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xE0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF,
  0xC1, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xF0, 0x01,
  0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x1F, 0xF1, 0xFF, 0x00,
  0x07, 0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F,
  0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x07,
  0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0x9F, 0xE0,
  0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0x3F, 0xC7, 0xFC, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07, 0xFB, 0xFC, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xE1, 0xFF, 0x87, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x81,
  0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x0F, 0xF0, 0x07, 0xFF, 0xC7, 0xFC, 0x03, 0xFF, 0xF9, 0xFF,
  0x01, 0xFF, 0xFE, 0x7F, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x9F, 0xFF, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x1F, 0xFC, 0x1F, 0xF8,
  0x07, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xE0, 0xFF,
  0xC0, 0x1F, 0xF8, 0x3F, 0xF0, 0x07, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x87,
  0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFC,
  0x3F, 0xF0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x3F,
  0xE0, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF0, 0x07, 0xFE, 0x0F, 0xFC, 0x01,
  0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xF0,
  0x1F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0xFF,
  0xF7, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0xFF, 0x80, 0x3F, 0xFF, 0xBF, 0xE0, 0x0F, 0xFF, 0xCF, 0xF0,
  0x01, 0xFF, 0xE3, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x0F, 0xC0, 0x00, 0xFF,
  0xCF, 0xFC, 0x00, 0x3F, 0xE7, 0xFF, 0x80, 0x0F, 0xFB, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xC0,
  0x0F, 0xFC, 0x1F, 0xF0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0xC1, 0xFF,
  0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x0F,
  0xF8, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x1F, 0xF8,
  0x7F, 0xE0, 0x07, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0xFF,
  0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xE0, 0x1F, 0xF8, 0x3F, 0xF8, 0x0F,
  0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xF9,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFB,
  0xFF, 0xFE, 0x01, 0xFE, 0xFF, 0xFF, 0x00, 0x7F, 0x9F, 0xFF, 0x80, 0x3F,
  0xC7, 0xFF, 0xC0, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0x83, 0xC0, 0x7F, 0xF8, 0x04,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x10, 0x1F, 0xFC, 0x07, 0x80, 0x7F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x7F, 0xC0,
  0x01, 0xFF, 0xE7, 0xFE, 0x00, 0x3F, 0xFF, 0xBF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFF,
  0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x07,
  0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x07, 0xFC,
  0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x0F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x3F,
  0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xBF, 0x80, 0x03, 0xFF, 0xF9, 0xFC, 0x00, 0x0F, 0xFF,
  0x0F, 0xE0, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x3F, 0xF0,
  0x0F, 0xF0, 0xFF, 0x80, 0x3F, 0xC7, 0xFE, 0x01, 0xFF, 0x1F, 0xF0, 0x07,
  0xFC, 0xFF, 0xC0, 0x1F, 0xF3, 0xFE, 0x00, 0xFF, 0x8F, 0xF8, 0x07, 0xFE,
  0x7F, 0xE0, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x40,
  0x7F, 0xE0, 0x0F, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x20, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x20, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x3F, 0xC0, 0x01, 0xFF, 0xE3, 0xFE, 0x00, 0x3F, 0xFF, 0x9F, 0xF0, 0x01,
  0xFF, 0xFE, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x0F, 0xFE,
  0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x7F,
  0xE0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x7F,
  0xE0, 0x7F, 0xF8, 0x03, 0xFF, 0x87, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF7, 0xFC, 0x00,
  0x0F, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x00, 0x38, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x02, 0x00, 0x01, 0xFF, 0x80, 0x18, 0x00, 0x1F, 0xFC, 0x00, 0xF8, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x0F, 0xE0,
  0x00, 0xFF, 0x8F, 0xFE, 0x00, 0x3F, 0xE7, 0xFF, 0xC0, 0x0F, 0xFB, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xCF, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x0F,
  0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xE0,
  0x7F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFF,
  0x81, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF0, 0x3F, 0xF0, 0x07,
  0xFC, 0x0F, 0xF8, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0x80,
  0x3F, 0xE0, 0x7F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF8, 0x03, 0xFE, 0x07, 0xFC,
  0x01, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF0, 0x3F,
  0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0xC0,
  0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF8, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x1F,
  0xF8, 0x3F, 0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFE,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x20, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xF8,
  0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0xC0, 0x07,
  0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFC,
  0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x07, 0xFC,
  0x7F, 0xE0, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00,
  0x1F, 0xF7, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFC,
  0xFF, 0xC0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x3F,
  0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x3F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xFC,
  0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xE1, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xFC,
  0x7F, 0xF8, 0x3F, 0xFE, 0x00, 0x7F, 0x1F, 0xFF, 0x8F, 0xFF, 0xE0, 0x0F,
  0xE7, 0xFF, 0xFB, 0xFF, 0xFC, 0x03, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F,
  0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0,
  0x1F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x07, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F,
  0xF8, 0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x3F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x83, 0xFF, 0x00, 0x0F, 0xE1, 0xFF,
  0xF0, 0x03, 0xF8, 0xFF, 0xFC, 0x00, 0xFE, 0x7F, 0xFF, 0x80, 0x7F, 0xBF,
  0xFF, 0xE0, 0x1F, 0xEF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xF1, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x0F,
  0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xE0,
  0x7F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF8, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF8, 0x3F, 0xF0, 0x07,
  0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80,
  0x3F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF8, 0x03, 0xFE, 0x07, 0xFE,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF8, 0x1F,
  0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF8, 0x03, 0xFE,
  0x07, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F,
  0xF8, 0x1F, 0xF0, 0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x9F,
  0xFC, 0x1F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0xFF, 0xC0, 0x3F,
  0xF1, 0xFF, 0x80, 0x3F, 0xE7, 0xFE, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0xFF,
  0x9F, 0xF0, 0x01, 0xFF, 0x7F, 0xE0, 0x03, 0xFE, 0xFF, 0xC0, 0x0F, 0xFD,
  0xFF, 0x80, 0x1F, 0xFB, 0xFE, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xBF, 0xF0, 0x01, 0xFF, 0x7F, 0xE0, 0x07, 0xFE, 0xFF,
  0xC0, 0x0F, 0xFD, 0xFF, 0x80, 0x1F, 0xFB, 0xFE, 0x00, 0x7F, 0xE7, 0xFC,
  0x00, 0xFF, 0xCF, 0xFC, 0x03, 0xFF, 0x9F, 0xF8, 0x07, 0xFE, 0x3F, 0xF0,
  0x1F, 0xFC, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0xC3, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xFE, 0x00, 0x03, 0xF8, 0xFF, 0xFC,
  0x00, 0x0F, 0xE7, 0xFF, 0xF8, 0x00, 0x7F, 0xBF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xC0,
  0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0xC0,
  0x3F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x7F,
  0xF0, 0x03, 0xFF, 0xE7, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFD, 0xFF, 0xFC,
  0x00, 0x1F, 0xF7, 0xFF, 0xE0, 0x00, 0xFF, 0xCF, 0xFF, 0x00, 0x03, 0xFE,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x1E, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x0F, 0xF0, 0x03, 0xFF, 0xE3,
  0xFC, 0x01, 0xFF, 0xF9, 0xFE, 0x00, 0xFF, 0xFF, 0x7F, 0x80, 0x7F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0x0F, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x83,
  0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xE0, 0x07, 0xFE,
  0x1F, 0xF8, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x1F,
  0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0x0F, 0xFC, 0x00,
  0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x0F, 0xF8, 0x3F, 0xF0,
  0x03, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xC0, 0xFF,
  0xC0, 0x3F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFF, 0x03,
  0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF3, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xDF, 0xF0, 0x01, 0xFF, 0xE7, 0xFC, 0x00, 0x3F, 0xE1,
  0xFF, 0x00, 0x01, 0xC0, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x3F,
  0xC7, 0xFC, 0x01, 0xFE, 0x7F, 0xE0, 0x0F, 0xF7, 0xFF, 0x00, 0xFF, 0xBF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x10, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x03,
  0xC0, 0x7F, 0xE0, 0x06, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x82, 0x00, 0x0F, 0xFC, 0x1C, 0x00, 0xFF, 0xE0,
  0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x8F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC3, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0xFF,
  0x80, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF8, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF,
  0xC0, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF8, 0x03,
  0xFE, 0x07, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xC0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x0F,
  0xF8, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xE0,
  0x7F, 0xC0, 0x1F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFF,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F,
  0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x8F, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFD, 0xFC, 0x01, 0xFF,
  0xFE, 0xFF, 0x00, 0x3F, 0xFF, 0x3F, 0xC0, 0x07, 0xFF, 0x8F, 0xF0, 0x00,
  0xFF, 0x83, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x7F, 0xCF,
  0xF8, 0x01, 0xFF, 0x9F, 0xF0, 0x03, 0xFE, 0x3F, 0xE0, 0x0F, 0xFC, 0x3F,
  0xC0, 0x1F, 0xF0, 0x7F, 0x80, 0x7F, 0xE0, 0xFF, 0x00, 0xFF, 0x81, 0xFE,
  0x01, 0xFF, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x80, 0x7F, 0xC3,
  0xFE, 0x00, 0xFF, 0x8F, 0xFC, 0x01, 0xFF, 0x1F, 0xF0, 0x03, 0xFE, 0x3F,
  0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x0F, 0xF9, 0xFF, 0x00, 0x1F, 0xF7, 0xFC,
  0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x7F, 0x80,
  0x3F, 0xF8, 0x03, 0xFE, 0x7F, 0x80, 0x3F, 0xF8, 0x07, 0xFC, 0x7F, 0x80,
  0x7F, 0xF8, 0x07, 0xFC, 0x7F, 0x80, 0x7F, 0xF8, 0x0F, 0xFC, 0x7F, 0x80,
  0xFF, 0xF8, 0x0F, 0xF8, 0x7F, 0x80, 0xFF, 0xF8, 0x0F, 0xF8, 0x7F, 0x80,
  0xFF, 0xF8, 0x1F, 0xF0, 0x7F, 0x81, 0xFF, 0xF8, 0x1F, 0xF0, 0xFF, 0x81,
  0xFF, 0xF8, 0x3F, 0xF0, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xE0, 0xFF, 0x83,
  0xFB, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFB, 0xF8, 0x7F, 0xC0, 0xFF, 0x87,
  0xFF, 0xF8, 0x7F, 0xC0, 0xFF, 0x87, 0xF7, 0xF8, 0xFF, 0x80, 0xFF, 0x8F,
  0xF7, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xE7, 0xF8, 0xFF, 0x80, 0xFF, 0x8F,
  0xE7, 0xF1, 0xFF, 0x00, 0xFF, 0x9F, 0xE7, 0xF1, 0xFF, 0x00, 0xFF, 0x9F,
  0xC7, 0xF1, 0xFE, 0x00, 0xFF, 0x9F, 0xC7, 0xF3, 0xFE, 0x00, 0xFF, 0xBF,
  0x87, 0xF3, 0xFC, 0x00, 0xFF, 0xBF, 0x87, 0xF3, 0xFC, 0x00, 0xFF, 0xFF,
  0x87, 0xF7, 0xFC, 0x00, 0xFF, 0xFF, 0x07, 0xF7, 0xF8, 0x00, 0xFF, 0x7F,
  0x07, 0xF7, 0xF8, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F,
  0xE0, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x03,
  0xFE, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x7F,
  0xE0, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00,
  0x3F, 0xEF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0xFF, 0x80, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x00,
  0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xFE,
  0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE,
  0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x3F,
  0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F,
  0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00,
  0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0x3F, 0xE0,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x00, 0x1F,
  0xE1, 0xFF, 0x00, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x00, 0x1F, 0xE3, 0xFE,
  0x00, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x00,
  0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x00, 0x1F, 0xEF,
  0xF8, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x02, 0x7F, 0xFE,
  0x00, 0x0D, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF2, 0x00, 0x00, 0xFF,
  0xC4, 0x00, 0x00, 0x00, 0x00,
};

const GFXglyph NotoSans_Condensed_BoldItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 21, 52, 19, 0, -51 },
  { 138, 25, 18, 30, 7, -51 },
  { 195, 40, 51, 38, 0, -51 },
  { 450, 34, 59, 33, 1, -55 },
  { 701, 48, 53, 54, 4, -52 },
  { 1019, 40, 53, 41, 1, -52 },
  { 1284, 12, 18, 18, 7, -51 },
  { 1311, 24, 62, 21, 2, -51 },
  { 1497, 25, 63, 21, -5, -52 },
  { 1694, 29, 31, 32, 6, -55 },
  { 1807, 31, 35, 36, 3, -43 },
  { 1943, 17, 19, 18, -4, -9 },
  { 1984, 19, 9, 22, 1, -24 },
  { 2006, 12, 12, 18, 0, -11 },
  { 2024, 38, 53, 28, -4, -52 },
  { 2276, 31, 53, 33, 2, -52 },
  { 2482, 25, 51, 34, 7, -51 },
  { 2642, 36, 52, 33, -2, -52 },
  { 2876, 35, 53, 33, -1, -52 },
  { 3108, 35, 52, 34, -1, -52 },
  { 3336, 34, 52, 33, 0, -51 },
  { 3557, 34, 53, 33, 2, -52 },
  { 3783, 35, 51, 33, 2, -51 },
  { 4007, 34, 53, 33, 0, -52 },
  { 4233, 32, 53, 33, 1, -52 },
  { 4445, 18, 41, 18, 0, -40 },
  { 4538, 22, 50, 18, -4, -40 },
  { 4676, 31, 36, 36, 3, -44 },
  { 4816, 31, 21, 36, 3, -36 },
  { 4898, 31, 36, 36, 3, -44 },
  { 5038, 27, 53, 27, 3, -52 },
  { 5217, 49, 58, 51, 2, -52 },
  { 5573, 37, 52, 37, -4, -52 },
  { 5814, 38, 51, 37, 0, -51 },
  { 6057, 37, 53, 35, 3, -52 },
  { 6303, 40, 51, 40, 0, -51 },
  { 6558, 35, 51, 32, 0, -51 },
  { 6782, 35, 51, 31, 0, -51 },
  { 7006, 40, 53, 41, 3, -52 },
  { 7271, 44, 51, 42, 0, -51 },
  { 7552, 32, 51, 24, -3, -51 },
  { 7756, 33, 66, 20, -11, -51 },
  { 8029, 43, 51, 37, 0, -51 },
  { 8304, 26, 51, 31, 0, -51 },
  { 8470, 56, 51, 54, 0, -51 },
  { 8827, 46, 51, 45, 0, -51 },
  { 9121, 39, 53, 43, 3, -52 },
  { 9380, 38, 51, 36, 0, -51 },
  { 9623, 39, 64, 43, 3, -52 },
  { 9935, 37, 51, 37, 0, -51 },
  { 10171, 36, 53, 32, -1, -52 },
  { 10410, 31, 51, 31, 6, -51 },
  { 10608, 40, 52, 41, 3, -51 },
  { 10868, 36, 51, 36, 6, -51 },
  { 11098, 55, 51, 55, 6, -51 },
  { 11449, 45, 51, 35, -4, -51 },
  { 11736, 34, 51, 34, 6, -51 },
  { 11953, 39, 51, 31, -3, -51 },
  { 12202, 29, 63, 21, -2, -52 },
  { 12431, 16, 53, 28, 7, -52 },
  { 12537, 29, 63, 21, -5, -52 },
  { 12766, 33, 31, 34, 0, -51 },
  { 12894, 26, 5, 25, -7, 6 },
  { 12911, 14, 11, 22, 10, -55 },
  { 12931, 34, 41, 36, 2, -40 },
  { 13106, 34, 56, 36, 0, -55 },
  { 13344, 29, 41, 29, 2, -40 },
  { 13493, 37, 56, 36, 2, -55 },
  { 13752, 30, 41, 33, 2, -40 },
  { 13906, 38, 72, 22, -8, -55 },
  { 14248, 37, 57, 36, -1, -40 },
  { 14512, 34, 55, 36, 0, -55 },
  { 14746, 21, 55, 18, 0, -55 },
  { 14891, 30, 72, 18, -9, -55 },
  { 15161, 37, 55, 34, 0, -55 },
  { 15416, 21, 55, 18, 0, -55 },
  { 15561, 51, 40, 53, 0, -40 },
  { 15816, 34, 40, 36, 0, -40 },
  { 15986, 31, 41, 35, 2, -40 },
  { 16145, 38, 57, 36, -4, -40 },
  { 16416, 34, 57, 36, 2, -40 },
  { 16659, 29, 40, 25, 0, -40 },
  { 16804, 29, 41, 28, 0, -40 },
  { 16953, 23, 49, 24, 3, -48 },
  { 17094, 34, 40, 36, 2, -39 },
  { 17264, 31, 39, 31, 4, -39 },
  { 17416, 48, 39, 48, 4, -39 },
  { 17650, 39, 39, 32, -4, -39 },
  { 17841, 40, 56, 31, -5, -39 },
  { 18121, 31, 39, 27, -2, -39 },
  { 18273, 29, 62, 25, 1, -51 },
  { 18498, 8, 71, 31, 11, -55 },
  { 18569, 28, 62, 25, -4, -51 },
  { 18786, 31, 12, 36, 3, -31 },
};

const GFXfont NotoSans_Condensed_BoldItalic72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic72pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC72PT7B_H_
