#ifndef _NOTOSANS_EXTRALIGHT52PT7B_H_
#define _NOTOSANS_EXTRALIGHT52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight52pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x00, 0x00, 0x04, 0xFF, 0xF0, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x02,
  0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x01, 0x80, 0x18, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x06, 0x00, 0x40, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x10, 0x03, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01,
  0x80, 0x10, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0x60, 0x04, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0x80, 0x30, 0x00, 0x02, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x02, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0x80, 0x18, 0x00, 0x03, 0x00, 0x30, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x20, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x70, 0xC1, 0xC3, 0x03, 0x00, 0x1C, 0x0C, 0x00, 0x60,
  0x30, 0x03, 0x80, 0xC0, 0x0C, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x30,
  0x01, 0x80, 0xC0, 0x06, 0x03, 0x00, 0x1C, 0x0C, 0x00, 0x38, 0x30, 0x00,
  0x78, 0xC0, 0x00, 0x7B, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0x3C, 0x00, 0x0C, 0x3C, 0x00, 0x30, 0x38, 0x00, 0xC0,
  0x60, 0x03, 0x01, 0xC0, 0x0C, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x30,
  0x03, 0x00, 0xC0, 0x0C, 0x07, 0x00, 0x30, 0x18, 0x00, 0xC0, 0xE8, 0x03,
  0x07, 0x3C, 0x0C, 0x78, 0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0x80, 0x38, 0x70, 0x00, 0x30, 0x03, 0x01,
  0x80, 0x03, 0x00, 0x60, 0x18, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x06, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x0C, 0x01,
  0x80, 0x0C, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x0C, 0x00,
  0x40, 0x60, 0x00, 0xC0, 0x04, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0xC0, 0x00,
  0xC0, 0x0C, 0x0C, 0x00, 0x0C, 0x00, 0xC1, 0x83, 0xE0, 0xC0, 0x0C, 0x30,
  0x7F, 0x04, 0x00, 0xC3, 0x0C, 0x18, 0x60, 0x0C, 0x61, 0x80, 0xC6, 0x01,
  0x86, 0x30, 0x0E, 0x30, 0x38, 0xC3, 0x00, 0x63, 0x87, 0x0C, 0x30, 0x06,
  0x1F, 0xE1, 0x86, 0x00, 0x60, 0x30, 0x18, 0x60, 0x02, 0x00, 0x03, 0x06,
  0x00, 0x30, 0x00, 0x60, 0x60, 0x03, 0x00, 0x06, 0x06, 0x00, 0x30, 0x00,
  0xC0, 0x60, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x30, 0x01, 0x80, 0x60, 0x03,
  0x00, 0x18, 0x06, 0x00, 0x60, 0x03, 0x00, 0x20, 0x06, 0x00, 0x30, 0x03,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x06, 0x00, 0xE0, 0x03, 0x80, 0xC0, 0x0C,
  0x00, 0x18, 0x0C, 0x01, 0x80, 0x00, 0xE3, 0x80, 0x18, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x07, 0x00, 0x70, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0x01, 0x81, 0xC0, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x06, 0x38, 0x03, 0x80,
  0x06, 0x70, 0x01, 0xC0, 0x0C, 0x60, 0x00, 0xE0, 0x0C, 0x60, 0x00, 0x70,
  0x1C, 0xC0, 0x00, 0x38, 0x18, 0xC0, 0x00, 0x1C, 0x38, 0xC0, 0x00, 0x0E,
  0x30, 0xC0, 0x00, 0x07, 0x60, 0xC0, 0x00, 0x03, 0xE0, 0x60, 0x00, 0x01,
  0xC0, 0x60, 0x00, 0x03, 0xE0, 0x70, 0x00, 0x07, 0x70, 0x38, 0x00, 0x0E,
  0x38, 0x1C, 0x00, 0x38, 0x1C, 0x0F, 0xC7, 0xF0, 0x0E, 0x03, 0xFF, 0xC0,
  0x07, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0xE0,
  0x30, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06,
  0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x18,
  0x03, 0x00, 0xC0, 0x18, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x03,
  0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00,
  0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x0E, 0x03, 0x01,
  0x80, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x38, 0x0C,
  0x03, 0xFC, 0x10, 0x7C, 0x7E, 0x4F, 0x80, 0x1F, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x61, 0xC0, 0x03,
  0x03, 0x00, 0x1C, 0x06, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x38, 0x04, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x18, 0xCE, 0x73, 0x18, 0xCC, 0x63, 0x11, 0x8C, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x4F, 0xFF, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0x80,
  0x07, 0x81, 0xE0, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x30, 0x18, 0x00, 0x18,
  0x30, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x70, 0x00, 0x0C, 0x60, 0x00, 0x0C,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x0C,
  0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x18, 0x18, 0x00, 0x18,
  0x0C, 0x00, 0x30, 0x0E, 0x00, 0xE0, 0x03, 0xE7, 0xC0, 0x01, 0xFF, 0x80,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x0F, 0x01, 0xF0, 0x73, 0x0E, 0x31, 0xC3,
  0x70, 0x3E, 0x03, 0x40, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x0F, 0xFE, 0x00, 0x7C, 0x0F, 0x01, 0xC0, 0x07, 0x07, 0x00,
  0x07, 0x04, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0x81, 0xF0, 0x3C, 0x00,
  0x38, 0x70, 0x00, 0x18, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x03, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x1C, 0xE0, 0x00,
  0x78, 0x7F, 0x03, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x1C, 0x18,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00,
  0xE0, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0x30, 0x01,
  0x80, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x01,
  0x80, 0x01, 0x80, 0x18, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x18, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC3, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x1B, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x80, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x32, 0x00, 0x01, 0xCC, 0x00, 0x1E, 0x3F, 0x07, 0xE0, 0x3F,
  0xFE, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0xF8, 0x08, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x7F, 0x00, 0x61, 0xFF, 0xE0, 0x67, 0x80, 0x70, 0xCE,
  0x00, 0x18, 0xD8, 0x00, 0x0C, 0xD0, 0x00, 0x0E, 0xF0, 0x00, 0x06, 0xE0,
  0x00, 0x06, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x06, 0x30,
  0x00, 0x06, 0x30, 0x00, 0x06, 0x18, 0x00, 0x0E, 0x1C, 0x00, 0x0C, 0x0C,
  0x00, 0x18, 0x07, 0x00, 0x70, 0x03, 0xE1, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFF, 0x80, 0x1E,
  0x07, 0x80, 0xE0, 0x03, 0x81, 0x80, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00,
  0x03, 0x38, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0xC0, 0x00,
  0x31, 0x80, 0x00, 0x63, 0x00, 0x01, 0x83, 0x00, 0x07, 0x07, 0x00, 0x1C,
  0x07, 0x80, 0x70, 0x03, 0xC3, 0x80, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x7C, 0x00, 0x70, 0x1E, 0x03, 0xC0, 0x0E, 0x0E, 0x00, 0x0E, 0x18,
  0x00, 0x0E, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0x60, 0x00, 0x0E, 0xE0, 0x00, 0x18, 0xE0, 0x00, 0x60, 0xE0, 0x03,
  0x80, 0xF8, 0x3E, 0x00, 0x7F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x07, 0xFE, 0x00, 0x3C, 0x0F, 0x00, 0xE0, 0x07, 0x03, 0x80, 0x07,
  0x0E, 0x00, 0x07, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0E, 0xC0, 0x00, 0x0D,
  0x80, 0x00, 0x1B, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0xC0,
  0x00, 0x1D, 0x80, 0x00, 0x79, 0x80, 0x01, 0xB3, 0x80, 0x06, 0x63, 0xC0,
  0x78, 0xC1, 0xFF, 0xC1, 0x80, 0x7E, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x03, 0x03, 0xE0, 0x07, 0xFF, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x6F, 0xF6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x4F, 0xFF, 0x18, 0xF3, 0xC6, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x86, 0x38,
  0xC3, 0x0C, 0x31, 0x86, 0x18, 0x43, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x0F, 0xFE,
  0x0F, 0xC3, 0xE3, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x03,
  0x80, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x38, 0x00, 0x00, 0x00, 0x06, 0x30, 0x00, 0x7F, 0xF0, 0x06, 0x70, 0x01,
  0xE0, 0x70, 0x06, 0x60, 0x03, 0x80, 0x30, 0x03, 0x60, 0x06, 0x00, 0x30,
  0x03, 0x40, 0x0C, 0x00, 0x30, 0x03, 0xC0, 0x0C, 0x00, 0x30, 0x03, 0xC0,
  0x18, 0x00, 0x30, 0x03, 0xC0, 0x18, 0x00, 0x30, 0x03, 0xC0, 0x18, 0x00,
  0x30, 0x03, 0xC0, 0x30, 0x00, 0x30, 0x03, 0xC0, 0x30, 0x00, 0x30, 0x03,
  0xC0, 0x30, 0x00, 0x30, 0x03, 0xC0, 0x30, 0x00, 0x30, 0x03, 0xC0, 0x18,
  0x00, 0x70, 0x02, 0xC0, 0x18, 0x00, 0x70, 0x06, 0xC0, 0x18, 0x00, 0x70,
  0x06, 0xC0, 0x0C, 0x00, 0xD0, 0x0C, 0xC0, 0x0E, 0x01, 0x98, 0x1C, 0x60,
  0x07, 0x8F, 0x1E, 0x78, 0x60, 0x03, 0xFC, 0x07, 0xE0, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x08,
  0x00, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0B, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0x00, 0x00,
  0xE0, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03,
  0x80, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x18,
  0xE0, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x00, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xC0, 0x00,
  0xF8, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x70, 0xC0, 0x0F, 0xE0, 0xFF, 0xFF, 0x00, 0xC0, 0x0F,
  0xF0, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x1C, 0xC0, 0x00,
  0x78, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x1E, 0x00, 0x06, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x02, 0x00, 0xFE, 0x1F, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x60, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xC0, 0x00, 0xF8, 0x0C, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03,
  0x8C, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0E, 0xC0,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03,
  0x8C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0xC0, 0xC0,
  0x01, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xE0, 0x1F, 0xC0, 0x3C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xDC, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00,
  0xC7, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x30,
  0x38, 0x00, 0x00, 0xC0, 0x7C, 0x00, 0x07, 0x00, 0x7F, 0x87, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x06,
  0xFF, 0x9F, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x0F, 0xFF, 0xF8, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x0E,
  0xFF, 0xCF, 0xF0, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x07, 0x30, 0x00, 0x07,
  0x18, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x06, 0x00, 0x07, 0x03, 0x00, 0x07,
  0x01, 0x80, 0x07, 0x00, 0xC0, 0x07, 0x00, 0x60, 0x07, 0x00, 0x30, 0x07,
  0x00, 0x18, 0x07, 0x00, 0x0C, 0x07, 0x00, 0x06, 0x07, 0x00, 0x03, 0x07,
  0x00, 0x01, 0x87, 0x00, 0x00, 0xC7, 0xC0, 0x00, 0x67, 0x60, 0x00, 0x37,
  0x18, 0x00, 0x1B, 0x0E, 0x00, 0x0F, 0x03, 0x80, 0x07, 0x00, 0xC0, 0x03,
  0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x07, 0x00, 0x60, 0x01, 0x80,
  0x30, 0x00, 0xE0, 0x18, 0x00, 0x38, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x03,
  0x03, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x18, 0x60, 0x00,
  0x06, 0x30, 0x00, 0x03, 0x98, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x60, 0x00, 0x00,
  0x1B, 0xD8, 0x00, 0x00, 0x06, 0xF3, 0x00, 0x00, 0x01, 0xBC, 0xC0, 0x00,
  0x00, 0xCF, 0x38, 0x00, 0x00, 0x33, 0xC6, 0x00, 0x00, 0x18, 0xF1, 0x80,
  0x00, 0x06, 0x3C, 0x30, 0x00, 0x01, 0x8F, 0x0C, 0x00, 0x00, 0xC3, 0xC3,
  0x80, 0x00, 0x30, 0xF0, 0x60, 0x00, 0x18, 0x3C, 0x18, 0x00, 0x06, 0x0F,
  0x03, 0x00, 0x01, 0x83, 0xC0, 0xC0, 0x00, 0xC0, 0xF0, 0x38, 0x00, 0x30,
  0x3C, 0x06, 0x00, 0x18, 0x0F, 0x01, 0x80, 0x06, 0x03, 0xC0, 0x30, 0x01,
  0x80, 0xF0, 0x0C, 0x00, 0xC0, 0x3C, 0x03, 0x80, 0x30, 0x0F, 0x00, 0x60,
  0x18, 0x03, 0xC0, 0x18, 0x06, 0x00, 0xF0, 0x03, 0x03, 0x80, 0x3C, 0x00,
  0xC0, 0xC0, 0x0F, 0x00, 0x38, 0x30, 0x03, 0xC0, 0x06, 0x18, 0x00, 0xF0,
  0x01, 0x86, 0x00, 0x3C, 0x00, 0x33, 0x80, 0x0F, 0x00, 0x0C, 0xC0, 0x03,
  0xC0, 0x03, 0xB0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3D,
  0x80, 0x00, 0x07, 0x98, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x1E, 0x30, 0x00,
  0x03, 0xC3, 0x00, 0x00, 0x78, 0x70, 0x00, 0x0F, 0x06, 0x00, 0x01, 0xE0,
  0x60, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x80, 0xC0, 0x00, 0xF0, 0x0C, 0x00,
  0x1E, 0x01, 0xC0, 0x03, 0xC0, 0x18, 0x00, 0x78, 0x01, 0x80, 0x0F, 0x00,
  0x38, 0x01, 0xE0, 0x03, 0x00, 0x3C, 0x00, 0x30, 0x07, 0x80, 0x07, 0x00,
  0xF0, 0x00, 0x60, 0x1E, 0x00, 0x06, 0x03, 0xC0, 0x00, 0xE0, 0x78, 0x00,
  0x0C, 0x0F, 0x00, 0x00, 0xC1, 0xE0, 0x00, 0x1C, 0x3C, 0x00, 0x01, 0xC7,
  0x80, 0x00, 0x18, 0xF0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x3B, 0xC0, 0x00,
  0x03, 0x78, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0E, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00,
  0xCE, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00,
  0x1D, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x01, 0xD8, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x18, 0x38,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x0C, 0x00, 0x1E, 0x30, 0x00, 0x1C, 0xC0, 0x00, 0x3B, 0x00, 0x00,
  0x6C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x06, 0xC0, 0x00, 0x3B, 0x00, 0x01, 0xCC, 0x00, 0x1E,
  0x30, 0x0F, 0xF0, 0xFF, 0xFE, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x07, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0xCE,
  0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x1D,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x01, 0xD8, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x18, 0x38, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x05, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0xC0, 0x01,
  0xE0, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x1C, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x1C, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0xE0, 0xC0, 0x07,
  0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x06,
  0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01,
  0xC0, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x70, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x0E, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x07, 0xFF,
  0xE0, 0x3E, 0x07, 0xF0, 0xE0, 0x00, 0xC3, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE6,
  0x00, 0x07, 0x8F, 0xE0, 0xFC, 0x07, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0,
  0x3C, 0x00, 0x38, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x60, 0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x70,
  0x00, 0x0E, 0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0x63, 0x80, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x06, 0x60, 0x00, 0x36, 0x00, 0x01, 0x98,
  0x00, 0x0D, 0x80, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00, 0x38, 0xC0, 0x00,
  0xCC, 0x00, 0x0C, 0x30, 0x00, 0x63, 0x00, 0x03, 0x0C, 0x00, 0x18, 0x60,
  0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x70, 0x60, 0x01, 0x06, 0x00, 0x18,
  0x18, 0x00, 0xC1, 0x80, 0x06, 0x06, 0x00, 0x30, 0x30, 0x01, 0x81, 0xC0,
  0x0C, 0x0C, 0x00, 0xC0, 0x30, 0x06, 0x03, 0x00, 0x30, 0x0C, 0x01, 0x80,
  0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x07, 0x00, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x18, 0x0C, 0x01, 0x80, 0x60, 0x06, 0x03, 0x00, 0x30, 0x18, 0x01,
  0x80, 0xC0, 0x0C, 0x0E, 0x00, 0x30, 0x60, 0x03, 0x03, 0x00, 0x0C, 0x18,
  0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x70, 0x00, 0xE1, 0x80, 0x06,
  0x18, 0x00, 0x18, 0xC0, 0x01, 0x86, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80,
  0x01, 0x8C, 0x00, 0x0C, 0xE0, 0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x0D,
  0x80, 0x00, 0xCC, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x30, 0x60, 0x00, 0x0E, 0x0E, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x01, 0xC0, 0x03, 0x00,
  0x18, 0x00, 0xE0, 0x01, 0x80, 0x18, 0x00, 0x38, 0x06, 0x00, 0x03, 0x01,
  0xC0, 0x00, 0x70, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x63, 0x80, 0x00,
  0x0E, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xB8, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x03, 0x07, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x38, 0x06, 0x00, 0x06, 0x00, 0xE0, 0x01, 0x80, 0x0C, 0x00, 0x70,
  0x00, 0xC0, 0x0C, 0x00, 0x1C, 0x03, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x38,
  0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x07, 0x30, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x19,
  0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x30, 0x30, 0x00,
  0x06, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x00,
  0xC0, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x01, 0xC0, 0x1C, 0x00, 0x18, 0x03,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x30, 0x18, 0x00, 0x07, 0x06, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x7F, 0xFF,
  0xFE, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00, 0x03, 0x0C, 0x00,
  0x01, 0x86, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x30,
  0x00, 0x60, 0x18, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x00,
  0xC0, 0x18, 0x00, 0x60, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x0C, 0x0C, 0x00,
  0x03, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x06, 0xFF, 0xFF, 0xF8, 0xE0, 0x30, 0x0C, 0x03,
  0x01, 0xC0, 0x70, 0x1C, 0x03, 0x00, 0xFF, 0x00, 0x3F, 0xFE, 0x07, 0x80,
  0x78, 0x10, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x7F, 0x80, 0xFF, 0xFC, 0x1F, 0x00, 0x63, 0xC0, 0x03, 0x38,
  0x00, 0x1B, 0x80, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1D, 0x80, 0x01, 0xEC, 0x00, 0x0B, 0x70, 0x00, 0xD9, 0xC0,
  0x1C, 0xC7, 0x83, 0xC6, 0x1F, 0xF8, 0x30, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x0F, 0xE0, 0x18,
  0xFF, 0xF8, 0x33, 0x80, 0x78, 0x6C, 0x00, 0x38, 0xF0, 0x00, 0x31, 0x60,
  0x00, 0x33, 0x80, 0x00, 0x67, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00,
  0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xB0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0xC0, 0x00, 0x33,
  0x80, 0x00, 0x65, 0x80, 0x01, 0x8B, 0x80, 0x07, 0x13, 0x80, 0x1C, 0x23,
  0xC1, 0xF0, 0x41, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xC0, 0x1F,
  0xFF, 0x07, 0x80, 0x30, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x01, 0x07, 0xE1, 0xF0, 0x1F, 0xFE, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x0F, 0xF0, 0x60, 0x7F,
  0xF8, 0xC3, 0xC0, 0x39, 0x8E, 0x00, 0x1B, 0x18, 0x00, 0x16, 0x60, 0x00,
  0x3D, 0xC0, 0x00, 0x3B, 0x00, 0x00, 0x76, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0x60, 0x00, 0x0E, 0xC0, 0x00, 0x1D, 0xC0,
  0x00, 0x79, 0x80, 0x00, 0xF1, 0x80, 0x03, 0x63, 0xC0, 0x0C, 0xC1, 0xE0,
  0xF1, 0x81, 0xFF, 0x83, 0x00, 0x38, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x70, 0x0E, 0x03, 0x00, 0x1C, 0x18, 0x00, 0x30, 0xC0, 0x00, 0x63,
  0x00, 0x01, 0x98, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x20, 0x7C, 0x1F, 0x80, 0x7F, 0xF8,
  0x00, 0x18, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0xC0, 0x70, 0x20, 0x60, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xFF, 0x87, 0xFF, 0xC0, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0x06, 0x07, 0xFF, 0x8C, 0x3C, 0x03,
  0x98, 0xE0, 0x01, 0xB1, 0x80, 0x01, 0xE6, 0x00, 0x03, 0xDC, 0x00, 0x03,
  0xB0, 0x00, 0x07, 0x60, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x36, 0x00, 0x00, 0xEC, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x98, 0x00,
  0x0F, 0x18, 0x00, 0x36, 0x1C, 0x00, 0xCC, 0x1E, 0x0F, 0x18, 0x1F, 0xF8,
  0x30, 0x01, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE4,
  0x00, 0x03, 0x86, 0x00, 0x0E, 0x0F, 0xE0, 0xF8, 0x07, 0xFF, 0xC0, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x0F, 0xE0, 0x63, 0xFF, 0xC3,
  0x38, 0x07, 0x9B, 0x00, 0x0C, 0xF0, 0x00, 0x37, 0x00, 0x01, 0xB8, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x5F, 0xF0, 0x00, 0x01,
  0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xC0, 0x00,
  0x80, 0x70, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x0E, 0xCF,
  0x3F, 0x80, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0xEC, 0x00,
  0x1C, 0xC0, 0x03, 0x8C, 0x00, 0x70, 0xC0, 0x0E, 0x0C, 0x01, 0xC0, 0xC0,
  0x18, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x0C, 0x0C, 0x00, 0xC1, 0x80, 0x0C,
  0x38, 0x00, 0xC7, 0x00, 0x0C, 0xF8, 0x00, 0xDD, 0x80, 0x0D, 0x8C, 0x00,
  0xF0, 0x60, 0x0E, 0x07, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0xC0, 0x0C,
  0x0C, 0x00, 0xE0, 0xC0, 0x06, 0x0C, 0x00, 0x30, 0xC0, 0x01, 0x8C, 0x00,
  0x1C, 0xC0, 0x00, 0xCC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFC, 0x00, 0xFE, 0x08, 0x7F, 0xF0, 0x3F,
  0xF8, 0x8C, 0x07, 0x8E, 0x01, 0xC9, 0x80, 0x19, 0xC0, 0x0E, 0xF0, 0x00,
  0xD8, 0x00, 0x6E, 0x00, 0x0F, 0x00, 0x06, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00,
  0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00,
  0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C,
  0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00,
  0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00,
  0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C,
  0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00,
  0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0x81, 0xFE,
  0x04, 0x3F, 0xFC, 0x23, 0x80, 0x79, 0x30, 0x00, 0xCB, 0x00, 0x03, 0x70,
  0x00, 0x1B, 0x80, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x30,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0x00, 0xF0, 0x0C, 0x00, 0x38,
  0x18, 0x00, 0x1C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0E, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x06, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x07,
  0x60, 0x00, 0x06, 0x70, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x1C,
  0x1C, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x07, 0xC3, 0xE0, 0x01, 0xFF, 0x80,
  0x00, 0x08, 0x00, 0x80, 0xFE, 0x01, 0x07, 0xFF, 0x82, 0x38, 0x07, 0x84,
  0xE0, 0x03, 0x89, 0x80, 0x03, 0x9E, 0x00, 0x03, 0x38, 0x00, 0x07, 0x70,
  0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0xDC, 0x00, 0x03, 0x38, 0x00, 0x06, 0x78, 0x00, 0x1C,
  0xD8, 0x00, 0x71, 0xB8, 0x01, 0xC3, 0x1E, 0x1F, 0x06, 0x1F, 0xF8, 0x0C,
  0x01, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFF,
  0x06, 0x07, 0xFF, 0x8C, 0x3C, 0x03, 0x98, 0xE0, 0x01, 0xB3, 0x80, 0x03,
  0x66, 0x00, 0x03, 0xDC, 0x00, 0x03, 0xB0, 0x00, 0x07, 0x60, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x76, 0x00, 0x00, 0xEC, 0x00,
  0x01, 0xDC, 0x00, 0x07, 0x98, 0x00, 0x0B, 0x38, 0x00, 0x36, 0x38, 0x01,
  0xCC, 0x3E, 0x1F, 0x18, 0x1F, 0xF8, 0x30, 0x03, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x81, 0xFE, 0x1F, 0xFC, 0xE0, 0x36, 0x00,
  0xF0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xFE, 0x1C,
  0x00, 0xE3, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xEC, 0x00, 0x1C, 0xFC,
  0x0F, 0x83, 0xFF, 0xE0, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x86, 0x07, 0xFC, 0x01,
  0x80, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x76, 0x00, 0x03, 0xD8, 0x00, 0x1B, 0x30, 0x00, 0xEC, 0xE0, 0x07,
  0x31, 0xF0, 0xF8, 0xC1, 0xFF, 0x83, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0D, 0x80, 0x00, 0x33, 0x00, 0x00, 0x63, 0x00, 0x00, 0xC6,
  0x00, 0x03, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x38,
  0x00, 0x60, 0x30, 0x01, 0x80, 0x60, 0x03, 0x00, 0x60, 0x0E, 0x00, 0xC0,
  0x18, 0x01, 0x80, 0x30, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x03, 0x03,
  0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0,
  0x00, 0x31, 0x80, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x0F, 0x80, 0x03, 0x80, 0x03, 0x30, 0x00, 0x78, 0x00, 0x66,
  0x00, 0x1B, 0x00, 0x0C, 0xC0, 0x03, 0x60, 0x01, 0x8C, 0x00, 0x66, 0x00,
  0x61, 0x80, 0x18, 0xC0, 0x0C, 0x30, 0x03, 0x18, 0x01, 0x86, 0x00, 0x61,
  0x80, 0x70, 0x60, 0x18, 0x30, 0x0C, 0x0C, 0x03, 0x06, 0x01, 0x81, 0x80,
  0x60, 0xE0, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x03, 0x03, 0x01, 0x81, 0x80,
  0x60, 0x60, 0x30, 0x30, 0x0C, 0x18, 0x03, 0x06, 0x00, 0xC3, 0x00, 0x61,
  0x80, 0x18, 0x60, 0x0C, 0x30, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x33, 0x00,
  0x18, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x00, 0xC8, 0x00, 0x36, 0x00, 0x1B,
  0x00, 0x06, 0xC0, 0x01, 0xE0, 0x00, 0xD0, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x60, 0x00, 0x0C,
  0xE0, 0x00, 0x38, 0xE0, 0x00, 0x60, 0xC0, 0x01, 0x80, 0xC0, 0x07, 0x01,
  0xC0, 0x1C, 0x01, 0x80, 0x30, 0x01, 0x80, 0xC0, 0x01, 0x83, 0x80, 0x03,
  0x06, 0x00, 0x03, 0x18, 0x00, 0x03, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x36, 0x00, 0x00, 0xEE, 0x00, 0x01, 0x8C,
  0x00, 0x06, 0x0C, 0x00, 0x1C, 0x0C, 0x00, 0x30, 0x1C, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x18, 0x0E, 0x00, 0x38, 0x18, 0x00, 0x38, 0x60, 0x00, 0x31,
  0xC0, 0x00, 0x37, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0D,
  0x80, 0x00, 0x33, 0x00, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x03, 0x0C,
  0x00, 0x06, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x18, 0x00, 0x60, 0x30,
  0x01, 0x80, 0x60, 0x03, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18, 0x01, 0xC0,
  0x30, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x03, 0x03, 0x00, 0x06, 0x0C,
  0x00, 0x0C, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x19, 0x80,
  0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x23, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1E, 0x00, 0xFC, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x60, 0x07, 0x80, 0x3C, 0x00, 0x3E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x80, 0x03,
  0xF0, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x01, 0xF8, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x3E, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x38, 0x07, 0xE0, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xF0, 0x01,
  0xE0, 0x7C, 0x07, 0x80, 0x0F, 0xFE, 0x80, 0x03, 0xF8,
};

const GFXglyph NotoSans_ExtraLight52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 37, 12, 4, -37 },
  { 20, 10, 13, 18, 4, -37 },
  { 37, 31, 37, 34, 1, -37 },
  { 181, 22, 42, 30, 3, -39 },
  { 297, 36, 39, 42, 3, -38 },
  { 473, 32, 39, 37, 3, -38 },
  { 629, 2, 13, 10, 4, -37 },
  { 633, 10, 45, 14, 2, -37 },
  { 690, 10, 45, 14, 2, -37 },
  { 747, 22, 21, 29, 3, -39 },
  { 805, 24, 24, 30, 3, -30 },
  { 877, 5, 13, 10, 2, -6 },
  { 886, 13, 2, 17, 2, -15 },
  { 890, 4, 4, 12, 4, -4 },
  { 892, 16, 37, 17, 1, -37 },
  { 966, 24, 39, 30, 3, -38 },
  { 1083, 12, 37, 30, 5, -37 },
  { 1139, 23, 38, 30, 3, -38 },
  { 1249, 24, 39, 30, 2, -38 },
  { 1366, 28, 37, 30, 1, -37 },
  { 1496, 22, 38, 30, 4, -37 },
  { 1601, 24, 39, 30, 3, -38 },
  { 1718, 24, 37, 30, 3, -37 },
  { 1829, 23, 39, 30, 3, -38 },
  { 1942, 23, 39, 30, 3, -38 },
  { 2055, 4, 28, 12, 4, -28 },
  { 2069, 6, 35, 12, 2, -28 },
  { 2096, 24, 24, 30, 3, -31 },
  { 2168, 24, 12, 30, 3, -24 },
  { 2204, 24, 24, 30, 3, -31 },
  { 2276, 18, 38, 22, 2, -38 },
  { 2362, 40, 42, 46, 3, -37 },
  { 2572, 31, 37, 31, 0, -37 },
  { 2716, 24, 37, 32, 5, -37 },
  { 2827, 28, 39, 32, 3, -38 },
  { 2964, 28, 37, 36, 5, -37 },
  { 3094, 20, 37, 29, 5, -37 },
  { 3187, 20, 37, 26, 5, -37 },
  { 3280, 30, 39, 38, 3, -38 },
  { 3427, 27, 37, 37, 5, -37 },
  { 3552, 9, 37, 15, 3, -37 },
  { 3594, 12, 46, 12, -5, -37 },
  { 3663, 25, 37, 30, 5, -37 },
  { 3779, 20, 37, 27, 5, -37 },
  { 3872, 34, 37, 44, 5, -37 },
  { 4030, 27, 37, 37, 5, -37 },
  { 4155, 33, 39, 39, 3, -38 },
  { 4316, 22, 37, 30, 5, -37 },
  { 4418, 33, 47, 39, 3, -38 },
  { 4612, 24, 37, 30, 5, -37 },
  { 4723, 23, 39, 28, 3, -38 },
  { 4836, 27, 37, 27, 0, -37 },
  { 4961, 27, 38, 37, 5, -37 },
  { 5090, 30, 37, 30, 0, -37 },
  { 5229, 42, 37, 46, 2, -37 },
  { 5424, 27, 37, 27, 0, -37 },
  { 5549, 27, 37, 27, 0, -37 },
  { 5674, 26, 37, 30, 2, -37 },
  { 5795, 11, 45, 16, 4, -37 },
  { 5857, 16, 37, 17, 1, -37 },
  { 5931, 11, 45, 16, 1, -37 },
  { 5993, 25, 23, 30, 2, -37 },
  { 6065, 21, 1, 21, 0, 5 },
  { 6068, 9, 8, 13, 2, -40 },
  { 6077, 21, 29, 27, 2, -28 },
  { 6154, 23, 41, 31, 5, -40 },
  { 6272, 20, 29, 25, 3, -28 },
  { 6345, 23, 41, 31, 3, -40 },
  { 6463, 22, 29, 28, 3, -28 },
  { 6543, 17, 40, 15, 1, -40 },
  { 6628, 23, 40, 31, 3, -28 },
  { 6743, 21, 40, 30, 5, -40 },
  { 6848, 3, 38, 11, 4, -38 },
  { 6863, 10, 50, 11, -3, -38 },
  { 6926, 20, 40, 24, 5, -40 },
  { 7026, 2, 40, 11, 5, -40 },
  { 7036, 36, 28, 45, 5, -28 },
  { 7162, 21, 28, 30, 5, -28 },
  { 7236, 24, 29, 30, 3, -28 },
  { 7323, 23, 40, 31, 5, -28 },
  { 7438, 23, 40, 31, 3, -28 },
  { 7553, 14, 28, 20, 5, -28 },
  { 7602, 20, 29, 24, 2, -28 },
  { 7675, 15, 35, 17, 1, -34 },
  { 7741, 22, 29, 30, 4, -28 },
  { 7821, 23, 28, 23, 0, -28 },
  { 7902, 35, 28, 37, 1, -28 },
  { 8025, 23, 28, 25, 1, -28 },
  { 8106, 23, 41, 23, 0, -28 },
  { 8224, 20, 28, 24, 2, -28 },
  { 8294, 15, 45, 18, 1, -37 },
  { 8379, 2, 53, 28, 13, -40 },
  { 8393, 15, 45, 18, 2, -37 },
  { 8478, 24, 5, 30, 3, -21 },
};

const GFXfont NotoSans_ExtraLight52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight52pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_EXTRALIGHT52PT7B_H_
