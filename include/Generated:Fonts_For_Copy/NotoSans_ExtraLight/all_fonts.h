#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/NotoSans_ExtraLight
// Headers: 67

#include "NotoSans_ExtraLight6pt7b.h"
#include "NotoSans_ExtraLight7pt7b.h"
#include "NotoSans_ExtraLight8pt7b.h"
#include "NotoSans_ExtraLight9pt7b.h"
#include "NotoSans_ExtraLight10pt7b.h"
#include "NotoSans_ExtraLight11pt7b.h"
#include "NotoSans_ExtraLight12pt7b.h"
#include "NotoSans_ExtraLight13pt7b.h"
#include "NotoSans_ExtraLight14pt7b.h"
#include "NotoSans_ExtraLight15pt7b.h"
#include "NotoSans_ExtraLight16pt7b.h"
#include "NotoSans_ExtraLight17pt7b.h"
#include "NotoSans_ExtraLight18pt7b.h"
#include "NotoSans_ExtraLight19pt7b.h"
#include "NotoSans_ExtraLight20pt7b.h"
#include "NotoSans_ExtraLight21pt7b.h"
#include "NotoSans_ExtraLight22pt7b.h"
#include "NotoSans_ExtraLight23pt7b.h"
#include "NotoSans_ExtraLight24pt7b.h"
#include "NotoSans_ExtraLight25pt7b.h"
#include "NotoSans_ExtraLight26pt7b.h"
#include "NotoSans_ExtraLight27pt7b.h"
#include "NotoSans_ExtraLight28pt7b.h"
#include "NotoSans_ExtraLight29pt7b.h"
#include "NotoSans_ExtraLight30pt7b.h"
#include "NotoSans_ExtraLight31pt7b.h"
#include "NotoSans_ExtraLight32pt7b.h"
#include "NotoSans_ExtraLight33pt7b.h"
#include "NotoSans_ExtraLight34pt7b.h"
#include "NotoSans_ExtraLight35pt7b.h"
#include "NotoSans_ExtraLight36pt7b.h"
#include "NotoSans_ExtraLight37pt7b.h"
#include "NotoSans_ExtraLight38pt7b.h"
#include "NotoSans_ExtraLight39pt7b.h"
#include "NotoSans_ExtraLight40pt7b.h"
#include "NotoSans_ExtraLight41pt7b.h"
#include "NotoSans_ExtraLight42pt7b.h"
#include "NotoSans_ExtraLight43pt7b.h"
#include "NotoSans_ExtraLight44pt7b.h"
#include "NotoSans_ExtraLight45pt7b.h"
#include "NotoSans_ExtraLight46pt7b.h"
#include "NotoSans_ExtraLight47pt7b.h"
#include "NotoSans_ExtraLight48pt7b.h"
#include "NotoSans_ExtraLight49pt7b.h"
#include "NotoSans_ExtraLight50pt7b.h"
#include "NotoSans_ExtraLight51pt7b.h"
#include "NotoSans_ExtraLight52pt7b.h"
#include "NotoSans_ExtraLight53pt7b.h"
#include "NotoSans_ExtraLight54pt7b.h"
#include "NotoSans_ExtraLight55pt7b.h"
#include "NotoSans_ExtraLight56pt7b.h"
#include "NotoSans_ExtraLight57pt7b.h"
#include "NotoSans_ExtraLight58pt7b.h"
#include "NotoSans_ExtraLight59pt7b.h"
#include "NotoSans_ExtraLight60pt7b.h"
#include "NotoSans_ExtraLight61pt7b.h"
#include "NotoSans_ExtraLight62pt7b.h"
#include "NotoSans_ExtraLight63pt7b.h"
#include "NotoSans_ExtraLight64pt7b.h"
#include "NotoSans_ExtraLight65pt7b.h"
#include "NotoSans_ExtraLight66pt7b.h"
#include "NotoSans_ExtraLight67pt7b.h"
#include "NotoSans_ExtraLight68pt7b.h"
#include "NotoSans_ExtraLight69pt7b.h"
#include "NotoSans_ExtraLight70pt7b.h"
#include "NotoSans_ExtraLight71pt7b.h"
#include "NotoSans_ExtraLight72pt7b.h"
