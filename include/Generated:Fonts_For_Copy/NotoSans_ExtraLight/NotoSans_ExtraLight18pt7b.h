#ifndef _NOTOSANS_EXTRALIGHT18PT7B_H_
#define _NOTOSANS_EXTRALIGHT18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight18pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x50, 0xC0, 0x99, 0x99, 0x90, 0x08, 0x81, 0x10, 0x22,
  0x04, 0x47, 0xFE, 0x12, 0x04, 0x40, 0x88, 0xFF, 0xC2, 0x20, 0x44, 0x11,
  0x02, 0x20, 0x10, 0x3C, 0x52, 0x90, 0x90, 0x90, 0x70, 0x18, 0x16, 0x11,
  0x11, 0x11, 0x92, 0x7C, 0x10, 0x70, 0x48, 0x84, 0x88, 0x88, 0x90, 0x89,
  0x08, 0xA6, 0x8A, 0x97, 0x51, 0x05, 0x10, 0x91, 0x09, 0x11, 0x09, 0x20,
  0xE0, 0x1C, 0x04, 0x41, 0x08, 0x21, 0x02, 0x20, 0x38, 0x0A, 0x02, 0x21,
  0x82, 0x50, 0x2A, 0x02, 0x40, 0xA7, 0xE2, 0xF8, 0x29, 0x49, 0x24, 0x92,
  0x48, 0x91, 0x91, 0x22, 0x49, 0x24, 0x94, 0xA4, 0x10, 0x10, 0x10, 0xF7,
  0x18, 0x18, 0x24, 0x46, 0x08, 0x08, 0x08, 0x08, 0xFF, 0x08, 0x08, 0x08,
  0x08, 0xEA, 0xF0, 0xC0, 0x04, 0x20, 0x82, 0x10, 0x41, 0x08, 0x21, 0x04,
  0x10, 0x80, 0x3C, 0x42, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x42, 0x3C, 0x17, 0x91, 0x11, 0x11, 0x11, 0x11, 0x10, 0x7C, 0x82,
  0x02, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x10, 0x20, 0x40, 0xFF, 0x7C,
  0x82, 0x01, 0x01, 0x02, 0x04, 0x3C, 0x02, 0x01, 0x01, 0x01, 0x02, 0xFC,
  0x01, 0x00, 0xC0, 0x50, 0x24, 0x09, 0x04, 0x42, 0x11, 0x04, 0x41, 0x3F,
  0xF0, 0x10, 0x04, 0x01, 0x00, 0x7E, 0x40, 0x40, 0x40, 0x40, 0x7C, 0x02,
  0x01, 0x01, 0x01, 0x01, 0x02, 0xFC, 0x1E, 0x20, 0x40, 0x40, 0x80, 0xBE,
  0xC1, 0x81, 0x81, 0x81, 0x41, 0x41, 0x3E, 0xFF, 0x01, 0x01, 0x02, 0x02,
  0x04, 0x04, 0x08, 0x08, 0x08, 0x10, 0x10, 0x20, 0x3C, 0x42, 0x81, 0x81,
  0x42, 0x24, 0x3C, 0x42, 0x81, 0x81, 0x81, 0x81, 0x7E, 0x3C, 0x42, 0x81,
  0x81, 0x81, 0x81, 0x83, 0x7D, 0x01, 0x01, 0x02, 0x06, 0x78, 0x70, 0x00,
  0x30, 0x70, 0x00, 0xAA, 0x01, 0x02, 0x1C, 0x60, 0x80, 0x60, 0x1C, 0x02,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x60, 0x18, 0x06, 0x01, 0x06, 0x18,
  0x60, 0x80, 0xF8, 0x10, 0x41, 0x04, 0x21, 0x08, 0x41, 0x00, 0x00, 0x60,
  0x07, 0xC0, 0x60, 0xC2, 0x00, 0x90, 0x02, 0x87, 0xC6, 0x21, 0x18, 0x84,
  0x64, 0x11, 0x88, 0x46, 0x23, 0x18, 0x73, 0x90, 0x00, 0x40, 0x00, 0xC0,
  0x80, 0xFC, 0x00, 0x04, 0x01, 0x80, 0x28, 0x05, 0x01, 0x10, 0x22, 0x08,
  0x41, 0xFC, 0x20, 0x88, 0x11, 0x01, 0x40, 0x28, 0x02, 0xFC, 0x82, 0x81,
  0x81, 0x81, 0x82, 0xFE, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFE, 0x1F, 0xC8,
  0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x04, 0x00,
  0x80, 0x1F, 0x80, 0xFC, 0x41, 0xA0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x6F, 0xC0, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x3F,
  0x40, 0x81, 0x02, 0x04, 0x0F, 0xE0, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x3F,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x00, 0x0F, 0xC6, 0x01, 0x00, 0x20, 0x08,
  0x01, 0x00, 0x20, 0xF4, 0x01, 0x80, 0x30, 0x05, 0x00, 0x90, 0x11, 0xFC,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0xFF, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x08, 0xE9, 0x24, 0x92, 0x49, 0x2E, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x5E, 0x81, 0x82, 0x84, 0x88, 0x90, 0xA0,
  0xD0, 0x90, 0x88, 0x84, 0x84, 0x82, 0x81, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x0F, 0xE0, 0x80, 0x30, 0x07, 0x01, 0xE0,
  0x3A, 0x07, 0x41, 0x64, 0x2C, 0x89, 0x91, 0x31, 0x46, 0x28, 0xC3, 0x18,
  0x42, 0x80, 0xC0, 0x70, 0x34, 0x1A, 0x0C, 0x86, 0x23, 0x09, 0x84, 0xC1,
  0x60, 0x70, 0x38, 0x08, 0x1F, 0x82, 0x04, 0x40, 0x24, 0x02, 0x80, 0x28,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x28, 0x02, 0x40, 0x22, 0x04, 0x1F, 0x80,
  0xFD, 0x06, 0x0C, 0x18, 0x30, 0x61, 0x7C, 0x81, 0x02, 0x04, 0x08, 0x00,
  0x1F, 0x82, 0x04, 0x40, 0x24, 0x02, 0x80, 0x28, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x28, 0x02, 0x40, 0x22, 0x04, 0x1F, 0x80, 0x10, 0x00, 0x80, 0x0C,
  0xFC, 0x82, 0x82, 0x81, 0x82, 0x82, 0x84, 0xF8, 0x88, 0x84, 0x82, 0x82,
  0x81, 0x3F, 0x40, 0x80, 0x80, 0x80, 0x60, 0x18, 0x06, 0x01, 0x01, 0x01,
  0x02, 0xFC, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x38, 0x23, 0xE0, 0x80, 0x60, 0x14, 0x05,
  0x02, 0x40, 0x88, 0x42, 0x10, 0x44, 0x12, 0x04, 0x80, 0xA0, 0x30, 0x04,
  0x00, 0x82, 0x06, 0x0C, 0x18, 0x30, 0x61, 0x41, 0x44, 0x89, 0x12, 0x24,
  0x48, 0x92, 0x24, 0x28, 0x50, 0xA1, 0x42, 0x85, 0x04, 0x08, 0x10, 0x20,
  0xC0, 0xA0, 0x88, 0x44, 0x41, 0x40, 0x60, 0x20, 0x28, 0x12, 0x11, 0x10,
  0x48, 0x18, 0x08, 0x80, 0xA0, 0x50, 0x44, 0x22, 0x20, 0x90, 0x50, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0xFF, 0x00, 0x80, 0x80, 0x40, 0x40,
  0x40, 0x20, 0x20, 0x20, 0x10, 0x10, 0x10, 0x0F, 0xF8, 0xF2, 0x49, 0x24,
  0x92, 0x49, 0x27, 0x81, 0x04, 0x10, 0x20, 0x82, 0x04, 0x10, 0x20, 0x82,
  0x04, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x08, 0x18, 0x14,
  0x24, 0x42, 0x42, 0x81, 0x81, 0xFE, 0x88, 0x80, 0x38, 0x88, 0x08, 0x11,
  0xEC, 0x60, 0xC1, 0x86, 0xF4, 0x80, 0x80, 0x80, 0x80, 0xB8, 0xC6, 0x82,
  0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0xFC, 0x1E, 0xC1, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x40, 0x7C, 0x01, 0x01, 0x01, 0x01, 0x3D, 0x43, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x43, 0x3D, 0x3C, 0x42, 0x81, 0x81, 0xFF, 0x80,
  0x80, 0x80, 0x40, 0x3E, 0x1C, 0x82, 0x08, 0xF8, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x80, 0x3D, 0x43, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x43,
  0x3D, 0x01, 0x01, 0x01, 0x7E, 0x81, 0x02, 0x04, 0x0B, 0x98, 0xA0, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x40, 0xC2, 0xAA, 0xAA, 0x80, 0x30, 0x02,
  0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0xE0, 0x81, 0x02, 0x04, 0x08, 0x51,
  0x24, 0x50, 0xA1, 0xC2, 0x44, 0x48, 0x90, 0xC0, 0xFF, 0xFC, 0xB8, 0xEC,
  0x71, 0x86, 0x18, 0x41, 0x84, 0x18, 0x41, 0x84, 0x18, 0x41, 0x84, 0x18,
  0x41, 0xB9, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x04, 0x3C, 0x42,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x3E, 0xB8, 0xC6, 0x82, 0x81,
  0x81, 0x81, 0x81, 0x82, 0x82, 0xFC, 0x80, 0x80, 0x80, 0x80, 0x3D, 0x43,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x43, 0x3D, 0x01, 0x01, 0x01, 0x01,
  0xBE, 0x21, 0x08, 0x42, 0x10, 0x84, 0x00, 0x7E, 0x08, 0x20, 0x60, 0x60,
  0x41, 0x07, 0xF0, 0x21, 0x3E, 0x84, 0x21, 0x08, 0x42, 0x08, 0x70, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x43, 0x3D, 0x81, 0x81, 0x42,
  0x42, 0x42, 0x24, 0x24, 0x18, 0x18, 0x18, 0x82, 0x18, 0x21, 0x45, 0x14,
  0x51, 0x45, 0x22, 0x8A, 0x28, 0xA2, 0x8A, 0x30, 0xC1, 0x04, 0x41, 0x42,
  0x22, 0x14, 0x18, 0x08, 0x14, 0x22, 0x42, 0xC1, 0x81, 0x81, 0x42, 0x42,
  0x42, 0x24, 0x24, 0x18, 0x18, 0x08, 0x10, 0x10, 0x10, 0xE0, 0xFE, 0x08,
  0x10, 0x41, 0x04, 0x08, 0x20, 0x81, 0xF8, 0x0C, 0x42, 0x08, 0x20, 0x82,
  0x08, 0xE0, 0x82, 0x08, 0x20, 0x81, 0x03, 0xFF, 0xFF, 0xC0, 0xC1, 0x08,
  0x42, 0x10, 0x82, 0x19, 0x08, 0x42, 0x10, 0x98, 0xF9, 0x06,
};

const GFXglyph NotoSans_ExtraLight18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 13, 4, 1, -13 },
  { 5, 4, 5, 6, 1, -13 },
  { 8, 11, 13, 12, 0, -13 },
  { 26, 8, 15, 10, 1, -14 },
  { 41, 12, 13, 14, 1, -13 },
  { 61, 11, 13, 13, 1, -13 },
  { 79, 1, 5, 3, 1, -13 },
  { 80, 3, 16, 5, 1, -13 },
  { 86, 3, 16, 5, 1, -13 },
  { 92, 8, 8, 10, 1, -14 },
  { 100, 8, 9, 10, 1, -11 },
  { 109, 2, 4, 4, 1, -2 },
  { 110, 4, 1, 6, 1, -5 },
  { 111, 2, 1, 4, 1, -1 },
  { 112, 6, 13, 6, 0, -13 },
  { 122, 8, 13, 10, 1, -13 },
  { 135, 4, 13, 10, 2, -13 },
  { 142, 8, 13, 10, 1, -13 },
  { 155, 8, 13, 10, 1, -13 },
  { 168, 10, 13, 10, 0, -13 },
  { 185, 8, 13, 10, 1, -13 },
  { 198, 8, 13, 10, 1, -13 },
  { 211, 8, 13, 10, 1, -13 },
  { 224, 8, 13, 10, 1, -13 },
  { 237, 8, 13, 10, 1, -13 },
  { 250, 2, 10, 4, 1, -10 },
  { 253, 2, 12, 4, 1, -10 },
  { 256, 8, 9, 10, 1, -11 },
  { 265, 8, 4, 10, 1, -8 },
  { 269, 8, 9, 10, 1, -11 },
  { 278, 6, 13, 8, 1, -13 },
  { 288, 14, 15, 16, 1, -13 },
  { 315, 11, 13, 11, 0, -13 },
  { 333, 8, 13, 11, 2, -13 },
  { 346, 10, 13, 11, 1, -13 },
  { 363, 9, 13, 13, 2, -13 },
  { 378, 7, 13, 10, 2, -13 },
  { 390, 7, 13, 9, 2, -13 },
  { 402, 11, 13, 13, 1, -13 },
  { 420, 9, 13, 13, 2, -13 },
  { 435, 3, 13, 5, 1, -13 },
  { 440, 5, 16, 4, -2, -13 },
  { 450, 8, 13, 10, 2, -13 },
  { 463, 7, 13, 9, 2, -13 },
  { 475, 11, 13, 15, 2, -13 },
  { 493, 9, 13, 13, 2, -13 },
  { 508, 12, 13, 14, 1, -13 },
  { 528, 7, 13, 10, 2, -13 },
  { 540, 12, 16, 14, 1, -13 },
  { 564, 8, 13, 11, 2, -13 },
  { 577, 8, 13, 10, 1, -13 },
  { 590, 9, 13, 9, 0, -13 },
  { 605, 9, 13, 13, 2, -13 },
  { 620, 10, 13, 10, 0, -13 },
  { 637, 14, 13, 16, 1, -13 },
  { 660, 9, 13, 9, 0, -13 },
  { 675, 9, 13, 9, 0, -13 },
  { 690, 9, 13, 10, 1, -13 },
  { 705, 3, 16, 6, 2, -13 },
  { 711, 6, 13, 6, 0, -13 },
  { 721, 4, 16, 6, 0, -13 },
  { 729, 8, 8, 10, 1, -13 },
  { 737, 7, 1, 7, 0, 1 },
  { 738, 3, 3, 5, 1, -14 },
  { 740, 7, 10, 9, 1, -10 },
  { 749, 8, 14, 11, 2, -14 },
  { 763, 7, 10, 9, 1, -10 },
  { 772, 8, 14, 11, 1, -14 },
  { 786, 8, 10, 10, 1, -10 },
  { 796, 6, 14, 5, 0, -14 },
  { 807, 8, 14, 11, 1, -10 },
  { 821, 7, 14, 10, 2, -14 },
  { 834, 2, 13, 4, 1, -13 },
  { 838, 4, 17, 4, -1, -13 },
  { 847, 7, 14, 8, 2, -14 },
  { 860, 1, 14, 4, 1, -14 },
  { 862, 12, 10, 16, 2, -10 },
  { 877, 7, 10, 10, 2, -10 },
  { 886, 8, 10, 10, 1, -10 },
  { 896, 8, 14, 11, 2, -10 },
  { 910, 8, 14, 11, 1, -10 },
  { 924, 5, 10, 7, 2, -10 },
  { 931, 6, 10, 8, 1, -10 },
  { 939, 5, 12, 6, 0, -12 },
  { 947, 8, 10, 10, 1, -10 },
  { 957, 8, 10, 8, 0, -10 },
  { 967, 12, 10, 13, 0, -10 },
  { 982, 8, 10, 9, 0, -10 },
  { 992, 8, 14, 8, 0, -10 },
  { 1006, 7, 10, 8, 1, -10 },
  { 1015, 6, 16, 6, 0, -13 },
  { 1027, 1, 18, 10, 4, -14 },
  { 1030, 5, 16, 6, 1, -13 },
  { 1040, 8, 2, 10, 1, -7 },
};

const GFXfont NotoSans_ExtraLight18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight18pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_EXTRALIGHT18PT7B_H_
