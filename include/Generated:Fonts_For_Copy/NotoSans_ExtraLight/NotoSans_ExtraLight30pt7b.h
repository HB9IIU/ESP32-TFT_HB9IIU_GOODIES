#ifndef _NOTOSANS_EXTRALIGHT30PT7B_H_
#define _NOTOSANS_EXTRALIGHT30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight30pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x01, 0xC0, 0x86, 0x18, 0x61, 0x86, 0x18,
  0x40, 0x01, 0x06, 0x00, 0xC1, 0x00, 0x20, 0x40, 0x08, 0x10, 0x02, 0x04,
  0x00, 0x82, 0x07, 0xFF, 0xFC, 0x10, 0x20, 0x04, 0x08, 0x01, 0x02, 0x00,
  0x41, 0x80, 0x10, 0x40, 0x08, 0x10, 0x3F, 0xFF, 0xC0, 0x81, 0x00, 0x20,
  0xC0, 0x08, 0x20, 0x04, 0x08, 0x01, 0x02, 0x00, 0x40, 0x80, 0x10, 0x60,
  0x00, 0x02, 0x00, 0x20, 0x1F, 0xC3, 0x27, 0x42, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x04, 0x20, 0x62, 0x01, 0xE0, 0x07, 0x80, 0x2C, 0x02, 0x20,
  0x21, 0x02, 0x10, 0x21, 0x02, 0x10, 0x21, 0x82, 0x6F, 0xFC, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x18, 0x00, 0x86, 0x60, 0x10, 0xC2, 0x02, 0x08, 0x10,
  0x20, 0x81, 0x04, 0x08, 0x10, 0x40, 0x81, 0x08, 0x08, 0x10, 0x80, 0x81,
  0x10, 0x08, 0x13, 0x3C, 0x83, 0x26, 0x2C, 0x24, 0x41, 0x66, 0x48, 0x11,
  0x88, 0x81, 0x00, 0x88, 0x10, 0x10, 0x81, 0x01, 0x08, 0x10, 0x20, 0x81,
  0x06, 0x08, 0x10, 0x40, 0xC1, 0x0C, 0x04, 0x20, 0x80, 0x3C, 0x07, 0x80,
  0x07, 0x38, 0x01, 0x02, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x03,
  0x03, 0x00, 0x40, 0x80, 0x08, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x6C,
  0x00, 0x61, 0x80, 0xD0, 0x30, 0x28, 0x06, 0x0A, 0x00, 0xC4, 0x80, 0x19,
  0x20, 0x03, 0x88, 0x00, 0x61, 0x00, 0x2C, 0x60, 0x31, 0x87, 0xF0, 0x30,
  0xFE, 0x0C, 0x41, 0x08, 0x21, 0x84, 0x10, 0x43, 0x0C, 0x20, 0x82, 0x08,
  0x30, 0x41, 0x04, 0x10, 0x20, 0x83, 0x04, 0x08, 0x30, 0xC1, 0x82, 0x04,
  0x10, 0x60, 0x82, 0x08, 0x20, 0xC3, 0x04, 0x30, 0xC3, 0x08, 0x20, 0x86,
  0x10, 0x42, 0x08, 0x43, 0x00, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x08,
  0x20, 0xF1, 0x3C, 0x7E, 0x00, 0xC0, 0x0D, 0x00, 0x4C, 0x04, 0x30, 0x60,
  0xC2, 0x04, 0x00, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x1F, 0xFF, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x2D, 0xA4, 0xA0, 0xFE, 0x70, 0x00, 0xC0, 0x20, 0x18, 0x04,
  0x01, 0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x04,
  0x01, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0xC6, 0x08, 0x08, 0x80, 0x24, 0x01, 0x60, 0x0E, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0A, 0x00, 0xD0, 0x04, 0x40, 0x63, 0x06, 0x0F, 0xE0, 0x06, 0x34,
  0xCA, 0x18, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x0F, 0x01, 0xCE, 0x30, 0x18, 0x00, 0x40,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x7F, 0xFC, 0x07, 0x80, 0xF3, 0x86, 0x01, 0x00, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0xFC,
  0x00, 0x78, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x80, 0x06, 0xC0, 0x31, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x50, 0x00, 0xD0, 0x00, 0x90, 0x01, 0x10, 0x03, 0x10, 0x02, 0x10,
  0x04, 0x10, 0x08, 0x10, 0x18, 0x10, 0x10, 0x10, 0x20, 0x10, 0x40, 0x10,
  0xC0, 0x10, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x3F, 0xF1, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x5F, 0x83, 0x07, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x05, 0x80,
  0xC7, 0xFC, 0x00, 0x01, 0xE0, 0x70, 0x86, 0x00, 0x60, 0x02, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x7E, 0x2C, 0x0D, 0x40, 0x3C, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x0A, 0x00, 0x50, 0x02, 0x40, 0x23,
  0x03, 0x07, 0xE0, 0xFF, 0xF8, 0x00, 0x40, 0x04, 0x00, 0x20, 0x03, 0x00,
  0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10,
  0x01, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01,
  0x80, 0x00, 0x07, 0x01, 0xC7, 0x18, 0x0C, 0x80, 0x24, 0x01, 0x20, 0x09,
  0x00, 0x48, 0x02, 0x20, 0x20, 0xC6, 0x01, 0xC0, 0x33, 0x82, 0x06, 0x20,
  0x0B, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x80, 0x26, 0x03,
  0x0F, 0xE0, 0x0F, 0x01, 0xC6, 0x18, 0x09, 0x80, 0x68, 0x01, 0x40, 0x0E,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xF0, 0x06, 0x80, 0x53, 0x0C, 0x87,
  0x84, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x80, 0x0C,
  0x3F, 0x80, 0x70, 0x00, 0x00, 0x07, 0x2C, 0x00, 0x00, 0x00, 0x00, 0x5A,
  0x4B, 0x40, 0x00, 0x08, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03,
  0x80, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80,
  0x04, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x60, 0x03, 0x00, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x40, 0x00,
  0x1C, 0x3C, 0xE0, 0x0C, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0xC0,
  0x60, 0x30, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x06, 0x00, 0x01, 0xFF, 0x80, 0x0E, 0x01, 0xC0, 0x30, 0x00,
  0xC0, 0x80, 0x00, 0xC2, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x90, 0x1F, 0xC1,
  0x60, 0x40, 0x83, 0x81, 0x01, 0x03, 0x04, 0x02, 0x06, 0x08, 0x04, 0x0C,
  0x10, 0x08, 0x18, 0x20, 0x10, 0x30, 0x40, 0x60, 0xE0, 0x80, 0xC1, 0x41,
  0x81, 0x82, 0x81, 0x8D, 0x99, 0x80, 0xE0, 0xE1, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0xE0, 0x00, 0xFE,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x16, 0x00, 0x04, 0x80, 0x03, 0x20,
  0x00, 0x84, 0x00, 0x21, 0x00, 0x10, 0x60, 0x04, 0x08, 0x01, 0x02, 0x00,
  0x80, 0xC0, 0x20, 0x10, 0x1F, 0xFC, 0x04, 0x00, 0x81, 0x00, 0x20, 0x80,
  0x0C, 0x20, 0x01, 0x18, 0x00, 0x44, 0x00, 0x19, 0x00, 0x02, 0x80, 0x00,
  0xC0, 0xFF, 0xE2, 0x00, 0xC8, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x28,
  0x00, 0xA0, 0x06, 0x80, 0x33, 0xFF, 0x08, 0x0F, 0x20, 0x06, 0x80, 0x0A,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x28, 0x01, 0xA0, 0x1C,
  0xFF, 0xC0, 0x00, 0xF0, 0x07, 0x0F, 0x08, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x02, 0x07, 0xFE, 0xFF, 0xE0,
  0x80, 0x38, 0x80, 0x0C, 0x80, 0x04, 0x80, 0x02, 0x80, 0x02, 0x80, 0x03,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x80, 0x02, 0x80, 0x02, 0x80, 0x06, 0x80, 0x0C, 0x80, 0x18,
  0x80, 0x70, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xFE, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xF0,
  0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0xFF, 0xE8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x00, 0xFC, 0x03, 0xC3,
  0xC3, 0x00, 0x22, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x0F, 0xF8, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0x40, 0x00, 0xB0, 0x00, 0x48, 0x00,
  0x22, 0x00, 0x10, 0xC0, 0x18, 0x1F, 0xF8, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0xF9,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x4F,
  0x80, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x05, 0xF0,
  0x80, 0x1E, 0x00, 0xC8, 0x06, 0x20, 0x10, 0x80, 0x82, 0x04, 0x08, 0x20,
  0x21, 0x00, 0x88, 0x02, 0x70, 0x0A, 0x40, 0x30, 0x80, 0x83, 0x02, 0x06,
  0x08, 0x08, 0x20, 0x10, 0x80, 0x62, 0x00, 0xC8, 0x01, 0x20, 0x02, 0x80,
  0x0C, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xF0, 0xC0, 0x00, 0x7C,
  0x00, 0x0E, 0x80, 0x01, 0xD0, 0x00, 0x59, 0x00, 0x0B, 0x20, 0x02, 0x66,
  0x00, 0x4C, 0x40, 0x19, 0x88, 0x02, 0x30, 0x80, 0x46, 0x10, 0x10, 0xC3,
  0x02, 0x18, 0x20, 0xC3, 0x04, 0x10, 0x60, 0x42, 0x0C, 0x08, 0x81, 0x81,
  0x90, 0x30, 0x16, 0x06, 0x02, 0x80, 0xC0, 0x30, 0x18, 0x04, 0x02, 0xC0,
  0x03, 0x80, 0x06, 0x80, 0x0D, 0x80, 0x19, 0x00, 0x31, 0x00, 0x63, 0x00,
  0xC3, 0x01, 0x82, 0x03, 0x06, 0x06, 0x06, 0x0C, 0x04, 0x18, 0x0C, 0x30,
  0x0C, 0x60, 0x08, 0xC0, 0x19, 0x80, 0x1B, 0x00, 0x16, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x20, 0x00, 0xF0, 0x01, 0xE3, 0x80, 0x60, 0x0C, 0x18, 0x00,
  0xC6, 0x00, 0x08, 0x80, 0x00, 0x90, 0x00, 0x16, 0x00, 0x02, 0x80, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x1E, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00, 0x18, 0x80, 0x02,
  0x18, 0x00, 0x80, 0xC0, 0x60, 0x0F, 0xF8, 0x00, 0xFF, 0xC4, 0x03, 0x20,
  0x05, 0x00, 0x28, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x02, 0x80, 0x14, 0x01,
  0xA0, 0x39, 0xFF, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xE3, 0x80,
  0x60, 0x0C, 0x18, 0x00, 0xC6, 0x00, 0x08, 0x80, 0x00, 0x90, 0x00, 0x16,
  0x00, 0x02, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1E, 0x00, 0x02, 0x40, 0x00, 0x48,
  0x00, 0x18, 0x80, 0x02, 0x18, 0x00, 0x80, 0xC0, 0x60, 0x0F, 0xF0, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0xFF, 0xC2, 0x00, 0xC8, 0x01, 0x20, 0x06, 0x80, 0x1A, 0x00, 0x68, 0x01,
  0xA0, 0x04, 0x80, 0x12, 0x00, 0x8F, 0xFC, 0x3F, 0xC0, 0x81, 0x82, 0x02,
  0x08, 0x04, 0x20, 0x18, 0x80, 0x22, 0x00, 0xC8, 0x01, 0x20, 0x02, 0x80,
  0x0C, 0x07, 0x81, 0xE7, 0x98, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x40, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x68, 0x06, 0x7F,
  0xE0, 0xFF, 0xFE, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80,
  0x02, 0x80, 0x02, 0x40, 0x02, 0x60, 0x04, 0x30, 0x18, 0x0F, 0xF0, 0xC0,
  0x00, 0xA0, 0x00, 0x90, 0x00, 0x4C, 0x00, 0x62, 0x00, 0x21, 0x00, 0x10,
  0x40, 0x18, 0x20, 0x08, 0x18, 0x04, 0x04, 0x04, 0x02, 0x02, 0x01, 0x83,
  0x00, 0x41, 0x00, 0x20, 0x80, 0x08, 0xC0, 0x04, 0x40, 0x03, 0x20, 0x00,
  0xA0, 0x00, 0x50, 0x00, 0x38, 0x00, 0x08, 0x00, 0x80, 0x18, 0x01, 0xE0,
  0x0C, 0x00, 0x90, 0x07, 0x00, 0x48, 0x06, 0x80, 0x64, 0x02, 0x40, 0x23,
  0x01, 0x20, 0x10, 0x80, 0x88, 0x18, 0x40, 0x84, 0x08, 0x20, 0x42, 0x04,
  0x08, 0x21, 0x82, 0x04, 0x10, 0x43, 0x02, 0x10, 0x21, 0x01, 0x88, 0x10,
  0x80, 0x44, 0x04, 0x40, 0x26, 0x02, 0x60, 0x12, 0x01, 0x20, 0x0D, 0x00,
  0xD0, 0x02, 0x80, 0x38, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x20,
  0x06, 0x00, 0x60, 0x06, 0x20, 0x04, 0x30, 0x08, 0x10, 0x18, 0x08, 0x10,
  0x0C, 0x20, 0x04, 0x20, 0x02, 0x40, 0x03, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x02, 0xC0, 0x06, 0x40, 0x04, 0x20, 0x08, 0x30, 0x08, 0x10, 0x10, 0x08,
  0x30, 0x0C, 0x20, 0x04, 0x40, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x04,
  0x20, 0x04, 0x20, 0x08, 0x10, 0x08, 0x18, 0x10, 0x08, 0x30, 0x0C, 0x20,
  0x04, 0x60, 0x06, 0x40, 0x02, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x7F, 0xFE, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x80, 0x02, 0x00, 0x0F, 0xFF, 0xE0, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x83, 0xF0, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x60,
  0x08, 0x02, 0x00, 0xC0, 0x10, 0x04, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00,
  0x40, 0x18, 0x02, 0x00, 0xC0, 0xFC, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x07,
  0xF0, 0x01, 0x00, 0x03, 0x00, 0x0A, 0x00, 0x12, 0x00, 0x44, 0x00, 0x84,
  0x02, 0x08, 0x04, 0x08, 0x10, 0x10, 0x20, 0x10, 0x80, 0x23, 0x00, 0x64,
  0x00, 0x58, 0x00, 0xC0, 0xFF, 0xF0, 0xC3, 0x08, 0x20, 0x80, 0x1F, 0xC3,
  0x06, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x7F, 0x38, 0x16,
  0x01, 0x40, 0x1C, 0x01, 0xC0, 0x34, 0x03, 0x60, 0x53, 0xF9, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x13, 0xF8, 0xB0,
  0x66, 0x01, 0xB0, 0x05, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0xE0, 0x05, 0x80, 0x2C, 0x03, 0x50, 0x32, 0x7E, 0x00,
  0x0F, 0xE7, 0x05, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x08, 0xFF, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x23, 0xF9, 0x30,
  0x6B, 0x01, 0xD0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x07, 0x80, 0x34, 0x01, 0x90, 0x14, 0x7F, 0x20,
  0x0F, 0xC1, 0x83, 0x18, 0x08, 0x80, 0x2C, 0x01, 0x40, 0x0A, 0x00, 0x7F,
  0xFF, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0,
  0x43, 0xFE, 0x03, 0xC3, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x83, 0xFC,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x1F, 0xC9, 0x83, 0x58, 0x06,
  0x80, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x3C, 0x01, 0xA0, 0x0C, 0x81, 0xA3, 0xF9, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x30, 0x01, 0x20, 0x30, 0xFF, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x09, 0xFC, 0xB0, 0x6C, 0x02,
  0xC0, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x70, 0x05, 0x55, 0x55,
  0x55, 0x50, 0x04, 0x30, 0x00, 0x00, 0x00, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x42, 0xF8,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x03, 0x80,
  0x90, 0x22, 0x0C, 0x43, 0x08, 0xC1, 0x30, 0x2E, 0x05, 0x60, 0xC4, 0x10,
  0x42, 0x0C, 0x40, 0xC8, 0x09, 0x00, 0xA0, 0x18, 0xFF, 0xFF, 0xFE, 0x9F,
  0x87, 0xE5, 0x06, 0xC1, 0xB0, 0x14, 0x05, 0x00, 0xC0, 0x28, 0x02, 0x01,
  0xC0, 0x10, 0x0E, 0x00, 0x80, 0x70, 0x04, 0x03, 0x80, 0x20, 0x1C, 0x01,
  0x00, 0xE0, 0x08, 0x07, 0x00, 0x40, 0x38, 0x02, 0x01, 0xC0, 0x10, 0x0E,
  0x00, 0x80, 0x70, 0x04, 0x03, 0x9F, 0xCB, 0x06, 0xC0, 0x2C, 0x03, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x0F, 0xC0, 0xC0, 0x86, 0x01, 0x10, 0x06,
  0x80, 0x0A, 0x00, 0x28, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xA0, 0x02, 0x40, 0x09, 0x80, 0x43, 0x02, 0x07, 0xF0, 0x8F, 0xC5, 0x83,
  0x30, 0x0D, 0x80, 0x28, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x3C, 0x01, 0x60, 0x1A, 0x81, 0x93, 0xF8, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x00, 0x1F,
  0xC9, 0x83, 0x58, 0x0A, 0x80, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x3C, 0x01, 0xA0, 0x14, 0x81, 0xA3,
  0xF1, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x9F, 0xA0, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x1F, 0xCC, 0x05, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x60, 0x1B, 0xFC, 0x10, 0x08, 0x04, 0x02, 0x0F, 0xF8, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x06,
  0x01, 0xF0, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x34, 0x01, 0xA0,
  0x14, 0x81, 0xA3, 0xF1, 0x80, 0x0A, 0x00, 0x50, 0x04, 0xC0, 0x22, 0x03,
  0x10, 0x10, 0xC0, 0x82, 0x0C, 0x10, 0x40, 0x42, 0x02, 0x20, 0x19, 0x00,
  0x58, 0x02, 0x80, 0x0C, 0x00, 0x40, 0xC0, 0x20, 0x1A, 0x01, 0x80, 0x90,
  0x1C, 0x04, 0xC0, 0xA0, 0x22, 0x04, 0x83, 0x10, 0x64, 0x10, 0x82, 0x20,
  0x82, 0x10, 0x84, 0x11, 0x84, 0x40, 0x88, 0x22, 0x06, 0x41, 0x90, 0x16,
  0x05, 0x80, 0xA0, 0x28, 0x05, 0x01, 0xC0, 0x18, 0x06, 0x00, 0x80, 0x30,
  0xC0, 0x1A, 0x01, 0x88, 0x18, 0x60, 0x81, 0x08, 0x04, 0xC0, 0x14, 0x00,
  0xC0, 0x06, 0x00, 0x68, 0x02, 0x20, 0x21, 0x83, 0x04, 0x30, 0x11, 0x00,
  0xD0, 0x02, 0x80, 0x0A, 0x00, 0x50, 0x04, 0xC0, 0x22, 0x03, 0x10, 0x10,
  0xC0, 0x82, 0x0C, 0x10, 0x40, 0x42, 0x02, 0x20, 0x19, 0x00, 0x58, 0x02,
  0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x80,
  0x0C, 0x03, 0xC0, 0x00, 0x7F, 0xF0, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x80,
  0x10, 0x03, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x06,
  0x00, 0x40, 0x0F, 0xFE, 0x07, 0x08, 0x18, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x30, 0xC0, 0x20, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x08, 0x0E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF0, 0x0C, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x00, 0x80, 0x38, 0x30, 0x30, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x30, 0x70, 0x40, 0x00, 0x7C, 0x0C, 0x18, 0x60,
  0x3C,
};

const GFXglyph NotoSans_ExtraLight30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 21, 7, 2, -21 },
  { 7, 6, 7, 10, 2, -21 },
  { 13, 18, 21, 19, 1, -21 },
  { 61, 12, 25, 17, 2, -23 },
  { 99, 20, 22, 24, 2, -22 },
  { 154, 18, 22, 21, 2, -22 },
  { 204, 1, 7, 5, 2, -21 },
  { 205, 6, 26, 8, 1, -21 },
  { 225, 6, 26, 8, 1, -21 },
  { 245, 13, 13, 17, 2, -23 },
  { 267, 13, 14, 17, 2, -18 },
  { 290, 3, 7, 6, 1, -3 },
  { 293, 7, 1, 10, 1, -9 },
  { 294, 2, 2, 7, 2, -2 },
  { 295, 10, 21, 10, 0, -21 },
  { 322, 13, 22, 17, 2, -22 },
  { 358, 7, 21, 17, 3, -21 },
  { 377, 13, 22, 17, 2, -22 },
  { 413, 14, 22, 17, 1, -22 },
  { 452, 16, 22, 17, 1, -22 },
  { 496, 13, 21, 17, 2, -21 },
  { 531, 13, 22, 17, 2, -22 },
  { 567, 13, 21, 17, 2, -21 },
  { 602, 13, 22, 17, 2, -22 },
  { 638, 13, 22, 17, 2, -22 },
  { 674, 2, 16, 7, 2, -16 },
  { 678, 3, 20, 7, 1, -16 },
  { 686, 13, 14, 17, 2, -18 },
  { 709, 13, 7, 17, 2, -14 },
  { 721, 13, 14, 17, 2, -18 },
  { 744, 10, 22, 13, 1, -22 },
  { 772, 23, 24, 26, 2, -21 },
  { 841, 18, 21, 18, 0, -21 },
  { 889, 14, 21, 19, 3, -21 },
  { 926, 16, 22, 19, 2, -22 },
  { 970, 16, 21, 21, 3, -21 },
  { 1012, 12, 21, 17, 3, -21 },
  { 1044, 12, 21, 15, 3, -21 },
  { 1076, 17, 22, 22, 2, -22 },
  { 1123, 15, 21, 21, 3, -21 },
  { 1163, 5, 21, 9, 2, -21 },
  { 1177, 7, 26, 7, -3, -21 },
  { 1200, 14, 21, 17, 3, -21 },
  { 1237, 12, 21, 15, 3, -21 },
  { 1269, 19, 21, 26, 3, -21 },
  { 1319, 15, 21, 21, 3, -21 },
  { 1359, 19, 22, 23, 2, -22 },
  { 1412, 13, 21, 17, 3, -21 },
  { 1447, 19, 27, 23, 2, -22 },
  { 1512, 14, 21, 18, 3, -21 },
  { 1549, 13, 22, 16, 2, -22 },
  { 1585, 15, 21, 15, 0, -21 },
  { 1625, 16, 21, 21, 3, -21 },
  { 1667, 17, 21, 17, 0, -21 },
  { 1712, 25, 21, 26, 1, -21 },
  { 1778, 16, 21, 16, 0, -21 },
  { 1820, 16, 21, 16, 0, -21 },
  { 1862, 15, 21, 17, 1, -21 },
  { 1902, 6, 26, 9, 3, -21 },
  { 1922, 10, 21, 10, 0, -21 },
  { 1949, 6, 26, 9, 1, -21 },
  { 1969, 15, 14, 17, 1, -22 },
  { 1996, 12, 1, 12, 0, 3 },
  { 1998, 5, 5, 8, 1, -23 },
  { 2002, 12, 16, 16, 1, -16 },
  { 2026, 13, 23, 18, 3, -23 },
  { 2064, 11, 16, 14, 2, -16 },
  { 2086, 13, 23, 18, 2, -23 },
  { 2124, 13, 16, 16, 2, -16 },
  { 2150, 10, 23, 9, 0, -23 },
  { 2179, 13, 23, 18, 2, -16 },
  { 2217, 12, 23, 17, 3, -23 },
  { 2252, 2, 22, 7, 2, -22 },
  { 2258, 6, 29, 7, -2, -22 },
  { 2280, 11, 23, 14, 3, -23 },
  { 2312, 1, 23, 7, 3, -23 },
  { 2315, 21, 16, 26, 3, -16 },
  { 2357, 12, 16, 17, 3, -16 },
  { 2381, 14, 16, 17, 2, -16 },
  { 2409, 13, 23, 18, 3, -16 },
  { 2447, 13, 23, 18, 2, -16 },
  { 2485, 8, 16, 11, 3, -16 },
  { 2501, 11, 16, 14, 1, -16 },
  { 2523, 9, 20, 10, 0, -20 },
  { 2546, 13, 16, 17, 2, -16 },
  { 2572, 13, 16, 13, 0, -16 },
  { 2598, 21, 16, 21, 0, -16 },
  { 2640, 13, 16, 15, 1, -16 },
  { 2666, 13, 23, 13, 0, -16 },
  { 2704, 12, 16, 14, 1, -16 },
  { 2728, 8, 26, 10, 1, -21 },
  { 2754, 2, 30, 16, 7, -23 },
  { 2762, 9, 26, 10, 1, -21 },
  { 2792, 13, 3, 17, 2, -12 },
};

const GFXfont NotoSans_ExtraLight30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight30pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_EXTRALIGHT30PT7B_H_
