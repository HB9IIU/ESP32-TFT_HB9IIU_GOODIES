#ifndef _NOTOSANS_EXTRALIGHT55PT7B_H_
#define _NOTOSANS_EXTRALIGHT55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight55pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xB6, 0xDB, 0x6D, 0xB2, 0x49, 0x24,
  0x00, 0x00, 0x6F, 0xFA, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x07, 0x80,
  0xF0, 0x16, 0x02, 0xC0, 0x58, 0x0B, 0x01, 0x60, 0x2C, 0x05, 0x80, 0x80,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x60, 0x02,
  0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x60, 0x00, 0x06, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x30, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0x80, 0x18, 0x01, 0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x02, 0x00, 0x30, 0x00, 0x03, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x20, 0x03, 0x00, 0x00, 0x30, 0x01, 0x00, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xE3, 0xC3, 0x07,
  0x1C, 0x0C, 0x04, 0x60, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x30,
  0x0C, 0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x30, 0x0C,
  0x00, 0xE0, 0x30, 0x01, 0xC0, 0xC0, 0x03, 0x83, 0x00, 0x07, 0x8C, 0x00,
  0x0F, 0xB0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x33, 0xE0, 0x00, 0xC3, 0xC0, 0x03, 0x03, 0x80, 0x0C, 0x06, 0x00, 0x30,
  0x0C, 0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x30, 0x0C,
  0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x07, 0x00, 0x30, 0x3A, 0x00,
  0xC1, 0xCF, 0x83, 0x3E, 0x3F, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x38, 0x01, 0xC3, 0x80, 0x00, 0xC0, 0x0C,
  0x07, 0x00, 0x06, 0x00, 0x70, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x30, 0x00,
  0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x1C,
  0x00, 0x30, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x06, 0x03, 0x00, 0x03, 0x00,
  0x18, 0x0C, 0x00, 0x0C, 0x00, 0x60, 0x60, 0x00, 0x30, 0x01, 0x81, 0x80,
  0x00, 0xC0, 0x06, 0x0C, 0x1F, 0x81, 0x80, 0x18, 0x30, 0xFF, 0x86, 0x00,
  0x61, 0x87, 0x07, 0x18, 0x03, 0x0E, 0x38, 0x0C, 0x70, 0x0C, 0x30, 0xC0,
  0x18, 0xC0, 0x71, 0x87, 0x00, 0x61, 0xC3, 0x86, 0x18, 0x01, 0x83, 0xFC,
  0x30, 0x60, 0x03, 0x03, 0xC0, 0xC1, 0x80, 0x0C, 0x00, 0x06, 0x06, 0x00,
  0x30, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x60, 0x03, 0x00, 0x07,
  0x01, 0x80, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x06,
  0x00, 0x60, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x01, 0x81, 0xC0, 0x0C, 0x00,
  0x07, 0x8E, 0x00, 0x60, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1E, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x03,
  0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x03, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00,
  0x18, 0x07, 0x00, 0x00, 0x03, 0x07, 0x80, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xCE, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x01, 0xE0, 0x38,
  0x00, 0x18, 0x60, 0x07, 0x00, 0x0E, 0x30, 0x00, 0xE0, 0x03, 0x1C, 0x00,
  0x1C, 0x00, 0xC6, 0x00, 0x03, 0x80, 0x71, 0x80, 0x00, 0x70, 0x18, 0xE0,
  0x00, 0x0E, 0x0E, 0x38, 0x00, 0x01, 0xC3, 0x0E, 0x00, 0x00, 0x39, 0x83,
  0x80, 0x00, 0x07, 0xE0, 0x60, 0x00, 0x00, 0xF0, 0x18, 0x00, 0x00, 0x3C,
  0x07, 0x00, 0x00, 0x1F, 0x80, 0xC0, 0x00, 0x0E, 0x70, 0x3C, 0x00, 0x07,
  0x0E, 0x07, 0x80, 0x07, 0x81, 0xC0, 0x7F, 0x7F, 0x80, 0x38, 0x0F, 0xFF,
  0x80, 0x07, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xE0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x18, 0x03,
  0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x80,
  0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80,
  0x30, 0x03, 0x00, 0x70, 0x07, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03,
  0x00, 0xE0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x18,
  0x07, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60,
  0x18, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x01, 0xC0, 0x60,
  0x38, 0x0C, 0x06, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x60, 0x18, 0x07, 0xFC, 0x18, 0x3F, 0x3F,
  0x98, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x66, 0x00, 0x00, 0xC3, 0x00, 0x01, 0xC1, 0x80, 0x03,
  0x81, 0xC0, 0x03, 0x00, 0xC0, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x04,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x61, 0x8E,
  0x38, 0xC3, 0x0C, 0x61, 0x86, 0x10, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0xDF,
  0xF4, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0xE0, 0x07,
  0x00, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x60, 0x60, 0x00, 0x38, 0x60, 0x00,
  0x0C, 0x30, 0x00, 0x07, 0x18, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x33, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x76, 0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0xC0, 0x00,
  0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x06, 0x1C, 0x00, 0x03, 0x06, 0x00,
  0x03, 0x03, 0x80, 0x01, 0x80, 0xE0, 0x01, 0x80, 0x38, 0x03, 0x80, 0x0F,
  0x8F, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x38, 0x03,
  0xC0, 0x76, 0x07, 0x30, 0x71, 0x8F, 0x0C, 0xE0, 0x7E, 0x03, 0x60, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0x81, 0xE0, 0x3C, 0x00,
  0x70, 0x70, 0x00, 0x38, 0x20, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0x01, 0xF0, 0x78, 0x00,
  0x38, 0xE0, 0x00, 0x1C, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x03, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0E, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x78, 0xFF, 0x87, 0xE0, 0x1F, 0xFF,
  0x80, 0x00, 0xA0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x07, 0x00, 0x60,
  0x00, 0x18, 0x01, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x07, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x06, 0x00, 0x38,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x60, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x06, 0x01, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x70, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0x8F,
  0xE0, 0x20, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x80, 0x00, 0x38, 0xE0, 0x00, 0xF0, 0xFF, 0x1F,
  0xC0, 0x1F, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0xF0, 0x04, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0xFF, 0x80, 0xC3, 0xFF,
  0xE0, 0xCF, 0x00, 0x78, 0xDC, 0x00, 0x1C, 0xD8, 0x00, 0x0C, 0xF0, 0x00,
  0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x07, 0x30, 0x00,
  0x06, 0x30, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x1C, 0x00, 0x1C, 0x0F, 0x00,
  0x78, 0x03, 0xE3, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xE0, 0x3C, 0x01, 0xC0, 0x03,
  0x81, 0xC0, 0x00, 0xC1, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x18, 0x60, 0x00,
  0x0C, 0x30, 0x00, 0x07, 0x18, 0x00, 0x03, 0x8C, 0x00, 0x01, 0x86, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x60, 0x70, 0x00, 0x70, 0x1C,
  0x00, 0x70, 0x07, 0x80, 0xF0, 0x00, 0xF1, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x1E, 0x7C, 0x00, 0x3C, 0x07, 0x80, 0x38, 0x00, 0xE0,
  0x38, 0x00, 0x38, 0x38, 0x00, 0x06, 0x38, 0x00, 0x03, 0x98, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x03, 0xB0, 0x00, 0x01, 0x9C, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0xC3, 0x80, 0x00, 0xE0, 0xF0, 0x01, 0xE0, 0x1F,
  0x07, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xFF, 0xE0, 0x03, 0xE0, 0x78, 0x03, 0xC0, 0x0E, 0x03, 0x80, 0x03,
  0x81, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x03, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xB0, 0x00, 0x01, 0xD8, 0x00, 0x01, 0xEE, 0x00, 0x01, 0xB3,
  0x80, 0x01, 0x98, 0xE0, 0x01, 0xDC, 0x3C, 0x03, 0x8C, 0x0F, 0xFF, 0x86,
  0x01, 0xFE, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1B, 0xFE, 0x80, 0x1C, 0x71, 0xC6, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x18, 0x63, 0x8E, 0x30, 0xC7, 0x18, 0x61, 0x8C, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0xC3, 0xF0, 0x7C, 0x60,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x30, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x30, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x0F, 0xF8, 0x00, 0xC3, 0x00,
  0x07, 0xFF, 0xC0, 0x1C, 0x60, 0x03, 0xC0, 0x18, 0x01, 0x98, 0x00, 0xE0,
  0x03, 0x00, 0x33, 0x00, 0x18, 0x00, 0x60, 0x06, 0x60, 0x06, 0x00, 0x0C,
  0x00, 0xD8, 0x01, 0xC0, 0x01, 0x80, 0x1F, 0x00, 0x30, 0x00, 0x30, 0x01,
  0xE0, 0x06, 0x00, 0x06, 0x00, 0x3C, 0x01, 0x80, 0x00, 0xC0, 0x07, 0x80,
  0x30, 0x00, 0x18, 0x01, 0xF0, 0x06, 0x00, 0x03, 0x00, 0x36, 0x00, 0xC0,
  0x00, 0x60, 0x06, 0xC0, 0x18, 0x00, 0x1C, 0x00, 0xD8, 0x03, 0x00, 0x03,
  0x80, 0x1B, 0x00, 0x70, 0x00, 0x70, 0x03, 0x60, 0x06, 0x00, 0x1E, 0x00,
  0xCC, 0x00, 0xC0, 0x03, 0xC0, 0x18, 0xC0, 0x0C, 0x00, 0xD8, 0x06, 0x18,
  0x01, 0xC0, 0x71, 0x81, 0x83, 0x00, 0x1F, 0xFC, 0x1F, 0xE0, 0x60, 0x00,
  0xFE, 0x01, 0xF8, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00,
  0x30, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00,
  0xE0, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x00, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xC0, 0x03,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x1C, 0x18,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x30, 0x00, 0x1E,
  0x18, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x1D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x39, 0x80, 0x00, 0x38, 0xC0, 0x00, 0x78, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x18, 0x00, 0xFE, 0x0C, 0x00, 0x03, 0xC6, 0x00, 0x00, 0x73,
  0x00, 0x00, 0x1D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x60, 0x00,
  0x03, 0xB0, 0x00, 0x03, 0x98, 0x00, 0x03, 0x8C, 0x00, 0x0F, 0x87, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xC0, 0x7E, 0x01, 0xE0, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x08, 0x01,
  0xFE, 0x7F, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xE8, 0x00, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x80, 0x30, 0x00, 0x3E, 0x01, 0x80, 0x00, 0x3C,
  0x0C, 0x00, 0x00, 0x70, 0x60, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x07, 0x18,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x1D, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x03, 0x86, 0x00, 0x00,
  0x38, 0x30, 0x00, 0x03, 0x81, 0x80, 0x00, 0x78, 0x0C, 0x00, 0x3F, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x78,
  0x00, 0x06, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x70, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x38, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x03, 0x0E, 0x00,
  0x00, 0x03, 0x07, 0x00, 0x00, 0x03, 0x03, 0x80, 0x00, 0x03, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x70, 0xFF,
  0xC7, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x3F, 0xFF, 0xFC,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60,
  0x07, 0x00, 0x73, 0x0F, 0x1F, 0xF0, 0x7C, 0x00, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0x30, 0x00, 0x07, 0x18, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x06,
  0x00, 0x07, 0x03, 0x00, 0x03, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x03, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x03, 0x00,
  0x06, 0x03, 0x00, 0x03, 0x03, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x63, 0xE0, 0x00, 0x33, 0x30, 0x00, 0x1B, 0x1C, 0x00, 0x0F, 0x07,
  0x00, 0x07, 0x01, 0xC0, 0x03, 0x00, 0x60, 0x01, 0x80, 0x38, 0x00, 0xC0,
  0x0E, 0x00, 0x60, 0x03, 0x80, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x70, 0x0C,
  0x00, 0x1C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x81, 0x80, 0x00, 0xE0,
  0xC0, 0x00, 0x38, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x07, 0x18, 0x00, 0x01,
  0xCC, 0x00, 0x00, 0x76, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0E, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFD, 0x80,
  0x00, 0x00, 0x37, 0xB0, 0x00, 0x00, 0x06, 0xF7, 0x00, 0x00, 0x01, 0x9E,
  0x60, 0x00, 0x00, 0x33, 0xCC, 0x00, 0x00, 0x0E, 0x78, 0xC0, 0x00, 0x01,
  0x8F, 0x18, 0x00, 0x00, 0x31, 0xE3, 0x80, 0x00, 0x0C, 0x3C, 0x30, 0x00,
  0x01, 0x87, 0x86, 0x00, 0x00, 0x70, 0xF0, 0x60, 0x00, 0x0C, 0x1E, 0x0C,
  0x00, 0x01, 0x83, 0xC1, 0xC0, 0x00, 0x60, 0x78, 0x18, 0x00, 0x0C, 0x0F,
  0x03, 0x00, 0x03, 0x81, 0xE0, 0x30, 0x00, 0x60, 0x3C, 0x06, 0x00, 0x0C,
  0x07, 0x80, 0xE0, 0x03, 0x00, 0xF0, 0x0C, 0x00, 0x60, 0x1E, 0x01, 0x80,
  0x18, 0x03, 0xC0, 0x18, 0x03, 0x00, 0x78, 0x03, 0x00, 0x60, 0x0F, 0x00,
  0x70, 0x18, 0x01, 0xE0, 0x06, 0x03, 0x00, 0x3C, 0x00, 0xE0, 0xC0, 0x07,
  0x80, 0x0C, 0x18, 0x00, 0xF0, 0x01, 0x87, 0x00, 0x1E, 0x00, 0x38, 0xC0,
  0x03, 0xC0, 0x03, 0x18, 0x00, 0x78, 0x00, 0x76, 0x00, 0x0F, 0x00, 0x06,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xB8, 0x00, 0x00, 0xF3, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x03, 0xC7,
  0x00, 0x00, 0x78, 0x60, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xE0, 0xE0, 0x00,
  0x3C, 0x0C, 0x00, 0x07, 0x81, 0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x1E, 0x01,
  0x80, 0x03, 0xC0, 0x38, 0x00, 0x78, 0x03, 0x80, 0x0F, 0x00, 0x30, 0x01,
  0xE0, 0x07, 0x00, 0x3C, 0x00, 0x70, 0x07, 0x80, 0x06, 0x00, 0xF0, 0x00,
  0xE0, 0x1E, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0xC0, 0x78, 0x00, 0x1C, 0x0F,
  0x00, 0x01, 0xC1, 0xE0, 0x00, 0x18, 0x3C, 0x00, 0x03, 0x87, 0x80, 0x00,
  0x38, 0xF0, 0x00, 0x03, 0x1E, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x07, 0x78,
  0x00, 0x00, 0x6F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x03, 0x83,
  0x00, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x00,
  0x67, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x50, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x83, 0x00, 0x07, 0xC6, 0x00, 0x03, 0xCC, 0x00, 0x03, 0x98, 0x00,
  0x03, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x73,
  0x00, 0x01, 0xC6, 0x00, 0x0F, 0x0C, 0x07, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F,
  0xE0, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x18,
  0x1C, 0x00, 0x00, 0x03, 0x83, 0x00, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00,
  0x07, 0x18, 0x00, 0x00, 0x00, 0x67, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x01, 0xD8, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x01,
  0x8E, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00,
  0x03, 0x81, 0x80, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x18, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x03, 0xE0, 0x01, 0xE0, 0x00,
  0x1F, 0xE7, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x30, 0x00, 0x7C, 0x18, 0x00, 0x0F,
  0x0C, 0x00, 0x01, 0xC6, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x1C, 0xC0, 0x00, 0x0E, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00,
  0x01, 0xCC, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x38, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x38, 0x30, 0x00, 0x38, 0x18,
  0x00, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0x00, 0x38, 0x01,
  0x80, 0x0E, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x01, 0xC0, 0x30, 0x00, 0x60,
  0x18, 0x00, 0x38, 0x0C, 0x00, 0x0E, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x0E, 0x30, 0x00,
  0x03, 0x18, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x3B, 0x00,
  0x00, 0x0E, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xF8, 0x0F, 0xC0, 0xFE, 0x1E,
  0x00, 0x06, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x78, 0xFF, 0x8F, 0xE0, 0x3F,
  0xFF, 0x80, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x00, 0xCE, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x03, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x78,
  0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x40, 0x00, 0xE0,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x33, 0x80,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0xE0, 0x30, 0x00, 0x01, 0x80, 0x70, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0xC0, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x30, 0x01, 0x80, 0x00,
  0xE0, 0x03, 0x80, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x38, 0x01, 0x80, 0x00, 0x30, 0x07, 0x00, 0x00, 0x70, 0x0C, 0x00,
  0x00, 0x60, 0x38, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x01, 0x83, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00,
  0x06, 0x38, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x66, 0x00, 0x00, 0xD8, 0x00, 0x07, 0x30,
  0x00, 0x0C, 0xC0, 0x00, 0x31, 0xC0, 0x00, 0x66, 0x00, 0x01, 0x86, 0x00,
  0x03, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x18, 0xC0, 0x00, 0xE1, 0x80, 0x01,
  0x86, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x30, 0x00, 0x61,
  0xC0, 0x03, 0x81, 0x80, 0x07, 0x06, 0x00, 0x1C, 0x0E, 0x00, 0x30, 0x30,
  0x00, 0xC0, 0x30, 0x01, 0x81, 0x80, 0x06, 0x01, 0x80, 0x0C, 0x06, 0x00,
  0x70, 0x0C, 0x00, 0xC0, 0x30, 0x03, 0x00, 0x70, 0x06, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x30, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x00,
  0x60, 0x18, 0x01, 0x80, 0x60, 0x01, 0x80, 0xC0, 0x0C, 0x03, 0x00, 0x0C,
  0x06, 0x00, 0x30, 0x38, 0x00, 0x60, 0x70, 0x01, 0x81, 0x80, 0x03, 0x03,
  0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x60, 0x00, 0x60, 0xC0,
  0x01, 0x87, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x1C, 0x60, 0x00,
  0x61, 0x80, 0x00, 0x63, 0x00, 0x03, 0x8C, 0x00, 0x03, 0x38, 0x00, 0x0C,
  0xE0, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x00, 0xEC, 0x00, 0x03, 0x30,
  0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x38, 0x03, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x30, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x07, 0x07, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x0E,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x60, 0x0E, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x70, 0x00, 0x01, 0xC3, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x30, 0x06, 0x00, 0x07, 0x00, 0x70, 0x00, 0x60, 0x03, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0xC0, 0x01, 0x80, 0x1C, 0x00, 0x1C, 0x01, 0x80, 0x00, 0xC0,
  0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x38, 0xC0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E,
  0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x03, 0x86, 0x00, 0x00, 0x60, 0x60, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x06, 0x01, 0x80, 0x00,
  0xC0, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x60,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00,
  0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x1C, 0x03, 0x80, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x3F, 0xFC,
  0x0F, 0xE0, 0xF0, 0x30, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x01, 0xFC, 0x07, 0xFF, 0xE1, 0xFC,
  0x03, 0x1E, 0x00, 0x19, 0xC0, 0x00, 0xD8, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x02, 0xF8, 0x00, 0x36, 0xE0, 0x07, 0x33, 0xE1, 0xF1, 0x8F,
  0xFE, 0x0C, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x1E, 0x00, 0xC1, 0xFF, 0xC0, 0xC7,
  0xC1, 0xF0, 0xCE, 0x00, 0x78, 0xDC, 0x00, 0x18, 0xD8, 0x00, 0x0C, 0xF0,
  0x00, 0x0E, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x06, 0xE0,
  0x00, 0x06, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x0C, 0xF0, 0x00, 0x1C, 0xD8,
  0x00, 0x38, 0xCE, 0x00, 0x70, 0xC7, 0xC7, 0xE0, 0xC1, 0xFF, 0x80, 0x00,
  0x18, 0x00, 0x00, 0x07, 0x80, 0x07, 0xFF, 0xC0, 0xFE, 0x1E, 0x0F, 0x00,
  0x10, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x10, 0x3F, 0x9F, 0x80, 0x7F, 0xF8, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x01, 0xE0, 0x38, 0x0F, 0xFE, 0x1C, 0x1F, 0x07, 0xCE, 0x1E,
  0x00, 0x73, 0x1C, 0x00, 0x19, 0x8C, 0x00, 0x06, 0xCE, 0x00, 0x01, 0x66,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x03, 0xB0, 0x00, 0x01, 0xD8, 0x00,
  0x01, 0xEE, 0x00, 0x00, 0xF3, 0x00, 0x00, 0x59, 0xC0, 0x00, 0x6C, 0x70,
  0x00, 0x66, 0x1C, 0x00, 0x63, 0x07, 0xE3, 0xE1, 0x80, 0xFF, 0xE0, 0xC0,
  0x02, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xC1, 0xE0,
  0x07, 0x00, 0x70, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x1C, 0x38, 0x00, 0x0C,
  0x30, 0x00, 0x06, 0x70, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x06, 0x03, 0xF1, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x04, 0x00,
  0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x1C, 0x04, 0x0E, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x3F, 0xFF, 0x0F, 0xFF, 0xC0, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0xFF, 0xE0, 0xC1, 0xF8, 0x7C, 0x61, 0xE0, 0x07, 0x31,
  0xC0, 0x01, 0xF8, 0xC0, 0x00, 0x7C, 0xE0, 0x00, 0x1E, 0x60, 0x00, 0x0F,
  0x70, 0x00, 0x03, 0xB0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x1E, 0xE0,
  0x00, 0x0F, 0x30, 0x00, 0x07, 0x9C, 0x00, 0x07, 0xC7, 0x00, 0x06, 0xE1,
  0xE0, 0x06, 0x70, 0x7E, 0x3E, 0x38, 0x0F, 0xFC, 0x1C, 0x00, 0x30, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x38, 0x40, 0x00, 0x38, 0x3C, 0x00, 0x78, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xF0, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x1E, 0x03, 0x07, 0xFF, 0x0C, 0x7C, 0x1E, 0x33, 0x80, 0x1C, 0xD8, 0x00,
  0x3B, 0x40, 0x00, 0x6F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x6F, 0xF6,
  0x00, 0x00, 0x00, 0x06, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0xC0, 0x3C, 0x07, 0x80, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x30, 0x0E, 0x7F, 0x8F, 0xE0, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x3B, 0x00, 0x03, 0x18, 0x00,
  0x38, 0xC0, 0x03, 0x86, 0x00, 0x38, 0x30, 0x03, 0x81, 0x80, 0x38, 0x0C,
  0x03, 0x80, 0x60, 0x38, 0x03, 0x01, 0x80, 0x18, 0x18, 0x00, 0xC1, 0x80,
  0x06, 0x1C, 0x00, 0x31, 0xE0, 0x01, 0x99, 0x80, 0x0D, 0x8E, 0x00, 0x7C,
  0x38, 0x03, 0xC0, 0xC0, 0x1C, 0x03, 0x00, 0xC0, 0x1C, 0x06, 0x00, 0x70,
  0x30, 0x01, 0x81, 0x80, 0x06, 0x0C, 0x00, 0x38, 0x60, 0x00, 0xE3, 0x00,
  0x03, 0x18, 0x00, 0x0C, 0xC0, 0x00, 0x76, 0x00, 0x01, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00,
  0x0F, 0x03, 0x0F, 0xFC, 0x03, 0xFF, 0x0C, 0x78, 0x78, 0x3E, 0x1F, 0x33,
  0x00, 0x71, 0xC0, 0x1E, 0xD8, 0x00, 0xE6, 0x00, 0x1B, 0xC0, 0x01, 0xB0,
  0x00, 0x7E, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x00,
  0x00, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0x00,
  0x00, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x0C, 0x00,
  0x03, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x00, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x00,
  0x0F, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00,
  0x0C, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0xC0, 0x00,
  0x30, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x3E, 0x03, 0x07,
  0xFF, 0x0C, 0x7C, 0x1E, 0x33, 0x80, 0x1C, 0xD8, 0x00, 0x3B, 0x40, 0x00,
  0x7F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x3C, 0x1F, 0x80, 0x3C, 0x00, 0xF0, 0x1C, 0x00, 0x0E, 0x06,
  0x00, 0x01, 0x83, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x0C, 0x70, 0x00, 0x03,
  0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x06, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x06,
  0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x67, 0x00, 0x00, 0x38, 0xC0, 0x00,
  0x0C, 0x38, 0x00, 0x07, 0x06, 0x00, 0x03, 0x80, 0xC0, 0x01, 0xC0, 0x1C,
  0x00, 0xE0, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0xC1, 0xFF, 0xC0, 0xC7, 0xC1, 0xF0, 0xCE, 0x00, 0x78,
  0xCC, 0x00, 0x1C, 0xD8, 0x00, 0x0C, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x06,
  0xE0, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0E,
  0xF0, 0x00, 0x0C, 0xD8, 0x00, 0x1C, 0xDC, 0x00, 0x38, 0xCE, 0x00, 0x70,
  0xC7, 0xE7, 0xE0, 0xC1, 0xFF, 0x80, 0xC0, 0x10, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xFF, 0xC1, 0x07, 0xC1, 0xE1, 0x0E, 0x00, 0x31, 0x1C, 0x00, 0x1B,
  0x18, 0x00, 0x0F, 0x30, 0x00, 0x07, 0x30, 0x00, 0x07, 0x60, 0x00, 0x07,
  0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x60, 0x00, 0x07, 0x70, 0x00, 0x07, 0x30, 0x00, 0x0F,
  0x38, 0x00, 0x0F, 0x1C, 0x00, 0x1B, 0x0E, 0x00, 0x73, 0x07, 0xC3, 0xE3,
  0x03, 0xFF, 0x83, 0x00, 0x18, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x31, 0x87, 0xFF, 0x1F, 0x3E,
  0x60, 0x0D, 0x80, 0x1A, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0x07, 0xC0, 0xFC, 0x70,
  0x00, 0x63, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xA0,
  0x00, 0x1D, 0xC0, 0x01, 0xCF, 0xE0, 0xFC, 0x1F, 0xFF, 0x80, 0x01, 0x40,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0xE7, 0x01,
  0xFF, 0x00, 0x10, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x36, 0x00, 0x00, 0xEC, 0x00, 0x01, 0xD8, 0x00, 0x03, 0xB0, 0x00, 0x0F,
  0x70, 0x00, 0x36, 0x70, 0x00, 0xEC, 0x70, 0x03, 0x98, 0x7C, 0x7E, 0x30,
  0x7F, 0xF0, 0x60, 0x04, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xB0, 0x00, 0x01,
  0x98, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xE1, 0x80, 0x00,
  0x60, 0x60, 0x00, 0x30, 0x30, 0x00, 0x38, 0x1C, 0x00, 0x18, 0x06, 0x00,
  0x0C, 0x03, 0x00, 0x0C, 0x01, 0xC0, 0x06, 0x00, 0x60, 0x07, 0x00, 0x30,
  0x03, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x01, 0xC0, 0x03, 0x80, 0xC0, 0x00,
  0xC0, 0x60, 0x00, 0x60, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x38, 0x00,
  0x06, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x1F, 0x00, 0x03, 0x80, 0x01, 0xD8, 0x00,
  0x1E, 0x00, 0x0C, 0xC0, 0x00, 0xB0, 0x00, 0x66, 0x00, 0x0D, 0x80, 0x03,
  0x38, 0x00, 0x66, 0x00, 0x38, 0xC0, 0x03, 0x30, 0x01, 0x86, 0x00, 0x31,
  0x80, 0x0C, 0x38, 0x01, 0x8E, 0x00, 0x60, 0xC0, 0x0C, 0x30, 0x06, 0x06,
  0x00, 0xC1, 0x80, 0x30, 0x30, 0x06, 0x0E, 0x01, 0x81, 0xC0, 0x30, 0x30,
  0x1C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x80,
  0xC0, 0x30, 0x30, 0x06, 0x0C, 0x01, 0x83, 0x80, 0x30, 0x60, 0x0C, 0x18,
  0x01, 0x83, 0x00, 0x30, 0xC0, 0x0E, 0x30, 0x01, 0x86, 0x00, 0x31, 0x80,
  0x0C, 0x60, 0x01, 0x8C, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00,
  0x36, 0x00, 0x0C, 0xC0, 0x01, 0xB0, 0x00, 0x3C, 0x00, 0x0D, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x18, 0x00,
  0x1C, 0x1C, 0x00, 0x18, 0x0E, 0x00, 0x30, 0x06, 0x00, 0x70, 0x03, 0x00,
  0x60, 0x03, 0x80, 0xC0, 0x01, 0x81, 0xC0, 0x00, 0xC3, 0x80, 0x00, 0xE3,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x76, 0x00, 0x00, 0x63, 0x00, 0x00, 0xC3,
  0x80, 0x01, 0xC1, 0xC0, 0x03, 0x80, 0xC0, 0x03, 0x00, 0x60, 0x06, 0x00,
  0x70, 0x0E, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x1C, 0x38, 0x00,
  0x0E, 0x70, 0x00, 0x06, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xB0, 0x00,
  0x01, 0x98, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x60, 0x60, 0x00, 0x30, 0x30, 0x00, 0x38, 0x1C, 0x00, 0x18, 0x06,
  0x00, 0x0C, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x07, 0x00,
  0x38, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x01, 0xC0, 0x03, 0x80, 0xC0,
  0x00, 0xC0, 0x60, 0x00, 0x60, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x38,
  0x00, 0x07, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0x00, 0x7F, 0x00, 0xF0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0xFC, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x70, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0xFC, 0x00,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0xBF, 0xFC, 0x00, 0x78, 0x0F, 0x80, 0x78,
  0x01, 0xFF, 0xE8, 0x00, 0x1F, 0xC0,
};

const GFXglyph NotoSans_ExtraLight55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 3, 40, 13, 5, -39 },
  { 16, 11, 14, 19, 4, -39 },
  { 36, 33, 39, 36, 1, -39 },
  { 197, 22, 45, 31, 4, -42 },
  { 321, 38, 41, 44, 3, -40 },
  { 516, 34, 41, 39, 3, -40 },
  { 691, 2, 14, 10, 4, -39 },
  { 695, 11, 48, 15, 2, -39 },
  { 761, 10, 48, 15, 2, -39 },
  { 821, 24, 23, 30, 3, -42 },
  { 890, 25, 25, 31, 3, -32 },
  { 969, 6, 13, 11, 2, -6 },
  { 979, 14, 2, 18, 2, -16 },
  { 983, 3, 5, 13, 5, -4 },
  { 985, 17, 39, 18, 1, -39 },
  { 1068, 25, 41, 31, 3, -40 },
  { 1197, 13, 39, 31, 5, -39 },
  { 1261, 24, 40, 31, 3, -40 },
  { 1381, 24, 41, 31, 3, -40 },
  { 1504, 30, 39, 31, 1, -39 },
  { 1651, 24, 40, 31, 4, -39 },
  { 1771, 24, 41, 31, 4, -40 },
  { 1894, 25, 39, 31, 3, -39 },
  { 2016, 25, 41, 31, 3, -40 },
  { 2145, 25, 41, 31, 3, -40 },
  { 2274, 3, 30, 13, 5, -29 },
  { 2286, 6, 36, 13, 2, -29 },
  { 2313, 25, 25, 31, 3, -32 },
  { 2392, 25, 13, 31, 3, -26 },
  { 2433, 25, 25, 31, 3, -32 },
  { 2512, 19, 41, 23, 2, -40 },
  { 2610, 43, 44, 49, 3, -39 },
  { 2847, 32, 39, 32, 0, -39 },
  { 3003, 25, 39, 34, 6, -39 },
  { 3125, 29, 41, 34, 3, -40 },
  { 3274, 29, 39, 39, 6, -39 },
  { 3416, 21, 39, 30, 6, -39 },
  { 3519, 21, 39, 27, 6, -39 },
  { 3622, 32, 41, 40, 3, -40 },
  { 3786, 28, 39, 39, 6, -39 },
  { 3923, 10, 39, 16, 3, -39 },
  { 3972, 13, 49, 13, -5, -39 },
  { 4052, 25, 39, 31, 6, -39 },
  { 4174, 21, 39, 28, 6, -39 },
  { 4277, 35, 39, 47, 6, -39 },
  { 4448, 27, 39, 39, 6, -39 },
  { 4580, 35, 41, 42, 3, -40 },
  { 4760, 23, 39, 32, 6, -39 },
  { 4873, 35, 49, 42, 3, -40 },
  { 5088, 25, 39, 32, 6, -39 },
  { 5210, 24, 41, 30, 3, -40 },
  { 5333, 28, 39, 28, 0, -39 },
  { 5470, 29, 40, 39, 5, -39 },
  { 5615, 31, 39, 31, 0, -39 },
  { 5767, 45, 39, 48, 2, -39 },
  { 5987, 29, 39, 29, 0, -39 },
  { 6129, 28, 39, 28, 0, -39 },
  { 6266, 28, 39, 32, 2, -39 },
  { 6403, 11, 48, 17, 5, -39 },
  { 6469, 17, 39, 18, 1, -39 },
  { 6552, 12, 48, 17, 1, -39 },
  { 6624, 27, 25, 31, 2, -40 },
  { 6709, 22, 2, 22, 0, 5 },
  { 6715, 10, 9, 14, 2, -42 },
  { 6727, 21, 31, 29, 3, -30 },
  { 6809, 24, 43, 32, 5, -42 },
  { 6938, 21, 31, 26, 3, -30 },
  { 7020, 25, 43, 32, 3, -42 },
  { 7155, 24, 31, 30, 3, -30 },
  { 7248, 18, 42, 16, 1, -42 },
  { 7343, 25, 43, 32, 3, -30 },
  { 7478, 22, 42, 32, 5, -42 },
  { 7594, 4, 40, 12, 4, -40 },
  { 7614, 11, 53, 12, -3, -40 },
  { 7687, 21, 42, 26, 5, -42 },
  { 7798, 2, 42, 12, 5, -42 },
  { 7809, 38, 30, 48, 5, -30 },
  { 7952, 22, 30, 32, 5, -30 },
  { 8035, 26, 31, 32, 3, -30 },
  { 8136, 24, 43, 32, 5, -30 },
  { 8265, 24, 43, 32, 3, -30 },
  { 8394, 15, 30, 21, 5, -30 },
  { 8451, 21, 31, 25, 2, -30 },
  { 8533, 16, 37, 18, 1, -36 },
  { 8607, 23, 30, 32, 4, -29 },
  { 8694, 25, 29, 25, 0, -29 },
  { 8785, 37, 29, 39, 1, -29 },
  { 8920, 24, 29, 27, 1, -29 },
  { 9007, 25, 42, 24, 0, -29 },
  { 9139, 21, 29, 25, 2, -29 },
  { 9216, 16, 48, 19, 1, -39 },
  { 9312, 2, 56, 30, 14, -42 },
  { 9326, 16, 48, 19, 2, -39 },
  { 9422, 25, 5, 31, 3, -22 },
};

const GFXfont NotoSans_ExtraLight55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight55pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_EXTRALIGHT55PT7B_H_
