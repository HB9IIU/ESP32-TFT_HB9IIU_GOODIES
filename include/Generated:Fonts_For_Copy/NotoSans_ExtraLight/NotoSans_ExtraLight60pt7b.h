#ifndef _NOTOSANS_EXTRALIGHT60PT7B_H_
#define _NOTOSANS_EXTRALIGHT60PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight60pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0x00, 0x00, 0x0E, 0xFF, 0xF4, 0xE0,
  0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0x60,
  0x36, 0x03, 0x60, 0x34, 0x03, 0x40, 0x34, 0x03, 0x40, 0x34, 0x03, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x30, 0x00, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x60, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x70, 0x01,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x3E, 0x67, 0xF8, 0x78, 0x30, 0x1C, 0x38, 0x18, 0x00,
  0x38, 0x0C, 0x00, 0x38, 0x06, 0x00, 0x1C, 0x03, 0x00, 0x0C, 0x01, 0x80,
  0x06, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0xE0, 0x18,
  0x00, 0x70, 0x0C, 0x00, 0x1C, 0x06, 0x00, 0x0F, 0x03, 0x00, 0x03, 0xC1,
  0x80, 0x00, 0xF8, 0xC0, 0x00, 0x1F, 0x60, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x06, 0x7C, 0x00, 0x03, 0x0F, 0x80,
  0x01, 0x81, 0xE0, 0x00, 0xC0, 0x70, 0x00, 0x60, 0x1C, 0x00, 0x30, 0x06,
  0x00, 0x18, 0x03, 0x80, 0x0C, 0x01, 0xC0, 0x06, 0x00, 0xE0, 0x03, 0x00,
  0x70, 0x01, 0x80, 0x38, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x1C, 0x00, 0x30,
  0x0E, 0x00, 0x18, 0x0E, 0x60, 0x0C, 0x1E, 0x3F, 0x86, 0x7E, 0x0F, 0xFF,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xC0, 0x03,
  0xFF, 0x00, 0x00, 0x60, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x00, 0xE0, 0x18,
  0x00, 0x0C, 0x00, 0x30, 0x07, 0x00, 0x07, 0x00, 0x1C, 0x00, 0xC0, 0x01,
  0x80, 0x06, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00,
  0x60, 0x01, 0x80, 0x18, 0x00, 0x18, 0x00, 0x60, 0x06, 0x00, 0x0E, 0x00,
  0x18, 0x03, 0x00, 0x03, 0x80, 0x06, 0x01, 0xC0, 0x00, 0xE0, 0x01, 0x80,
  0x60, 0x00, 0x38, 0x00, 0x60, 0x38, 0x00, 0x0E, 0x00, 0x18, 0x0C, 0x00,
  0x03, 0x80, 0x06, 0x07, 0x00, 0x00, 0x60, 0x01, 0x81, 0x80, 0x00, 0x18,
  0x00, 0x60, 0xC0, 0xFE, 0x06, 0x00, 0x38, 0x30, 0xFF, 0xC1, 0x80, 0x0C,
  0x18, 0x38, 0x38, 0x70, 0x03, 0x06, 0x18, 0x07, 0x0C, 0x01, 0xC3, 0x0E,
  0x00, 0xC3, 0x80, 0x61, 0xC3, 0x00, 0x38, 0x70, 0x38, 0x60, 0xC0, 0x06,
  0x0F, 0xFC, 0x38, 0x70, 0x01, 0x81, 0xFC, 0x0C, 0x18, 0x00, 0x60, 0x00,
  0x06, 0x06, 0x00, 0x18, 0x00, 0x01, 0x81, 0x80, 0x07, 0x00, 0x00, 0xC0,
  0x60, 0x01, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x70, 0x00, 0x18, 0x06, 0x00,
  0x1C, 0x00, 0x0E, 0x01, 0x80, 0x07, 0x00, 0x03, 0x00, 0x60, 0x01, 0xC0,
  0x01, 0xC0, 0x18, 0x00, 0x60, 0x00, 0x60, 0x06, 0x00, 0x18, 0x00, 0x30,
  0x01, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0xE0, 0x01, 0x80, 0x03, 0x80, 0x30, 0x00, 0xC0, 0x00, 0x60, 0x1C,
  0x00, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x18, 0x00, 0x03, 0xCF, 0x00, 0x0E,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x38, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x03, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x1C, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00,
  0x0E, 0x03, 0xC0, 0x00, 0x61, 0xE0, 0x0F, 0x00, 0x03, 0x0E, 0x00, 0x3C,
  0x00, 0x38, 0xE0, 0x00, 0xF0, 0x01, 0x8E, 0x00, 0x03, 0xC0, 0x0C, 0x70,
  0x00, 0x0F, 0x00, 0xE3, 0x00, 0x00, 0x3C, 0x06, 0x18, 0x00, 0x00, 0xF0,
  0x70, 0xC0, 0x00, 0x03, 0xC7, 0x06, 0x00, 0x00, 0x0F, 0x30, 0x30, 0x00,
  0x00, 0x3F, 0x81, 0x80, 0x00, 0x00, 0xF8, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x00, 0x3E, 0x01, 0xC0, 0x00, 0x03, 0xB8, 0x0E, 0x00, 0x00,
  0x38, 0xE0, 0x3C, 0x00, 0x07, 0x83, 0x80, 0xF8, 0x00, 0xF8, 0x0E, 0x03,
  0xFF, 0xFF, 0x00, 0x38, 0x07, 0xFF, 0xE0, 0x00, 0xF0, 0x02, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x6D, 0xA4, 0x92, 0x00, 0xE0, 0x38, 0x0E,
  0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x18,
  0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03,
  0x80, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0xF0, 0xE0, 0x0E, 0x00, 0xC0,
  0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00,
  0xC0, 0x18, 0x03, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01,
  0x80, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x03,
  0x80, 0x60, 0x1C, 0x07, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x60, 0x04,
  0x01, 0xDF, 0x01, 0x01, 0xFB, 0xF8, 0x43, 0xF8, 0x0F, 0xD7, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xCE, 0x00,
  0x00, 0x71, 0x80, 0x00, 0x18, 0x30, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x01,
  0xC0, 0x03, 0x80, 0x30, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x08,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x1C, 0x71, 0xC7, 0x18, 0x63, 0x8E, 0x30, 0xC3,
  0x18, 0x61, 0x8C, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xEF, 0xFF, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xC0,
  0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x06, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x18, 0x30, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x06, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x01, 0xB8,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x37, 0x00, 0x00, 0x06,
  0xE0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x38, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x30, 0x70, 0x00, 0x06, 0x06, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x00, 0xF0, 0x07, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0xF0,
  0x0F, 0xC0, 0x7F, 0x03, 0x9C, 0x3C, 0x71, 0xE1, 0xCE, 0x07, 0xF0, 0x1F,
  0x80, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0xE0, 0x3E, 0x00,
  0x0E, 0x03, 0x00, 0x00, 0xE0, 0x40, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0xF0,
  0x3C, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xE4, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x3E, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x07, 0x01, 0x80, 0x00,
  0x0E, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x38, 0x01, 0x80, 0x00, 0x30, 0x01, 0x80, 0x00, 0x60, 0x01, 0x80, 0x00,
  0xE0, 0x01, 0x80, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x01, 0x80, 0x07, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x01, 0x80, 0x0C,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x38, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x1F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x0F, 0x80, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0x9F, 0xE0, 0x10, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF3, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x7C,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x81,
  0xFF, 0xC0, 0x60, 0xFF, 0xFE, 0x0C, 0x78, 0x01, 0xE1, 0x9C, 0x00, 0x0E,
  0x37, 0x00, 0x00, 0xE6, 0xC0, 0x00, 0x0C, 0xF0, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x03, 0x70, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0xEC, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0x98, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE0, 0x60, 0x00,
  0x18, 0x0F, 0x00, 0x07, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0xF0, 0x03, 0xC0, 0x70,
  0x00, 0x38, 0x38, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x0E, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x19, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x70, 0x70, 0x00, 0x38, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x1C, 0x00,
  0x1F, 0x1E, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7D, 0xF8,
  0x00, 0x3C, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x1C, 0x00, 0x0E, 0x0E, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x39, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xD8, 0x00, 0x00, 0x67, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x3C, 0x1E,
  0x00, 0x1E, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1E, 0x00, 0xF0, 0x07, 0x00,
  0x0F, 0x01, 0xC0, 0x00, 0x60, 0x70, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x0C, 0x60, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x1B, 0x80, 0x00,
  0x03, 0x70, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0x1D, 0x80, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xF3, 0x00, 0x00, 0x36, 0x70,
  0x00, 0x0E, 0xC7, 0x00, 0x03, 0x98, 0x78, 0x01, 0xE3, 0x07, 0xF3, 0xF8,
  0x60, 0x3F, 0xFC, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x03, 0xC7, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xEF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xEF, 0xFF, 0x40, 0x1C, 0x3C,
  0x78, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x70, 0xE1, 0xC3,
  0x06, 0x1C, 0x38, 0x60, 0xC3, 0x86, 0x0C, 0x18, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x03, 0xFF,
  0xFC, 0x3C, 0x00, 0xF0, 0x80, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x02,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0xFF, 0xF8, 0x01, 0x87, 0x00, 0x07, 0xF7,
  0xF0, 0x03, 0x8C, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x18, 0x00, 0x70, 0x00,
  0xC0, 0x06, 0x60, 0x01, 0xC0, 0x01, 0x80, 0x0C, 0xC0, 0x07, 0x00, 0x03,
  0x00, 0x1D, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x3B, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x3E, 0x00, 0x60, 0x00, 0x18, 0x00, 0x7C, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0xF0, 0x01, 0x80, 0x00, 0x60, 0x01, 0xE0, 0x03, 0x00, 0x01, 0xC0,
  0x07, 0xC0, 0x0E, 0x00, 0x03, 0x80, 0x0D, 0x80, 0x1C, 0x00, 0x07, 0x00,
  0x1B, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x36, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x6E, 0x00, 0x60, 0x00, 0x78, 0x01, 0xDC, 0x00, 0xC0, 0x00, 0xF0, 0x03,
  0x18, 0x01, 0xC0, 0x03, 0x60, 0x0E, 0x30, 0x01, 0xC0, 0x06, 0xC0, 0x18,
  0x60, 0x01, 0xC0, 0x38, 0xC0, 0x70, 0xE0, 0x01, 0xF3, 0xE1, 0xF7, 0xC0,
  0xC0, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0x80, 0x00, 0x20, 0x00, 0x30, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x07,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x38, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x03, 0x80, 0x30, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x80, 0xC0, 0x01, 0xFE, 0x0C, 0x00, 0x00, 0xF0, 0xC0, 0x00, 0x03,
  0x8C, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0x0E, 0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x1C, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0x1E, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0,
  0xC0, 0x00, 0x0F, 0x0C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x01, 0xCC, 0x00,
  0x00, 0x0E, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0xF0, 0xC0, 0x00, 0x7E, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xF8,
  0x00, 0xF8, 0x07, 0x80, 0x00, 0x20, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x0C, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0xC0, 0x03, 0xFE, 0x00, 0xC0, 0x00, 0x1F, 0x00, 0xC0, 0x00, 0x03,
  0xC0, 0xC0, 0x00, 0x01, 0xE0, 0xC0, 0x00, 0x00, 0xF0, 0xC0, 0x00, 0x00,
  0x78, 0xC0, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x01,
  0xE0, 0xC0, 0x00, 0x07, 0xC0, 0xC0, 0x00, 0x1F, 0x00, 0xC0, 0x01, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xB0, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x0F,
  0x00, 0x00, 0x18, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x07,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x38, 0xFF, 0xFF, 0xFC,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC7, 0xFF, 0x0F, 0xFC,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1C, 0xC0, 0x00,
  0x03, 0x8C, 0x00, 0x00, 0x78, 0xC0, 0x00, 0x0F, 0x0C, 0x00, 0x01, 0xE0,
  0xC0, 0x00, 0x3C, 0x0C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x70, 0x0C, 0x00,
  0x0E, 0x00, 0xC0, 0x01, 0xC0, 0x0C, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00,
  0x0C, 0x00, 0xE0, 0x00, 0xC0, 0x1C, 0x00, 0x0C, 0x03, 0x80, 0x00, 0xC0,
  0x70, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x0C, 0x3E, 0x00,
  0x00, 0xC7, 0x70, 0x00, 0x0C, 0xE3, 0x80, 0x00, 0xDC, 0x38, 0x00, 0x0F,
  0x81, 0xC0, 0x00, 0xF0, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xC0, 0x07,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0xC0, 0x01, 0xC0, 0x0C, 0x00, 0x1C, 0x00,
  0xC0, 0x00, 0xE0, 0x0C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x38, 0x0C, 0x00,
  0x03, 0x80, 0xC0, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x1C, 0xC0,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0xC0, 0x00, 0x00, 0x01, 0xBD, 0x80, 0x00,
  0x00, 0x03, 0x7B, 0x80, 0x00, 0x00, 0x0E, 0xF3, 0x00, 0x00, 0x00, 0x19,
  0xE7, 0x00, 0x00, 0x00, 0x73, 0xC6, 0x00, 0x00, 0x00, 0xC7, 0x8C, 0x00,
  0x00, 0x01, 0x8F, 0x1C, 0x00, 0x00, 0x07, 0x1E, 0x18, 0x00, 0x00, 0x0C,
  0x3C, 0x38, 0x00, 0x00, 0x38, 0x78, 0x30, 0x00, 0x00, 0x60, 0xF0, 0x70,
  0x00, 0x00, 0xC1, 0xE0, 0xE0, 0x00, 0x03, 0x83, 0xC0, 0xC0, 0x00, 0x06,
  0x07, 0x81, 0xC0, 0x00, 0x1C, 0x0F, 0x01, 0x80, 0x00, 0x30, 0x1E, 0x03,
  0x80, 0x00, 0x60, 0x3C, 0x07, 0x00, 0x01, 0xC0, 0x78, 0x06, 0x00, 0x03,
  0x00, 0xF0, 0x0E, 0x00, 0x0E, 0x01, 0xE0, 0x0C, 0x00, 0x18, 0x03, 0xC0,
  0x1C, 0x00, 0x30, 0x07, 0x80, 0x38, 0x00, 0xE0, 0x0F, 0x00, 0x30, 0x01,
  0x80, 0x1E, 0x00, 0x70, 0x07, 0x00, 0x3C, 0x00, 0x60, 0x0C, 0x00, 0x78,
  0x00, 0xE0, 0x18, 0x00, 0xF0, 0x00, 0xC0, 0x60, 0x01, 0xE0, 0x01, 0x80,
  0xC0, 0x03, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x80, 0x03, 0x06, 0x00, 0x0F,
  0x00, 0x07, 0x1C, 0x00, 0x1E, 0x00, 0x06, 0x30, 0x00, 0x3C, 0x00, 0x0C,
  0x60, 0x00, 0x78, 0x00, 0x1D, 0xC0, 0x00, 0xF0, 0x00, 0x1B, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x03, 0xC7, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x3C, 0x38, 0x00,
  0x00, 0xF0, 0x70, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00,
  0x3C, 0x07, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x0F,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0xF0, 0x03, 0x80, 0x03, 0xC0,
  0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0xF0, 0x00,
  0x70, 0x03, 0xC0, 0x00, 0xE0, 0x0F, 0x00, 0x01, 0x80, 0x3C, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x18, 0x0F, 0x00, 0x00, 0x70,
  0x3C, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x01, 0x83, 0xC0, 0x00, 0x07, 0x0F,
  0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x18, 0xF0, 0x00, 0x00, 0x73, 0xC0,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x01, 0xBC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x38, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x30, 0x01, 0xFE, 0x18, 0x00, 0x07,
  0x8C, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xB0, 0x00, 0x01, 0xD8,
  0x00, 0x00, 0xCC, 0x00, 0x01, 0xE6, 0x00, 0x01, 0xE3, 0x00, 0x0F, 0xC1,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x00, 0x1B,
  0x80, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0xC0, 0x07, 0xF8, 0x0C, 0x00, 0x03, 0xE0, 0xC0, 0x00,
  0x0E, 0x0C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x38,
  0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x07, 0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x3C, 0x0C, 0x00, 0x0F,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0xC0, 0x03, 0x80, 0x0C,
  0x00, 0x38, 0x00, 0xC0, 0x01, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0xE0, 0x0C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x18, 0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x0E, 0x0C, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03,
  0x8C, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x0E, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x3E, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x41, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE4, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x3E, 0x1F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x33, 0x80,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x01, 0x87, 0x00, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1A, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0x19, 0xC0,
  0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x00, 0xC3,
  0x80, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x06,
  0x07, 0x00, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00,
  0x70, 0x06, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x06, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x0C, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x30, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x06, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x07, 0x00, 0x00, 0x70, 0x01, 0x80, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x18, 0x07,
  0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x30,
  0x38, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x36, 0x00, 0x00, 0x33, 0x80, 0x00, 0x1B, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x1C, 0x60, 0x00, 0x0C, 0xE0,
  0x00, 0x0C, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x1C, 0x00, 0x03, 0x18,
  0x00, 0x07, 0x06, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x01, 0x87,
  0x00, 0x01, 0x81, 0x80, 0x00, 0xC1, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0xE0,
  0xC0, 0x00, 0xE0, 0x30, 0x00, 0x60, 0x70, 0x00, 0x60, 0x18, 0x00, 0x30,
  0x18, 0x00, 0x30, 0x0E, 0x00, 0x18, 0x0C, 0x00, 0x38, 0x07, 0x00, 0x1C,
  0x06, 0x00, 0x1C, 0x01, 0x80, 0x0C, 0x03, 0x80, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x60, 0x07, 0x00, 0x18, 0x03,
  0x00, 0x38, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x06, 0x00,
  0xC0, 0x06, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x03, 0x00, 0xE0, 0x00, 0xC0,
  0x60, 0x01, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x60, 0x30, 0x00, 0x38,
  0x18, 0x00, 0x30, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x18, 0x00, 0x06,
  0x0C, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x03, 0x0E, 0x00, 0x01,
  0xC7, 0x00, 0x01, 0x87, 0x00, 0x00, 0x63, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x31, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x19, 0xC0, 0x00,
  0x0E, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x07, 0x60, 0x00,
  0x01, 0xB0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x06,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x38, 0x18,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0E, 0x60,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x06, 0xE0,
  0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x18, 0x38,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x60, 0x0E,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x01, 0x80, 0x07, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00,
  0x19, 0xC0, 0x00, 0x00, 0x71, 0x80, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x06, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70,
  0x06, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x70, 0x07, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x01, 0x9C, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x60, 0x70, 0x00, 0x07, 0x01, 0x80, 0x00, 0x30, 0x0E, 0x00, 0x03, 0x80,
  0x30, 0x00, 0x18, 0x01, 0xC0, 0x01, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0xC0, 0x06, 0x00, 0x07, 0x00, 0x70, 0x00, 0x18, 0x03,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x01, 0x80, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x76, 0x00, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x7C, 0x01, 0xE0, 0xC0, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0x0F,
  0xE0, 0x06, 0x3C, 0x00, 0x0C, 0xE0, 0x00, 0x1B, 0x80, 0x00, 0x36, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xB7, 0x00, 0x06,
  0x67, 0x00, 0x38, 0xC7, 0xE7, 0xE1, 0x87, 0xFF, 0x03, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x1F, 0xF8, 0x07, 0x0F, 0xFF, 0xC0, 0xE3, 0x80, 0x3C, 0x1C, 0xC0, 0x01,
  0xC3, 0xB0, 0x00, 0x1C, 0x7C, 0x00, 0x01, 0xCD, 0x80, 0x00, 0x19, 0xE0,
  0x00, 0x03, 0xBC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00,
  0xDC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x67,
  0x80, 0x00, 0x1C, 0xD8, 0x00, 0x03, 0x9B, 0x80, 0x00, 0xE3, 0x38, 0x00,
  0x38, 0x63, 0x80, 0x1E, 0x0C, 0x3F, 0xFF, 0x81, 0x81, 0xFF, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0x01, 0xE0, 0x06,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x02, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x1F, 0xF8, 0x18, 0x0F, 0xFF, 0xC3,
  0x03, 0xC0, 0x1C, 0x61, 0xE0, 0x01, 0xCC, 0x38, 0x00, 0x0D, 0x8E, 0x00,
  0x01, 0xB3, 0x80, 0x00, 0x1E, 0x70, 0x00, 0x03, 0xCC, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x0F, 0x18, 0x00, 0x03,
  0x63, 0x80, 0x00, 0x6C, 0x38, 0x00, 0x19, 0x83, 0xC0, 0x0E, 0x30, 0x3F,
  0xFF, 0x86, 0x01, 0xFF, 0xC0, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x3C, 0x03, 0xC0, 0x1C, 0x00, 0x38, 0x0E, 0x00,
  0x07, 0x07, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x06, 0x30,
  0x00, 0x01, 0x9C, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x03,
  0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x37, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x81, 0xF0, 0x00, 0xE0, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0x40, 0x00, 0x00, 0x1F, 0xC0,
  0x07, 0xFF, 0x00, 0xF8, 0x30, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xFE, 0x0F, 0xFF,
  0xE0, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xE0, 0x60, 0x3F, 0xFF, 0x0C, 0x1F,
  0x00, 0x71, 0x87, 0x80, 0x03, 0x30, 0xE0, 0x00, 0x36, 0x38, 0x00, 0x03,
  0xCE, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x07, 0x30, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x3C, 0x60, 0x00, 0x0D, 0x8E,
  0x00, 0x01, 0xB0, 0xE0, 0x00, 0x66, 0x0F, 0x00, 0x38, 0xC0, 0xFF, 0xFE,
  0x18, 0x07, 0xFF, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x1C, 0x1F, 0x00, 0x0F, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x81, 0xFF, 0x81, 0xC3, 0xFF, 0xF0, 0xE7, 0x80, 0x3C, 0x77, 0x00, 0x07,
  0x3B, 0x00, 0x01, 0xDF, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x37, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0C, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80,
  0xE7, 0xFC, 0xFE, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x07, 0x70,
  0x00, 0x1C, 0xE0, 0x00, 0x71, 0xC0, 0x01, 0xC3, 0x80, 0x07, 0x07, 0x00,
  0x0C, 0x0E, 0x00, 0x30, 0x1C, 0x00, 0xE0, 0x38, 0x03, 0x80, 0x70, 0x0E,
  0x00, 0xE0, 0x38, 0x01, 0xC0, 0xE0, 0x03, 0x83, 0x80, 0x07, 0x0E, 0x00,
  0x0E, 0x3C, 0x00, 0x1C, 0xFC, 0x00, 0x39, 0x9C, 0x00, 0x76, 0x18, 0x00,
  0xF8, 0x38, 0x01, 0xE0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x30, 0x0E,
  0x00, 0x70, 0x1C, 0x00, 0x70, 0x38, 0x00, 0x70, 0x70, 0x00, 0x60, 0xE0,
  0x00, 0xE1, 0xC0, 0x00, 0xE3, 0x80, 0x00, 0xE7, 0x00, 0x00, 0xCE, 0x00,
  0x01, 0xDC, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0,
  0xFF, 0x80, 0x1F, 0xF8, 0x30, 0xFF, 0xF8, 0x0F, 0xFF, 0x8C, 0x70, 0x0F,
  0x0F, 0x00, 0xF3, 0x38, 0x00, 0xE7, 0x00, 0x1E, 0xD8, 0x00, 0x39, 0x80,
  0x03, 0xBE, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x30,
  0x00, 0x03, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x30, 0x00, 0x03, 0xE0,
  0x00, 0x0C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x30, 0x00, 0x03, 0xE0, 0x00, 0x0C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x30, 0x00, 0x03, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x30,
  0x00, 0x03, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x30, 0x00, 0x03, 0xC0,
  0x7F, 0xE0, 0x60, 0xFF, 0xFC, 0x30, 0xE0, 0x0F, 0x18, 0xC0, 0x01, 0xCC,
  0xC0, 0x00, 0x77, 0xC0, 0x00, 0x3B, 0xC0, 0x00, 0x0D, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xC0,
  0x1E, 0x00, 0x70, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C,
  0x18, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x67, 0x00,
  0x00, 0x06, 0x70, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x73,
  0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0C, 0x1C, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x38, 0x0F, 0x00, 0x07, 0x00, 0x78, 0x01, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x7F, 0xE0, 0x18, 0x3F, 0xFF, 0x03, 0x0E, 0x00, 0xF0, 0x63, 0x80, 0x07,
  0x0C, 0xC0, 0x00, 0x71, 0xF8, 0x00, 0x07, 0x3E, 0x00, 0x00, 0x67, 0x80,
  0x00, 0x0E, 0xF0, 0x00, 0x00, 0xDE, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xB8, 0x00, 0x00, 0x37, 0x80, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xDF,
  0x00, 0x00, 0x73, 0xE0, 0x00, 0x0E, 0x76, 0x00, 0x03, 0x8E, 0xE0, 0x00,
  0xE1, 0xCF, 0x00, 0x78, 0x38, 0xFF, 0xFE, 0x07, 0x07, 0xFF, 0x00, 0xE0,
  0x0D, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x60, 0x3F, 0xFF, 0x0C, 0x1F, 0x00, 0x71, 0x87, 0x80, 0x07,
  0x30, 0xE0, 0x00, 0x76, 0x38, 0x00, 0x06, 0xCE, 0x00, 0x00, 0x79, 0x80,
  0x00, 0x0F, 0x30, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x03,
  0xB0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0E, 0xC0, 0x00,
  0x01, 0xD8, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x30, 0x00, 0x01, 0xE7,
  0x00, 0x00, 0x3C, 0xE0, 0x00, 0x0D, 0x8E, 0x00, 0x03, 0xB0, 0xE0, 0x00,
  0xE6, 0x0E, 0x00, 0x38, 0xC0, 0xFE, 0xFE, 0x18, 0x0F, 0xFF, 0x03, 0x00,
  0x1F, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0xC0,
  0xFF, 0xE1, 0xFF, 0xF9, 0xE0, 0x1D, 0xC0, 0x0E, 0xC0, 0x07, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE3, 0xC0, 0x07, 0x9C, 0x00, 0x02, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x80, 0x00, 0x3B, 0x80, 0x03, 0xCF, 0xF9, 0xFE, 0x0F, 0xFF, 0xE0, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC3,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F,
  0xFE, 0x01, 0xFF, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xD8, 0x00, 0x03, 0xEE, 0x00, 0x03, 0x73, 0x80, 0x03,
  0xB9, 0xE0, 0x07, 0x9C, 0x3F, 0xFF, 0x06, 0x0F, 0xFF, 0x03, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x19, 0x80, 0x00, 0x07,
  0x38, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x18, 0x60, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x18, 0x1C, 0x00, 0x07, 0x01, 0x80, 0x00, 0xC0,
  0x30, 0x00, 0x38, 0x07, 0x00, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x0E, 0x00,
  0x38, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x01, 0xC0, 0x03, 0x80, 0x38, 0x00,
  0x30, 0x06, 0x00, 0x06, 0x01, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x0C, 0x06,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x03, 0x0E, 0x00, 0x00,
  0x71, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x1D, 0x80,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x60, 0x00, 0x3E, 0x00, 0x07, 0x70, 0x00,
  0x36, 0x00, 0x06, 0x70, 0x00, 0x36, 0x00, 0x06, 0x30, 0x00, 0x77, 0x00,
  0x0E, 0x30, 0x00, 0x63, 0x00, 0x0E, 0x38, 0x00, 0x63, 0x00, 0x0C, 0x18,
  0x00, 0xE3, 0x80, 0x0C, 0x18, 0x00, 0xC1, 0x80, 0x1C, 0x1C, 0x00, 0xC1,
  0x80, 0x18, 0x1C, 0x01, 0xC1, 0xC0, 0x18, 0x0C, 0x01, 0x80, 0xC0, 0x18,
  0x0C, 0x01, 0x80, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x06, 0x03,
  0x00, 0x60, 0x30, 0x06, 0x03, 0x00, 0x60, 0x70, 0x06, 0x07, 0x00, 0x70,
  0x70, 0x07, 0x06, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30, 0x60, 0x03,
  0x0E, 0x00, 0x30, 0xE0, 0x03, 0x8C, 0x00, 0x38, 0xC0, 0x01, 0x8C, 0x00,
  0x18, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x98, 0x00, 0x1D, 0xC0,
  0x01, 0xD8, 0x00, 0x0D, 0x80, 0x00, 0xD8, 0x00, 0x0D, 0x80, 0x00, 0xF0,
  0x00, 0x0D, 0x80, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x70, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x70, 0x60, 0x00, 0x0C, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x0C,
  0x00, 0x18, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x70,
  0x00, 0x18, 0x0C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x37, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x06, 0x0C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x1C, 0x00,
  0x1C, 0x01, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00,
  0x38, 0x06, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x77, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x07, 0x38, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x1C, 0x00, 0x07,
  0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x38, 0x07, 0x00, 0x06, 0x00, 0x60,
  0x00, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0,
  0x03, 0x80, 0x38, 0x00, 0x30, 0x06, 0x00, 0x06, 0x01, 0xC0, 0x00, 0xE0,
  0x30, 0x00, 0x0C, 0x06, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x18, 0x30, 0x00,
  0x03, 0x0E, 0x00, 0x00, 0x71, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0xCE,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x1F, 0xC0, 0x1F, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x7E, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x1F, 0xE0, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x07, 0xC0,
  0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x3F, 0x80,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x13, 0xFF, 0xC0, 0x01, 0x70, 0x1F,
  0x00, 0x7C, 0x00, 0x7E, 0x1E, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xE0,
};

const GFXglyph NotoSans_ExtraLight60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 4, 44, 14, 5, -43 },
  { 23, 12, 16, 20, 4, -43 },
  { 47, 35, 43, 39, 2, -43 },
  { 236, 25, 49, 34, 4, -46 },
  { 390, 42, 44, 48, 3, -43 },
  { 621, 37, 45, 42, 4, -44 },
  { 830, 3, 16, 11, 4, -43 },
  { 836, 11, 52, 16, 3, -43 },
  { 908, 11, 52, 16, 2, -43 },
  { 980, 26, 24, 33, 3, -45 },
  { 1058, 28, 28, 34, 3, -35 },
  { 1156, 6, 15, 12, 2, -7 },
  { 1168, 15, 2, 19, 2, -17 },
  { 1172, 4, 5, 14, 5, -4 },
  { 1175, 18, 43, 20, 1, -43 },
  { 1272, 27, 45, 34, 4, -44 },
  { 1424, 14, 43, 34, 6, -43 },
  { 1500, 27, 43, 34, 3, -43 },
  { 1646, 27, 44, 34, 3, -43 },
  { 1795, 32, 43, 34, 1, -43 },
  { 1967, 26, 44, 34, 4, -43 },
  { 2110, 27, 45, 34, 4, -44 },
  { 2262, 28, 43, 34, 3, -43 },
  { 2413, 26, 44, 34, 4, -43 },
  { 2556, 27, 44, 34, 3, -43 },
  { 2705, 4, 33, 14, 5, -32 },
  { 2722, 7, 40, 14, 2, -32 },
  { 2757, 28, 27, 34, 3, -35 },
  { 2852, 28, 14, 34, 3, -28 },
  { 2901, 28, 27, 34, 3, -35 },
  { 2996, 21, 44, 25, 2, -43 },
  { 3112, 47, 48, 53, 3, -42 },
  { 3394, 35, 43, 35, 0, -43 },
  { 3583, 28, 43, 37, 6, -43 },
  { 3734, 31, 44, 37, 4, -43 },
  { 3905, 32, 43, 42, 6, -43 },
  { 4077, 23, 43, 33, 6, -43 },
  { 4201, 23, 43, 30, 6, -43 },
  { 4325, 35, 45, 43, 4, -44 },
  { 4522, 31, 43, 43, 6, -43 },
  { 4689, 11, 43, 18, 3, -43 },
  { 4749, 15, 54, 14, -6, -43 },
  { 4851, 28, 43, 34, 6, -43 },
  { 5002, 23, 43, 31, 6, -43 },
  { 5126, 39, 43, 51, 6, -43 },
  { 5336, 30, 43, 43, 6, -43 },
  { 5498, 38, 45, 46, 4, -44 },
  { 5712, 25, 43, 35, 6, -43 },
  { 5847, 38, 54, 46, 4, -44 },
  { 6104, 28, 43, 35, 6, -43 },
  { 6255, 27, 44, 33, 3, -43 },
  { 6404, 31, 43, 31, 0, -43 },
  { 6571, 31, 44, 43, 6, -43 },
  { 6742, 34, 43, 34, 0, -43 },
  { 6925, 49, 43, 53, 2, -43 },
  { 7189, 32, 43, 32, 0, -43 },
  { 7361, 31, 43, 31, 0, -43 },
  { 7528, 30, 43, 35, 2, -43 },
  { 7690, 12, 52, 19, 5, -43 },
  { 7768, 18, 43, 20, 1, -43 },
  { 7865, 13, 52, 19, 1, -43 },
  { 7950, 29, 26, 34, 3, -43 },
  { 8045, 24, 2, 24, 0, 5 },
  { 8051, 11, 10, 15, 2, -46 },
  { 8065, 23, 33, 31, 3, -32 },
  { 8160, 27, 47, 35, 5, -46 },
  { 8319, 24, 33, 28, 3, -32 },
  { 8418, 27, 47, 35, 3, -46 },
  { 8577, 26, 33, 33, 3, -32 },
  { 8685, 20, 46, 17, 1, -46 },
  { 8800, 27, 46, 35, 3, -32 },
  { 8956, 25, 46, 35, 5, -46 },
  { 9100, 3, 43, 13, 5, -43 },
  { 9117, 11, 57, 13, -3, -43 },
  { 9196, 23, 46, 28, 5, -46 },
  { 9329, 3, 46, 13, 5, -46 },
  { 9347, 42, 32, 52, 5, -32 },
  { 9515, 25, 32, 35, 5, -32 },
  { 9615, 28, 33, 35, 3, -32 },
  { 9731, 27, 46, 35, 5, -32 },
  { 9887, 27, 46, 35, 3, -32 },
  { 10043, 17, 32, 23, 5, -32 },
  { 10111, 22, 33, 28, 3, -32 },
  { 10202, 17, 41, 20, 1, -40 },
  { 10290, 25, 33, 35, 5, -32 },
  { 10394, 27, 32, 27, 0, -32 },
  { 10502, 40, 32, 42, 1, -32 },
  { 10662, 27, 32, 29, 1, -32 },
  { 10770, 27, 47, 27, 0, -32 },
  { 10929, 23, 32, 28, 2, -32 },
  { 11021, 17, 52, 21, 2, -43 },
  { 11132, 2, 61, 32, 15, -46 },
  { 11148, 17, 52, 21, 2, -43 },
  { 11259, 28, 6, 34, 3, -24 },
};

const GFXfont NotoSans_ExtraLight60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight60pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_EXTRALIGHT60PT7B_H_
