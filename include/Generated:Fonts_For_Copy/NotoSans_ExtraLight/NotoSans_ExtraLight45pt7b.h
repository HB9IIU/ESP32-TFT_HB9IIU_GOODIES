#ifndef _NOTOSANS_EXTRALIGHT45PT7B_H_
#define _NOTOSANS_EXTRALIGHT45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight45pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x24, 0x92, 0x00, 0x01,
  0xBF, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xD0, 0x60, 0x00, 0x10, 0x04, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x30,
  0x00, 0x18, 0x06, 0x00, 0x02, 0x00, 0x80, 0x00, 0x40, 0x10, 0x00, 0x08,
  0x02, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x02, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x20, 0x08, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x30, 0x0C, 0x00, 0x04, 0x01, 0x00, 0x00, 0x80, 0x20, 0x00,
  0x30, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x0F, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x40, 0x10, 0x00, 0x08, 0x02, 0x00, 0x01, 0x00, 0xC0,
  0x00, 0x60, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x40, 0x00, 0x20,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x07, 0xFF, 0x01,
  0xCC, 0xF8, 0xE1, 0x81, 0x18, 0x30, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x18,
  0x18, 0x03, 0x03, 0x00, 0x60, 0x60, 0x0C, 0x0C, 0x00, 0xC1, 0x80, 0x1C,
  0x30, 0x01, 0xE6, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x6F, 0x00, 0x0C, 0x38, 0x01, 0x83, 0x00, 0x30, 0x30, 0x06, 0x06, 0x00,
  0xC0, 0x60, 0x18, 0x0C, 0x03, 0x01, 0x00, 0x60, 0x60, 0x0C, 0x0C, 0x01,
  0x83, 0x20, 0x30, 0xE7, 0xF7, 0xF0, 0x3F, 0xF8, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x06, 0x03, 0x0C, 0x00, 0x30, 0x18, 0x18, 0x00, 0x80, 0xC0, 0x20, 0x06,
  0x03, 0x00, 0xC0, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x0C, 0x06, 0x00,
  0x80, 0x30, 0x18, 0x02, 0x00, 0xC0, 0xC0, 0x08, 0x03, 0x02, 0x00, 0x20,
  0x0C, 0x18, 0x00, 0x80, 0x30, 0x40, 0x02, 0x00, 0xC3, 0x07, 0x0C, 0x03,
  0x08, 0x7F, 0x30, 0x0C, 0x63, 0x06, 0xC0, 0x63, 0x18, 0x19, 0x81, 0x8C,
  0x40, 0x37, 0x0C, 0x63, 0x00, 0xCF, 0xE1, 0x0C, 0x03, 0x04, 0x0C, 0x30,
  0x04, 0x00, 0x20, 0xC0, 0x10, 0x01, 0x83, 0x00, 0x40, 0x04, 0x0C, 0x01,
  0x00, 0x30, 0x30, 0x04, 0x01, 0x80, 0xC0, 0x10, 0x06, 0x03, 0x00, 0x40,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x00, 0x60, 0x30, 0x10,
  0x01, 0x81, 0x80, 0xC0, 0x03, 0x0C, 0x06, 0x00, 0x07, 0xE0, 0x00, 0x70,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x08, 0x00, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x80,
  0x0C, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x08, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0xE0, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0x38, 0x18, 0x00, 0x63, 0x00, 0xC0, 0x0C, 0x60, 0x06, 0x00, 0xCC,
  0x00, 0x30, 0x08, 0xC0, 0x01, 0x81, 0x8C, 0x00, 0x0C, 0x18, 0xC0, 0x00,
  0x63, 0x0C, 0x00, 0x03, 0x60, 0xC0, 0x00, 0x1E, 0x0C, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x1E, 0x06, 0x00, 0x07, 0x30, 0x30, 0x00, 0xE1, 0x81, 0xE0,
  0x78, 0x0C, 0x07, 0xFE, 0x00, 0x70, 0xFF, 0xFF, 0xF4, 0x03, 0x06, 0x0C,
  0x0C, 0x18, 0x18, 0x30, 0x30, 0x20, 0x60, 0x60, 0x60, 0x40, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x40,
  0x60, 0x60, 0x60, 0x20, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x04, 0x06, 0x03,
  0xC0, 0x60, 0x60, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x0C, 0x06, 0x06, 0x06,
  0x02, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x02, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x30,
  0x20, 0x60, 0xC0, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x20, 0x10, 0x1F, 0x82, 0x1F, 0x3E, 0x5F,
  0x00, 0x7E, 0x00, 0x03, 0x80, 0x00, 0xD0, 0x00, 0x33, 0x00, 0x06, 0x30,
  0x01, 0x83, 0x00, 0x60, 0x60, 0x1C, 0x06, 0x03, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x33, 0x33, 0x66, 0x64, 0xCC, 0x80,
  0xFF, 0xFF, 0xFC, 0xDF, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03,
  0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x00,
  0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x08,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x00, 0xF0, 0x00,
  0x7F, 0xE0, 0x0E, 0x07, 0x01, 0x80, 0x18, 0x30, 0x00, 0x83, 0x00, 0x0C,
  0x60, 0x00, 0x46, 0x00, 0x06, 0x40, 0x00, 0x6C, 0x00, 0x02, 0xC0, 0x00,
  0x2C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x02, 0xC0, 0x00, 0x64,
  0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x04, 0x30, 0x00, 0xC3, 0x00, 0x18,
  0x18, 0x03, 0x80, 0xF0, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0xE0, 0x3C, 0x0D,
  0x87, 0x31, 0xC6, 0x60, 0xF8, 0x1A, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x01, 0xFF, 0x80, 0xF0, 0x38, 0x70,
  0x01, 0x84, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x70, 0x00, 0xFF, 0xE0, 0x3E, 0x07, 0x8F, 0x00, 0x1C, 0x40, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x07, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0xC0, 0x01, 0xCF, 0x80, 0x78, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x06,
  0x40, 0x00, 0x0C, 0x40, 0x00, 0x08, 0x40, 0x00, 0x18, 0x40, 0x00, 0x30,
  0x40, 0x00, 0x60, 0x40, 0x00, 0x60, 0x40, 0x00, 0xC0, 0x40, 0x01, 0x80,
  0x40, 0x03, 0x00, 0x40, 0x03, 0x00, 0x40, 0x06, 0x00, 0x40, 0x0C, 0x00,
  0x40, 0x08, 0x00, 0x40, 0x18, 0x00, 0x40, 0x30, 0x00, 0x40, 0x60, 0x00,
  0x40, 0x60, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x1F, 0xFF,
  0xC3, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0xFF, 0xC0, 0x7C, 0x1F, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xCC, 0x00,
  0x38, 0xF8, 0x0F, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x0F, 0xFC, 0x03,
  0xC0, 0x40, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x0F, 0xC0, 0xC7, 0xFF, 0x0C, 0xE0, 0x18, 0xD8, 0x00,
  0xCF, 0x00, 0x06, 0xE0, 0x00, 0x2C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x40, 0x00, 0x36, 0x00, 0x03, 0x60,
  0x00, 0x36, 0x00, 0x02, 0x30, 0x00, 0x61, 0x80, 0x0C, 0x1C, 0x01, 0xC0,
  0xF0, 0x78, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xE0, 0x1C, 0x07,
  0x03, 0x80, 0x18, 0x30, 0x00, 0xC6, 0x00, 0x04, 0x60, 0x00, 0x66, 0x00,
  0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0xC3, 0x00, 0x0C, 0x38,
  0x01, 0x81, 0xC0, 0x70, 0x07, 0x1C, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00,
  0xF0, 0xE0, 0x1C, 0x03, 0x83, 0x00, 0x1C, 0x60, 0x00, 0xEC, 0x00, 0x06,
  0xC0, 0x00, 0x2C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x02, 0xC0, 0x00, 0x66, 0x00, 0x0C, 0x30, 0x01, 0xC1, 0xE0,
  0x70, 0x07, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x3F, 0xF0, 0x03, 0x81, 0xC0,
  0x30, 0x03, 0x03, 0x00, 0x0C, 0x10, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00,
  0x06, 0x40, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x05, 0x80, 0x00, 0x34,
  0x00, 0x01, 0xA0, 0x00, 0x0D, 0x80, 0x00, 0xEC, 0x00, 0x07, 0x30, 0x00,
  0x59, 0xC0, 0x06, 0xC7, 0x00, 0xE6, 0x0F, 0xFC, 0x20, 0x0F, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x04, 0x07, 0x80, 0x3F, 0xF0, 0x00, 0x18, 0x00, 0x00, 0xDF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xBF, 0x31, 0xCE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x63, 0x19, 0x8C, 0x63, 0x11,
  0x8C, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x80, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x00, 0x3F,
  0xF8, 0xF0, 0x1C, 0x40, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x01, 0xE0, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x0E, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x1F, 0xC0, 0x18, 0xC0,
  0x0F, 0xFE, 0x01, 0x90, 0x03, 0x00, 0xC0, 0x36, 0x00, 0xC0, 0x18, 0x06,
  0xC0, 0x30, 0x03, 0x00, 0xD0, 0x04, 0x00, 0x60, 0x0A, 0x01, 0x80, 0x0C,
  0x01, 0xC0, 0x30, 0x01, 0x80, 0x38, 0x04, 0x00, 0x30, 0x07, 0x00, 0x80,
  0x06, 0x00, 0xE0, 0x10, 0x00, 0xC0, 0x3C, 0x02, 0x00, 0x18, 0x07, 0x80,
  0x40, 0x07, 0x00, 0xD0, 0x0C, 0x00, 0xE0, 0x12, 0x01, 0x80, 0x34, 0x06,
  0x60, 0x18, 0x0C, 0xC1, 0x8C, 0x01, 0xE7, 0x1C, 0xE0, 0x80, 0x1F, 0xC1,
  0xF8, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x08, 0x00, 0x03, 0xE0, 0x3F, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x28, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x62,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x0C, 0x18, 0x00, 0x03, 0x01, 0x00, 0x00, 0x60, 0x30, 0x00, 0x08, 0x06,
  0x00, 0x03, 0x00, 0x40, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x03,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0xFF, 0xFE,
  0x00, 0x40, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x30, 0x18, 0x00, 0x03, 0x02, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x04,
  0x18, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x90, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x08, 0x0F, 0xF0, 0x80, 0x01,
  0xC8, 0x00, 0x0E, 0x80, 0x00, 0x68, 0x00, 0x06, 0x80, 0x00, 0x28, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x02, 0x80, 0x00, 0x68, 0x00, 0x06, 0x80,
  0x00, 0xC8, 0x00, 0x38, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x80, 0x03, 0x88,
  0x00, 0x0E, 0x80, 0x00, 0x68, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x06, 0x80, 0x00, 0xE8, 0x00, 0x1C, 0xFF, 0xFF, 0x0F, 0xFF,
  0x80, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0x80, 0x78, 0x1C, 0x00,
  0x10, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x7F, 0xF8,
  0xFF, 0xF8, 0x00, 0x81, 0xFF, 0x00, 0x80, 0x03, 0xC0, 0x80, 0x00, 0xE0,
  0x80, 0x00, 0x30, 0x80, 0x00, 0x18, 0x80, 0x00, 0x1C, 0x80, 0x00, 0x0C,
  0x80, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06,
  0x80, 0x00, 0x02, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x02, 0x80, 0x00, 0x06,
  0x80, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x0C,
  0x80, 0x00, 0x0C, 0x80, 0x00, 0x18, 0x80, 0x00, 0x38, 0x80, 0x00, 0x70,
  0x80, 0x00, 0xE0, 0x80, 0x07, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0xFF, 0xFD, 0xFF, 0xFE, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x1F,
  0x00, 0x7C, 0x0E, 0x00, 0x02, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x60, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x1C,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0x30, 0x78, 0x00, 0x0C, 0x07, 0xC0, 0x3F,
  0x00, 0x7F, 0xFE, 0x00, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x0C, 0x03, 0x01, 0x80, 0xEF, 0xF3, 0xF0, 0x80, 0x00,
  0x74, 0x00, 0x07, 0x20, 0x00, 0x71, 0x00, 0x07, 0x08, 0x00, 0x70, 0x40,
  0x03, 0x02, 0x00, 0x30, 0x10, 0x03, 0x00, 0x80, 0x30, 0x04, 0x03, 0x00,
  0x20, 0x30, 0x01, 0x03, 0x00, 0x08, 0x30, 0x00, 0x43, 0x00, 0x02, 0x3C,
  0x00, 0x13, 0x70, 0x00, 0xB1, 0x80, 0x07, 0x06, 0x00, 0x30, 0x18, 0x01,
  0x00, 0xE0, 0x08, 0x03, 0x00, 0x40, 0x0C, 0x02, 0x00, 0x30, 0x10, 0x01,
  0x80, 0x80, 0x06, 0x04, 0x00, 0x18, 0x20, 0x00, 0xE1, 0x00, 0x03, 0x08,
  0x00, 0x0C, 0x40, 0x00, 0x32, 0x00, 0x01, 0xD0, 0x00, 0x07, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xE8, 0x00, 0x00, 0x1F, 0x60, 0x00, 0x00, 0xBB, 0x00, 0x00, 0x0D,
  0xCC, 0x00, 0x00, 0x6E, 0x60, 0x00, 0x06, 0x71, 0x00, 0x00, 0x33, 0x8C,
  0x00, 0x01, 0x1C, 0x60, 0x00, 0x18, 0xE1, 0x80, 0x00, 0xC7, 0x0C, 0x00,
  0x0C, 0x38, 0x20, 0x00, 0x61, 0xC1, 0x80, 0x02, 0x0E, 0x0C, 0x00, 0x30,
  0x70, 0x30, 0x01, 0x83, 0x81, 0x80, 0x18, 0x1C, 0x04, 0x00, 0xC0, 0xE0,
  0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x06, 0x02, 0x01, 0xC0, 0x30,
  0x30, 0x0E, 0x00, 0x81, 0x80, 0x70, 0x06, 0x18, 0x03, 0x80, 0x30, 0xC0,
  0x1C, 0x00, 0xC4, 0x00, 0xE0, 0x06, 0x60, 0x07, 0x00, 0x13, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xC0, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x6C, 0x00,
  0x01, 0xB0, 0x00, 0x06, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x01,
  0x86, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0x60, 0x01, 0x80,
  0xC0, 0x06, 0x03, 0x00, 0x18, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x60, 0x03, 0x01, 0x80, 0x06, 0x06,
  0x00, 0x0C, 0x18, 0x00, 0x38, 0x60, 0x00, 0x61, 0x80, 0x00, 0xC6, 0x00,
  0x03, 0x98, 0x00, 0x06, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x0E, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x0C, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x80,
  0xE0, 0x00, 0x30, 0x07, 0x00, 0x0E, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x10, 0x3F, 0xC2, 0x00, 0x1C, 0x40, 0x00, 0xC8,
  0x00, 0x0D, 0x00, 0x01, 0xA0, 0x00, 0x34, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0x40, 0x00, 0x68, 0x00, 0x0D, 0x00, 0x01, 0xA0,
  0x00, 0x64, 0x00, 0x18, 0x80, 0x1E, 0x1F, 0xFF, 0x03, 0xF8, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0E, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x0C, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x80,
  0xE0, 0x00, 0x30, 0x07, 0x00, 0x0E, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0xFF, 0xF8, 0x08, 0x1F, 0xE0, 0x80,
  0x07, 0x88, 0x00, 0x18, 0x80, 0x00, 0xC8, 0x00, 0x0C, 0x80, 0x00, 0x48,
  0x00, 0x06, 0x80, 0x00, 0x68, 0x00, 0x06, 0x80, 0x00, 0x48, 0x00, 0x0C,
  0x80, 0x00, 0xC8, 0x00, 0x18, 0x80, 0x03, 0x08, 0x00, 0xE0, 0xFF, 0xFC,
  0x0F, 0xFF, 0x00, 0x80, 0x30, 0x08, 0x01, 0x80, 0x80, 0x18, 0x08, 0x00,
  0xC0, 0x80, 0x0E, 0x08, 0x00, 0x60, 0x80, 0x03, 0x08, 0x00, 0x30, 0x80,
  0x01, 0x88, 0x00, 0x1C, 0x80, 0x00, 0xC8, 0x00, 0x06, 0x80, 0x00, 0x68,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x3F, 0xFC, 0x0F, 0x01, 0xE1, 0x80, 0x02,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x80, 0x01, 0xCF, 0xC0, 0xF8, 0x3F, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x03,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x1C,
  0x1C, 0x00, 0x38, 0x07, 0x81, 0xE0, 0x03, 0xFF, 0x80, 0xC0, 0x00, 0x00,
  0xD0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0x30, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x60, 0x60, 0x00, 0x18, 0x18,
  0x00, 0x04, 0x02, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x60,
  0x06, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00,
  0xC0, 0x03, 0x00, 0x20, 0x00, 0x40, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06,
  0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x18, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x08, 0xC0, 0x00, 0x03, 0x30,
  0x00, 0x00, 0xC8, 0x00, 0x00, 0x16, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1B, 0x00, 0x03,
  0x80, 0x00, 0xD8, 0x00, 0x1C, 0x00, 0x06, 0xC0, 0x00, 0xB0, 0x00, 0x22,
  0x00, 0x05, 0x80, 0x03, 0x18, 0x00, 0x64, 0x00, 0x18, 0xC0, 0x03, 0x20,
  0x00, 0xC6, 0x00, 0x11, 0x80, 0x0C, 0x10, 0x01, 0x8C, 0x00, 0x60, 0xC0,
  0x0C, 0x20, 0x03, 0x06, 0x00, 0x61, 0x80, 0x18, 0x30, 0x02, 0x0C, 0x01,
  0x80, 0xC0, 0x30, 0x60, 0x0C, 0x06, 0x01, 0x81, 0x00, 0x60, 0x30, 0x08,
  0x0C, 0x02, 0x00, 0x80, 0x40, 0x60, 0x30, 0x06, 0x06, 0x01, 0x01, 0x80,
  0x30, 0x30, 0x0C, 0x0C, 0x01, 0x81, 0x00, 0x60, 0xC0, 0x04, 0x18, 0x03,
  0x06, 0x00, 0x30, 0xC0, 0x08, 0x30, 0x01, 0x86, 0x00, 0x61, 0x80, 0x0C,
  0x20, 0x03, 0x18, 0x00, 0x23, 0x00, 0x08, 0xC0, 0x01, 0x98, 0x00, 0x66,
  0x00, 0x0C, 0x80, 0x03, 0x20, 0x00, 0x2C, 0x00, 0x1B, 0x00, 0x01, 0xE0,
  0x00, 0x58, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0E,
  0x30, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x30,
  0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x03, 0x01, 0x80,
  0x01, 0x81, 0x80, 0x00, 0xC3, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x66, 0x00, 0x00, 0xC3, 0x00, 0x01, 0x83, 0x00,
  0x01, 0x81, 0x80, 0x03, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x06, 0x00, 0x60,
  0x0C, 0x00, 0x30, 0x18, 0x00, 0x30, 0x18, 0x00, 0x18, 0x30, 0x00, 0x18,
  0x30, 0x00, 0x0C, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x19, 0x80, 0x00, 0x31, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x83,
  0x00, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x0C, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x10, 0x00, 0x30,
  0x60, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x58,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0xFE, 0xC0, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x06,
  0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18,
  0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x40,
  0x03, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00,
  0x08, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0xFF, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x07, 0xFE, 0x00, 0x30, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60,
  0x00, 0xC0, 0xC0, 0x02, 0x03, 0x00, 0x18, 0x06, 0x00, 0x40, 0x18, 0x03,
  0x00, 0x30, 0x08, 0x00, 0xC0, 0x60, 0x01, 0x81, 0x00, 0x06, 0x0C, 0x00,
  0x0C, 0x20, 0x00, 0x31, 0x80, 0x00, 0x64, 0x00, 0x01, 0xB0, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x07, 0xFC, 0x0F, 0xE7, 0xC1, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0xFC, 0x0F, 0xFF, 0x1F, 0x00, 0xCE, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x60, 0x02, 0xD8,
  0x01, 0xB3, 0x81, 0xCC, 0x7F, 0xC3, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC3, 0xFC, 0x0C, 0xF0, 0xF0,
  0xD8, 0x01, 0x8D, 0x00, 0x0C, 0xE0, 0x00, 0xCE, 0x00, 0x06, 0xE0, 0x00,
  0x6C, 0x00, 0x02, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x2C, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x0C, 0xF0, 0x00, 0xCD,
  0x80, 0x38, 0x8E, 0x0F, 0x08, 0x7F, 0xC0, 0x01, 0xFF, 0x03, 0xE3, 0xC7,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x0E, 0x07, 0xFE, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x03,
  0xFC, 0x30, 0xF0, 0xE3, 0x18, 0x03, 0x33, 0x00, 0x0B, 0x60, 0x00, 0xF6,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x40, 0x00, 0x76, 0x00,
  0x0F, 0x70, 0x00, 0xB3, 0x80, 0x1B, 0x1E, 0x07, 0x30, 0x7F, 0xC3, 0x03,
  0xFC, 0x01, 0xE1, 0xC0, 0x70, 0x0C, 0x18, 0x00, 0xC6, 0x00, 0x0C, 0xC0,
  0x01, 0x90, 0x00, 0x16, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x83, 0xC0, 0xF0, 0x3F, 0xFC, 0x01, 0xFE, 0x07, 0x08,
  0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x03, 0xFC, 0x30, 0xF0, 0xF3, 0x18, 0x01, 0xB3, 0x00, 0x0B, 0x60, 0x00,
  0xF6, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x40, 0x00, 0x76,
  0x00, 0x0F, 0x30, 0x00, 0xB3, 0x80, 0x13, 0x1E, 0x0F, 0x30, 0x7F, 0xC3,
  0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xC4, 0x00, 0x1C, 0x70, 0x03, 0x83, 0xFF,
  0xE0, 0x03, 0xF8, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x3F, 0xC3, 0x3C, 0x7C, 0xD8, 0x03, 0xBC, 0x00, 0x6E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x10, 0xBE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x02, 0x03, 0x03, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x06, 0x06,
  0xFC, 0xF8, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0xD8, 0x00, 0xCC, 0x00, 0xC6, 0x00, 0xC3, 0x00, 0xC1, 0x80, 0xE0,
  0xC0, 0xE0, 0x60, 0x60, 0x30, 0x60, 0x18, 0x60, 0x0C, 0x60, 0x06, 0x78,
  0x03, 0x66, 0x01, 0xE3, 0x00, 0xE0, 0xC0, 0x60, 0x30, 0x30, 0x0C, 0x18,
  0x06, 0x0C, 0x01, 0x86, 0x00, 0x63, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x03,
  0x60, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x87, 0xF8, 0x0F, 0xF1, 0x1C, 0x38, 0x7C, 0xF3, 0x60, 0x19, 0xC0, 0x37,
  0x80, 0x1A, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x30, 0x00, 0xF0,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x83, 0xFC, 0x23,
  0xC7, 0xCD, 0x80, 0x3B, 0x40, 0x06, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0x03, 0xFE, 0x00, 0xF0, 0xF0, 0x1C, 0x01, 0x83, 0x00,
  0x0C, 0x60, 0x00, 0x66, 0x00, 0x06, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x60, 0x00, 0x66, 0x00, 0x06, 0x30, 0x00, 0xC1, 0x80, 0x18, 0x0E, 0x07,
  0x00, 0x7F, 0xE0, 0xC3, 0xFC, 0x0C, 0x70, 0xF0, 0xDC, 0x01, 0x8D, 0x00,
  0x0C, 0xF0, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0x6C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x2C, 0x00, 0x06,
  0xE0, 0x00, 0x6E, 0x00, 0x0C, 0xF0, 0x00, 0xCD, 0x80, 0x18, 0xCE, 0x0F,
  0x0C, 0x3F, 0xC0, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x21, 0xE1, 0xC4,
  0x60, 0x0C, 0x98, 0x00, 0xD6, 0x00, 0x0E, 0xC0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xB0, 0x00, 0x57, 0x00, 0x1A, 0x70, 0x06, 0x47,
  0x03, 0x88, 0x3F, 0xE1, 0x00, 0xC0, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0xC3, 0xFE, 0x79, 0xB6, 0x01,
  0xE0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x0F, 0xFC,
  0x1F, 0x0F, 0x9C, 0x00, 0x4C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x34, 0x00, 0x3B, 0xC0, 0x78, 0xFF,
  0xF0, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x07,
  0xFF, 0xBF, 0xFE, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x80, 0x07, 0x04, 0x0F, 0xF0, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0x60, 0x03, 0x5C, 0x01, 0x93, 0xC1, 0xC4, 0x7F, 0xC1,
  0xC0, 0x00, 0x34, 0x00, 0x03, 0x60, 0x00, 0x66, 0x00, 0x06, 0x20, 0x00,
  0x43, 0x00, 0x0C, 0x30, 0x00, 0xC1, 0x80, 0x18, 0x18, 0x01, 0x80, 0x80,
  0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x02, 0x00, 0x60, 0x60, 0x02,
  0x06, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x10, 0x80, 0x01, 0x98, 0x00,
  0x19, 0x80, 0x00, 0xD0, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x90,
  0x01, 0xE0, 0x06, 0x60, 0x06, 0x80, 0x19, 0x80, 0x13, 0x00, 0x66, 0x00,
  0xCC, 0x01, 0x0C, 0x03, 0x10, 0x0C, 0x30, 0x08, 0x60, 0x30, 0xC0, 0x61,
  0x80, 0xC1, 0x01, 0x82, 0x02, 0x06, 0x04, 0x0C, 0x18, 0x18, 0x30, 0x30,
  0x60, 0x60, 0xC0, 0x41, 0x80, 0xC2, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x30,
  0x0C, 0x60, 0x18, 0xC0, 0x11, 0x00, 0x32, 0x00, 0x6C, 0x00, 0xD8, 0x01,
  0xB0, 0x03, 0x60, 0x06, 0x80, 0x05, 0x80, 0x0A, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x67, 0x00, 0x0C, 0x30,
  0x00, 0xC1, 0x80, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x06, 0x06, 0x00,
  0x30, 0xC0, 0x03, 0x18, 0x00, 0x19, 0x80, 0x00, 0xF0, 0x00, 0x06, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0x98, 0x00, 0x30, 0xC0, 0x06, 0x0C,
  0x00, 0x60, 0x60, 0x0C, 0x03, 0x01, 0x80, 0x18, 0x18, 0x01, 0x83, 0x00,
  0x0C, 0x60, 0x00, 0x6C, 0x00, 0x07, 0xC0, 0x00, 0x34, 0x00, 0x03, 0x60,
  0x00, 0x66, 0x00, 0x06, 0x30, 0x00, 0x43, 0x00, 0x0C, 0x30, 0x00, 0xC1,
  0x80, 0x18, 0x18, 0x01, 0x80, 0x80, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x06, 0x02, 0x00, 0x60, 0x60, 0x02, 0x06, 0x00, 0x30, 0xC0, 0x03, 0x0C,
  0x00, 0x10, 0x80, 0x01, 0x98, 0x00, 0x09, 0x80, 0x00, 0xD0, 0x00, 0x0F,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xBF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x78, 0x0F, 0x80, 0xE0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x1E, 0x01, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00,
  0x38, 0x00, 0xFC, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x0F, 0x80, 0x0C, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01, 0xE0, 0x07, 0x01,
  0xC0, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C,
  0x0F, 0x80, 0xE0, 0x00, 0x1F, 0x80, 0x0B, 0xDF, 0x00, 0x70, 0x0F, 0x0F,
  0x00, 0x1F, 0xC0,
};

const GFXglyph NotoSans_ExtraLight45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 3, 32, 10, 4, -32 },
  { 13, 9, 11, 15, 3, -32 },
  { 26, 27, 32, 29, 1, -32 },
  { 134, 19, 37, 26, 3, -34 },
  { 222, 30, 33, 36, 3, -33 },
  { 346, 28, 33, 32, 3, -33 },
  { 462, 2, 11, 8, 3, -32 },
  { 465, 8, 39, 12, 2, -32 },
  { 504, 8, 39, 12, 2, -32 },
  { 543, 19, 18, 25, 3, -34 },
  { 586, 21, 21, 26, 2, -26 },
  { 642, 4, 11, 9, 2, -5 },
  { 648, 11, 2, 14, 2, -13 },
  { 651, 3, 3, 10, 4, -3 },
  { 653, 13, 32, 15, 1, -32 },
  { 705, 20, 33, 26, 3, -33 },
  { 788, 11, 32, 26, 4, -32 },
  { 832, 19, 33, 26, 3, -33 },
  { 911, 20, 33, 26, 2, -33 },
  { 994, 24, 32, 26, 1, -32 },
  { 1090, 20, 32, 26, 3, -32 },
  { 1170, 20, 33, 26, 3, -33 },
  { 1253, 21, 32, 26, 2, -32 },
  { 1337, 20, 33, 26, 3, -33 },
  { 1420, 21, 34, 26, 2, -33 },
  { 1510, 3, 24, 10, 4, -24 },
  { 1519, 5, 30, 10, 2, -24 },
  { 1538, 21, 21, 26, 2, -27 },
  { 1594, 21, 10, 26, 2, -21 },
  { 1621, 21, 21, 26, 2, -27 },
  { 1677, 16, 33, 19, 1, -33 },
  { 1743, 35, 36, 40, 2, -32 },
  { 1901, 27, 32, 27, 0, -32 },
  { 2009, 20, 32, 28, 5, -32 },
  { 2089, 23, 33, 28, 3, -33 },
  { 2184, 24, 32, 32, 5, -32 },
  { 2280, 17, 32, 25, 5, -32 },
  { 2348, 17, 32, 22, 5, -32 },
  { 2416, 26, 33, 32, 3, -33 },
  { 2524, 23, 32, 32, 5, -32 },
  { 2616, 8, 32, 13, 3, -32 },
  { 2648, 10, 40, 11, -4, -32 },
  { 2698, 21, 32, 26, 5, -32 },
  { 2782, 17, 32, 23, 5, -32 },
  { 2850, 29, 32, 38, 5, -32 },
  { 2966, 22, 32, 32, 5, -32 },
  { 3054, 28, 33, 34, 3, -33 },
  { 3170, 19, 32, 26, 5, -32 },
  { 3246, 28, 41, 34, 3, -33 },
  { 3390, 20, 32, 26, 5, -32 },
  { 3470, 20, 33, 24, 2, -33 },
  { 3553, 23, 32, 23, 0, -32 },
  { 3645, 24, 32, 32, 4, -32 },
  { 3741, 26, 32, 26, 0, -32 },
  { 3845, 37, 32, 40, 1, -32 },
  { 3993, 24, 32, 24, 0, -32 },
  { 4089, 23, 32, 23, 0, -32 },
  { 4181, 22, 32, 26, 2, -32 },
  { 4269, 9, 39, 14, 4, -32 },
  { 4313, 13, 32, 15, 1, -32 },
  { 4365, 9, 39, 14, 1, -32 },
  { 4409, 22, 20, 26, 2, -32 },
  { 4464, 18, 2, 18, 0, 4 },
  { 4469, 8, 7, 12, 2, -34 },
  { 4476, 18, 24, 23, 2, -24 },
  { 4530, 20, 34, 27, 4, -34 },
  { 4615, 17, 24, 21, 3, -24 },
  { 4666, 20, 34, 27, 3, -34 },
  { 4751, 19, 24, 25, 3, -24 },
  { 4808, 15, 34, 13, 1, -34 },
  { 4872, 20, 35, 27, 3, -24 },
  { 4960, 18, 34, 26, 4, -34 },
  { 5037, 2, 33, 10, 4, -33 },
  { 5046, 8, 44, 10, -2, -33 },
  { 5090, 17, 34, 21, 4, -34 },
  { 5163, 2, 34, 10, 4, -34 },
  { 5172, 31, 24, 39, 4, -24 },
  { 5265, 18, 24, 26, 4, -24 },
  { 5319, 20, 24, 26, 3, -24 },
  { 5379, 20, 35, 27, 4, -24 },
  { 5467, 19, 35, 27, 3, -24 },
  { 5551, 13, 24, 17, 4, -24 },
  { 5590, 17, 24, 21, 2, -24 },
  { 5641, 14, 30, 15, 0, -30 },
  { 5694, 18, 24, 26, 4, -24 },
  { 5748, 20, 24, 20, 0, -24 },
  { 5808, 30, 24, 32, 1, -24 },
  { 5898, 20, 24, 22, 1, -24 },
  { 5958, 20, 35, 20, 0, -24 },
  { 6046, 17, 24, 21, 2, -24 },
  { 6097, 13, 39, 16, 1, -32 },
  { 6161, 2, 45, 24, 11, -34 },
  { 6173, 12, 39, 16, 2, -32 },
  { 6232, 21, 4, 26, 2, -18 },
};

const GFXfont NotoSans_ExtraLight45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight45pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_EXTRALIGHT45PT7B_H_
