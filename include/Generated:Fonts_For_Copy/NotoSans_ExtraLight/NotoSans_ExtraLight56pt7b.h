#ifndef _NOTOSANS_EXTRALIGHT56PT7B_H_
#define _NOTOSANS_EXTRALIGHT56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight56pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x6D, 0xB6, 0xDB, 0x6D, 0xB4,
  0x80, 0x00, 0x0F, 0xFF, 0x40, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xC0, 0x00, 0x06, 0x00, 0x60, 0x00, 0x06, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x18, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x18, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x60, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x10, 0x01,
  0x80, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0xFE, 0x07, 0x8C, 0x3E, 0x1C, 0x18, 0x0C, 0x70, 0x30, 0x01,
  0xC0, 0x60, 0x03, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x18,
  0x06, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x18, 0x00, 0xE0, 0x30, 0x00, 0xC0,
  0x60, 0x01, 0xC0, 0xC0, 0x01, 0xE1, 0x80, 0x01, 0xF3, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x37, 0xC0, 0x00, 0x63,
  0xE0, 0x00, 0xC1, 0xE0, 0x01, 0x80, 0xE0, 0x03, 0x00, 0xC0, 0x06, 0x01,
  0x80, 0x0C, 0x03, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x38, 0x01, 0x80, 0x60, 0x03, 0x01, 0xC0, 0x06, 0x03, 0x20,
  0x0C, 0x1E, 0x7C, 0x18, 0xF0, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0E, 0x00, 0x79, 0xE0, 0x00,
  0x18, 0x01, 0xC0, 0xE0, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x03, 0x00,
  0x18, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x03, 0x00, 0x06, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x00, 0x30,
  0x18, 0x00, 0x18, 0x00, 0x60, 0x30, 0x00, 0x30, 0x00, 0xC0, 0xC0, 0x00,
  0x60, 0x01, 0x83, 0x80, 0x00, 0xC0, 0x03, 0x06, 0x03, 0x00, 0xC0, 0x0C,
  0x18, 0x3F, 0xC1, 0x80, 0x18, 0x30, 0xF3, 0xC3, 0x00, 0x30, 0xC3, 0x81,
  0xC6, 0x00, 0x61, 0x86, 0x01, 0x86, 0x01, 0x86, 0x18, 0x03, 0x8E, 0x07,
  0x0C, 0x30, 0x03, 0x0F, 0x3C, 0x30, 0x60, 0x06, 0x0F, 0xF0, 0xE1, 0x80,
  0x0C, 0x02, 0x01, 0x83, 0x00, 0x18, 0x00, 0x06, 0x06, 0x00, 0x38, 0x00,
  0x0C, 0x0C, 0x00, 0x30, 0x00, 0x30, 0x18, 0x00, 0x60, 0x00, 0x60, 0x30,
  0x00, 0xC0, 0x01, 0x80, 0x60, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x07, 0x00,
  0x0C, 0x01, 0x80, 0x0C, 0x00, 0x38, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x01, 0xC0,
  0x0C, 0x00, 0x0C, 0x03, 0x00, 0x18, 0x00, 0x1C, 0x0E, 0x00, 0x60, 0x00,
  0x1C, 0x78, 0x01, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xE7, 0xC0,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x03, 0x80, 0x00, 0x30, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0x70, 0xE0, 0x0E, 0x00, 0x0C, 0x38, 0x00, 0xE0,
  0x01, 0x86, 0x00, 0x0E, 0x00, 0x31, 0xC0, 0x00, 0xE0, 0x0C, 0x30, 0x00,
  0x0E, 0x01, 0x86, 0x00, 0x00, 0xE0, 0x71, 0xC0, 0x00, 0x0E, 0x0C, 0x38,
  0x00, 0x00, 0xE3, 0x87, 0x00, 0x00, 0x0E, 0xE0, 0x60, 0x00, 0x00, 0xF8,
  0x0C, 0x00, 0x00, 0x0F, 0x01, 0x80, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00,
  0x7E, 0x03, 0x80, 0x00, 0x3C, 0xE0, 0x38, 0x00, 0x0E, 0x0E, 0x07, 0x80,
  0x07, 0x80, 0xE0, 0x3F, 0xBF, 0xE0, 0x0E, 0x01, 0xFF, 0xE0, 0x00, 0xE0,
  0x01, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x38, 0x06,
  0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x1C,
  0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x70,
  0x06, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xE0, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00,
  0xE0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x18, 0x07,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x18,
  0x06, 0x01, 0x80, 0xE0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x18,
  0x0E, 0x03, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x40, 0x18, 0x01, 0xF8, 0x08, 0x0F, 0xFF, 0x08, 0x7F,
  0x0F, 0xCB, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x63, 0x00, 0x00, 0xC1, 0x80, 0x01, 0x81, 0xC0,
  0x03, 0x80, 0xC0, 0x03, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x30,
  0x02, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x71, 0x86, 0x18, 0xE3, 0x0C, 0x31, 0xC6,
  0x18, 0x63, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF4, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x1C, 0x00, 0xE0, 0x0E,
  0x00, 0x1C, 0x03, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0xE0, 0x00, 0x18,
  0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x06, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x06, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x1B,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x06, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x03, 0x80,
  0x07, 0x00, 0x70, 0x03, 0x80, 0x0F, 0xCF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x30, 0x0F, 0x01, 0xF0, 0x3B, 0x0F, 0x31, 0xC3,
  0x38, 0x3F, 0x03, 0xC0, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x08, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xF9, 0xF8,
  0x03, 0xC0, 0x0E, 0x07, 0x80, 0x03, 0x81, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x08, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFC, 0xFC, 0x07, 0x80, 0x0F,
  0x0F, 0x00, 0x01, 0xC2, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE4, 0x00, 0x00, 0xE3, 0x80,
  0x01, 0xE1, 0xFF, 0x1F, 0xE0, 0x1F, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x00, 0x76, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x86, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x81, 0x80, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x1C, 0x01, 0x80,
  0x00, 0x60, 0x06, 0x00, 0x03, 0x00, 0x18, 0x00, 0x18, 0x00, 0x60, 0x00,
  0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x18, 0x00, 0xE0,
  0x00, 0x60, 0x03, 0x00, 0x01, 0x80, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x18, 0x07, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x73, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x38, 0x01, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x80, 0x00, 0x38, 0xE0, 0x00, 0xF0,
  0xFF, 0x9F, 0xE0, 0x1F, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0x87, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x1E, 0x00, 0x60, 0xFF, 0xF0, 0x31, 0xF0, 0x3E, 0x19, 0xC0, 0x07, 0x8D,
  0xC0, 0x00, 0xE7, 0xC0, 0x00, 0x33, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x06,
  0xE0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x06, 0xC0, 0x00,
  0x07, 0x60, 0x00, 0x03, 0x38, 0x00, 0x01, 0x8C, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0xE0, 0x60, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x07,
  0xE7, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF,
  0xF0, 0x01, 0xFC, 0xFE, 0x01, 0xE0, 0x07, 0x81, 0xC0, 0x00, 0xE0, 0xC0,
  0x00, 0x30, 0xE0, 0x00, 0x1C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x30, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x38,
  0x01, 0xE0, 0x70, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x1C, 0x00, 0x38, 0x1C, 0x00,
  0x0E, 0x1C, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x38, 0x00, 0xF0, 0x0F, 0xC3, 0xF0,
  0x01, 0xFF, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF,
  0xC0, 0x01, 0xF9, 0xF8, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x03, 0x81, 0xC0,
  0x00, 0xE0, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x07, 0x70,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xF3, 0x00, 0x00,
  0xD9, 0xC0, 0x00, 0xEC, 0x70, 0x00, 0xE6, 0x1F, 0x03, 0xC3, 0x03, 0xFF,
  0xC1, 0x80, 0x1E, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x70, 0x3F, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xD0, 0x1C, 0x71, 0xC7, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x1C, 0x61, 0x8E, 0x38, 0xC3, 0x0C, 0x61, 0x86, 0x10, 0xC0, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x07, 0xFF,
  0x83, 0xFD, 0xFC, 0x70, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x0B, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x7E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x18, 0x00, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x63, 0x80, 0x03, 0xFF, 0xC0, 0x0C, 0x60, 0x00,
  0xF8, 0x7C, 0x01, 0xDC, 0x00, 0x78, 0x01, 0x80, 0x1B, 0x00, 0x1C, 0x00,
  0x30, 0x03, 0x60, 0x03, 0x00, 0x06, 0x00, 0x6C, 0x00, 0xC0, 0x00, 0xC0,
  0x0F, 0x00, 0x38, 0x00, 0x30, 0x01, 0xE0, 0x06, 0x00, 0x06, 0x00, 0x3C,
  0x00, 0xC0, 0x00, 0xC0, 0x07, 0x80, 0x18, 0x00, 0x18, 0x00, 0xF0, 0x03,
  0x00, 0x03, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x60, 0x03, 0xC0, 0x1C, 0x00,
  0x0C, 0x00, 0x78, 0x01, 0x80, 0x01, 0x80, 0x0F, 0x00, 0x30, 0x00, 0x30,
  0x01, 0xE0, 0x06, 0x00, 0x0E, 0x00, 0x6C, 0x00, 0xC0, 0x01, 0x40, 0x0D,
  0x80, 0x1C, 0x00, 0x6C, 0x03, 0x98, 0x01, 0xC0, 0x19, 0x80, 0x63, 0x00,
  0x1C, 0x06, 0x18, 0x38, 0x60, 0x01, 0xFF, 0x83, 0xFE, 0x06, 0x00, 0x0F,
  0xC0, 0x1F, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x20, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00,
  0x0E, 0x18, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x30, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x60, 0x03, 0x00,
  0x00, 0x30, 0x01, 0x80, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0x80, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x38, 0x00,
  0x00, 0x38, 0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x00, 0x73, 0x00,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x0C, 0x00, 0x0F, 0x83, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x0E, 0x30, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x03, 0xB0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x3B, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x38, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x3C, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0xF8, 0x30, 0x00, 0x07, 0x8C, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0xEC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x1E, 0x30,
  0x00, 0x3E, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xF7, 0xFE, 0x01, 0xE0, 0x00, 0xE0,
  0x3C, 0x00, 0x01, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xC0, 0x1F, 0xF7, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x0C, 0x00, 0x1F, 0x80, 0x30, 0x00, 0x0F, 0x80, 0xC0, 0x00, 0x0F,
  0x03, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x38,
  0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0xCC, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x07, 0x0C, 0x00, 0x00, 0x38, 0x30, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x3C,
  0x03, 0x00, 0x0F, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x3F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xEC, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0x83, 0xFF, 0x00, 0xF8, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x02, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x70, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x03, 0x1C, 0x00,
  0x00, 0x03, 0x0E, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x03, 0x03, 0xC0,
  0x00, 0x03, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x0F, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x03, 0x90, 0x3C, 0xFF, 0x83,
  0xF0, 0x00, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x38, 0x30, 0x00, 0x1C, 0x0C, 0x00, 0x0E,
  0x03, 0x00, 0x07, 0x00, 0xC0, 0x03, 0x80, 0x30, 0x01, 0xC0, 0x0C, 0x00,
  0xE0, 0x03, 0x00, 0x70, 0x00, 0xC0, 0x38, 0x00, 0x30, 0x1C, 0x00, 0x0C,
  0x0E, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0xF0, 0x00,
  0x0C, 0x7C, 0x00, 0x03, 0x33, 0x80, 0x00, 0xD8, 0x70, 0x00, 0x3C, 0x0C,
  0x00, 0x0E, 0x03, 0x80, 0x03, 0x00, 0x70, 0x00, 0xC0, 0x0E, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x00, 0x0E, 0x00, 0xC0, 0x01, 0xC0,
  0x30, 0x00, 0x30, 0x0C, 0x00, 0x0E, 0x03, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x30, 0x30, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x06, 0x30, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1B, 0xD8, 0x00, 0x00, 0x01, 0xBD, 0x80, 0x00, 0x00, 0x3B,
  0xDC, 0x00, 0x00, 0x03, 0x3C, 0xC0, 0x00, 0x00, 0x33, 0xCE, 0x00, 0x00,
  0x06, 0x3C, 0x60, 0x00, 0x00, 0x63, 0xC6, 0x00, 0x00, 0x0E, 0x3C, 0x70,
  0x00, 0x00, 0xC3, 0xC3, 0x00, 0x00, 0x0C, 0x3C, 0x38, 0x00, 0x01, 0x83,
  0xC1, 0x80, 0x00, 0x18, 0x3C, 0x18, 0x00, 0x03, 0x83, 0xC1, 0xC0, 0x00,
  0x30, 0x3C, 0x0C, 0x00, 0x03, 0x03, 0xC0, 0xE0, 0x00, 0x60, 0x3C, 0x06,
  0x00, 0x06, 0x03, 0xC0, 0x60, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0x0C, 0x03,
  0xC0, 0x30, 0x00, 0xC0, 0x3C, 0x03, 0x80, 0x18, 0x03, 0xC0, 0x18, 0x01,
  0x80, 0x3C, 0x01, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x03, 0x00, 0x3C, 0x00,
  0xC0, 0x30, 0x03, 0xC0, 0x0E, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x60, 0x03,
  0xC0, 0x06, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0xC0, 0x03, 0xC0, 0x03, 0x1C,
  0x00, 0x3C, 0x00, 0x39, 0x80, 0x03, 0xC0, 0x01, 0x98, 0x00, 0x3C, 0x00,
  0x1B, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3D, 0x80, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x3C, 0xE0, 0x00,
  0x03, 0xC7, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x3C,
  0x1C, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x03, 0xC0, 0x70,
  0x00, 0x3C, 0x07, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x3C, 0x01, 0xC0, 0x03,
  0xC0, 0x0C, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x3C, 0x00,
  0x30, 0x03, 0xC0, 0x03, 0x80, 0x3C, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0xC0,
  0x3C, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x70, 0x3C, 0x00, 0x03, 0x03, 0xC0,
  0x00, 0x38, 0x3C, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0C, 0x3C, 0x00, 0x00,
  0xE3, 0xC0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x33, 0xC0, 0x00, 0x03, 0xBC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x00, 0x63, 0x80, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0x60, 0x70, 0x00,
  0x00, 0x18, 0x07, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x07, 0xFD, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x83, 0x00, 0x0F, 0xC6, 0x00, 0x03, 0xCC, 0x00, 0x03, 0xD8,
  0x00, 0x03, 0xB0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0D, 0x80, 0x00,
  0x3B, 0x00, 0x00, 0xE6, 0x00, 0x03, 0x8C, 0x00, 0x3E, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x0E, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x30, 0x00, 0xFC, 0x18, 0x00, 0x0F,
  0x0C, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x39, 0x80, 0x00,
  0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00, 0x00, 0x39, 0x80,
  0x00, 0x18, 0xC0, 0x00, 0x1C, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x1C, 0x18,
  0x00, 0x1C, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x03, 0x00, 0x38, 0x01,
  0x80, 0x0E, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x01, 0xC0, 0x30, 0x00, 0x60,
  0x18, 0x00, 0x38, 0x0C, 0x00, 0x0E, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x0E, 0x30, 0x00,
  0x03, 0x18, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x3B, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC1, 0xE0, 0x01, 0xC1, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE3, 0x80, 0x01, 0xE1, 0xFF, 0x9F, 0xE0, 0x3F, 0xFF,
  0xC0, 0x00, 0x58, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x38, 0xC0, 0x00,
  0x00, 0xC3, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x01,
  0xC0, 0x1E, 0x00, 0x1E, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30,
  0x0E, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60,
  0x07, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x01, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x03, 0x80,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x70, 0x0C, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x98, 0x00, 0x03, 0x60, 0x00, 0x06, 0x60, 0x00, 0x0D, 0x80, 0x00,
  0x39, 0x80, 0x00, 0x36, 0x00, 0x00, 0xC7, 0x00, 0x00, 0xD8, 0x00, 0x03,
  0x0C, 0x00, 0x06, 0x30, 0x00, 0x1C, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x70,
  0xC0, 0x00, 0x63, 0x00, 0x01, 0x83, 0x80, 0x01, 0x8E, 0x00, 0x06, 0x06,
  0x00, 0x0C, 0x18, 0x00, 0x38, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC0, 0x70,
  0x00, 0xC1, 0x80, 0x03, 0x00, 0xC0, 0x07, 0x03, 0x00, 0x0C, 0x03, 0x00,
  0x18, 0x0C, 0x00, 0x70, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x80, 0x38, 0x01,
  0x80, 0xE0, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x38, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xE0, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x1C, 0x03, 0x00,
  0x30, 0x0C, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x70, 0x00, 0xC0, 0x60, 0x03,
  0x01, 0x80, 0x03, 0x01, 0x80, 0x0E, 0x06, 0x00, 0x06, 0x0E, 0x00, 0x18,
  0x18, 0x00, 0x18, 0x30, 0x00, 0x60, 0xE0, 0x00, 0x60, 0xC0, 0x01, 0x83,
  0x00, 0x01, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x70,
  0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x00, 0x31, 0x80, 0x00, 0xE6, 0x00,
  0x00, 0xEE, 0x00, 0x01, 0x98, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xE0, 0x00,
  0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x70, 0x00,
  0x00, 0x31, 0xC0, 0x00, 0x03, 0x86, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01,
  0x80, 0xE0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x30,
  0x07, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x07, 0x03, 0x00, 0x00, 0x18, 0x38,
  0x00, 0x00, 0xE1, 0x80, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x73, 0x00, 0x00, 0x03, 0x1C,
  0x00, 0x00, 0x30, 0x70, 0x00, 0x03, 0x81, 0x80, 0x00, 0x18, 0x0E, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0xE0, 0x00, 0x60, 0x06, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x0C, 0x07, 0x00, 0x00, 0x70, 0x30, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3B, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x1C, 0x60, 0x00,
  0x00, 0xC3, 0x80, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x38, 0x00, 0x38, 0x00,
  0xC0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xE0,
  0x0E, 0x00, 0x03, 0x00, 0x60, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x03, 0x83, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x07, 0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x71, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00,
  0x18, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x00,
  0x30, 0x06, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xE0, 0x0E, 0x04, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0xC3, 0xF0, 0x07, 0x3C, 0x00,
  0x1D, 0xC0, 0x00, 0x76, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x01, 0xB6, 0x00, 0x0C, 0xDC, 0x00, 0xE3, 0x3F, 0x1F, 0x0C, 0x3F, 0xF0,
  0x30, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x07, 0xFC, 0x03,
  0x0F, 0xFF, 0x81, 0x8E, 0x00, 0xF0, 0xCC, 0x00, 0x3C, 0x6C, 0x00, 0x06,
  0x36, 0x00, 0x03, 0x9E, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x1B, 0x80, 0x00, 0x0D, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x70,
  0x00, 0x01, 0xB8, 0x00, 0x00, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x67,
  0x80, 0x00, 0x73, 0x60, 0x00, 0x71, 0xB8, 0x00, 0x70, 0xCE, 0x00, 0x78,
  0x63, 0xF3, 0xF0, 0x30, 0x7F, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x07, 0xFF, 0xF0, 0x3C, 0x00, 0x81, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x03, 0x03, 0xF9, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x07, 0xFC, 0x0C, 0x0F, 0xFF, 0x86, 0x0F,
  0x00, 0xF3, 0x0E, 0x00, 0x19, 0x8E, 0x00, 0x06, 0xCE, 0x00, 0x01, 0xE6,
  0x00, 0x00, 0xF3, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0x80, 0x00, 0x0E,
  0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xB0, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0xEC, 0x00, 0x00, 0x73, 0x00, 0x00, 0x79, 0x80, 0x00, 0x3C, 0xE0,
  0x00, 0x36, 0x38, 0x00, 0x3B, 0x0F, 0x00, 0x39, 0x83, 0xF9, 0xF8, 0xC0,
  0x7F, 0xF0, 0x60, 0x01, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xE0,
  0x07, 0x80, 0x70, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x18, 0x00, 0x0E,
  0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x70, 0x00, 0x07, 0x60, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x06, 0x03, 0xF9, 0xFE, 0x00, 0xFF, 0xF8,
  0x00, 0x04, 0x00, 0x00, 0x1F, 0xA0, 0x1F, 0xF8, 0x07, 0x81, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x3F, 0xF8,
  0x3F, 0xFF, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFF,
  0xC1, 0x81, 0xFF, 0xF0, 0xC1, 0xE0, 0x0E, 0x61, 0xC0, 0x03, 0xB1, 0xC0,
  0x00, 0xD9, 0xC0, 0x00, 0x3C, 0xC0, 0x00, 0x0E, 0x60, 0x00, 0x07, 0x70,
  0x00, 0x03, 0xB0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0x60, 0x00,
  0x0F, 0x38, 0x00, 0x07, 0x8C, 0x00, 0x06, 0xC7, 0x00, 0x07, 0x61, 0xE0,
  0x07, 0x30, 0x7F, 0x3F, 0x18, 0x0F, 0xFE, 0x0C, 0x00, 0x20, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x40, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xF8,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x1F, 0xF0, 0x30, 0xFF, 0xF8, 0x63, 0x80, 0x38, 0xCC,
  0x00, 0x39, 0xB0, 0x00, 0x3B, 0xC0, 0x00, 0x37, 0x80, 0x00, 0x6E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x18, 0x27, 0xF7, 0x00, 0x00, 0x00, 0x06, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x60, 0x00, 0x40, 0x1C, 0x07, 0x80, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07,
  0x01, 0xCF, 0xF1, 0xFC, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x1B, 0x00, 0x01, 0x98, 0x00, 0x18, 0xC0,
  0x01, 0x86, 0x00, 0x1C, 0x30, 0x01, 0xC1, 0x80, 0x1C, 0x0C, 0x01, 0xC0,
  0x60, 0x1C, 0x03, 0x01, 0xC0, 0x18, 0x1C, 0x00, 0xC0, 0xC0, 0x06, 0x0C,
  0x00, 0x30, 0xE0, 0x01, 0x8F, 0x80, 0x0C, 0xCE, 0x00, 0x6C, 0x30, 0x03,
  0xE1, 0xC0, 0x1E, 0x07, 0x00, 0xE0, 0x1C, 0x06, 0x00, 0x60, 0x30, 0x03,
  0x81, 0x80, 0x0E, 0x0C, 0x00, 0x38, 0x60, 0x00, 0xC3, 0x00, 0x07, 0x18,
  0x00, 0x1C, 0xC0, 0x00, 0x76, 0x00, 0x01, 0xB0, 0x00, 0x0E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC1, 0xFF, 0x00,
  0x3F, 0xC1, 0x8F, 0xFF, 0x01, 0xFF, 0xE3, 0x38, 0x07, 0x0F, 0x01, 0xE6,
  0xE0, 0x07, 0x38, 0x00, 0xED, 0x80, 0x07, 0x60, 0x00, 0xDE, 0x00, 0x07,
  0x80, 0x01, 0xB8, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0x1C, 0x00, 0x03,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0xC0, 0xFF, 0x81, 0x87, 0xFF, 0xC3, 0x1C, 0x01, 0xC6, 0x60, 0x01, 0xCD,
  0x80, 0x01, 0xDE, 0x00, 0x01, 0xBC, 0x00, 0x03, 0x70, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x78, 0x03,
  0xC0, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x06, 0x06, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0x38, 0xC0, 0x00, 0x06, 0x70, 0x00, 0x01, 0x98, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x60, 0x00, 0x01, 0xD8,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x03,
  0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0xF0, 0x03, 0xF3,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0x40, 0x00, 0xC0, 0xFF, 0x80, 0x61,
  0xFF, 0xF0, 0x31, 0xC0, 0x1E, 0x19, 0xC0, 0x03, 0x8D, 0x80, 0x00, 0xC6,
  0xC0, 0x00, 0x73, 0xC0, 0x00, 0x19, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x03,
  0x70, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x37, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x1D, 0xE0, 0x00, 0x0C, 0xF0,
  0x00, 0x0E, 0x6C, 0x00, 0x06, 0x37, 0x00, 0x07, 0x19, 0xC0, 0x0F, 0x0C,
  0x7F, 0x7F, 0x06, 0x0F, 0xFE, 0x03, 0x00, 0x20, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x81, 0x81, 0xFF, 0xF0, 0xC1, 0xE0, 0x1C, 0x61, 0xC0, 0x03, 0x31,
  0xC0, 0x00, 0xD9, 0xC0, 0x00, 0x3C, 0xC0, 0x00, 0x1E, 0xE0, 0x00, 0x07,
  0x60, 0x00, 0x03, 0xB0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x0E, 0xE0,
  0x00, 0x0F, 0x30, 0x00, 0x07, 0x9C, 0x00, 0x06, 0xC7, 0x00, 0x06, 0x61,
  0xC0, 0x06, 0x30, 0x7E, 0x3E, 0x18, 0x0F, 0xFE, 0x0C, 0x00, 0x70, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0xC0, 0xFF, 0xC3, 0xFE, 0xCF, 0x00, 0xCC, 0x00, 0xD8, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xFF, 0xC7, 0x80, 0x1C, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xE0, 0x00,
  0x1D, 0xC0, 0x01, 0xCF, 0xE0, 0xFC, 0x1F, 0xFF, 0x80, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0xE7,
  0x01, 0xFF, 0x00, 0x10, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1E, 0xC0, 0x00, 0x7D, 0xC0, 0x01, 0x99, 0xC0, 0x0E,
  0x31, 0xF9, 0xF8, 0x61, 0xFF, 0xC0, 0xC0, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xCE, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x38, 0x30, 0x00, 0x18, 0x18,
  0x00, 0x0C, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x01, 0xC0, 0x07, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x06, 0x00, 0xC0,
  0x03, 0x00, 0x60, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x38, 0x38,
  0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x1F, 0x80, 0x00, 0xE0, 0x00, 0x6E, 0x00, 0x07, 0x80, 0x01, 0x98, 0x00,
  0x1E, 0x00, 0x06, 0x60, 0x00, 0x78, 0x00, 0x39, 0xC0, 0x03, 0x30, 0x00,
  0xC3, 0x00, 0x0C, 0xC0, 0x03, 0x0C, 0x00, 0x33, 0x00, 0x0C, 0x30, 0x01,
  0xC6, 0x00, 0x70, 0xE0, 0x06, 0x18, 0x01, 0x81, 0x80, 0x18, 0x60, 0x06,
  0x06, 0x00, 0xE0, 0xC0, 0x18, 0x1C, 0x03, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x0C, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x70,
  0x0E, 0x06, 0x01, 0x81, 0x80, 0x18, 0x38, 0x07, 0x06, 0x00, 0x60, 0xC0,
  0x0C, 0x18, 0x01, 0x83, 0x00, 0x30, 0xE0, 0x03, 0x1C, 0x00, 0xE3, 0x00,
  0x0C, 0x60, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0xE6, 0x00,
  0x19, 0x80, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00,
  0x1B, 0x00, 0x03, 0x60, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x70, 0x00, 0x07, 0x18, 0x00,
  0x03, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x03, 0x80, 0xC0, 0x01, 0x80, 0x30,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x00,
  0xE0, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x70, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x18, 0xE0, 0x00, 0x18, 0x30, 0x00, 0x1C, 0x0C,
  0x00, 0x1C, 0x07, 0x00, 0x0C, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x0E, 0x00,
  0x38, 0x06, 0x00, 0x0E, 0x06, 0x00, 0x03, 0x07, 0x00, 0x00, 0xC7, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xD8,
  0x00, 0x00, 0xCE, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30,
  0xE0, 0x00, 0x38, 0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x0C,
  0x03, 0x00, 0x06, 0x01, 0xC0, 0x07, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01,
  0x80, 0x1C, 0x01, 0xC0, 0x06, 0x00, 0xC0, 0x03, 0x80, 0x60, 0x00, 0xC0,
  0x60, 0x00, 0x60, 0x30, 0x00, 0x38, 0x38, 0x00, 0x0C, 0x18, 0x00, 0x06,
  0x0C, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x47, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x02, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x78,
  0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x07, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0,
  0x00, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0xFC, 0x00, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x5F, 0x7F, 0x00, 0x3E, 0x01, 0xF0, 0x3A, 0x00,
  0x1F, 0xFC, 0x80, 0x00, 0xFC, 0x00,
};

const GFXglyph NotoSans_ExtraLight56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 3, 41, 13, 5, -40 },
  { 17, 11, 14, 19, 4, -40 },
  { 37, 33, 40, 36, 2, -40 },
  { 202, 23, 46, 32, 4, -43 },
  { 335, 39, 42, 45, 3, -41 },
  { 540, 35, 42, 40, 3, -41 },
  { 724, 2, 14, 10, 4, -40 },
  { 728, 11, 49, 15, 2, -40 },
  { 796, 10, 49, 15, 2, -40 },
  { 858, 24, 23, 31, 3, -42 },
  { 927, 26, 26, 32, 3, -33 },
  { 1012, 6, 14, 11, 2, -7 },
  { 1023, 14, 2, 18, 2, -16 },
  { 1027, 3, 5, 13, 5, -4 },
  { 1029, 17, 40, 19, 1, -40 },
  { 1114, 26, 42, 32, 3, -41 },
  { 1251, 12, 40, 32, 6, -40 },
  { 1311, 25, 41, 32, 3, -41 },
  { 1440, 25, 42, 32, 3, -41 },
  { 1572, 30, 40, 32, 1, -40 },
  { 1722, 24, 41, 32, 4, -40 },
  { 1845, 25, 42, 32, 4, -41 },
  { 1977, 26, 40, 32, 3, -40 },
  { 2107, 25, 42, 32, 3, -41 },
  { 2239, 25, 42, 32, 3, -41 },
  { 2371, 3, 31, 13, 5, -30 },
  { 2383, 6, 37, 13, 2, -30 },
  { 2411, 26, 26, 32, 3, -33 },
  { 2496, 26, 13, 32, 3, -26 },
  { 2539, 26, 26, 32, 3, -33 },
  { 2624, 19, 42, 23, 2, -41 },
  { 2724, 43, 45, 49, 3, -40 },
  { 2966, 33, 40, 33, 0, -40 },
  { 3131, 26, 40, 35, 6, -40 },
  { 3261, 29, 42, 35, 4, -41 },
  { 3414, 30, 40, 39, 6, -40 },
  { 3564, 21, 40, 31, 6, -40 },
  { 3669, 21, 40, 28, 6, -40 },
  { 3774, 32, 42, 40, 4, -41 },
  { 3942, 28, 40, 40, 6, -40 },
  { 4082, 10, 40, 16, 3, -40 },
  { 4132, 13, 50, 13, -5, -40 },
  { 4214, 26, 40, 32, 6, -40 },
  { 4344, 21, 40, 29, 6, -40 },
  { 4449, 36, 40, 48, 6, -40 },
  { 4629, 28, 40, 40, 6, -40 },
  { 4769, 35, 42, 43, 4, -41 },
  { 4953, 23, 40, 32, 6, -40 },
  { 5068, 35, 51, 43, 4, -41 },
  { 5292, 25, 40, 33, 6, -40 },
  { 5417, 25, 42, 30, 3, -41 },
  { 5549, 29, 40, 29, 0, -40 },
  { 5694, 30, 41, 40, 5, -40 },
  { 5848, 32, 40, 32, 0, -40 },
  { 6008, 46, 40, 49, 2, -40 },
  { 6238, 29, 40, 29, 0, -40 },
  { 6383, 29, 40, 29, 0, -40 },
  { 6528, 28, 40, 32, 2, -40 },
  { 6668, 11, 49, 18, 5, -40 },
  { 6736, 17, 40, 19, 1, -40 },
  { 6821, 12, 49, 18, 1, -40 },
  { 6895, 27, 25, 32, 2, -40 },
  { 6980, 23, 2, 23, 0, 5 },
  { 6986, 10, 9, 14, 2, -43 },
  { 6998, 22, 31, 29, 3, -30 },
  { 7084, 25, 44, 33, 5, -43 },
  { 7222, 22, 31, 27, 3, -30 },
  { 7308, 25, 44, 33, 3, -43 },
  { 7446, 24, 31, 31, 3, -30 },
  { 7539, 19, 43, 16, 1, -43 },
  { 7642, 25, 43, 33, 3, -30 },
  { 7777, 23, 43, 33, 5, -43 },
  { 7901, 4, 41, 12, 4, -41 },
  { 7922, 11, 54, 12, -3, -41 },
  { 7997, 21, 43, 26, 5, -43 },
  { 8110, 2, 43, 12, 5, -43 },
  { 8121, 39, 30, 49, 5, -30 },
  { 8268, 23, 30, 33, 5, -30 },
  { 8355, 26, 31, 33, 3, -30 },
  { 8456, 25, 43, 33, 5, -30 },
  { 8591, 25, 43, 33, 3, -30 },
  { 8726, 16, 30, 21, 5, -30 },
  { 8786, 21, 31, 26, 2, -30 },
  { 8868, 16, 38, 18, 1, -37 },
  { 8944, 23, 31, 33, 5, -30 },
  { 9034, 25, 30, 25, 0, -30 },
  { 9128, 38, 30, 40, 1, -30 },
  { 9271, 25, 30, 27, 1, -30 },
  { 9365, 25, 44, 25, 0, -30 },
  { 9503, 21, 30, 26, 2, -30 },
  { 9582, 16, 49, 19, 1, -40 },
  { 9680, 2, 57, 30, 14, -43 },
  { 9695, 16, 49, 19, 2, -40 },
  { 9793, 26, 5, 32, 3, -22 },
};

const GFXfont NotoSans_ExtraLight56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight56pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_EXTRALIGHT56PT7B_H_
