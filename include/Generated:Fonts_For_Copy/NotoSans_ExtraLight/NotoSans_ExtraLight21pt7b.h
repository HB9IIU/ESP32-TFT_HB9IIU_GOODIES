#ifndef _NOTOSANS_EXTRALIGHT21PT7B_H_
#define _NOTOSANS_EXTRALIGHT21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight21pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xE2, 0x8C, 0x63, 0x18, 0x80, 0x08, 0x40, 0x84, 0x08, 0x40,
  0x88, 0x10, 0x8F, 0xFF, 0x10, 0x81, 0x08, 0x11, 0x0D, 0xFE, 0x21, 0x02,
  0x10, 0x21, 0x02, 0x20, 0x22, 0x00, 0x08, 0x0F, 0x1A, 0x49, 0x08, 0x84,
  0x41, 0x20, 0x70, 0x0C, 0x05, 0x82, 0x21, 0x10, 0x88, 0x47, 0x2C, 0x78,
  0x08, 0x00, 0x78, 0x10, 0x88, 0x42, 0x10, 0x84, 0x22, 0x08, 0x44, 0x10,
  0x90, 0x21, 0x4F, 0x22, 0xA2, 0x7A, 0x42, 0x04, 0x84, 0x11, 0x08, 0x22,
  0x10, 0x84, 0x21, 0x08, 0x84, 0x0E, 0x00, 0x1F, 0x01, 0x08, 0x08, 0x20,
  0x41, 0x02, 0x10, 0x09, 0x00, 0x30, 0x06, 0x80, 0x42, 0x0A, 0x08, 0xA0,
  0x25, 0x00, 0xC8, 0x06, 0x20, 0x48, 0xFC, 0x20, 0xF8, 0x32, 0x44, 0x88,
  0x88, 0x88, 0x88, 0x88, 0x44, 0x23, 0x84, 0x42, 0x22, 0x11, 0x11, 0x11,
  0x22, 0x24, 0x48, 0x08, 0x04, 0x02, 0x19, 0x33, 0xE0, 0x60, 0x48, 0x44,
  0x21, 0x00, 0x08, 0x02, 0x00, 0x80, 0x20, 0xFF, 0xC2, 0x00, 0x80, 0x20,
  0x08, 0x00, 0x5A, 0x80, 0xF8, 0x80, 0x02, 0x08, 0x10, 0x40, 0x81, 0x04,
  0x08, 0x10, 0x40, 0x82, 0x04, 0x08, 0x20, 0x00, 0x1F, 0x08, 0x44, 0x09,
  0x02, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x05, 0x02, 0x40,
  0x88, 0x41, 0xE0, 0x19, 0x53, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x20, 0x3E, 0x20, 0x80, 0x20, 0x10, 0x08, 0x04, 0x04, 0x04, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x03, 0xFE, 0x7E, 0x40, 0x80, 0x20, 0x10, 0x08,
  0x08, 0x08, 0x7C, 0x01, 0x80, 0x40, 0x20, 0x10, 0x08, 0x0F, 0xF8, 0x00,
  0x80, 0x18, 0x02, 0x80, 0x48, 0x04, 0x80, 0x88, 0x10, 0x81, 0x08, 0x20,
  0x84, 0x08, 0xFF, 0xF0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x7F, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x03, 0xF0, 0x06, 0x01, 0x00, 0x40, 0x20, 0x10,
  0x14, 0x1B, 0xF0, 0x0F, 0x8C, 0x02, 0x01, 0x00, 0x40, 0x10, 0x09, 0xF3,
  0x82, 0xC0, 0x60, 0x18, 0x05, 0x01, 0x40, 0x88, 0x21, 0xF0, 0xFF, 0xC0,
  0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40,
  0x20, 0x08, 0x04, 0x01, 0x00, 0x3F, 0x10, 0x24, 0x09, 0x02, 0x40, 0x88,
  0x41, 0xE0, 0x78, 0x61, 0x90, 0x28, 0x06, 0x01, 0x80, 0x50, 0x23, 0xF0,
  0x3E, 0x10, 0x48, 0x0A, 0x02, 0x80, 0xA0, 0x18, 0x0D, 0x05, 0x3E, 0x40,
  0x20, 0x08, 0x02, 0x01, 0x00, 0xC7, 0xC0, 0x80, 0x20, 0x40, 0x00, 0x16,
  0xA0, 0x00, 0xC0, 0xC1, 0xC0, 0x80, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0xC0, 0x0C, 0x00, 0xE0,
  0x04, 0x00, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x00, 0xFC, 0x04, 0x08, 0x10,
  0x20, 0x41, 0x0C, 0x20, 0x40, 0x80, 0x00, 0x00, 0x08, 0x00, 0x03, 0xF0,
  0x0C, 0x0C, 0x10, 0x02, 0x20, 0x02, 0x41, 0xE1, 0x42, 0x11, 0x84, 0x11,
  0x88, 0x11, 0x88, 0x11, 0x88, 0x11, 0x88, 0x21, 0x84, 0x52, 0x43, 0x8C,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x08, 0x0F, 0xF0, 0x02, 0x00, 0x60, 0x05,
  0x00, 0x90, 0x09, 0x00, 0x88, 0x10, 0x81, 0x04, 0x20, 0x43, 0xFC, 0x20,
  0x24, 0x02, 0x40, 0x24, 0x01, 0x80, 0x10, 0xFF, 0x20, 0x28, 0x0A, 0x01,
  0x80, 0xA0, 0x28, 0x13, 0xFC, 0x80, 0xA0, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x2F, 0xF0, 0x0F, 0xE2, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x60, 0x03, 0xF8, 0xFE,
  0x10, 0x32, 0x01, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x05, 0x03, 0x3F, 0x80, 0xFF, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xFF,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x0F, 0xF1, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x08, 0x1E, 0x80, 0x18, 0x01, 0x40, 0x14, 0x01, 0x20, 0x11, 0x01, 0x0F,
  0xF0, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0F, 0xFF,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0xF2, 0x22,
  0x22, 0x22, 0x22, 0x22, 0x22, 0xF0, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0xB8, 0x80, 0xE0, 0x48, 0x22, 0x10, 0x88,
  0x24, 0x0B, 0x03, 0x40, 0x88, 0x21, 0x08, 0x22, 0x08, 0x81, 0x20, 0x28,
  0x04, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0xFF, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0x68, 0x05, 0xA0,
  0x16, 0x40, 0x99, 0x02, 0x64, 0x11, 0x88, 0x46, 0x21, 0x18, 0x48, 0x61,
  0x21, 0x83, 0x06, 0x0C, 0x18, 0x20, 0x40, 0x80, 0x38, 0x06, 0x80, 0xD0,
  0x19, 0x03, 0x10, 0x62, 0x0C, 0x21, 0x82, 0x30, 0x46, 0x04, 0xC0, 0x58,
  0x0B, 0x00, 0xE0, 0x08, 0x0F, 0xC0, 0xC0, 0xC2, 0x01, 0x10, 0x02, 0x40,
  0x0A, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x14, 0x00, 0x90,
  0x02, 0x20, 0x10, 0xC0, 0xC0, 0xFC, 0x00, 0xFE, 0x40, 0xA0, 0x30, 0x18,
  0x0C, 0x06, 0x05, 0x06, 0xFC, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00,
  0x0F, 0xC0, 0xC0, 0xC2, 0x01, 0x10, 0x02, 0x40, 0x0A, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x14, 0x00, 0x90, 0x02, 0x20, 0x10, 0xC0,
  0xC0, 0xFC, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0xFE, 0x20,
  0x48, 0x0A, 0x02, 0x80, 0xA0, 0x28, 0x12, 0x18, 0xFC, 0x20, 0x88, 0x22,
  0x04, 0x81, 0x20, 0x28, 0x0C, 0x3F, 0xA0, 0x20, 0x10, 0x08, 0x02, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x40, 0x20, 0x10, 0x08, 0x0F, 0xF8, 0xFF, 0xE0,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x02, 0x80, 0x8F, 0xE0, 0x80, 0x18, 0x02, 0x40, 0x24, 0x02, 0x20, 0x42,
  0x04, 0x20, 0x41, 0x08, 0x10, 0x81, 0x08, 0x09, 0x00, 0x90, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x80, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x50, 0x28, 0x24,
  0x24, 0x12, 0x12, 0x11, 0x08, 0x88, 0x44, 0x44, 0x24, 0x22, 0x12, 0x12,
  0x09, 0x05, 0x02, 0x82, 0x81, 0x81, 0x40, 0xC0, 0x40, 0x20, 0x20, 0xC0,
  0x68, 0x08, 0x82, 0x08, 0x81, 0x10, 0x14, 0x01, 0x00, 0x20, 0x0A, 0x02,
  0x20, 0x44, 0x10, 0x42, 0x08, 0x80, 0xA0, 0x08, 0x80, 0x28, 0x09, 0x01,
  0x10, 0x42, 0x10, 0x22, 0x04, 0x80, 0x50, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0xFF, 0xC0, 0x20, 0x08, 0x04, 0x02, 0x00,
  0x80, 0x40, 0x20, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x0F, 0xFC,
  0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x8F, 0x80, 0x81, 0x02,
  0x02, 0x04, 0x04, 0x08, 0x10, 0x10, 0x20, 0x40, 0x40, 0x80, 0x80, 0xF1,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x0C, 0x03, 0x01, 0x20,
  0x48, 0x21, 0x08, 0x44, 0x09, 0x02, 0x80, 0x40, 0xFF, 0x84, 0x30, 0x7E,
  0x01, 0x01, 0x01, 0x03, 0x3D, 0x41, 0x81, 0x81, 0x83, 0x7D, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x05, 0xF3, 0x05, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x07, 0x05, 0x7C, 0x1F, 0x60, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x40, 0x60, 0x1F, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x4F, 0xD4, 0x0D,
  0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x50, 0x34, 0x14, 0xF9, 0x3F,
  0x20, 0x90, 0x30, 0x18, 0x0F, 0xFA, 0x01, 0x00, 0x40, 0x20, 0x0F, 0xE0,
  0x1E, 0x20, 0x81, 0x02, 0x1F, 0x88, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x3F, 0x50, 0x34, 0x0E, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x40, 0xD0, 0x53, 0xE4, 0x01, 0x00, 0x40, 0x28, 0x09, 0xFC, 0x80, 0x80,
  0x80, 0x80, 0x80, 0xBE, 0xC1, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x8F, 0xFE, 0x10, 0x00, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x1E, 0x80, 0x80, 0x80, 0x80, 0x81, 0x82, 0x84, 0x88, 0x90, 0xA0,
  0xD0, 0x88, 0x88, 0x84, 0x82, 0x81, 0xFF, 0xFF, 0xBE, 0xFD, 0x86, 0x0A,
  0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x60, 0x40, 0xC0, 0x81, 0x81,
  0x03, 0x02, 0x06, 0x04, 0x08, 0xBE, 0xC1, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x3F, 0x10, 0x24, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x40, 0x90, 0x23, 0xF0, 0xBE, 0x60, 0xA0, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xE0, 0xAF, 0x90, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x3F, 0xA0, 0x50, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x40, 0xA0, 0xCF,
  0xA0, 0x10, 0x08, 0x04, 0x02, 0x01, 0xBF, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x00, 0x7E, 0x80, 0x80, 0x80, 0x60, 0x1C, 0x02, 0x01, 0x01,
  0x02, 0xFC, 0x20, 0x82, 0x3F, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x70, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x83, 0x7D,
  0x80, 0xA0, 0x50, 0x48, 0x22, 0x11, 0x10, 0x88, 0x24, 0x14, 0x06, 0x02,
  0x00, 0x81, 0x06, 0x82, 0x09, 0x0A, 0x12, 0x14, 0x22, 0x28, 0x84, 0x89,
  0x09, 0x12, 0x12, 0x24, 0x18, 0x30, 0x30, 0x60, 0x40, 0x40, 0x40, 0x88,
  0x41, 0x10, 0x48, 0x0C, 0x03, 0x00, 0xC0, 0x48, 0x21, 0x08, 0x2C, 0x0C,
  0x80, 0xA0, 0x50, 0x48, 0x22, 0x11, 0x10, 0x88, 0x24, 0x14, 0x06, 0x02,
  0x01, 0x00, 0x80, 0x80, 0x41, 0xC0, 0xFF, 0x02, 0x04, 0x04, 0x08, 0x10,
  0x10, 0x20, 0x40, 0x80, 0xFF, 0x1C, 0x82, 0x08, 0x20, 0x82, 0x08, 0x43,
  0x02, 0x08, 0x20, 0x82, 0x08, 0x20, 0x70, 0xFF, 0xFF, 0xF8, 0xC0, 0x82,
  0x08, 0x20, 0x82, 0x04, 0x10, 0x71, 0x08, 0x20, 0x82, 0x08, 0x23, 0x00,
  0xFC, 0x40, 0xE0,
};

const GFXglyph NotoSans_ExtraLight21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 15, 5, 2, -15 },
  { 3, 5, 5, 7, 1, -15 },
  { 7, 12, 15, 14, 1, -15 },
  { 30, 9, 17, 12, 1, -16 },
  { 50, 15, 15, 17, 1, -15 },
  { 79, 13, 15, 15, 1, -15 },
  { 104, 1, 5, 4, 1, -15 },
  { 105, 4, 18, 6, 1, -15 },
  { 114, 4, 18, 6, 1, -15 },
  { 123, 9, 9, 12, 1, -16 },
  { 134, 10, 9, 12, 1, -12 },
  { 146, 2, 5, 4, 1, -2 },
  { 148, 5, 1, 7, 1, -6 },
  { 149, 1, 1, 5, 2, -1 },
  { 150, 7, 15, 7, 0, -15 },
  { 164, 10, 15, 12, 1, -15 },
  { 183, 5, 15, 12, 2, -15 },
  { 193, 9, 15, 12, 1, -15 },
  { 210, 9, 15, 12, 1, -15 },
  { 227, 12, 15, 12, 0, -15 },
  { 250, 9, 15, 12, 2, -15 },
  { 267, 10, 15, 12, 1, -15 },
  { 286, 10, 15, 12, 1, -15 },
  { 305, 10, 15, 12, 1, -15 },
  { 324, 10, 15, 12, 1, -15 },
  { 343, 1, 11, 5, 2, -11 },
  { 345, 2, 14, 5, 1, -11 },
  { 349, 10, 9, 12, 1, -12 },
  { 361, 10, 5, 12, 1, -10 },
  { 368, 10, 9, 12, 1, -12 },
  { 380, 7, 15, 9, 1, -15 },
  { 394, 16, 17, 19, 1, -15 },
  { 428, 12, 15, 12, 0, -15 },
  { 451, 10, 15, 13, 2, -15 },
  { 470, 11, 15, 13, 1, -15 },
  { 491, 11, 15, 15, 2, -15 },
  { 512, 8, 15, 12, 2, -15 },
  { 527, 8, 15, 10, 2, -15 },
  { 542, 12, 15, 15, 1, -15 },
  { 565, 11, 15, 15, 2, -15 },
  { 586, 4, 15, 6, 1, -15 },
  { 594, 5, 19, 5, -2, -15 },
  { 606, 10, 15, 12, 2, -15 },
  { 625, 8, 15, 11, 2, -15 },
  { 640, 14, 15, 18, 2, -15 },
  { 667, 11, 15, 15, 2, -15 },
  { 688, 14, 15, 16, 1, -15 },
  { 715, 9, 15, 12, 2, -15 },
  { 732, 14, 19, 16, 1, -15 },
  { 766, 10, 15, 12, 2, -15 },
  { 785, 9, 15, 11, 1, -15 },
  { 802, 11, 15, 11, 0, -15 },
  { 823, 11, 15, 15, 2, -15 },
  { 844, 12, 15, 12, 0, -15 },
  { 867, 17, 15, 19, 1, -15 },
  { 899, 11, 15, 11, 0, -15 },
  { 920, 11, 15, 11, 0, -15 },
  { 941, 10, 15, 12, 1, -15 },
  { 960, 4, 18, 7, 2, -15 },
  { 969, 7, 15, 7, 0, -15 },
  { 983, 4, 18, 7, 1, -15 },
  { 992, 10, 9, 12, 1, -15 },
  { 1004, 8, 1, 8, 0, 2 },
  { 1005, 4, 3, 5, 1, -16 },
  { 1007, 8, 11, 11, 1, -11 },
  { 1018, 9, 16, 12, 2, -16 },
  { 1036, 8, 11, 10, 1, -11 },
  { 1047, 10, 16, 12, 1, -16 },
  { 1067, 9, 11, 11, 1, -11 },
  { 1080, 7, 16, 6, 0, -16 },
  { 1094, 10, 16, 12, 1, -11 },
  { 1114, 8, 16, 12, 2, -16 },
  { 1130, 1, 15, 5, 2, -15 },
  { 1132, 4, 20, 5, -1, -15 },
  { 1142, 8, 16, 10, 2, -16 },
  { 1158, 1, 16, 5, 2, -16 },
  { 1160, 15, 11, 18, 2, -11 },
  { 1181, 8, 11, 12, 2, -11 },
  { 1192, 10, 11, 12, 1, -11 },
  { 1206, 9, 16, 12, 2, -11 },
  { 1224, 9, 16, 12, 1, -11 },
  { 1242, 6, 11, 8, 2, -11 },
  { 1251, 8, 11, 10, 1, -11 },
  { 1262, 6, 14, 7, 0, -14 },
  { 1273, 8, 11, 12, 2, -11 },
  { 1284, 9, 11, 9, 0, -11 },
  { 1297, 15, 11, 15, 0, -11 },
  { 1318, 10, 11, 10, 0, -11 },
  { 1332, 9, 16, 9, 0, -11 },
  { 1350, 8, 11, 10, 1, -11 },
  { 1361, 6, 18, 7, 1, -15 },
  { 1375, 1, 21, 11, 5, -16 },
  { 1378, 6, 18, 7, 1, -15 },
  { 1392, 10, 2, 12, 1, -8 },
};

const GFXfont NotoSans_ExtraLight21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight21pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_EXTRALIGHT21PT7B_H_
