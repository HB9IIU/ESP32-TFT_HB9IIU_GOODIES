#ifndef _NOTOSANS_EXTRALIGHT26PT7B_H_
#define _NOTOSANS_EXTRALIGHT26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight26pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x55, 0x55, 0x50, 0x3C, 0x8C, 0x63, 0x18, 0xC6, 0x20, 0x02,
  0x08, 0x04, 0x20, 0x10, 0x40, 0x20, 0x80, 0x41, 0x00, 0x82, 0x1F, 0xFF,
  0x84, 0x10, 0x08, 0x20, 0x10, 0x40, 0x20, 0x80, 0x42, 0x0F, 0xFF, 0xC2,
  0x08, 0x04, 0x10, 0x08, 0x20, 0x10, 0x80, 0x21, 0x00, 0x82, 0x00, 0x08,
  0x02, 0x03, 0xF9, 0x21, 0x88, 0x22, 0x08, 0x82, 0x20, 0xC8, 0x1A, 0x01,
  0xC0, 0x2C, 0x08, 0xC2, 0x10, 0x84, 0x21, 0x08, 0x42, 0x3E, 0xB8, 0x70,
  0x08, 0x02, 0x00, 0x1C, 0x02, 0x09, 0x81, 0x04, 0x20, 0x41, 0x04, 0x20,
  0x41, 0x08, 0x20, 0x44, 0x08, 0x11, 0x01, 0x04, 0x80, 0x42, 0x2F, 0x90,
  0x92, 0x12, 0x69, 0x04, 0x62, 0x41, 0x01, 0x10, 0x40, 0x44, 0x10, 0x21,
  0x04, 0x08, 0x41, 0x04, 0x10, 0x41, 0x02, 0x30, 0x80, 0x78, 0x0F, 0x00,
  0x30, 0x80, 0x20, 0x40, 0x20, 0x40, 0x20, 0x40, 0x20, 0x40, 0x20, 0x80,
  0x11, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x62, 0x02, 0xC1, 0x02, 0x80, 0x84,
  0x80, 0x44, 0x80, 0x28, 0x80, 0x18, 0x80, 0x38, 0x40, 0x64, 0x3F, 0x83,
  0xFE, 0x08, 0x88, 0x44, 0x21, 0x08, 0x84, 0x21, 0x08, 0x42, 0x10, 0x42,
  0x10, 0x42, 0x08, 0x60, 0x82, 0x10, 0x42, 0x08, 0x42, 0x08, 0x42, 0x10,
  0x84, 0x22, 0x10, 0x84, 0x42, 0x23, 0x00, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x0C, 0x4E, 0x76, 0x03, 0x00, 0x90, 0x12, 0x04, 0x21, 0x82, 0x00, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x0F, 0xFF, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x69, 0x29, 0x00, 0xFC, 0xF0, 0x01, 0x01,
  0x03, 0x02, 0x02, 0x04, 0x04, 0x04, 0x08, 0x08, 0x18, 0x10, 0x10, 0x20,
  0x20, 0x20, 0x40, 0x40, 0xC0, 0x1F, 0x04, 0x31, 0x01, 0x20, 0x28, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x02, 0x40, 0x44, 0x10, 0x7C, 0x00, 0x04, 0x72, 0x71, 0x84,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x40, 0x0F,
  0x03, 0x0C, 0x40, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x40, 0x0C, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0xFF, 0xF0, 0x0F, 0x07, 0x0C, 0xC0, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x04, 0x01, 0x81, 0xF8, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x28, 0x06, 0x7F, 0x80, 0x00, 0x40, 0x03,
  0x00, 0x0C, 0x00, 0x50, 0x02, 0x40, 0x11, 0x00, 0x44, 0x02, 0x10, 0x10,
  0x40, 0xC1, 0x02, 0x04, 0x10, 0x10, 0x80, 0x43, 0xFF, 0xF0, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x7F, 0xC8, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xFF, 0x00, 0x18, 0x01, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x50, 0x1B, 0xFC, 0x00, 0x07, 0xC3,
  0x00, 0x80, 0x30, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0xBF, 0x9C, 0x0B,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0E, 0x01, 0x40, 0x64, 0x08, 0x7E,
  0x00, 0xFF, 0xF0, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x06, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x18, 0x00, 0x1E, 0x0C, 0x11, 0x01, 0x40, 0x28,
  0x03, 0x00, 0x90, 0x13, 0x04, 0x1B, 0x03, 0xC0, 0x86, 0x20, 0x28, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x28, 0x08, 0xFE, 0x00, 0x0F, 0x03, 0x0C,
  0x60, 0x64, 0x02, 0x40, 0x38, 0x01, 0x80, 0x18, 0x01, 0x40, 0x14, 0x03,
  0x30, 0xD1, 0xF1, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08,
  0x7F, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x6C, 0x00, 0x00, 0x00, 0x34, 0x94,
  0x80, 0x00, 0x10, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60,
  0x01, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x08, 0x00, 0x3C, 0x61,
  0x80, 0x40, 0x10, 0x08, 0x04, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x01,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x03, 0xFF, 0x00, 0x20,
  0x04, 0x06, 0x00, 0x10, 0x20, 0x00, 0x42, 0x00, 0x01, 0x20, 0x7F, 0x09,
  0x04, 0x08, 0x48, 0x60, 0x42, 0x82, 0x02, 0x0C, 0x10, 0x10, 0x60, 0x81,
  0x05, 0x04, 0x08, 0x28, 0x20, 0x41, 0x21, 0x85, 0x11, 0x07, 0xCF, 0x88,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0E, 0x3C,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x03, 0x00, 0x0A, 0x00, 0x14, 0x00,
  0x24, 0x00, 0x88, 0x01, 0x08, 0x02, 0x10, 0x08, 0x20, 0x10, 0x20, 0x40,
  0x40, 0xFF, 0x81, 0x00, 0x84, 0x01, 0x08, 0x01, 0x20, 0x02, 0x40, 0x04,
  0x80, 0x06, 0x00, 0x08, 0xF8, 0x08, 0x3C, 0x80, 0x68, 0x02, 0x80, 0x28,
  0x02, 0x80, 0x28, 0x04, 0x81, 0x8F, 0xF8, 0x80, 0x48, 0x02, 0x80, 0x38,
  0x01, 0x80, 0x18, 0x02, 0x80, 0x28, 0x0C, 0xFF, 0x00, 0x03, 0xE0, 0x60,
  0xCC, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x03, 0xFE, 0xF8, 0x02, 0x0F, 0x08, 0x06, 0x20, 0x04, 0x80,
  0x12, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x38, 0x00, 0xA0,
  0x02, 0x80, 0x0A, 0x00, 0x28, 0x01, 0xA0, 0x04, 0x80, 0x22, 0x03, 0x0F,
  0xF0, 0x00, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x3F, 0xE8, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x0F, 0xFC, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x0F, 0xFA, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x00, 0x03, 0xF0, 0x18, 0x18, 0x40, 0x01, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x03, 0xFC, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0xA0, 0x01, 0x20, 0x02, 0x30, 0x04,
  0x3F, 0xF0, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0xF9, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x3E, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x0C, 0x2B, 0xB8, 0x80, 0x38, 0x06, 0x80, 0xC8, 0x18, 0x83, 0x08, 0x60,
  0x8C, 0x09, 0x80, 0xB0, 0x0E, 0x80, 0xCC, 0x08, 0x40, 0x82, 0x08, 0x10,
  0x81, 0x88, 0x08, 0x80, 0x48, 0x06, 0x80, 0x30, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0F, 0xFC, 0x80, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xA0, 0x05, 0xA0, 0x05, 0x90, 0x0D, 0x90, 0x09,
  0x90, 0x09, 0x88, 0x11, 0x88, 0x11, 0x84, 0x21, 0x84, 0x21, 0x84, 0x21,
  0x82, 0x41, 0x82, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x80, 0x0C,
  0x00, 0x70, 0x03, 0xC0, 0x1A, 0x00, 0xC8, 0x06, 0x60, 0x31, 0x01, 0x84,
  0x0C, 0x30, 0x60, 0x83, 0x02, 0x18, 0x18, 0xC0, 0x46, 0x01, 0x30, 0x05,
  0x80, 0x2C, 0x00, 0xE0, 0x02, 0x07, 0xE0, 0x18, 0x38, 0x30, 0x0C, 0x40,
  0x06, 0x40, 0x02, 0x80, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x02, 0x40,
  0x02, 0x20, 0x04, 0x10, 0x18, 0x0F, 0xF0, 0xFC, 0x10, 0xF2, 0x03, 0x40,
  0x28, 0x07, 0x00, 0x60, 0x1C, 0x02, 0x80, 0x50, 0x13, 0xFC, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x00, 0x07, 0xE0,
  0x18, 0x38, 0x30, 0x0C, 0x40, 0x06, 0x40, 0x02, 0x80, 0x02, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x03, 0xC0, 0x02, 0x40, 0x02, 0x20, 0x04, 0x10, 0x18, 0x0F, 0xF0,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0xFC, 0x08, 0x78, 0x80,
  0xC8, 0x04, 0x80, 0x68, 0x02, 0x80, 0x68, 0x04, 0x80, 0xC8, 0x18, 0xFE,
  0x08, 0x20, 0x83, 0x08, 0x10, 0x80, 0x88, 0x08, 0x80, 0x48, 0x06, 0x80,
  0x30, 0x0F, 0x83, 0x06, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x06,
  0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x28, 0x06, 0xFF, 0x80, 0xFF, 0xF8, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x07,
  0x00, 0x14, 0x00, 0x50, 0x01, 0x60, 0x08, 0xC0, 0x40, 0xFE, 0x00, 0x80,
  0x03, 0x00, 0x09, 0x00, 0x12, 0x00, 0x22, 0x00, 0x84, 0x01, 0x08, 0x06,
  0x08, 0x08, 0x10, 0x10, 0x20, 0x40, 0x20, 0x80, 0x41, 0x00, 0xC4, 0x00,
  0x88, 0x01, 0x10, 0x01, 0x40, 0x02, 0x80, 0x06, 0x00, 0x04, 0x00, 0x80,
  0x20, 0x0C, 0x01, 0x00, 0x60, 0x14, 0x02, 0x80, 0xA0, 0x24, 0x05, 0x01,
  0x20, 0x48, 0x09, 0x02, 0x20, 0xC4, 0x11, 0x04, 0x20, 0x88, 0x21, 0x08,
  0x41, 0x0C, 0x41, 0x10, 0x22, 0x08, 0x81, 0x10, 0x44, 0x09, 0x01, 0x20,
  0x28, 0x0A, 0x01, 0x40, 0x50, 0x0C, 0x02, 0x80, 0x60, 0x0C, 0x01, 0x00,
  0x40, 0x40, 0x09, 0x00, 0x62, 0x01, 0x0C, 0x08, 0x10, 0x60, 0x21, 0x00,
  0xC8, 0x01, 0x20, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x20, 0x08, 0xC0,
  0x21, 0x01, 0x02, 0x08, 0x08, 0x20, 0x11, 0x00, 0x28, 0x00, 0xC0, 0x80,
  0x0A, 0x00, 0x50, 0x04, 0x40, 0x22, 0x02, 0x08, 0x10, 0x41, 0x01, 0x08,
  0x08, 0x80, 0x2C, 0x01, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x7F, 0xF8, 0x00, 0x80, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x18, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x06, 0x00, 0x3F,
  0xFE, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x0F, 0xC0, 0x80, 0x40, 0x40, 0x40, 0x20,
  0x20, 0x10, 0x10, 0x10, 0x08, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x02,
  0x01, 0x01, 0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x87, 0xE0, 0x02, 0x00, 0x18, 0x01, 0x40, 0x11, 0x00,
  0x88, 0x08, 0x20, 0x41, 0x04, 0x0C, 0x20, 0x22, 0x00, 0x90, 0x05, 0x00,
  0x30, 0xFF, 0xE0, 0xC2, 0x08, 0x30, 0x1F, 0x08, 0x30, 0x04, 0x01, 0x00,
  0x40, 0x10, 0xFC, 0xC1, 0x40, 0x60, 0x18, 0x06, 0x01, 0x40, 0xCF, 0xD0,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x8F, 0x8B, 0x04,
  0xA0, 0x2C, 0x02, 0xC0, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03,
  0xC0, 0x2C, 0x02, 0xA0, 0x49, 0xF8, 0x1F, 0x8C, 0x14, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x60, 0x07, 0xE0,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x47, 0xCB, 0x05, 0x40,
  0x70, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x38,
  0x0D, 0x02, 0x9F, 0x90, 0x1F, 0x04, 0x11, 0x01, 0x40, 0x28, 0x05, 0x00,
  0x7F, 0xFC, 0x00, 0x80, 0x10, 0x02, 0x00, 0x60, 0x06, 0x04, 0x7F, 0x80,
  0x07, 0x84, 0x04, 0x02, 0x01, 0x00, 0x83, 0xF8, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x1F,
  0x2C, 0x15, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xE0, 0x34, 0x0A, 0x7E, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0A,
  0x03, 0x3F, 0xC0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x23,
  0xE5, 0x86, 0xC0, 0x78, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0xB0, 0x2A, 0xAA, 0xAA, 0xA8,
  0x10, 0xC0, 0x00, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0xE0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x0E, 0x06, 0x83, 0x20, 0x88, 0x42, 0x20, 0x98, 0x2A, 0x0C, 0x42, 0x08,
  0x83, 0x20, 0x48, 0x0A, 0x01, 0xFF, 0xFF, 0xF0, 0x9F, 0x0F, 0xA8, 0x2C,
  0x3C, 0x0E, 0x07, 0x01, 0x01, 0x80, 0x40, 0x60, 0x10, 0x18, 0x04, 0x06,
  0x01, 0x01, 0x80, 0x40, 0x60, 0x10, 0x18, 0x04, 0x06, 0x01, 0x01, 0x80,
  0x40, 0x60, 0x10, 0x10, 0x8F, 0x96, 0x1B, 0x01, 0xE0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40,
  0x1F, 0x06, 0x0C, 0x40, 0x48, 0x02, 0x80, 0x28, 0x02, 0x80, 0x18, 0x03,
  0x80, 0x38, 0x02, 0x80, 0x24, 0x06, 0x60, 0xC3, 0xF8, 0x8F, 0x8B, 0x04,
  0xA0, 0x2C, 0x02, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x03,
  0xC0, 0x2C, 0x02, 0xA0, 0x49, 0xF8, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x0F, 0x93, 0x05, 0x20, 0x34, 0x03, 0x40, 0x14, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x14, 0x01, 0x40, 0x34, 0x03, 0x20, 0x51, 0xF9,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x9F, 0xA0, 0xC0,
  0xC0, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x3F,
  0x90, 0x24, 0x02, 0x00, 0x40, 0x18, 0x01, 0x80, 0x1C, 0x00, 0x80, 0x10,
  0x04, 0x01, 0x80, 0xBF, 0xC0, 0x20, 0x20, 0x20, 0xFF, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x10, 0x1F, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x01, 0xE0, 0x34, 0x0A, 0x7E, 0x40, 0x80, 0x3C, 0x02, 0x40, 0x24, 0x04,
  0x20, 0x42, 0x04, 0x20, 0x81, 0x08, 0x11, 0x00, 0x90, 0x09, 0x00, 0xA0,
  0x06, 0x00, 0x60, 0xC0, 0x40, 0x50, 0x30, 0x14, 0x0A, 0x09, 0x02, 0x82,
  0x21, 0x20, 0x88, 0x44, 0x22, 0x11, 0x10, 0x88, 0x44, 0x12, 0x11, 0x04,
  0x82, 0x81, 0x60, 0xA0, 0x30, 0x28, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x80,
  0x68, 0x08, 0x82, 0x10, 0x81, 0x30, 0x14, 0x03, 0x00, 0x60, 0x0A, 0x02,
  0x20, 0x86, 0x30, 0x44, 0x05, 0x00, 0xC0, 0x80, 0x3C, 0x02, 0x40, 0x24,
  0x04, 0x20, 0x42, 0x04, 0x20, 0x81, 0x08, 0x11, 0x00, 0x90, 0x09, 0x00,
  0xA0, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x0F,
  0x00, 0x7F, 0xC0, 0x20, 0x08, 0x04, 0x02, 0x01, 0x80, 0x40, 0x20, 0x18,
  0x04, 0x02, 0x01, 0x00, 0x40, 0x3F, 0xF0, 0x02, 0x18, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x60, 0x86, 0x06, 0x04, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0xC0, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x20, 0x30, 0xC1, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x38, 0x00, 0x7E, 0x18, 0x1F,
};

const GFXglyph NotoSans_ExtraLight26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 19, 6, 2, -19 },
  { 6, 5, 7, 9, 2, -19 },
  { 11, 15, 19, 17, 1, -19 },
  { 47, 10, 22, 15, 2, -20 },
  { 75, 18, 19, 21, 1, -19 },
  { 118, 16, 19, 18, 2, -19 },
  { 156, 1, 7, 5, 2, -19 },
  { 157, 5, 23, 7, 1, -19 },
  { 172, 5, 23, 7, 1, -19 },
  { 187, 11, 11, 14, 2, -20 },
  { 203, 12, 12, 15, 1, -15 },
  { 221, 3, 6, 5, 1, -3 },
  { 224, 6, 1, 8, 1, -8 },
  { 225, 2, 2, 6, 2, -2 },
  { 226, 8, 19, 9, 0, -19 },
  { 245, 11, 19, 15, 2, -19 },
  { 272, 6, 19, 15, 3, -19 },
  { 287, 12, 19, 15, 1, -19 },
  { 316, 12, 19, 15, 1, -19 },
  { 345, 14, 19, 15, 1, -19 },
  { 379, 11, 19, 15, 2, -19 },
  { 406, 11, 19, 15, 2, -19 },
  { 433, 12, 19, 15, 1, -19 },
  { 462, 11, 19, 15, 2, -19 },
  { 489, 12, 19, 15, 1, -19 },
  { 518, 2, 14, 6, 2, -14 },
  { 522, 3, 17, 6, 1, -14 },
  { 529, 12, 12, 15, 1, -15 },
  { 547, 12, 6, 15, 1, -12 },
  { 556, 12, 12, 15, 1, -15 },
  { 574, 9, 19, 11, 1, -19 },
  { 596, 21, 21, 23, 1, -18 },
  { 652, 15, 19, 15, 0, -19 },
  { 688, 12, 19, 16, 3, -19 },
  { 717, 13, 19, 16, 2, -19 },
  { 748, 14, 19, 18, 3, -19 },
  { 782, 10, 19, 14, 3, -19 },
  { 806, 10, 19, 13, 3, -19 },
  { 830, 15, 19, 19, 2, -19 },
  { 866, 13, 19, 19, 3, -19 },
  { 897, 5, 19, 8, 1, -19 },
  { 909, 6, 24, 6, -2, -19 },
  { 927, 12, 19, 15, 3, -19 },
  { 956, 10, 19, 13, 3, -19 },
  { 980, 16, 19, 22, 3, -19 },
  { 1018, 13, 19, 18, 3, -19 },
  { 1049, 16, 19, 20, 2, -19 },
  { 1087, 11, 19, 15, 3, -19 },
  { 1114, 16, 23, 20, 2, -19 },
  { 1160, 12, 19, 15, 3, -19 },
  { 1189, 12, 19, 14, 1, -19 },
  { 1218, 13, 19, 13, 0, -19 },
  { 1249, 14, 19, 19, 2, -19 },
  { 1283, 15, 19, 15, 0, -19 },
  { 1319, 21, 19, 23, 1, -19 },
  { 1369, 14, 19, 14, 0, -19 },
  { 1403, 13, 19, 13, 0, -19 },
  { 1434, 13, 19, 15, 1, -19 },
  { 1465, 6, 23, 8, 2, -19 },
  { 1483, 8, 19, 9, 0, -19 },
  { 1502, 5, 23, 8, 1, -19 },
  { 1517, 13, 12, 15, 1, -19 },
  { 1537, 11, 1, 10, 0, 2 },
  { 1539, 5, 4, 7, 1, -20 },
  { 1542, 10, 14, 14, 1, -14 },
  { 1560, 12, 20, 15, 2, -20 },
  { 1590, 10, 14, 12, 2, -14 },
  { 1608, 11, 20, 15, 2, -20 },
  { 1636, 11, 14, 14, 2, -14 },
  { 1656, 9, 20, 7, 0, -20 },
  { 1679, 11, 20, 15, 2, -14 },
  { 1707, 11, 20, 15, 2, -20 },
  { 1735, 2, 19, 6, 2, -19 },
  { 1740, 5, 25, 6, -1, -19 },
  { 1756, 10, 20, 12, 2, -20 },
  { 1781, 1, 20, 6, 2, -20 },
  { 1784, 18, 14, 23, 2, -14 },
  { 1816, 11, 14, 15, 2, -14 },
  { 1836, 12, 14, 15, 2, -14 },
  { 1857, 12, 20, 15, 2, -14 },
  { 1887, 12, 20, 15, 1, -14 },
  { 1917, 8, 14, 10, 2, -14 },
  { 1931, 10, 14, 12, 1, -14 },
  { 1949, 8, 17, 9, 0, -17 },
  { 1966, 11, 14, 15, 2, -14 },
  { 1986, 12, 14, 12, 0, -14 },
  { 2007, 18, 14, 18, 0, -14 },
  { 2039, 11, 14, 13, 1, -14 },
  { 2059, 12, 20, 12, 0, -14 },
  { 2089, 10, 14, 12, 1, -14 },
  { 2107, 7, 23, 9, 1, -19 },
  { 2128, 1, 26, 14, 6, -20 },
  { 2132, 7, 23, 9, 1, -19 },
  { 2153, 12, 2, 15, 1, -10 },
};

const GFXfont NotoSans_ExtraLight26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight26pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_EXTRALIGHT26PT7B_H_
