#ifndef _NOTOSANS_EXTRALIGHT64PT7B_H_
#define _NOTOSANS_EXTRALIGHT64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight64pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0x00,
  0x00, 0x00, 0x00, 0x1D, 0xEF, 0xB8, 0x80, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x30, 0x00, 0x01, 0x80,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x03, 0x80, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x60, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x01,
  0xC0, 0x07, 0x00, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x07, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x60, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x60, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0xF8, 0x60, 0x7C, 0x3C, 0x0C, 0x01, 0x07, 0x01, 0x80, 0x01, 0xC0, 0x30,
  0x00, 0x30, 0x06, 0x00, 0x0E, 0x00, 0xC0, 0x01, 0xC0, 0x18, 0x00, 0x38,
  0x03, 0x00, 0x07, 0x00, 0x60, 0x00, 0xE0, 0x0C, 0x00, 0x1C, 0x01, 0x80,
  0x01, 0x80, 0x30, 0x00, 0x38, 0x06, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x78,
  0x18, 0x00, 0x07, 0xC3, 0x00, 0x00, 0x3E, 0x60, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xC7, 0xC0, 0x00, 0x18, 0x3C, 0x00, 0x03, 0x01, 0xE0, 0x00, 0x60, 0x1C,
  0x00, 0x0C, 0x01, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x30, 0x03, 0x00, 0x06,
  0x00, 0x70, 0x00, 0xC0, 0x0E, 0x00, 0x18, 0x01, 0xC0, 0x03, 0x00, 0x38,
  0x00, 0x60, 0x06, 0x00, 0x0C, 0x01, 0xC0, 0x01, 0x80, 0x38, 0x00, 0x30,
  0x0E, 0x40, 0x06, 0x03, 0x8F, 0x00, 0xC1, 0xE1, 0xFF, 0xDF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x70, 0x01, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x1C, 0x1E,
  0x00, 0x00, 0xC0, 0x03, 0x80, 0x60, 0x00, 0x1C, 0x00, 0x70, 0x07, 0x00,
  0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0x38, 0x00, 0x60, 0x03, 0x80, 0x03,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x1C, 0x00, 0x0C,
  0x00, 0x18, 0x01, 0x80, 0x00, 0xC0, 0x01, 0x80, 0x38, 0x00, 0x0C, 0x00,
  0x18, 0x03, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x70, 0x00, 0x0C, 0x00, 0x18,
  0x06, 0x00, 0x00, 0xC0, 0x01, 0x80, 0xE0, 0x00, 0x0C, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0xC0, 0x01, 0x81, 0x80, 0xFC, 0x0C, 0x00, 0x18, 0x38, 0x3F,
  0xF0, 0xE0, 0x03, 0x83, 0x07, 0x87, 0x86, 0x00, 0x38, 0x70, 0xE0, 0x38,
  0x60, 0x03, 0x06, 0x0C, 0x01, 0xC7, 0x00, 0x70, 0xE1, 0xC0, 0x0C, 0x38,
  0x06, 0x0C, 0x18, 0x00, 0xE3, 0xC1, 0xE1, 0xC3, 0x80, 0x0E, 0x1F, 0xFC,
  0x18, 0x38, 0x00, 0x60, 0x7F, 0x03, 0x03, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x30, 0x00, 0x60, 0x00, 0x06, 0x03, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x30,
  0x00, 0x70, 0x00, 0x0C, 0x03, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x30, 0x00,
  0x70, 0x00, 0x18, 0x03, 0x00, 0x07, 0x00, 0x03, 0x80, 0x30, 0x00, 0x70,
  0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xE0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0,
  0x01, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x80, 0x01,
  0xC0, 0x0C, 0x00, 0x30, 0x00, 0x0C, 0x01, 0xC0, 0x07, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x60, 0x00, 0x07, 0xDF, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00,
  0x00, 0x70, 0xF0, 0x00, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x00, 0x03, 0xE3, 0x80, 0x00, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x38,
  0x00, 0x18, 0x70, 0x00, 0x1C, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x00, 0x38,
  0xE0, 0x00, 0x07, 0x00, 0x30, 0xE0, 0x00, 0x03, 0x80, 0x70, 0xE0, 0x00,
  0x01, 0xC0, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0xC0, 0x00, 0x00, 0x71,
  0xC0, 0xE0, 0x00, 0x00, 0x39, 0x80, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x00,
  0x1F, 0x80, 0x70, 0x00, 0x00, 0x39, 0xC0, 0x38, 0x00, 0x00, 0xF0, 0xE0,
  0x1E, 0x00, 0x03, 0xE0, 0x70, 0x0F, 0x80, 0x0F, 0x80, 0x38, 0x07, 0xFF,
  0xFF, 0x00, 0x1C, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x18,
  0x03, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80,
  0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0x80,
  0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30,
  0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0F, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80,
  0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x18,
  0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x80, 0x07, 0xC0, 0x10, 0x07, 0xFF, 0x02, 0x07, 0xF3, 0xFC,
  0x47, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x06, 0x30, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x0E, 0x00,
  0x1C, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x08, 0x00,
  0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x1C, 0x70, 0xE1, 0xC3, 0x86, 0x1C, 0x38, 0x70,
  0xC1, 0x86, 0x0C, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x77,
  0xBE, 0xE2, 0x00, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xF0, 0x0F, 0x80, 0x0E, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x38, 0x0E,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x18, 0x38, 0x00,
  0x00, 0xE1, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0xDC,
  0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x37, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x03, 0x70, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0xDC, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x73, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x18,
  0xE0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x06, 0x00, 0x3C,
  0x00, 0xF8, 0x07, 0xB0, 0x1E, 0x60, 0x78, 0xC3, 0xC3, 0x8F, 0x07, 0x3C,
  0x0F, 0xE0, 0x1D, 0x80, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0x80, 0x7C, 0x03, 0xC0, 0x01,
  0xE0, 0x70, 0x00, 0x07, 0x02, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0xF0, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x30, 0x00, 0x01, 0xE1, 0xF8, 0x00, 0x3E, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0x30, 0x07, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x07, 0x00, 0x00, 0xE0, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x70, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x07, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x00, 0x70, 0x06, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x07, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x1F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x3B, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x70, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x90, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x78,
  0x7C, 0x00, 0x3E, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0x80,
  0x10, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x07, 0xFE, 0x00, 0xC1,
  0xFF, 0xFC, 0x0E, 0x1E, 0x00, 0xF0, 0x73, 0xC0, 0x01, 0xC3, 0xB8, 0x00,
  0x07, 0x1D, 0x80, 0x00, 0x1C, 0xF8, 0x00, 0x00, 0x67, 0x80, 0x00, 0x03,
  0xBC, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0x60, 0x00,
  0x00, 0x3B, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x73, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x01, 0xE0,
  0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x0D, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x07,
  0xC0, 0x1F, 0x00, 0xF0, 0x00, 0x78, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x30, 0x00,
  0x00, 0xE3, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x18,
  0x1E, 0x00, 0x03, 0x80, 0xF0, 0x00, 0xF0, 0x07, 0xC0, 0x1C, 0x00, 0x1F,
  0x07, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0x0F, 0x80, 0x03, 0xC0, 0x3E, 0x00, 0xF0, 0x00, 0xF0, 0x1E,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x06,
  0x70, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x80, 0xF0,
  0x00, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0E, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xF0, 0x0F, 0x80,
  0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x07, 0x06, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x63, 0x80, 0x00,
  0x03, 0x98, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03,
  0x70, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0x3B, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x03,
  0x63, 0x80, 0x00, 0x33, 0x0E, 0x00, 0x07, 0x18, 0x3C, 0x00, 0xF0, 0xC0,
  0xFF, 0xFF, 0x0E, 0x01, 0xFF, 0xE0, 0x70, 0x00, 0x40, 0x03, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xF0, 0x01, 0xFB, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x77, 0xBF, 0xE6, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xDE,
  0xFB, 0x88, 0x0E, 0x1E, 0x1F, 0x1E, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0x18,
  0x38, 0x38, 0x30, 0x30, 0x70, 0x60, 0x60, 0xE0, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x01, 0xFF, 0xFF, 0x0F, 0xC0, 0x3E, 0x18, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x03, 0x07, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0xE1, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x18, 0xE0, 0x00, 0xF0, 0x01, 0xC0,
  0x06, 0x30, 0x00, 0x78, 0x00, 0x60, 0x01, 0x8C, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x77, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x1D, 0x80, 0x07, 0x00, 0x01,
  0x80, 0x03, 0x60, 0x01, 0x80, 0x00, 0x60, 0x00, 0xD8, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x36, 0x00, 0x30, 0x00, 0x06, 0x00, 0x0D, 0x80, 0x0C, 0x00,
  0x01, 0x80, 0x03, 0xE0, 0x03, 0x00, 0x00, 0x60, 0x00, 0xF8, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x3E, 0x00, 0x30, 0x00, 0x06, 0x00, 0x1F, 0x80, 0x0C,
  0x00, 0x03, 0x80, 0x07, 0xE0, 0x03, 0x00, 0x00, 0xE0, 0x01, 0xB8, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x66, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x19, 0x80,
  0x0E, 0x00, 0x07, 0x80, 0x0E, 0x60, 0x03, 0x80, 0x01, 0xE0, 0x03, 0x18,
  0x00, 0x70, 0x00, 0xDC, 0x01, 0xC7, 0x00, 0x0E, 0x00, 0x63, 0x00, 0xE1,
  0xC0, 0x03, 0xC0, 0x78, 0xE0, 0x70, 0x30, 0x00, 0x3F, 0xF8, 0x1F, 0xF8,
  0x0E, 0x00, 0x07, 0xF8, 0x01, 0xF8, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0xEC, 0x00, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x00, 0x71, 0x80, 0x00, 0x00, 0x01, 0x87, 0x00, 0x00, 0x00,
  0x0E, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x00, 0xC0, 0xE0,
  0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x03, 0x80, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x38, 0x00, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x00, 0x00, 0x70, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0x80, 0x00, 0x3F, 0x0C, 0x00, 0x00,
  0x3C, 0x60, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x1D, 0x80,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x3B, 0x00, 0x00,
  0x01, 0xD8, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x0E,
  0x30, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x0E, 0x0C, 0x00, 0x07, 0xE0, 0x7F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x18, 0x00, 0x0F, 0xE0, 0xC0, 0x00,
  0x07, 0x86, 0x00, 0x00, 0x0F, 0x30, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00,
  0xEC, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0xE6,
  0x00, 0x00, 0x0E, 0x30, 0x00, 0x01, 0xE1, 0x80, 0x00, 0xFE, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xF0, 0x00, 0x06, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x08, 0x01, 0xF8, 0x00,
  0x1E, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x03, 0x00, 0x00, 0xFE, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0x30,
  0x00, 0x00, 0x7C, 0x0C, 0x00, 0x00, 0x07, 0x83, 0x00, 0x00, 0x00, 0xE0,
  0xC0, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x00,
  0xE3, 0x00, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0x0E, 0xC0, 0x00,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0x00, 0x3B, 0x00, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x03, 0x83,
  0x00, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x01, 0xE0, 0x30, 0x00, 0x00, 0xF0,
  0x0C, 0x00, 0x01, 0xF8, 0x03, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0xF8, 0x00, 0x00,
  0xE0, 0x0F, 0x00, 0x00, 0x01, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0x03, 0x70, 0x00,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x00, 0x06,
  0x70, 0x00, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x01, 0x8E, 0x00, 0x00,
  0x00, 0x0C, 0x38, 0x00, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x03, 0x03,
  0x80, 0x00, 0x00, 0x18, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x3E, 0x00, 0x00,
  0x0E, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x20, 0x3C, 0x7F,
  0xF0, 0xFF, 0xC0, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xB0, 0x00,
  0x00, 0x39, 0x80, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x38, 0x60, 0x00, 0x03,
  0x83, 0x00, 0x00, 0x38, 0x18, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x38, 0x06,
  0x00, 0x03, 0x80, 0x30, 0x00, 0x38, 0x01, 0x80, 0x03, 0x80, 0x0C, 0x00,
  0x38, 0x00, 0x60, 0x03, 0x80, 0x03, 0x00, 0x38, 0x00, 0x18, 0x03, 0x80,
  0x00, 0xC0, 0x38, 0x00, 0x06, 0x03, 0x80, 0x00, 0x30, 0x38, 0x00, 0x01,
  0x83, 0x80, 0x00, 0x0C, 0x3E, 0x00, 0x00, 0x63, 0xF8, 0x00, 0x03, 0x39,
  0xC0, 0x00, 0x1B, 0x87, 0x00, 0x00, 0xF8, 0x1C, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x38, 0x03, 0x80, 0x01, 0x80, 0x0E, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x00, 0x07, 0x00, 0x18, 0x00, 0x1C, 0x00, 0xC0,
  0x00, 0xF0, 0x06, 0x00, 0x03, 0x80, 0x30, 0x00, 0x0E, 0x01, 0x80, 0x00,
  0x38, 0x0C, 0x00, 0x01, 0xE0, 0x60, 0x00, 0x07, 0x03, 0x00, 0x00, 0x1C,
  0x18, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x86, 0x00, 0x00, 0x0E, 0x30,
  0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x07, 0x60, 0x00,
  0x00, 0x1C, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xBF, 0x80, 0x00, 0x00, 0x01, 0xDE, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x70, 0x00, 0x00, 0x00, 0x6F, 0x98, 0x00, 0x00, 0x00,
  0x77, 0xCE, 0x00, 0x00, 0x00, 0x33, 0xE7, 0x00, 0x00, 0x00, 0x39, 0xF1,
  0x80, 0x00, 0x00, 0x1C, 0xF8, 0xE0, 0x00, 0x00, 0x0C, 0x7C, 0x30, 0x00,
  0x00, 0x0E, 0x3E, 0x1C, 0x00, 0x00, 0x06, 0x1F, 0x0E, 0x00, 0x00, 0x07,
  0x0F, 0x83, 0x80, 0x00, 0x03, 0x87, 0xC1, 0xC0, 0x00, 0x01, 0x83, 0xE0,
  0x60, 0x00, 0x01, 0xC1, 0xF0, 0x38, 0x00, 0x00, 0xC0, 0xF8, 0x1C, 0x00,
  0x00, 0xE0, 0x7C, 0x07, 0x00, 0x00, 0x60, 0x3E, 0x03, 0x80, 0x00, 0x30,
  0x1F, 0x00, 0xC0, 0x00, 0x38, 0x0F, 0x80, 0x70, 0x00, 0x18, 0x07, 0xC0,
  0x18, 0x00, 0x1C, 0x03, 0xE0, 0x0E, 0x00, 0x0C, 0x01, 0xF0, 0x07, 0x00,
  0x06, 0x00, 0xF8, 0x01, 0x80, 0x07, 0x00, 0x7C, 0x00, 0xE0, 0x03, 0x00,
  0x3E, 0x00, 0x30, 0x03, 0x80, 0x1F, 0x00, 0x1C, 0x01, 0x80, 0x0F, 0x80,
  0x0E, 0x00, 0xC0, 0x07, 0xC0, 0x03, 0x00, 0xE0, 0x03, 0xE0, 0x01, 0xC0,
  0x60, 0x01, 0xF0, 0x00, 0x60, 0x70, 0x00, 0xF8, 0x00, 0x38, 0x30, 0x00,
  0x7C, 0x00, 0x1C, 0x18, 0x00, 0x3E, 0x00, 0x06, 0x1C, 0x00, 0x1F, 0x00,
  0x03, 0x8C, 0x00, 0x0F, 0x80, 0x00, 0xCE, 0x00, 0x07, 0xC0, 0x00, 0x76,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xDC, 0x00, 0x00, 0x07, 0xCE, 0x00, 0x00, 0x07,
  0xCE, 0x00, 0x00, 0x07, 0xC7, 0x00, 0x00, 0x07, 0xC3, 0x80, 0x00, 0x07,
  0xC3, 0x80, 0x00, 0x07, 0xC1, 0xC0, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0x07,
  0xC0, 0xE0, 0x00, 0x07, 0xC0, 0x70, 0x00, 0x07, 0xC0, 0x38, 0x00, 0x07,
  0xC0, 0x38, 0x00, 0x07, 0xC0, 0x1C, 0x00, 0x07, 0xC0, 0x0E, 0x00, 0x07,
  0xC0, 0x0F, 0x00, 0x07, 0xC0, 0x07, 0x00, 0x07, 0xC0, 0x03, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x01, 0xC0, 0x07, 0xC0, 0x00, 0xE0, 0x07,
  0xC0, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x70, 0x07, 0xC0, 0x00, 0x38, 0x07,
  0xC0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x1C, 0x07, 0xC0, 0x00, 0x0E, 0x07,
  0xC0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x07, 0x07, 0xC0, 0x00, 0x03, 0x83,
  0xC0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x00, 0xE3,
  0xC0, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0x3B,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x00,
  0xF0, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC3, 0x00, 0x00,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x00,
  0x1C, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0x00, 0xDC, 0x00, 0x00,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00,
  0x00, 0x00, 0xDC, 0x00, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x60, 0x00, 0x3F, 0x0C, 0x00,
  0x00, 0xF1, 0x80, 0x00, 0x0F, 0x30, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x0E,
  0xC0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x3B, 0x00, 0x00,
  0x07, 0x60, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x39, 0x80, 0x00, 0x0E, 0x30,
  0x00, 0x07, 0x86, 0x00, 0x03, 0xE0, 0xC0, 0x3F, 0xF8, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00,
  0x00, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00,
  0x00, 0x1C, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0x00, 0xDC, 0x00,
  0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x07, 0x80,
  0x00, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x01, 0x80, 0x00, 0x7C, 0x0C, 0x00, 0x00, 0xF0, 0x60, 0x00, 0x03, 0xC3,
  0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x01, 0xC6, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0xCC, 0x00, 0x00,
  0x0E, 0x60, 0x00, 0x00, 0x73, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0xE1, 0x80,
  0x00, 0x07, 0x0C, 0x00, 0x00, 0x70, 0x60, 0x00, 0x07, 0x03, 0x00, 0x00,
  0xF0, 0x18, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x70, 0x03, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x0E, 0x00, 0xC0, 0x00,
  0x38, 0x06, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x07, 0x01, 0x80, 0x00, 0x1C,
  0x0C, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x03, 0x83, 0x00, 0x00, 0x1C, 0x18,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x0E, 0x30, 0x00,
  0x00, 0x39, 0x80, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00,
  0x1C, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0x00, 0x3F, 0x0F,
  0x00, 0x00, 0xE3, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x72, 0x00,
  0x00, 0x3C, 0x78, 0x00, 0x1F, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x06, 0x70,
  0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1D, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x70, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x01, 0x80, 0x00, 0x01, 0x80, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x70, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00,
  0x01, 0x81, 0xC0, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x00,
  0x33, 0x80, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0x0E, 0xC0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x38, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x06, 0x60, 0x00, 0x03, 0x86, 0x00, 0x00, 0x33, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x01, 0x9C, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x1C, 0xE0, 0x00,
  0x06, 0x06, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x70, 0x30, 0x00, 0x06, 0x18,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x18, 0x0E, 0x00, 0x03,
  0x83, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x18, 0x18, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0xC0, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x60, 0x18, 0x00, 0x38, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x01,
  0xC0, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x18,
  0x00, 0xE0, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0x80, 0x03, 0x80,
  0x38, 0x00, 0xC0, 0x1C, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x00, 0xE0, 0x00,
  0x60, 0x0C, 0x00, 0x38, 0x06, 0x00, 0x03, 0x80, 0xE0, 0x00, 0xC0, 0x30,
  0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x80, 0x00, 0x60, 0x30, 0x00, 0x38,
  0x1C, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC0, 0xC0, 0x00, 0x1C, 0x1C, 0x00,
  0x06, 0x0E, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x70, 0x00, 0x03, 0x06,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x06, 0x18, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x31, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x19, 0xC0, 0x00, 0x0E, 0x60, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x01, 0xC0, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x06, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x60, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x0C, 0x1C, 0x00,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x1C, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00,
  0x1C, 0x0C, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x01, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x00, 0x61, 0xC0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x01,
  0x9C, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x38, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x70,
  0x03, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x60, 0x01, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x80, 0x0E,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x07, 0x00, 0x70, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x00, 0x02, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFE,
  0x03, 0xF0, 0x07, 0xC0, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0xC1,
  0xF8, 0x00, 0x63, 0xE0, 0x00, 0x33, 0xC0, 0x00, 0x1B, 0xC0, 0x00, 0x0D,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x6D, 0xC0, 0x00, 0x66, 0xF0, 0x00, 0x73, 0x3C, 0x00, 0xF1, 0x8F, 0xFF,
  0xE0, 0xC1, 0xFF, 0xE0, 0x60, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x07, 0x00,
  0x0C, 0x0F, 0xFF, 0x00, 0xC1, 0xFF, 0xFC, 0x0C, 0x78, 0x01, 0xE0, 0xCE,
  0x00, 0x07, 0x0C, 0xC0, 0x00, 0x38, 0xD8, 0x00, 0x01, 0xCF, 0x00, 0x00,
  0x1C, 0xF0, 0x00, 0x00, 0xCF, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1C, 0xF0,
  0x00, 0x01, 0xCF, 0x80, 0x00, 0x38, 0xDC, 0x00, 0x07, 0x8C, 0xE0, 0x00,
  0xF0, 0xC7, 0x00, 0x3E, 0x0C, 0x3F, 0xFF, 0x80, 0xC0, 0xFF, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFF,
  0x03, 0xE0, 0x03, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x03, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x02, 0x00, 0x30, 0x0F, 0xFF, 0x03, 0x01,
  0xFF, 0xFC, 0x30, 0x7C, 0x01, 0xE3, 0x0F, 0x00, 0x07, 0x31, 0xE0, 0x00,
  0x33, 0x1C, 0x00, 0x01, 0xB3, 0x80, 0x00, 0x1F, 0x70, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x0F, 0x60, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x30, 0x00, 0x00, 0xF3, 0x80, 0x00,
  0x1B, 0x1C, 0x00, 0x03, 0x31, 0xE0, 0x00, 0x73, 0x0F, 0x80, 0x1E, 0x30,
  0x3F, 0xFF, 0xC3, 0x00, 0xFF, 0xF0, 0x30, 0x00, 0xF0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xE0, 0x0F, 0x00,
  0xF0, 0x00, 0xF0, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x0C, 0x30, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x02, 0x07, 0xC0,
  0x03, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0x0E, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x0F, 0xFF, 0x03, 0x03, 0xFF, 0xFC, 0x30, 0x7C, 0x01, 0xE3, 0x0F,
  0x00, 0x07, 0x31, 0xE0, 0x00, 0x3B, 0x1C, 0x00, 0x01, 0xB3, 0x80, 0x00,
  0x0F, 0x30, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x76, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x38,
  0x00, 0x00, 0xB3, 0x80, 0x00, 0x1B, 0x1C, 0x00, 0x03, 0x30, 0xE0, 0x00,
  0x73, 0x07, 0x80, 0x1E, 0x30, 0x3F, 0xFF, 0x87, 0x00, 0xFF, 0xF0, 0x70,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC4, 0x00,
  0x00, 0x3C, 0x30, 0x00, 0x07, 0x83, 0xF0, 0x01, 0xF0, 0x1F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x20, 0x03, 0x03, 0xFF, 0xC0, 0xC1, 0xFF, 0xFC, 0x31,
  0xE0, 0x0F, 0x8C, 0xE0, 0x00, 0xF3, 0x70, 0x00, 0x1C, 0xD8, 0x00, 0x03,
  0xBC, 0x00, 0x00, 0x6F, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x1C, 0x83, 0xCF,
  0xF8, 0xFF, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x70,
  0xC0, 0x00, 0xE0, 0xC0, 0x01, 0xC0, 0xC0, 0x03, 0x80, 0xC0, 0x07, 0x00,
  0xC0, 0x0E, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x38, 0x00,
  0xC0, 0x70, 0x00, 0xC0, 0xE0, 0x00, 0xC1, 0xC0, 0x00, 0xC3, 0xC0, 0x00,
  0xC7, 0xE0, 0x00, 0xCE, 0x70, 0x00, 0xDC, 0x38, 0x00, 0xD8, 0x38, 0x00,
  0xF0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x07, 0x00,
  0xC0, 0x03, 0x80, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0xE0,
  0xC0, 0x00, 0x70, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x1C,
  0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x20,
  0x0C, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0xC3, 0xFF, 0xF0, 0x1F, 0xFF, 0x8C,
  0x70, 0x0F, 0x87, 0x80, 0x3C, 0xCC, 0x00, 0x38, 0xE0, 0x01, 0xED, 0x80,
  0x01, 0xCC, 0x00, 0x0E, 0xF0, 0x00, 0x0D, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x60, 0x00, 0x03, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x60, 0x00, 0x03, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x30,
  0x3F, 0xFC, 0x0C, 0x1F, 0xFF, 0xC3, 0x1E, 0x00, 0xF8, 0xCE, 0x00, 0x0F,
  0x37, 0x00, 0x01, 0xCD, 0x80, 0x00, 0x3B, 0xC0, 0x00, 0x06, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0x80, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x03, 0x98, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x01,
  0x9C, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x01, 0xE0, 0x00, 0xF0, 0x07, 0xC0,
  0x0F, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x0C, 0x07, 0xFF, 0x00, 0xC1, 0xFF, 0xFC, 0x0C,
  0x3C, 0x01, 0xE0, 0xC7, 0x00, 0x07, 0x0C, 0xC0, 0x00, 0x38, 0xD8, 0x00,
  0x01, 0xCD, 0x80, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x0C, 0xF0, 0x00, 0x01, 0xCD, 0x80, 0x00, 0x38, 0xDC, 0x00,
  0x07, 0x8C, 0xE0, 0x00, 0xF0, 0xC7, 0x80, 0x3E, 0x0C, 0x3F, 0xFF, 0xC0,
  0xC0, 0xFF, 0xF0, 0x0C, 0x01, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0F, 0xFF, 0x03, 0x03, 0xFF, 0xF8, 0x30, 0x7C, 0x01, 0xE3, 0x0F, 0x00,
  0x07, 0x31, 0xC0, 0x00, 0x33, 0x38, 0x00, 0x01, 0xB3, 0x80, 0x00, 0x1F,
  0x70, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x60, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x60, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x70, 0x00,
  0x01, 0xB3, 0x80, 0x00, 0x1B, 0x1C, 0x00, 0x03, 0x31, 0xE0, 0x00, 0x67,
  0x0F, 0x80, 0x1C, 0x70, 0x7F, 0xFF, 0x87, 0x01, 0xFF, 0xE0, 0x70, 0x01,
  0xF0, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0xC0, 0xFF, 0xE1, 0xFF, 0xF1, 0xE0, 0x39, 0xC0, 0x0D,
  0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x1E, 0x00, 0x3C, 0x38, 0x00, 0x04, 0x70, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x80, 0x00, 0x1C, 0xF0, 0x00, 0x78, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0x00, 0xF8, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xFF,
  0xC0, 0x3F, 0xF0, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x0F,
  0x70, 0x00, 0x06, 0xCE, 0x00, 0x03, 0xB3, 0xC0, 0x01, 0xCC, 0x78, 0x01,
  0xE3, 0x0F, 0xFF, 0xF0, 0xC0, 0xFF, 0xF0, 0x30, 0x07, 0xC0, 0x00, 0xE0,
  0x00, 0x00, 0x3B, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x07,
  0x03, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0xE0, 0x1C, 0x00, 0x06, 0x00, 0x60, 0x00, 0x70, 0x03, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x0C,
  0x00, 0x0C, 0x00, 0xE0, 0x00, 0x70, 0x06, 0x00, 0x03, 0x80, 0x30, 0x00,
  0x0C, 0x03, 0x80, 0x00, 0x70, 0x18, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x70, 0x60, 0x00, 0x01, 0x87, 0x00, 0x00, 0x0E, 0x30,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x0E, 0xC0, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x1D, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x80, 0x00,
  0x67, 0x00, 0x01, 0xF8, 0x00, 0x0C, 0xE0, 0x00, 0x33, 0x00, 0x03, 0x8C,
  0x00, 0x06, 0x60, 0x00, 0x71, 0xC0, 0x01, 0xCE, 0x00, 0x0C, 0x38, 0x00,
  0x39, 0xC0, 0x03, 0x83, 0x00, 0x06, 0x18, 0x00, 0x70, 0x70, 0x01, 0xC3,
  0x00, 0x0C, 0x0E, 0x00, 0x38, 0x70, 0x01, 0x81, 0xC0, 0x06, 0x06, 0x00,
  0x70, 0x18, 0x01, 0xC0, 0xC0, 0x0E, 0x03, 0x80, 0x38, 0x1C, 0x01, 0x80,
  0x70, 0x06, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x00, 0xC0,
  0x38, 0x07, 0x01, 0xC0, 0x1C, 0x06, 0x00, 0x60, 0x30, 0x01, 0x81, 0xC0,
  0x0C, 0x06, 0x00, 0x30, 0x38, 0x01, 0xC1, 0xC0, 0x07, 0x06, 0x00, 0x18,
  0x30, 0x00, 0xE1, 0xC0, 0x03, 0x06, 0x00, 0x0C, 0x38, 0x00, 0x71, 0xC0,
  0x01, 0x86, 0x00, 0x06, 0x38, 0x00, 0x38, 0xC0, 0x00, 0xC6, 0x00, 0x03,
  0x38, 0x00, 0x1C, 0xC0, 0x00, 0x66, 0x00, 0x03, 0xB8, 0x00, 0x0C, 0xC0,
  0x00, 0x37, 0x00, 0x01, 0xF8, 0x00, 0x06, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x03, 0x81, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80,
  0x38, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x30, 0x01,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x70, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x60, 0xE0, 0x00, 0x07, 0x03, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x70, 0x03, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xC0, 0x03, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x70,
  0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x70, 0x18,
  0x00, 0x01, 0x81, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x60, 0x00,
  0x01, 0x87, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01,
  0x9C, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xC0,
  0x07, 0xF0, 0x03, 0xFC, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x07, 0xC0, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x0F, 0xE0, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x5F, 0xBF, 0x80,
  0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0x40, 0x00, 0x7F, 0xE0,
};

const GFXglyph NotoSans_ExtraLight64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 5, 47, 15, 5, -46 },
  { 31, 12, 17, 22, 5, -46 },
  { 57, 38, 46, 41, 2, -46 },
  { 276, 27, 53, 36, 4, -49 },
  { 455, 44, 47, 51, 4, -46 },
  { 714, 40, 47, 45, 4, -46 },
  { 949, 2, 17, 12, 5, -46 },
  { 954, 12, 56, 17, 3, -46 },
  { 1038, 12, 56, 17, 2, -46 },
  { 1122, 27, 27, 35, 4, -49 },
  { 1214, 30, 29, 36, 3, -37 },
  { 1323, 7, 15, 13, 2, -7 },
  { 1337, 15, 3, 21, 3, -19 },
  { 1343, 5, 5, 15, 5, -4 },
  { 1347, 19, 46, 21, 1, -46 },
  { 1457, 29, 47, 36, 4, -46 },
  { 1628, 15, 46, 36, 6, -46 },
  { 1715, 28, 46, 36, 4, -46 },
  { 1876, 29, 47, 36, 3, -46 },
  { 2047, 34, 46, 36, 2, -46 },
  { 2243, 27, 47, 36, 5, -46 },
  { 2402, 29, 47, 36, 4, -46 },
  { 2573, 29, 46, 36, 4, -46 },
  { 2740, 28, 47, 36, 4, -46 },
  { 2905, 29, 47, 36, 3, -46 },
  { 3076, 5, 35, 15, 5, -34 },
  { 3098, 8, 42, 15, 2, -34 },
  { 3140, 29, 29, 36, 4, -38 },
  { 3246, 29, 15, 36, 4, -30 },
  { 3301, 29, 29, 36, 4, -38 },
  { 3407, 22, 47, 27, 2, -46 },
  { 3537, 50, 51, 56, 3, -45 },
  { 3856, 38, 46, 38, 0, -46 },
  { 4075, 29, 46, 40, 7, -46 },
  { 4242, 34, 47, 40, 4, -46 },
  { 4442, 34, 46, 45, 7, -46 },
  { 4638, 24, 46, 35, 7, -46 },
  { 4776, 24, 46, 32, 7, -46 },
  { 4914, 37, 47, 46, 4, -46 },
  { 5132, 32, 46, 46, 7, -46 },
  { 5316, 11, 46, 19, 4, -46 },
  { 5380, 15, 57, 15, -6, -46 },
  { 5487, 29, 46, 36, 7, -46 },
  { 5654, 24, 46, 33, 7, -46 },
  { 5792, 41, 46, 54, 7, -46 },
  { 6028, 32, 46, 46, 7, -46 },
  { 6212, 41, 47, 49, 4, -46 },
  { 6453, 27, 46, 37, 7, -46 },
  { 6609, 41, 57, 49, 4, -46 },
  { 6902, 29, 46, 38, 7, -46 },
  { 7069, 27, 47, 35, 4, -46 },
  { 7228, 33, 46, 33, 0, -46 },
  { 7418, 34, 47, 46, 6, -46 },
  { 7618, 37, 46, 37, 0, -46 },
  { 7831, 53, 46, 56, 2, -46 },
  { 8136, 34, 46, 34, 0, -46 },
  { 8332, 33, 46, 33, 0, -46 },
  { 8522, 32, 46, 37, 2, -46 },
  { 8706, 14, 56, 20, 5, -46 },
  { 8804, 19, 46, 21, 1, -46 },
  { 8914, 13, 56, 20, 2, -46 },
  { 9005, 31, 28, 36, 3, -46 },
  { 9114, 26, 2, 26, 0, 6 },
  { 9121, 11, 10, 16, 3, -49 },
  { 9135, 25, 36, 33, 3, -35 },
  { 9248, 28, 50, 38, 6, -49 },
  { 9423, 24, 36, 30, 4, -35 },
  { 9531, 28, 50, 38, 4, -49 },
  { 9706, 27, 36, 35, 4, -35 },
  { 9828, 21, 49, 18, 1, -49 },
  { 9957, 28, 50, 38, 4, -35 },
  { 10132, 26, 49, 37, 6, -49 },
  { 10292, 4, 46, 14, 5, -46 },
  { 10315, 12, 61, 14, -3, -46 },
  { 10407, 24, 49, 30, 6, -49 },
  { 10554, 2, 49, 14, 6, -49 },
  { 10567, 44, 35, 56, 6, -35 },
  { 10760, 26, 35, 37, 6, -35 },
  { 10874, 29, 36, 37, 4, -35 },
  { 11005, 28, 50, 38, 6, -35 },
  { 11180, 28, 50, 38, 4, -35 },
  { 11355, 17, 34, 25, 6, -34 },
  { 11428, 24, 36, 30, 3, -35 },
  { 11536, 18, 43, 21, 1, -42 },
  { 11633, 26, 35, 37, 5, -34 },
  { 11747, 29, 34, 29, 0, -34 },
  { 11871, 43, 34, 45, 1, -34 },
  { 12054, 28, 34, 31, 2, -34 },
  { 12173, 29, 49, 28, 0, -34 },
  { 12351, 24, 34, 29, 3, -34 },
  { 12453, 18, 56, 22, 2, -46 },
  { 12579, 2, 65, 34, 16, -49 },
  { 12596, 18, 56, 22, 2, -46 },
  { 12722, 29, 6, 36, 4, -26 },
};

const GFXfont NotoSans_ExtraLight64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight64pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_EXTRALIGHT64PT7B_H_
