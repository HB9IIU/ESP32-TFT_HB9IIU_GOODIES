#ifndef _NOTOSANS_EXTRALIGHT65PT7B_H_
#define _NOTOSANS_EXTRALIGHT65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight65pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x18, 0xC6, 0x31, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x1D, 0xFF, 0xB8, 0x80, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x00, 0x01, 0x80, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0x60, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x06, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x60, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x03,
  0x00, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x03,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x01, 0x80, 0x00, 0x01, 0x80, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00,
  0x03, 0x80, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x03, 0xE3, 0x87, 0xE0, 0xF0, 0x70,
  0x1C, 0x38, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x70,
  0x07, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x03, 0x80,
  0x07, 0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x0C, 0x01, 0xC0, 0x01, 0xC0,
  0x38, 0x00, 0x3C, 0x07, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x3C, 0x1C, 0x00,
  0x03, 0xE3, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xE3, 0xE0,
  0x00, 0x1C, 0x1E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x0E,
  0x00, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x07, 0x00, 0x30,
  0x00, 0xE0, 0x06, 0x00, 0x1C, 0x00, 0xC0, 0x03, 0x80, 0x38, 0x00, 0x70,
  0x07, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x0F, 0x40,
  0x07, 0x03, 0xCF, 0x00, 0xE1, 0xF1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x60, 0x03, 0x80, 0x60, 0x00, 0x0E, 0x00, 0x30, 0x07, 0x00, 0x00, 0xC0,
  0x07, 0x00, 0x30, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x03, 0x80, 0x0E,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x0C, 0x00, 0x1C, 0x01,
  0x80, 0x00, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0x0C, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0xC0, 0x01, 0xC0, 0x60, 0x00, 0x0C, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0xC0, 0x01, 0xC0, 0xC0, 0x00, 0x0C, 0x00, 0x18, 0x1C, 0x1F, 0xE0, 0xE0,
  0x01, 0x81, 0x83, 0xFF, 0x8E, 0x00, 0x18, 0x38, 0x70, 0x3C, 0x60, 0x03,
  0x83, 0x0E, 0x01, 0xC7, 0x00, 0x30, 0x60, 0xE0, 0x0E, 0x30, 0x07, 0x0E,
  0x1C, 0x00, 0x63, 0x80, 0xE0, 0xC1, 0xC0, 0x06, 0x1E, 0x1E, 0x1C, 0x18,
  0x00, 0x70, 0xFF, 0x81, 0x81, 0x80, 0x07, 0x03, 0xF0, 0x38, 0x38, 0x00,
  0x30, 0x00, 0x03, 0x03, 0x80, 0x03, 0x00, 0x00, 0x70, 0x38, 0x00, 0x30,
  0x00, 0x06, 0x03, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x30, 0x00,
  0x1C, 0x03, 0x80, 0x03, 0x00, 0x01, 0x80, 0x38, 0x00, 0x30, 0x00, 0x38,
  0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x03,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x60, 0x01, 0xC0, 0x01, 0xC0, 0x06,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0xE0, 0x03, 0x00, 0x00, 0xE0, 0x0C, 0x00,
  0x70, 0x00, 0x07, 0x03, 0xC0, 0x06, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00,
  0x01, 0xE0, 0x07, 0x00, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x00, 0x39, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x00, 0x03, 0xC1, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x70, 0x00, 0x0C,
  0x1C, 0x00, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x70, 0x00,
  0x0E, 0x00, 0x18, 0x60, 0x00, 0x07, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x80,
  0x38, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0xE0, 0x00, 0x00, 0xE0, 0x70, 0xE0,
  0x00, 0x00, 0x70, 0xE0, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0xE0, 0x00, 0x00,
  0x1D, 0xC0, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x60, 0x00, 0x00, 0x0F, 0x80, 0x70, 0x00, 0x00, 0x1D, 0xC0, 0x78, 0x00,
  0x00, 0x38, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x1E, 0x00, 0x01, 0xE0,
  0x78, 0x0F, 0x80, 0x0F, 0xC0, 0x3C, 0x07, 0xFF, 0xFF, 0x00, 0x1E, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xF0, 0x0C, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00,
  0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00,
  0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0xF0, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x60,
  0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03,
  0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80,
  0x18, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x60, 0x06, 0xFC, 0x06, 0x03, 0xF7, 0xF8,
  0x61, 0xFE, 0x07, 0xF6, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x03, 0x1C, 0x00, 0x00,
  0x70, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x03,
  0x80, 0x03, 0x80, 0x38, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x0E, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x71, 0xC7, 0x38,
  0xE3, 0x8C, 0x31, 0xC7, 0x18, 0x63, 0x8C, 0x30, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x77, 0xFE, 0xE2, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xF8, 0x0F, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x07, 0x03, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0xE1, 0x80, 0x00,
  0x03, 0x1C, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3B, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0xE0, 0x0E, 0x00, 0x0E, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x01,
  0xF8, 0x07, 0xB0, 0x3C, 0x60, 0xF0, 0xC3, 0xC1, 0x9E, 0x03, 0xF8, 0x06,
  0xE0, 0x0D, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xE0, 0xFC, 0x03, 0xE0, 0x01, 0xE0,
  0x78, 0x00, 0x07, 0x03, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFC, 0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x3C, 0x38, 0x00, 0x00, 0xE1, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x20, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x07, 0x8F, 0xC0,
  0x01, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0xC0, 0x70,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x0C, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x70, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xC0,
  0x07, 0x00, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x1C,
  0x01, 0x80, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF8, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xF7, 0xFC, 0x03, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x88, 0x00, 0x00, 0x78,
  0xC0, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0xC0, 0x7F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xC0, 0x30, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x01, 0xF0, 0x00, 0xC0, 0x7F, 0xF8, 0x06, 0x0F, 0xFF, 0xF0, 0x71, 0xE0,
  0x03, 0xC3, 0x9C, 0x00, 0x07, 0x1D, 0xC0, 0x00, 0x1C, 0xFC, 0x00, 0x00,
  0x77, 0xC0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xDC, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x0F, 0x00, 0x07, 0x80, 0x3E, 0x00,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xF8, 0x0F, 0xC0, 0x1E, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x63, 0x80, 0x00, 0x03, 0x1C,
  0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x03, 0x83, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x01,
  0x80, 0x70, 0x00, 0x3C, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x78, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xC0, 0x01,
  0xE0, 0x38, 0x00, 0x07, 0x83, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x06,
  0x70, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x07, 0x80, 0xF8, 0x00, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x02, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xF8, 0x3F, 0x00, 0x1E, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x70, 0x1C,
  0x00, 0x01, 0xC0, 0xC0, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x38, 0x60, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00,
  0xEC, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xB0, 0x00, 0x00,
  0x7D, 0xC0, 0x00, 0x03, 0xE7, 0x00, 0x00, 0x37, 0x38, 0x00, 0x07, 0x38,
  0xF0, 0x00, 0x71, 0xC3, 0xE0, 0x1F, 0x0C, 0x07, 0xFF, 0xF0, 0x60, 0x0F,
  0xFC, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x73,
  0xBF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0xFF, 0xDC, 0x40, 0x0E, 0x1E,
  0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38,
  0x30, 0x70, 0x70, 0x60, 0xE0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x7F, 0xFF, 0x83, 0xFC, 0x1F, 0x83, 0x80, 0x07, 0x84, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x38, 0x00, 0x03, 0xFF, 0x00, 0x03, 0x07, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x70, 0xC0, 0x00, 0xF8, 0x07, 0x80, 0x0E, 0x38,
  0x00, 0x3C, 0x00, 0x30, 0x00, 0xC6, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x18,
  0xC0, 0x03, 0x80, 0x00, 0xC0, 0x03, 0xB8, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x76, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x0E, 0xC0, 0x03, 0x00, 0x00, 0x60,
  0x01, 0xD8, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x1B, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x03, 0x60, 0x03, 0x00, 0x00, 0x70, 0x00, 0xFC, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x1F, 0x80, 0x0C, 0x00, 0x01, 0xC0, 0x03, 0xF0, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x7E, 0x00, 0x30, 0x00, 0x07, 0x00, 0x0D, 0xC0, 0x06,
  0x00, 0x00, 0xC0, 0x01, 0x98, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x33, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x0E, 0x60, 0x03, 0x80, 0x00, 0xF0, 0x01, 0x8C,
  0x00, 0x30, 0x00, 0x36, 0x00, 0x71, 0x80, 0x07, 0x00, 0x0E, 0xC0, 0x0C,
  0x38, 0x00, 0x70, 0x03, 0x9C, 0x03, 0x83, 0x00, 0x07, 0x81, 0xE1, 0xE1,
  0xE0, 0x60, 0x00, 0x7F, 0xF0, 0x1F, 0xF0, 0x0E, 0x00, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x00,
  0x71, 0x80, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x06, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x60, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x30, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x06, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x01,
  0x80, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF8, 0x0C, 0x00, 0x03, 0xF8, 0x30, 0x00, 0x00, 0xF0,
  0xC0, 0x00, 0x01, 0xE3, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x07, 0x30,
  0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00,
  0xE3, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x38, 0x30, 0x00, 0x03, 0xC0,
  0xC0, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x30,
  0x00, 0x03, 0xE0, 0xC0, 0x00, 0x03, 0xC3, 0x00, 0x00, 0x03, 0x8C, 0x00,
  0x00, 0x07, 0x30, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x3B, 0x00, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x03, 0xB0,
  0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0xF3, 0x00, 0x00, 0x07, 0x8C, 0x00,
  0x00, 0x7C, 0x30, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0x03, 0xFC, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0x80,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x02, 0x00, 0x7E, 0x00,
  0x07, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0C, 0x00,
  0x07, 0xF8, 0x03, 0x00, 0x00, 0x1F, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x30,
  0x00, 0x00, 0x1E, 0x0C, 0x00, 0x00, 0x03, 0xC3, 0x00, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x00,
  0x73, 0x00, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00,
  0x00, 0xEC, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x03, 0xB0, 0x00,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0x1C, 0xC0,
  0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x03, 0xC3,
  0x00, 0x00, 0x01, 0xE0, 0xC0, 0x00, 0x00, 0xF0, 0x30, 0x00, 0x00, 0xF8,
  0x0C, 0x00, 0x01, 0xF8, 0x03, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x78, 0x00, 0x00, 0x10, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x00, 0x73,
  0x00, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x3E, 0x00, 0x00, 0x07, 0x00,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1C, 0xFF, 0xE7, 0xF8, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0,
  0x07, 0x20, 0x3E, 0x7F, 0xF8, 0xFF, 0xC0, 0x10, 0x00, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xCC, 0x00, 0x00, 0x1E, 0x30, 0x00, 0x00, 0xF0,
  0xC0, 0x00, 0x07, 0x83, 0x00, 0x00, 0x3C, 0x0C, 0x00, 0x00, 0xE0, 0x30,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0x38, 0x03, 0x00, 0x01, 0xC0, 0x0C, 0x00,
  0x0E, 0x00, 0x30, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0xE0, 0x00, 0x30, 0x07, 0x00, 0x00, 0xC0, 0x38, 0x00,
  0x03, 0x01, 0xC0, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x30, 0x78, 0x00, 0x00,
  0xC3, 0xE0, 0x00, 0x03, 0x1D, 0xC0, 0x00, 0x0C, 0xE3, 0x80, 0x00, 0x37,
  0x0F, 0x00, 0x00, 0xF8, 0x1C, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x30, 0x01, 0xE0, 0x00, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x07,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x70,
  0x03, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x03, 0xC0, 0x30, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x78, 0x30,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x03, 0x8C, 0x00,
  0x00, 0x0F, 0x30, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x3B, 0x00, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xDC,
  0x00, 0x00, 0x00, 0x0D, 0xF7, 0x00, 0x00, 0x00, 0x07, 0x7C, 0xC0, 0x00,
  0x00, 0x01, 0xDF, 0x38, 0x00, 0x00, 0x00, 0x67, 0xCE, 0x00, 0x00, 0x00,
  0x39, 0xF1, 0xC0, 0x00, 0x00, 0x0C, 0x7C, 0x70, 0x00, 0x00, 0x07, 0x1F,
  0x0C, 0x00, 0x00, 0x01, 0xC7, 0xC3, 0x80, 0x00, 0x00, 0x61, 0xF0, 0xE0,
  0x00, 0x00, 0x38, 0x7C, 0x1C, 0x00, 0x00, 0x0C, 0x1F, 0x07, 0x00, 0x00,
  0x07, 0x07, 0xC0, 0xC0, 0x00, 0x01, 0xC1, 0xF0, 0x38, 0x00, 0x00, 0x60,
  0x7C, 0x0E, 0x00, 0x00, 0x38, 0x1F, 0x01, 0xC0, 0x00, 0x0C, 0x07, 0xC0,
  0x70, 0x00, 0x07, 0x01, 0xF0, 0x0C, 0x00, 0x01, 0xC0, 0x7C, 0x03, 0x80,
  0x00, 0x60, 0x1F, 0x00, 0x60, 0x00, 0x38, 0x07, 0xC0, 0x1C, 0x00, 0x0C,
  0x01, 0xF0, 0x07, 0x00, 0x07, 0x00, 0x7C, 0x00, 0xC0, 0x01, 0xC0, 0x1F,
  0x00, 0x38, 0x00, 0x60, 0x07, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xF0, 0x01,
  0xC0, 0x0C, 0x00, 0x7C, 0x00, 0x70, 0x07, 0x00, 0x1F, 0x00, 0x0C, 0x01,
  0x80, 0x07, 0xC0, 0x03, 0x80, 0x60, 0x01, 0xF0, 0x00, 0x60, 0x38, 0x00,
  0x7C, 0x00, 0x1C, 0x0C, 0x00, 0x1F, 0x00, 0x07, 0x07, 0x00, 0x07, 0xC0,
  0x00, 0xC1, 0x80, 0x01, 0xF0, 0x00, 0x38, 0xE0, 0x00, 0x7C, 0x00, 0x06,
  0x38, 0x00, 0x1F, 0x00, 0x01, 0xCC, 0x00, 0x07, 0xC0, 0x00, 0x77, 0x00,
  0x01, 0xF0, 0x00, 0x0D, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3E, 0xE0, 0x00, 0x00, 0x1F, 0x38, 0x00, 0x00, 0x0F, 0x9C, 0x00, 0x00,
  0x07, 0xC7, 0x00, 0x00, 0x03, 0xE1, 0xC0, 0x00, 0x01, 0xF0, 0xE0, 0x00,
  0x00, 0xF8, 0x38, 0x00, 0x00, 0x7C, 0x0E, 0x00, 0x00, 0x3E, 0x07, 0x00,
  0x00, 0x1F, 0x01, 0xC0, 0x00, 0x0F, 0x80, 0x70, 0x00, 0x07, 0xC0, 0x38,
  0x00, 0x03, 0xE0, 0x0E, 0x00, 0x01, 0xF0, 0x03, 0x80, 0x00, 0xF8, 0x01,
  0xC0, 0x00, 0x7C, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x1F, 0x00,
  0x0E, 0x00, 0x0F, 0x80, 0x03, 0x80, 0x07, 0xC0, 0x00, 0xE0, 0x03, 0xE0,
  0x00, 0x70, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0xE0, 0x1F, 0x00, 0x00, 0x38, 0x0F,
  0x80, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x07, 0x03, 0xE0, 0x00, 0x01, 0xC1,
  0xF0, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x38, 0x7C, 0x00, 0x00, 0x0E,
  0x3E, 0x00, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x01, 0xCF, 0x80, 0x00, 0x00,
  0x77, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0x00, 0x1D,
  0x80, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x70, 0x00,
  0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x00, 0x00, 0x60, 0x78, 0x00, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xB8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x03, 0x00, 0x03, 0xF8, 0x60, 0x00, 0x0F, 0x8C, 0x00, 0x00,
  0x79, 0x80, 0x00, 0x07, 0x30, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0E, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x39, 0x80, 0x00, 0x0E, 0x30, 0x00,
  0x07, 0x86, 0x00, 0x07, 0xE0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0x80, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x03, 0xB0,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x3B, 0x00, 0x00, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x78,
  0x00, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xBF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF0, 0x0C, 0x00, 0x07, 0xE0, 0x30, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x07,
  0x83, 0x00, 0x00, 0x0F, 0x0C, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x0E, 0x30,
  0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x03, 0x8C, 0x00,
  0x00, 0x0E, 0x30, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x07, 0x0C, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x07,
  0x03, 0x00, 0x00, 0x78, 0x0C, 0x00, 0x07, 0xC0, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0x70, 0x00, 0xC0, 0x00, 0xE0, 0x03, 0x00, 0x01, 0xC0, 0x0C, 0x00,
  0x07, 0x00, 0x30, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x38, 0x03, 0x00, 0x00,
  0x70, 0x0C, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x07,
  0x03, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x0E, 0x30,
  0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xF0, 0x3F, 0xE0, 0xF0, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0x43, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xC8, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x3F,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x00, 0x1D, 0x80, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x01, 0x9C, 0x00,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0xC0,
  0x0F, 0xC0, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3B, 0x00, 0x00,
  0x00, 0x01, 0x9C, 0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x03, 0x80, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x70, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x31,
  0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0x38, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0xE0, 0x60, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x81, 0x80, 0x00,
  0x38, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x1C,
  0x00, 0x03, 0x06, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x1C, 0x1C, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x70, 0x30, 0x00, 0x18, 0x03, 0x80, 0x01, 0x80, 0xC0,
  0x00, 0xE0, 0x0E, 0x00, 0x06, 0x03, 0x80, 0x03, 0x80, 0x18, 0x00, 0x38,
  0x0E, 0x00, 0x0E, 0x00, 0x70, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x01, 0xC0,
  0x03, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x00,
  0x0C, 0x00, 0x70, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x00, 0xE0, 0x06, 0x00, 0x38, 0x03, 0x80, 0x01, 0x80, 0x38, 0x00,
  0xE0, 0x0E, 0x00, 0x06, 0x00, 0xE0, 0x01, 0x80, 0x30, 0x00, 0x1C, 0x03,
  0x00, 0x06, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0xC0, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x81, 0x80, 0x00, 0xC0, 0x60,
  0x00, 0x0E, 0x06, 0x00, 0x03, 0x83, 0x80, 0x00, 0x18, 0x38, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x18, 0x38, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0x61, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0C,
  0x70, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0xE6, 0x00, 0x00, 0x33, 0x80, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x06, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x06, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x0E,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x03, 0x80,
  0x00, 0x70, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00,
  0x00, 0xE3, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x0E,
  0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x60, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0x01, 0xCC, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00,
  0x18, 0x38, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x03,
  0x80, 0x60, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x06, 0x00,
  0x03, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x30, 0x00, 0x06, 0x00, 0xE0, 0x00,
  0x0E, 0x01, 0x80, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00,
  0x18, 0x38, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00,
  0x73, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xFE, 0x01, 0xFE, 0x07, 0xC0, 0x38, 0x00, 0x78, 0x08, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x7F, 0xF8, 0x70, 0x7C, 0x00, 0x1C, 0x78, 0x00,
  0x07, 0x3C, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xD8, 0x00, 0x03, 0x77, 0x00, 0x01,
  0xDD, 0xE0, 0x00, 0xE7, 0x3C, 0x00, 0xF1, 0xC7, 0xFF, 0xF8, 0x70, 0x7F,
  0xF8, 0x1C, 0x01, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0xFF, 0x80, 0x18,
  0x1F, 0xFF, 0x80, 0xC3, 0xF0, 0x7E, 0x06, 0x38, 0x00, 0x78, 0x33, 0x80,
  0x00, 0xE1, 0xB8, 0x00, 0x03, 0x8D, 0x80, 0x00, 0x1C, 0x78, 0x00, 0x00,
  0x73, 0xC0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0xE7, 0x80, 0x00,
  0x07, 0x3C, 0x00, 0x00, 0x71, 0xB0, 0x00, 0x03, 0x8D, 0xC0, 0x00, 0x38,
  0x67, 0x00, 0x07, 0x83, 0x1E, 0x00, 0x78, 0x18, 0x7F, 0xFF, 0x80, 0xC0,
  0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x7F, 0x07, 0xE0, 0x78, 0x00, 0x20, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xC0, 0x03, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0xFF, 0x80, 0xE0, 0x1F, 0xFF, 0x07, 0x03, 0xF0,
  0x3E, 0x38, 0x3C, 0x00, 0x79, 0xC3, 0x80, 0x00, 0xEE, 0x38, 0x00, 0x03,
  0x73, 0x80, 0x00, 0x0F, 0x9C, 0x00, 0x00, 0x7D, 0xC0, 0x00, 0x01, 0xEE,
  0x00, 0x00, 0x0F, 0x60, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xEC, 0x00, 0x00,
  0x0F, 0x70, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x07, 0xCE, 0x00, 0x00, 0x3E,
  0x70, 0x00, 0x03, 0x71, 0xC0, 0x00, 0x3B, 0x87, 0x00, 0x03, 0x9C, 0x1E,
  0x00, 0x78, 0xE0, 0x7F, 0xFF, 0x87, 0x00, 0xFF, 0xF0, 0x38, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xF0, 0x7E,
  0x00, 0x78, 0x00, 0xF0, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x1C,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x30, 0x00, 0x00, 0xC7, 0x00, 0x00,
  0x0E, 0x60, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x04, 0x07, 0xC0, 0x03, 0xC0, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xC1, 0xC0, 0xFC, 0x0F,
  0x8E, 0x0F, 0x00, 0x0E, 0x70, 0xE0, 0x00, 0x3B, 0x8E, 0x00, 0x00, 0xDC,
  0xE0, 0x00, 0x03, 0xE7, 0x00, 0x00, 0x1F, 0x70, 0x00, 0x00, 0x7B, 0x80,
  0x00, 0x03, 0xD8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7B, 0x00, 0x00, 0x03,
  0xDC, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x01, 0xF3, 0x80, 0x00, 0x0F, 0x9C,
  0x00, 0x00, 0xDC, 0x70, 0x00, 0x0E, 0xE1, 0xE0, 0x00, 0xE7, 0x07, 0x80,
  0x1E, 0x38, 0x1F, 0xFF, 0xE1, 0xC0, 0x3F, 0xFC, 0x0E, 0x00, 0x1F, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0xC0, 0x00, 0x0E, 0x07, 0xC0, 0x01, 0xE0, 0x3F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x03, 0xFE, 0x03, 0x03, 0xFF, 0xE0, 0xC3,
  0xE0, 0x7E, 0x31, 0xC0, 0x03, 0xCC, 0xE0, 0x00, 0x7B, 0x70, 0x00, 0x0E,
  0xD8, 0x00, 0x01, 0xBC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xC0, 0x7F,
  0xFF, 0x60, 0x00, 0x00, 0x00, 0x06, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00,
  0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xE0, 0x1C, 0xFF, 0x8F, 0xF0, 0x18, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x3C,
  0xC0, 0x00, 0x1C, 0x60, 0x00, 0x1C, 0x30, 0x00, 0x1C, 0x18, 0x00, 0x1C,
  0x0C, 0x00, 0x1C, 0x06, 0x00, 0x1C, 0x03, 0x00, 0x1C, 0x01, 0x80, 0x1C,
  0x00, 0xC0, 0x1C, 0x00, 0x60, 0x1E, 0x00, 0x30, 0x0E, 0x00, 0x18, 0x0E,
  0x00, 0x0C, 0x0E, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x0F, 0x80, 0x01, 0x8E,
  0xE0, 0x00, 0xCE, 0x70, 0x00, 0x6E, 0x1C, 0x00, 0x3E, 0x07, 0x00, 0x1E,
  0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x38, 0x03, 0x00, 0x0E, 0x01,
  0x80, 0x03, 0x80, 0xC0, 0x01, 0xC0, 0x60, 0x00, 0x70, 0x30, 0x00, 0x1C,
  0x18, 0x00, 0x07, 0x0C, 0x00, 0x03, 0x86, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x39, 0x80, 0x00, 0x0E, 0xC0, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x80,
  0x03, 0xFE, 0x06, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x31, 0xF0, 0x7E, 0x0F,
  0x81, 0xF1, 0x9E, 0x00, 0x70, 0xF0, 0x03, 0xCC, 0xC0, 0x01, 0xCE, 0x00,
  0x0F, 0x6C, 0x00, 0x07, 0x60, 0x00, 0x3B, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0xDE, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x3F, 0xE0, 0x30, 0x3F, 0xFE, 0x0C, 0x3E, 0x07, 0xE3,
  0x1C, 0x00, 0x3C, 0xCE, 0x00, 0x07, 0xB7, 0x00, 0x00, 0xED, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x0E,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0xE6, 0x00, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x03, 0x8C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x06, 0x07, 0xFF, 0xE0, 0x30, 0xFC, 0x1F, 0x81, 0x8F, 0x00,
  0x1E, 0x0C, 0xE0, 0x00, 0x38, 0x66, 0x00, 0x00, 0xE3, 0x60, 0x00, 0x07,
  0x1B, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x67, 0x80, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0x70, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0xDC, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00,
  0x39, 0xE0, 0x00, 0x01, 0xCF, 0x80, 0x00, 0x1C, 0x6C, 0x00, 0x00, 0xE3,
  0x30, 0x00, 0x0E, 0x19, 0xC0, 0x00, 0xE0, 0xC7, 0x80, 0x1E, 0x06, 0x1F,
  0xFF, 0xE0, 0x30, 0x3F, 0xFC, 0x01, 0x80, 0x1E, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x83, 0x03, 0xE0, 0x3C, 0x30,
  0x78, 0x00, 0xF3, 0x0E, 0x00, 0x03, 0x31, 0xC0, 0x00, 0x1B, 0x38, 0x00,
  0x01, 0xF3, 0x80, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x0F, 0x30, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x1B, 0x1C, 0x00,
  0x03, 0xB1, 0xE0, 0x00, 0x73, 0x0F, 0x80, 0x1E, 0x30, 0x3F, 0xFF, 0x83,
  0x01, 0xFF, 0xF0, 0x30, 0x01, 0xF0, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x7F, 0xB0, 0x7F,
  0xFC, 0x3E, 0x1F, 0x1C, 0x00, 0xCC, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x1F, 0x80, 0xFE,
  0x3C, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x80, 0x00, 0x1C, 0xF0, 0x00, 0x78, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0x01, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x07, 0x00,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3D, 0x80, 0x00, 0x07, 0xB8, 0x00, 0x01, 0xB7, 0x00,
  0x00, 0x36, 0x70, 0x00, 0x0C, 0xCF, 0x00, 0x07, 0x18, 0xF8, 0x03, 0xC3,
  0x0F, 0xFF, 0xF0, 0x60, 0x7F, 0xF8, 0x0C, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3B, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x1C, 0x60, 0x00,
  0x00, 0xC3, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x70, 0x60, 0x00, 0x03,
  0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x0C, 0x03,
  0x80, 0x00, 0xE0, 0x0C, 0x00, 0x06, 0x00, 0x70, 0x00, 0x70, 0x03, 0x80,
  0x03, 0x80, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x01, 0x80, 0x0C,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x70, 0x07, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x76, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x70, 0x00, 0x0F, 0x00, 0x00, 0x67, 0x00, 0x00, 0xF8, 0x00,
  0x0E, 0x70, 0x00, 0x0D, 0x80, 0x00, 0xE3, 0x00, 0x01, 0xD8, 0x00, 0x0C,
  0x38, 0x00, 0x19, 0xC0, 0x00, 0xC3, 0x80, 0x01, 0x8C, 0x00, 0x1C, 0x18,
  0x00, 0x38, 0xC0, 0x01, 0xC1, 0x80, 0x03, 0x0E, 0x00, 0x18, 0x1C, 0x00,
  0x30, 0x60, 0x03, 0x81, 0xC0, 0x07, 0x06, 0x00, 0x38, 0x0C, 0x00, 0x60,
  0x70, 0x03, 0x00, 0xE0, 0x06, 0x07, 0x00, 0x30, 0x0E, 0x00, 0xE0, 0x30,
  0x07, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x38, 0x06,
  0x00, 0x70, 0x1C, 0x01, 0x80, 0x60, 0x07, 0x01, 0x80, 0x1C, 0x0E, 0x00,
  0x30, 0x18, 0x01, 0xC0, 0xE0, 0x03, 0x03, 0x80, 0x0C, 0x0C, 0x00, 0x38,
  0x30, 0x00, 0xE1, 0xC0, 0x01, 0x83, 0x00, 0x0E, 0x1C, 0x00, 0x18, 0x70,
  0x00, 0x61, 0x80, 0x01, 0xC6, 0x00, 0x07, 0x18, 0x00, 0x1C, 0x60, 0x00,
  0x73, 0x80, 0x00, 0xCE, 0x00, 0x03, 0x38, 0x00, 0x0C, 0xC0, 0x00, 0x33,
  0x00, 0x00, 0xEC, 0x00, 0x03, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0xF0, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70,
  0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x38,
  0x01, 0xC0, 0x01, 0x80, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1B, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80,
  0x38, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0,
  0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3B, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0xC3,
  0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x70, 0x60, 0x00, 0x03, 0x03, 0x80,
  0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0C, 0x03, 0x80, 0x00,
  0xE0, 0x0C, 0x00, 0x06, 0x00, 0x70, 0x00, 0x70, 0x03, 0x80, 0x03, 0x80,
  0x0C, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x0E,
  0x00, 0x60, 0x00, 0x70, 0x07, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x30, 0x1C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1D,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x07, 0xC0,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x3F, 0xC0, 0x07, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x09, 0xFF, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x07,
  0x80, 0x0F, 0xC0, 0xF8, 0x00, 0x1F, 0xFF, 0x40, 0x00, 0x1F, 0xE0,
};

const GFXglyph NotoSans_ExtraLight65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 5, 47, 15, 5, -46 },
  { 31, 12, 16, 22, 5, -46 },
  { 55, 38, 46, 42, 2, -46 },
  { 274, 27, 53, 37, 4, -49 },
  { 453, 44, 48, 52, 4, -47 },
  { 717, 40, 48, 46, 4, -47 },
  { 957, 2, 16, 12, 5, -46 },
  { 961, 12, 56, 17, 3, -46 },
  { 1045, 13, 56, 17, 2, -46 },
  { 1136, 28, 26, 36, 4, -49 },
  { 1227, 30, 30, 37, 4, -38 },
  { 1340, 6, 16, 13, 3, -8 },
  { 1352, 15, 3, 21, 3, -19 },
  { 1358, 5, 5, 15, 5, -4 },
  { 1362, 20, 46, 22, 1, -46 },
  { 1477, 29, 48, 37, 4, -47 },
  { 1651, 15, 46, 37, 6, -46 },
  { 1738, 28, 47, 37, 4, -47 },
  { 1903, 29, 48, 37, 3, -47 },
  { 2077, 34, 47, 37, 2, -47 },
  { 2277, 28, 47, 37, 5, -46 },
  { 2442, 29, 48, 37, 4, -47 },
  { 2616, 29, 46, 37, 4, -46 },
  { 2783, 29, 48, 37, 4, -47 },
  { 2957, 29, 48, 37, 4, -47 },
  { 3131, 5, 36, 15, 5, -35 },
  { 3154, 8, 43, 15, 2, -35 },
  { 3197, 29, 29, 37, 4, -38 },
  { 3303, 29, 16, 37, 4, -31 },
  { 3361, 29, 29, 37, 4, -38 },
  { 3467, 23, 48, 27, 2, -47 },
  { 3605, 51, 52, 57, 3, -46 },
  { 3937, 38, 47, 38, 0, -47 },
  { 4161, 30, 46, 40, 7, -46 },
  { 4334, 34, 48, 40, 4, -47 },
  { 4538, 34, 46, 46, 7, -46 },
  { 4734, 25, 46, 36, 7, -46 },
  { 4878, 25, 46, 32, 7, -46 },
  { 5022, 38, 48, 47, 4, -47 },
  { 5250, 33, 46, 46, 7, -46 },
  { 5440, 11, 46, 19, 4, -46 },
  { 5504, 15, 58, 16, -6, -46 },
  { 5613, 30, 46, 37, 7, -46 },
  { 5786, 25, 46, 33, 7, -46 },
  { 5930, 42, 46, 55, 7, -46 },
  { 6172, 33, 46, 46, 7, -46 },
  { 6362, 41, 48, 49, 4, -47 },
  { 6608, 27, 46, 38, 7, -46 },
  { 6764, 41, 58, 49, 4, -47 },
  { 7062, 30, 46, 38, 7, -46 },
  { 7235, 28, 48, 35, 4, -47 },
  { 7403, 33, 46, 33, 0, -46 },
  { 7593, 34, 47, 47, 6, -46 },
  { 7793, 37, 46, 37, 0, -46 },
  { 8006, 54, 46, 57, 2, -46 },
  { 8317, 34, 46, 34, 0, -46 },
  { 8513, 34, 46, 34, 0, -46 },
  { 8709, 33, 46, 38, 2, -46 },
  { 8899, 13, 56, 21, 6, -46 },
  { 8990, 20, 46, 22, 1, -46 },
  { 9105, 13, 56, 21, 2, -46 },
  { 9196, 31, 29, 37, 3, -47 },
  { 9309, 26, 2, 26, 0, 6 },
  { 9316, 11, 11, 17, 3, -50 },
  { 9332, 26, 36, 34, 3, -35 },
  { 9449, 29, 50, 38, 6, -49 },
  { 9631, 25, 36, 31, 4, -35 },
  { 9744, 29, 50, 38, 4, -49 },
  { 9926, 28, 36, 35, 4, -35 },
  { 10052, 22, 50, 19, 1, -50 },
  { 10190, 29, 51, 38, 4, -35 },
  { 10375, 26, 49, 38, 6, -49 },
  { 10535, 4, 47, 14, 5, -47 },
  { 10559, 12, 63, 14, -3, -47 },
  { 10654, 25, 49, 31, 6, -49 },
  { 10808, 2, 49, 14, 6, -49 },
  { 10821, 45, 35, 56, 6, -35 },
  { 11018, 26, 35, 38, 6, -35 },
  { 11132, 30, 36, 38, 4, -35 },
  { 11267, 29, 50, 38, 6, -35 },
  { 11449, 28, 50, 38, 4, -35 },
  { 11624, 18, 35, 25, 6, -35 },
  { 11703, 24, 36, 30, 3, -35 },
  { 11811, 19, 44, 21, 1, -43 },
  { 11916, 27, 35, 38, 5, -34 },
  { 12035, 29, 34, 29, 0, -34 },
  { 12159, 44, 34, 46, 1, -34 },
  { 12346, 28, 34, 32, 2, -34 },
  { 12465, 29, 50, 29, 0, -34 },
  { 12647, 24, 34, 30, 3, -34 },
  { 12749, 18, 56, 22, 2, -46 },
  { 12875, 3, 66, 35, 16, -50 },
  { 12900, 19, 56, 22, 2, -46 },
  { 13033, 29, 6, 37, 4, -26 },
};

const GFXfont NotoSans_ExtraLight65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight65pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_EXTRALIGHT65PT7B_H_
