#ifndef _NOTOSANS_EXTRALIGHT38PT7B_H_
#define _NOTOSANS_EXTRALIGHT38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight38pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x20, 0x00, 0x5F, 0x80,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x04, 0x00, 0x40, 0x60,
  0x01, 0x01, 0x00, 0x0C, 0x04, 0x00, 0x30, 0x10, 0x00, 0x80, 0x40, 0x02,
  0x03, 0x00, 0x08, 0x08, 0x00, 0x60, 0x20, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF0, 0x10, 0x18, 0x00, 0x40, 0x60, 0x01, 0x01, 0x00, 0x0C, 0x04, 0x00,
  0x20, 0x10, 0x00, 0x80, 0xC0, 0x02, 0x03, 0x03, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0x81, 0x80, 0x80, 0x04, 0x06, 0x00, 0x10, 0x18, 0x00, 0x40, 0x40,
  0x03, 0x01, 0x00, 0x0C, 0x04, 0x00, 0x20, 0x30, 0x00, 0x80, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x0F, 0xFC, 0x38, 0x86, 0x60, 0x80,
  0x40, 0x80, 0x40, 0x80, 0xC0, 0x80, 0xC0, 0x80, 0x40, 0x80, 0x60, 0x80,
  0x30, 0x80, 0x1C, 0x80, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xB8, 0x00, 0x8C,
  0x00, 0x86, 0x00, 0x83, 0x00, 0x81, 0x00, 0x81, 0x00, 0x81, 0x00, 0x83,
  0x00, 0x83, 0x00, 0x86, 0x60, 0x9C, 0x3F, 0xF0, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x04, 0x00, 0x00, 0x07, 0xC0, 0x02, 0x02, 0x08, 0x01, 0x81,
  0x83, 0x00, 0x40, 0x40, 0x40, 0x20, 0x30, 0x10, 0x18, 0x0C, 0x06, 0x04,
  0x03, 0x01, 0x83, 0x00, 0xC0, 0x60, 0x80, 0x30, 0x18, 0x60, 0x0C, 0x06,
  0x10, 0x03, 0x01, 0x8C, 0x30, 0xC0, 0x42, 0x3F, 0x10, 0x11, 0x18, 0x66,
  0x0C, 0xC4, 0x08, 0x82, 0x23, 0x03, 0x3F, 0x18, 0x80, 0x41, 0x04, 0x20,
  0x10, 0x03, 0x08, 0x04, 0x00, 0x82, 0x01, 0x00, 0x60, 0x80, 0x40, 0x10,
  0x20, 0x10, 0x0C, 0x08, 0x04, 0x06, 0x02, 0x03, 0x01, 0x00, 0xC0, 0xC0,
  0xC0, 0x10, 0x20, 0x20, 0x06, 0x18, 0x18, 0x00, 0xFC, 0x00, 0x60, 0x00,
  0x03, 0xF8, 0x00, 0x0E, 0x0C, 0x00, 0x08, 0x06, 0x00, 0x18, 0x02, 0x00,
  0x18, 0x03, 0x00, 0x18, 0x03, 0x00, 0x18, 0x02, 0x00, 0x08, 0x06, 0x00,
  0x0C, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x02, 0x30, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x60, 0x00, 0x18, 0x30, 0x06, 0x30, 0x18, 0x06,
  0x60, 0x0C, 0x04, 0x40, 0x06, 0x0C, 0xC0, 0x07, 0x08, 0xC0, 0x03, 0x98,
  0xC0, 0x01, 0xD0, 0xC0, 0x00, 0xF0, 0x40, 0x00, 0x60, 0x60, 0x00, 0xF0,
  0x30, 0x03, 0x98, 0x1C, 0x0E, 0x0C, 0x0F, 0xF8, 0x07, 0xFF, 0xC0, 0x06,
  0x18, 0x60, 0x83, 0x04, 0x18, 0x30, 0x41, 0x83, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x30, 0x60, 0x40, 0xC1, 0x81, 0x03,
  0x02, 0x06, 0x06, 0x06, 0xC0, 0x40, 0xC0, 0x81, 0x81, 0x03, 0x02, 0x04,
  0x0C, 0x18, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x41,
  0x83, 0x04, 0x08, 0x30, 0x41, 0x82, 0x0C, 0x30, 0xC0, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x04, 0x04, 0x07, 0xC2, 0x1E,
  0x7D, 0x78, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0xD8, 0x00, 0xC4, 0x00, 0x43,
  0x00, 0x60, 0xC0, 0x60, 0x30, 0x10, 0x10, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0xFF, 0xFF, 0xC0, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x33, 0x32,
  0x26, 0x64, 0xC0, 0xFF, 0x80, 0x5F, 0x80, 0x00, 0x30, 0x03, 0x00, 0x20,
  0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x01,
  0x80, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x00,
  0x00, 0x80, 0x03, 0xFC, 0x03, 0x03, 0x02, 0x00, 0xC3, 0x00, 0x31, 0x00,
  0x09, 0x80, 0x04, 0x80, 0x03, 0x40, 0x01, 0xA0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x28, 0x00, 0x14, 0x00, 0x1B, 0x00, 0x0D, 0x80,
  0x04, 0x40, 0x06, 0x30, 0x02, 0x0C, 0x03, 0x03, 0x03, 0x00, 0xFF, 0x00,
  0x03, 0x07, 0x0D, 0x39, 0x61, 0xC1, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x00, 0x80, 0x07, 0xF8, 0x0E, 0x07, 0x0C, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x80, 0x0F, 0xFC, 0x1C, 0x03, 0x18, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x7F, 0x00, 0x3F, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x40, 0x03, 0x38, 0x07,
  0x0F, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0A, 0x00, 0x01,
  0xA0, 0x00, 0x32, 0x00, 0x02, 0x20, 0x00, 0x42, 0x00, 0x0C, 0x20, 0x01,
  0x82, 0x00, 0x10, 0x20, 0x03, 0x02, 0x00, 0x60, 0x20, 0x0C, 0x02, 0x00,
  0x80, 0x20, 0x18, 0x02, 0x03, 0x00, 0x20, 0x20, 0x02, 0x04, 0x00, 0x20,
  0xC0, 0x02, 0x0F, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x3F,
  0xFE, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x7F, 0xF0, 0x60,
  0x38, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x80,
  0x0C, 0xE0, 0x38, 0x7F, 0xE0, 0x00, 0x18, 0x00, 0x7F, 0xC0, 0x70, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x07, 0xC0, 0x47, 0xFC, 0x17, 0x01,
  0x85, 0x00, 0x13, 0x80, 0x06, 0xE0, 0x00, 0xB0, 0x00, 0x24, 0x00, 0x0D,
  0x00, 0x03, 0x40, 0x00, 0xD8, 0x00, 0x26, 0x00, 0x08, 0x80, 0x06, 0x30,
  0x01, 0x06, 0x00, 0xC0, 0xC0, 0xE0, 0x1F, 0xE0, 0xFF, 0xFF, 0xC0, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x07,
  0xFC, 0x06, 0x03, 0x86, 0x00, 0x62, 0x00, 0x33, 0x00, 0x09, 0x80, 0x04,
  0xC0, 0x02, 0x60, 0x01, 0x10, 0x01, 0x8C, 0x01, 0x83, 0x81, 0x80, 0x73,
  0x00, 0x0E, 0x00, 0x1D, 0xE0, 0x38, 0x18, 0x30, 0x06, 0x30, 0x01, 0x90,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x02, 0x80, 0x03,
  0x60, 0x01, 0x18, 0x01, 0x86, 0x03, 0x81, 0xFF, 0x00, 0x00, 0x80, 0x07,
  0xF8, 0x06, 0x07, 0x06, 0x00, 0xC6, 0x00, 0x22, 0x00, 0x1B, 0x00, 0x05,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1A, 0x00, 0x1D, 0x80, 0x1A, 0x60, 0x19, 0x1F, 0xF9, 0x80, 0xC0, 0xC0,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x07, 0xF8, 0x00, 0xFD, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0B, 0xF0, 0x39, 0xC4, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x31, 0x8C, 0x42, 0x31, 0x08, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x40,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x00, 0x80, 0x00, 0x00,
  0x02, 0x03, 0xFF, 0x30, 0x1C, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x1C, 0x00, 0x30, 0x01, 0xC0, 0x00,
  0x70, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x81, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x04, 0x20, 0x0F, 0xF8, 0x19, 0x80, 0x60, 0x20, 0x24,
  0x02, 0x01, 0x80, 0x90, 0x18, 0x06, 0x02, 0xC0, 0xC0, 0x18, 0x0B, 0x03,
  0x00, 0x60, 0x38, 0x08, 0x01, 0x80, 0xA0, 0x20, 0x06, 0x02, 0x80, 0x80,
  0x18, 0x0A, 0x02, 0x00, 0x60, 0x28, 0x08, 0x01, 0x81, 0xB0, 0x30, 0x0E,
  0x04, 0xC0, 0x60, 0x68, 0x31, 0x00, 0xE7, 0x39, 0x84, 0x01, 0xF0, 0x7C,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x02, 0x80, 0x00, 0x1A, 0x00, 0x00, 0x4C, 0x00, 0x03, 0x10, 0x00,
  0x0C, 0x60, 0x00, 0x21, 0x80, 0x01, 0x82, 0x00, 0x04, 0x0C, 0x00, 0x30,
  0x10, 0x00, 0xC0, 0x60, 0x02, 0x01, 0x80, 0x18, 0x02, 0x00, 0x40, 0x0C,
  0x01, 0x00, 0x30, 0x0F, 0xFF, 0xC0, 0x20, 0x01, 0x81, 0x80, 0x02, 0x06,
  0x00, 0x0C, 0x10, 0x00, 0x30, 0xC0, 0x00, 0x42, 0x00, 0x01, 0x98, 0x00,
  0x06, 0x60, 0x00, 0x09, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x40, 0xFF, 0xF0,
  0x40, 0x1F, 0x20, 0x01, 0xD0, 0x00, 0x68, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0x40, 0x01, 0xA0, 0x00, 0x90, 0x01, 0x8F,
  0xFF, 0x04, 0x03, 0xE2, 0x00, 0x1D, 0x00, 0x02, 0x80, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x06, 0x80, 0x07, 0x40, 0x3E, 0x3F, 0xFC, 0x00, 0x00, 0x04, 0x00, 0x0F,
  0xFE, 0x03, 0x80, 0x30, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x30, 0x0F, 0xFE, 0xFF, 0xF0, 0x08, 0x07, 0xC0, 0x80,
  0x07, 0x08, 0x00, 0x18, 0x80, 0x00, 0xC8, 0x00, 0x04, 0x80, 0x00, 0x68,
  0x00, 0x02, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x28, 0x00, 0x06, 0x80, 0x00, 0x68, 0x00,
  0x0C, 0x80, 0x00, 0xC8, 0x00, 0x38, 0x80, 0x07, 0x08, 0x0F, 0xC0, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x0F, 0xFF, 0xD0, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x03, 0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x1F, 0xFF, 0xBF, 0xFF, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x03,
  0xFF, 0xE0, 0x3C, 0x01, 0xC1, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x03, 0xFF, 0xC0, 0x00, 0x05, 0x00, 0x00, 0x14, 0x00, 0x00,
  0x58, 0x00, 0x01, 0x60, 0x00, 0x04, 0x80, 0x00, 0x13, 0x00, 0x00, 0x46,
  0x00, 0x01, 0x0C, 0x00, 0x04, 0x18, 0x00, 0x10, 0x3C, 0x01, 0xC0, 0x3F,
  0xFC, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x23, 0xF8, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x06, 0x06, 0xFE, 0x3C, 0x00, 0x80, 0x01, 0xA0,
  0x00, 0xC8, 0x00, 0x62, 0x00, 0x30, 0x80, 0x18, 0x20, 0x0C, 0x08, 0x06,
  0x02, 0x03, 0x00, 0x81, 0x80, 0x20, 0xC0, 0x08, 0x60, 0x02, 0x30, 0x00,
  0x9E, 0x00, 0x2C, 0xC0, 0x0E, 0x18, 0x03, 0x06, 0x00, 0x80, 0xC0, 0x20,
  0x18, 0x08, 0x02, 0x02, 0x00, 0xC0, 0x80, 0x18, 0x20, 0x03, 0x08, 0x00,
  0x42, 0x00, 0x18, 0x80, 0x03, 0x20, 0x00, 0x68, 0x00, 0x1C, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x03, 0xFF,
  0xF8, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xA0, 0x00, 0x07, 0xB0, 0x00,
  0x05, 0xB0, 0x00, 0x0D, 0x90, 0x00, 0x09, 0x98, 0x00, 0x09, 0x88, 0x00,
  0x19, 0x8C, 0x00, 0x11, 0x8C, 0x00, 0x31, 0x84, 0x00, 0x21, 0x86, 0x00,
  0x21, 0x82, 0x00, 0x61, 0x83, 0x00, 0x41, 0x83, 0x00, 0xC1, 0x81, 0x00,
  0x81, 0x81, 0x81, 0x81, 0x80, 0x81, 0x81, 0x80, 0xC1, 0x01, 0x80, 0x43,
  0x01, 0x80, 0x42, 0x01, 0x80, 0x66, 0x01, 0x80, 0x26, 0x01, 0x80, 0x34,
  0x01, 0x80, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0xD8, 0x00, 0x19, 0x00, 0x03, 0x30, 0x00,
  0x63, 0x00, 0x0C, 0x20, 0x01, 0x86, 0x00, 0x30, 0x60, 0x06, 0x04, 0x00,
  0xC0, 0xC0, 0x18, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x0C, 0x01, 0x81,
  0x80, 0x10, 0x30, 0x03, 0x06, 0x00, 0x30, 0xC0, 0x03, 0x18, 0x00, 0x63,
  0x00, 0x06, 0x60, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0x00, 0x70,
  0x0E, 0x00, 0x38, 0x18, 0x00, 0x0C, 0x10, 0x00, 0x04, 0x30, 0x00, 0x06,
  0x20, 0x00, 0x02, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x40, 0x00, 0x01,
  0x40, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x20, 0x00, 0x02, 0x30, 0x00, 0x06,
  0x18, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x0E, 0x00, 0x30, 0x03, 0x80, 0xE0,
  0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x80, 0x78, 0x80, 0x0C, 0x80, 0x06, 0x80,
  0x02, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x02, 0x80, 0x06, 0x80, 0x0C, 0x80, 0x18, 0xFF, 0xF0, 0xFE, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x01, 0xFF, 0xC0, 0x03, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x18, 0x00, 0x0C,
  0x10, 0x00, 0x04, 0x30, 0x00, 0x06, 0x20, 0x00, 0x02, 0x60, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x40, 0x00, 0x01, 0x40, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x40, 0x00, 0x01, 0x40, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03,
  0x20, 0x00, 0x02, 0x30, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x08,
  0x0E, 0x00, 0x38, 0x03, 0x80, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x38, 0xFF, 0xE0, 0x40, 0x3E, 0x20, 0x03, 0x90, 0x00, 0xC8,
  0x00, 0x34, 0x00, 0x1A, 0x00, 0x0D, 0x00, 0x06, 0x80, 0x03, 0x40, 0x01,
  0xA0, 0x00, 0x90, 0x00, 0xC8, 0x00, 0xC4, 0x03, 0xC3, 0xFF, 0x01, 0x00,
  0x80, 0x80, 0x60, 0x40, 0x18, 0x20, 0x0C, 0x10, 0x03, 0x08, 0x00, 0x84,
  0x00, 0x62, 0x00, 0x19, 0x00, 0x0C, 0x80, 0x03, 0x40, 0x00, 0xA0, 0x00,
  0x60, 0x00, 0xC0, 0x07, 0xFF, 0x06, 0x01, 0xC6, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x38, 0x07, 0x0F, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x02, 0x80, 0x00, 0x2C, 0x00,
  0x06, 0x40, 0x00, 0x66, 0x00, 0x0C, 0x30, 0x01, 0x81, 0xC0, 0x70, 0x07,
  0xFC, 0x00, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00,
  0x04, 0x20, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x02, 0x04, 0x00, 0x18,
  0x18, 0x00, 0x40, 0x20, 0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x20, 0x04,
  0x01, 0x80, 0x18, 0x06, 0x00, 0x60, 0x10, 0x00, 0x80, 0xC0, 0x03, 0x02,
  0x00, 0x04, 0x08, 0x00, 0x18, 0x60, 0x00, 0x61, 0x00, 0x00, 0x8C, 0x00,
  0x03, 0x30, 0x00, 0x0C, 0x80, 0x00, 0x16, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x80, 0x07, 0x00,
  0x0D, 0x00, 0x0E, 0x00, 0x1B, 0x00, 0x14, 0x00, 0x36, 0x00, 0x2C, 0x00,
  0x44, 0x00, 0xC8, 0x01, 0x88, 0x01, 0x10, 0x03, 0x18, 0x02, 0x30, 0x04,
  0x30, 0x04, 0x60, 0x08, 0x20, 0x18, 0x40, 0x30, 0x60, 0x20, 0x80, 0x60,
  0xC0, 0x41, 0x80, 0x80, 0x81, 0x81, 0x03, 0x01, 0x03, 0x02, 0x06, 0x03,
  0x04, 0x06, 0x08, 0x06, 0x08, 0x0C, 0x10, 0x04, 0x30, 0x08, 0x60, 0x08,
  0x40, 0x10, 0xC0, 0x18, 0x80, 0x31, 0x00, 0x33, 0x00, 0x66, 0x00, 0x26,
  0x00, 0x4C, 0x00, 0x48, 0x00, 0xD8, 0x00, 0xD0, 0x01, 0xA0, 0x00, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x63, 0x00, 0x04, 0x30, 0x00, 0xC1, 0x80, 0x18,
  0x08, 0x01, 0x00, 0xC0, 0x30, 0x06, 0x06, 0x00, 0x20, 0x40, 0x03, 0x0C,
  0x00, 0x18, 0x80, 0x00, 0x90, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xF0, 0x00, 0x19, 0x80, 0x01, 0x08, 0x00, 0x30, 0xC0, 0x06,
  0x06, 0x00, 0x40, 0x20, 0x0C, 0x03, 0x01, 0x80, 0x10, 0x18, 0x01, 0x83,
  0x00, 0x0C, 0x20, 0x00, 0x46, 0x00, 0x06, 0xC0, 0x00, 0x30, 0xC0, 0x00,
  0x36, 0x00, 0x06, 0x60, 0x00, 0x43, 0x00, 0x0C, 0x10, 0x00, 0x81, 0x80,
  0x18, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x04, 0x06, 0x00, 0x60, 0x40, 0x02,
  0x0C, 0x00, 0x30, 0x80, 0x01, 0x18, 0x00, 0x19, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xC0, 0x06, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C,
  0x00, 0x40, 0x06, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00,
  0x30, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xFF, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x12, 0x00, 0x0C, 0x80, 0x02, 0x10, 0x01, 0x84, 0x00,
  0x40, 0x80, 0x30, 0x20, 0x08, 0x04, 0x06, 0x01, 0x01, 0x00, 0x20, 0xC0,
  0x08, 0x20, 0x03, 0x18, 0x00, 0x44, 0x00, 0x0B, 0x00, 0x02, 0x80, 0x00,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0xC1, 0x02, 0x0C, 0x18, 0x10, 0x1F, 0xF0,
  0x60, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x0E, 0x1F, 0xFC, 0xE0, 0x1B, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x2D, 0x81, 0x99, 0xFE, 0x30,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x40, 0x63, 0xFC, 0x37, 0x03, 0x9A,
  0x00, 0xCE, 0x00, 0x37, 0x00, 0x0B, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x01, 0x70, 0x01, 0xBC, 0x01, 0x9B, 0x83, 0x8C,
  0x7F, 0x80, 0x00, 0x20, 0x0F, 0xFC, 0x30, 0x08, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xE0, 0x30, 0x7F, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0xC0, 0x83, 0xFC, 0x47, 0x03, 0x26, 0x00, 0xD2, 0x00, 0x2B, 0x00, 0x0D,
  0x00, 0x06, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x06, 0x80, 0x03, 0x60, 0x01, 0xB0,
  0x01, 0x4C, 0x01, 0xA3, 0x81, 0x90, 0xFF, 0x88, 0x00, 0xC0, 0x07, 0xF8,
  0x1C, 0x0C, 0x10, 0x06, 0x20, 0x02, 0x60, 0x03, 0x40, 0x01, 0x40, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x03,
  0x07, 0xFE, 0x01, 0xF8, 0x18, 0x41, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x07, 0xFE, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x03, 0xFC, 0x47, 0x03, 0x26, 0x00, 0x52, 0x00,
  0x3B, 0x00, 0x0D, 0x00, 0x06, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x06, 0x80, 0x03,
  0x60, 0x01, 0x90, 0x01, 0x4C, 0x01, 0xA3, 0x81, 0x90, 0x7F, 0x08, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC8,
  0x00, 0xC7, 0xC1, 0xC0, 0x7F, 0x80, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC7, 0xF8, 0xDC, 0x0C, 0xD0, 0x06, 0xE0, 0x02, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x02,
  0x0C, 0x18, 0x00, 0x00, 0x00, 0x00, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x14, 0x6F, 0x80, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x1B, 0x00, 0x66, 0x01, 0x8C, 0x06, 0x18, 0x18, 0x30, 0x60,
  0x61, 0x80, 0xC6, 0x01, 0x88, 0x03, 0x38, 0x06, 0x98, 0x0E, 0x18, 0x1C,
  0x10, 0x30, 0x30, 0x60, 0x30, 0xC0, 0x31, 0x80, 0x23, 0x00, 0x66, 0x00,
  0x6C, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x80, 0x08, 0x19, 0xFE, 0x0F, 0xE3, 0x60, 0x67, 0x07, 0x78, 0x06, 0x80,
  0x6E, 0x00, 0xE0, 0x07, 0x80, 0x0C, 0x00, 0xF0, 0x01, 0x80, 0x1E, 0x00,
  0x20, 0x03, 0xC0, 0x04, 0x00, 0x78, 0x00, 0x80, 0x0F, 0x00, 0x10, 0x01,
  0xE0, 0x02, 0x00, 0x3C, 0x00, 0x40, 0x07, 0x80, 0x08, 0x00, 0xF0, 0x01,
  0x00, 0x1E, 0x00, 0x20, 0x03, 0xC0, 0x04, 0x00, 0x78, 0x00, 0x80, 0x0F,
  0x00, 0x10, 0x01, 0xE0, 0x02, 0x00, 0x3C, 0x00, 0x40, 0x06, 0x00, 0xC0,
  0xC7, 0xF8, 0xD8, 0x0C, 0xD0, 0x06, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x00, 0x40, 0x01, 0xFF, 0x01, 0xC0, 0xE0, 0xC0,
  0x0C, 0x20, 0x01, 0x18, 0x00, 0x64, 0x00, 0x09, 0x00, 0x02, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x34,
  0x00, 0x09, 0x00, 0x02, 0x60, 0x01, 0x88, 0x00, 0x43, 0x00, 0x30, 0x70,
  0x38, 0x07, 0xF8, 0x00, 0x00, 0x40, 0x63, 0xFC, 0x33, 0x03, 0x9A, 0x00,
  0x4E, 0x00, 0x37, 0x00, 0x0B, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x01, 0x70, 0x01, 0xB4, 0x01, 0x99, 0x81, 0x8C, 0x7F,
  0x86, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x07, 0xFC,
  0x47, 0x03, 0x26, 0x00, 0xD2, 0x00, 0x2B, 0x00, 0x0D, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x06, 0x80, 0x03, 0x60, 0x03, 0xB0, 0x01, 0x4C, 0x01,
  0xA3, 0x01, 0xB0, 0xFF, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0xCF, 0xFB, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x00, 0x01, 0x00, 0x7F, 0xE7, 0x01, 0x90, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x01, 0xB0, 0x0C, 0x7F, 0xE0, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x81,
  0xFF, 0xC6, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x10, 0x03,
  0x00, 0x60, 0x07, 0xE0, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0x40, 0x07, 0x60, 0x0B, 0x30, 0x3B, 0x1F, 0xE3, 0xC0, 0x01, 0xA0, 0x00,
  0x98, 0x00, 0xCC, 0x00, 0x62, 0x00, 0x21, 0x80, 0x30, 0x40, 0x10, 0x20,
  0x18, 0x18, 0x0C, 0x04, 0x04, 0x03, 0x06, 0x01, 0x82, 0x00, 0x41, 0x00,
  0x31, 0x80, 0x08, 0x80, 0x04, 0xC0, 0x03, 0x60, 0x00, 0xA0, 0x00, 0x70,
  0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x05, 0x00,
  0x68, 0x02, 0xC0, 0x24, 0x03, 0x60, 0x13, 0x01, 0x90, 0x19, 0x80, 0x88,
  0x08, 0x40, 0xC6, 0x04, 0x30, 0x61, 0x06, 0x18, 0x20, 0x83, 0x04, 0x30,
  0x61, 0x02, 0x18, 0x10, 0x81, 0x88, 0x08, 0xC0, 0xCC, 0x06, 0x60, 0x26,
  0x01, 0x20, 0x12, 0x00, 0x90, 0x0D, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01,
  0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x03, 0x30, 0x03, 0x0C, 0x03,
  0x03, 0x01, 0x80, 0x81, 0x80, 0x61, 0x80, 0x18, 0x80, 0x04, 0xC0, 0x03,
  0xC0, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x68, 0x00, 0x66, 0x00, 0x21, 0x80,
  0x30, 0x60, 0x30, 0x10, 0x30, 0x0C, 0x10, 0x03, 0x18, 0x00, 0x98, 0x00,
  0x70, 0xC0, 0x01, 0xA0, 0x00, 0x98, 0x00, 0xCC, 0x00, 0x62, 0x00, 0x21,
  0x80, 0x30, 0x40, 0x10, 0x30, 0x18, 0x18, 0x0C, 0x04, 0x04, 0x03, 0x06,
  0x00, 0x82, 0x00, 0x41, 0x00, 0x31, 0x80, 0x08, 0x80, 0x06, 0xC0, 0x03,
  0x60, 0x00, 0xA0, 0x00, 0x70, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x0F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x20,
  0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x00,
  0x0C, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00,
  0x3F, 0xFF, 0x01, 0xE0, 0x70, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x01, 0x80,
  0xE0, 0x07, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x1E, 0x00, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x07,
  0x00, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x30, 0x0C,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x03, 0x03, 0xC0, 0xF0, 0x00, 0x3F, 0x00, 0x70, 0x70,
  0x38, 0x07, 0xF0,
};

const GFXglyph NotoSans_ExtraLight38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 27, 9, 3, -27 },
  { 12, 7, 10, 13, 3, -27 },
  { 21, 22, 27, 25, 1, -27 },
  { 96, 16, 31, 22, 2, -29 },
  { 158, 26, 28, 30, 2, -28 },
  { 249, 24, 28, 27, 2, -28 },
  { 333, 1, 10, 7, 3, -27 },
  { 335, 7, 33, 10, 2, -27 },
  { 364, 7, 33, 10, 1, -27 },
  { 393, 17, 16, 21, 2, -29 },
  { 427, 18, 17, 22, 2, -22 },
  { 466, 4, 9, 8, 1, -4 },
  { 471, 9, 1, 12, 2, -11 },
  { 473, 3, 3, 9, 3, -3 },
  { 475, 12, 27, 13, 0, -27 },
  { 516, 17, 28, 22, 2, -28 },
  { 576, 8, 27, 22, 4, -27 },
  { 603, 17, 28, 22, 2, -28 },
  { 663, 17, 28, 22, 2, -28 },
  { 723, 20, 27, 22, 1, -27 },
  { 791, 16, 27, 22, 3, -27 },
  { 845, 18, 28, 22, 2, -28 },
  { 908, 18, 27, 22, 2, -27 },
  { 969, 17, 28, 22, 2, -28 },
  { 1029, 17, 28, 22, 2, -28 },
  { 1089, 3, 20, 9, 3, -20 },
  { 1097, 5, 25, 9, 1, -20 },
  { 1113, 18, 17, 22, 2, -22 },
  { 1152, 18, 9, 22, 2, -18 },
  { 1173, 18, 17, 22, 2, -22 },
  { 1212, 13, 28, 16, 1, -28 },
  { 1258, 30, 31, 34, 2, -27 },
  { 1375, 22, 27, 22, 0, -27 },
  { 1450, 17, 27, 24, 4, -27 },
  { 1508, 20, 28, 23, 2, -28 },
  { 1578, 20, 27, 27, 4, -27 },
  { 1646, 15, 27, 21, 4, -27 },
  { 1697, 15, 27, 19, 4, -27 },
  { 1748, 22, 28, 27, 2, -28 },
  { 1825, 19, 27, 27, 4, -27 },
  { 1890, 7, 27, 11, 2, -27 },
  { 1914, 9, 34, 9, -4, -27 },
  { 1953, 18, 27, 22, 4, -27 },
  { 2014, 15, 27, 19, 4, -27 },
  { 2065, 24, 27, 32, 4, -27 },
  { 2146, 19, 27, 27, 4, -27 },
  { 2211, 24, 28, 29, 2, -28 },
  { 2295, 16, 27, 22, 4, -27 },
  { 2349, 24, 34, 29, 2, -28 },
  { 2451, 17, 27, 22, 4, -27 },
  { 2509, 17, 28, 21, 2, -28 },
  { 2569, 19, 27, 20, 0, -27 },
  { 2634, 20, 27, 27, 4, -27 },
  { 2702, 22, 27, 22, 0, -27 },
  { 2777, 31, 27, 33, 1, -27 },
  { 2882, 20, 27, 20, 0, -27 },
  { 2950, 20, 27, 20, 0, -27 },
  { 3018, 19, 27, 22, 1, -27 },
  { 3083, 8, 33, 12, 3, -27 },
  { 3116, 12, 27, 13, 0, -27 },
  { 3157, 8, 33, 12, 1, -27 },
  { 3190, 18, 17, 22, 2, -27 },
  { 3229, 15, 2, 15, 0, 3 },
  { 3233, 6, 6, 10, 2, -29 },
  { 3238, 15, 20, 20, 2, -20 },
  { 3276, 17, 29, 22, 3, -29 },
  { 3338, 15, 21, 18, 2, -21 },
  { 3378, 17, 29, 22, 2, -29 },
  { 3440, 16, 21, 21, 2, -21 },
  { 3482, 13, 29, 11, 0, -29 },
  { 3530, 17, 30, 22, 2, -21 },
  { 3594, 16, 29, 22, 3, -29 },
  { 3652, 2, 28, 8, 3, -28 },
  { 3659, 7, 37, 8, -2, -28 },
  { 3692, 15, 29, 18, 3, -29 },
  { 3747, 2, 29, 8, 3, -29 },
  { 3755, 27, 21, 33, 3, -21 },
  { 3826, 16, 21, 22, 3, -21 },
  { 3868, 18, 21, 22, 2, -21 },
  { 3916, 17, 30, 22, 3, -21 },
  { 3980, 17, 30, 22, 2, -21 },
  { 4044, 11, 20, 15, 3, -20 },
  { 4072, 14, 21, 18, 2, -21 },
  { 4109, 11, 25, 12, 0, -25 },
  { 4144, 16, 20, 22, 3, -20 },
  { 4184, 17, 20, 17, 0, -20 },
  { 4227, 25, 20, 27, 1, -20 },
  { 4290, 17, 20, 19, 1, -20 },
  { 4333, 17, 29, 17, 0, -20 },
  { 4395, 14, 20, 17, 2, -20 },
  { 4430, 11, 33, 13, 1, -27 },
  { 4476, 2, 38, 20, 9, -29 },
  { 4486, 11, 33, 13, 1, -27 },
  { 4532, 18, 3, 22, 2, -15 },
};

const GFXfont NotoSans_ExtraLight38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight38pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_EXTRALIGHT38PT7B_H_
