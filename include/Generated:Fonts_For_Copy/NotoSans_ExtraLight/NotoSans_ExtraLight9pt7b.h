#ifndef _NOTOSANS_EXTRALIGHT9PT7B_H_
#define _NOTOSANS_EXTRALIGHT9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xC0, 0x28, 0xB5, 0x3E, 0x51, 0x40, 0x5F, 0x66, 0xFA, 0x8B,
  0x4D, 0x3F, 0xB5, 0x55, 0xC0, 0x45, 0x28, 0x8A, 0xCB, 0xE0, 0xC0, 0x6A,
  0xA4, 0xD5, 0x5C, 0x5D, 0x50, 0x27, 0xC8, 0x40, 0xC0, 0xE0, 0x80, 0x29,
  0x29, 0x00, 0x69, 0x99, 0x99, 0xE0, 0xD5, 0x50, 0xC4, 0x95, 0x38, 0x69,
  0x16, 0x11, 0xF0, 0x31, 0x95, 0x27, 0x88, 0xE8, 0xE1, 0x1E, 0x68, 0x8E,
  0x99, 0xE0, 0xF8, 0x84, 0x42, 0x20, 0x69, 0x96, 0xB9, 0xE0, 0x64, 0xA3,
  0x17, 0x89, 0xC0, 0x88, 0x8C, 0x3E, 0x08, 0x30, 0xFF, 0xC0, 0xE0, 0xC9,
  0x80, 0xC4, 0x94, 0x10, 0x7E, 0xB6, 0x9D, 0x3B, 0xE8, 0x0F, 0x00, 0x22,
  0x94, 0xE8, 0xC4, 0xF9, 0xE9, 0x9F, 0x78, 0x88, 0x88, 0xF0, 0xF4, 0x63,
  0x18, 0xF8, 0xF3, 0xC9, 0xC0, 0xF3, 0xC9, 0x00, 0x7C, 0x21, 0x68, 0xC5,
  0xE0, 0x8C, 0x7F, 0x18, 0xC4, 0xFC, 0x55, 0x56, 0xBC, 0xCA, 0xA9, 0x92,
  0x49, 0xC0, 0x86, 0x3C, 0xF5, 0xB6, 0x90, 0x9D, 0xDB, 0x99, 0x74, 0x63,
  0x18, 0xC7, 0xC0, 0xF9, 0xBC, 0x88, 0x74, 0x63, 0x18, 0xC7, 0xC2, 0x08,
  0xF9, 0x9E, 0xA9, 0x78, 0x86, 0x11, 0xF0, 0xF9, 0x08, 0x42, 0x10, 0x8C,
  0x63, 0x18, 0xF8, 0x8C, 0x54, 0xA2, 0x10, 0x91, 0x9A, 0x5A, 0x66, 0x24,
  0x24, 0x9A, 0x88, 0xC5, 0x44, 0x9A, 0x98, 0x42, 0x10, 0x78, 0x88, 0x44,
  0x7C, 0xEA, 0xAC, 0x89, 0x22, 0x40, 0xD5, 0x5C, 0x22, 0x93, 0x10, 0xF0,
  0x90, 0x71, 0x79, 0xF0, 0x88, 0xE9, 0x99, 0xE0, 0xF2, 0x4E, 0x11, 0xF9,
  0x99, 0xF0, 0xF7, 0xCE, 0x6B, 0x24, 0x90, 0xF9, 0x99, 0xF1, 0xE0, 0x93,
  0xDB, 0x68, 0xBE, 0xBF, 0x80, 0x92, 0xE9, 0xA8, 0xFE, 0xFE, 0x9A, 0x69,
  0xA4, 0xF6, 0xDA, 0xE9, 0x99, 0xE0, 0xE9, 0x99, 0xE8, 0x80, 0x79, 0x99,
  0x71, 0x10, 0xEA, 0x80, 0x78, 0x61, 0xF0, 0x5E, 0x48, 0xC0, 0xB6, 0xDE,
  0x99, 0x66, 0x40, 0x96, 0x5B, 0x52, 0x48, 0x96, 0x26, 0x90, 0x99, 0x66,
  0x44, 0xC0, 0x72, 0x24, 0xF0, 0x69, 0x44, 0x98, 0xFF, 0x80, 0xC9, 0x14,
  0xB0, 0xF8,
};

const GFXglyph NotoSans_ExtraLight9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 6, 2, 1, -6 },
  { 2, 1, 2, 3, 1, -6 },
  { 3, 6, 6, 6, 0, -6 },
  { 8, 3, 8, 5, 1, -7 },
  { 11, 6, 7, 7, 1, -7 },
  { 17, 5, 7, 6, 1, -7 },
  { 22, 1, 2, 2, 0, -6 },
  { 23, 2, 7, 2, 0, -6 },
  { 25, 2, 7, 2, 0, -6 },
  { 27, 3, 4, 5, 1, -7 },
  { 29, 5, 4, 5, 0, -5 },
  { 32, 1, 2, 2, 0, -1 },
  { 33, 3, 1, 3, 0, -3 },
  { 34, 1, 1, 2, 1, -1 },
  { 35, 3, 6, 3, 0, -6 },
  { 38, 4, 7, 5, 1, -7 },
  { 42, 2, 6, 5, 1, -6 },
  { 44, 3, 7, 5, 1, -7 },
  { 47, 4, 7, 5, 0, -7 },
  { 51, 5, 6, 5, 0, -6 },
  { 55, 4, 6, 5, 1, -6 },
  { 58, 4, 7, 5, 1, -7 },
  { 62, 5, 6, 5, 0, -6 },
  { 66, 4, 7, 5, 1, -7 },
  { 70, 5, 7, 5, 0, -7 },
  { 75, 1, 5, 2, 1, -5 },
  { 76, 1, 6, 2, 0, -5 },
  { 77, 5, 4, 5, 0, -5 },
  { 80, 5, 2, 5, 0, -4 },
  { 82, 5, 4, 5, 0, -5 },
  { 85, 3, 7, 4, 0, -7 },
  { 88, 7, 7, 8, 0, -6 },
  { 95, 5, 6, 5, 0, -6 },
  { 99, 4, 6, 6, 1, -6 },
  { 102, 4, 7, 6, 1, -7 },
  { 106, 5, 6, 6, 1, -6 },
  { 110, 3, 6, 5, 1, -6 },
  { 113, 3, 6, 4, 1, -6 },
  { 116, 5, 7, 7, 1, -7 },
  { 121, 5, 6, 6, 1, -6 },
  { 125, 1, 6, 3, 1, -6 },
  { 126, 2, 8, 2, -1, -6 },
  { 128, 4, 6, 5, 1, -6 },
  { 131, 3, 6, 5, 1, -6 },
  { 134, 6, 6, 8, 1, -6 },
  { 139, 4, 6, 6, 1, -6 },
  { 142, 5, 7, 7, 1, -7 },
  { 147, 4, 6, 5, 1, -6 },
  { 150, 5, 9, 7, 1, -7 },
  { 156, 4, 6, 5, 1, -6 },
  { 159, 4, 7, 5, 0, -7 },
  { 163, 5, 6, 5, 0, -6 },
  { 167, 5, 6, 6, 1, -6 },
  { 171, 5, 6, 5, 0, -6 },
  { 175, 8, 6, 8, 0, -6 },
  { 181, 5, 6, 5, 0, -6 },
  { 185, 5, 6, 5, 0, -6 },
  { 189, 5, 6, 5, 0, -6 },
  { 193, 2, 7, 3, 1, -6 },
  { 195, 3, 6, 3, 0, -6 },
  { 198, 2, 7, 3, 0, -6 },
  { 200, 5, 4, 5, 0, -6 },
  { 203, 4, 1, 4, 0, 0 },
  { 204, 2, 2, 2, 0, -7 },
  { 205, 4, 5, 5, 0, -5 },
  { 208, 4, 7, 5, 1, -7 },
  { 212, 3, 5, 4, 1, -5 },
  { 214, 4, 7, 5, 1, -7 },
  { 218, 3, 5, 5, 1, -5 },
  { 220, 3, 7, 3, 0, -7 },
  { 223, 4, 7, 5, 1, -5 },
  { 227, 3, 7, 5, 1, -7 },
  { 230, 1, 7, 2, 0, -7 },
  { 231, 1, 9, 2, 0, -7 },
  { 233, 3, 7, 4, 1, -7 },
  { 236, 1, 7, 2, 0, -7 },
  { 237, 6, 5, 8, 1, -5 },
  { 241, 3, 5, 5, 1, -5 },
  { 243, 4, 5, 5, 1, -5 },
  { 246, 4, 7, 5, 1, -5 },
  { 250, 4, 7, 5, 0, -5 },
  { 254, 2, 5, 3, 1, -5 },
  { 256, 4, 5, 4, 0, -5 },
  { 259, 3, 6, 3, 0, -6 },
  { 262, 3, 5, 5, 1, -5 },
  { 264, 4, 5, 4, 0, -5 },
  { 267, 6, 5, 6, 0, -5 },
  { 271, 4, 5, 4, 0, -5 },
  { 274, 4, 7, 4, 0, -5 },
  { 278, 4, 5, 4, 0, -5 },
  { 281, 3, 7, 3, 0, -6 },
  { 284, 1, 9, 5, 2, -7 },
  { 286, 3, 7, 3, 0, -6 },
  { 289, 5, 1, 5, 0, -4 },
};

const GFXfont NotoSans_ExtraLight9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight9pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_EXTRALIGHT9PT7B_H_
