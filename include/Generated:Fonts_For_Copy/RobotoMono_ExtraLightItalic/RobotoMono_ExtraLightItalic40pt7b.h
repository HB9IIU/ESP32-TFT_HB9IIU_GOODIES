#ifndef _ROBOTOMONO_EXTRALIGHTITALIC40PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x0C, 0x10, 0x20, 0xC1, 0x83, 0x06, 0x08, 0x10, 0x60, 0xC1,
  0x83, 0x04, 0x08, 0x30, 0x60, 0xC1, 0x80, 0x00, 0x00, 0x00, 0x00, 0x83,
  0x87, 0x00, 0x63, 0x43, 0x42, 0xC2, 0xC2, 0xC6, 0x86, 0x84, 0x00, 0x18,
  0x18, 0x00, 0x30, 0x20, 0x00, 0x40, 0x40, 0x01, 0x81, 0x80, 0x02, 0x02,
  0x00, 0x04, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x20, 0x20, 0x1F, 0xFF, 0xFE,
  0x01, 0x81, 0x80, 0x02, 0x02, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00,
  0x20, 0x20, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x00, 0x02, 0x02, 0x00, 0x0C,
  0x0C, 0x00, 0x18, 0x10, 0x07, 0xFF, 0xFF, 0x00, 0xC0, 0xC0, 0x01, 0x81,
  0x00, 0x02, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x10, 0x10, 0x00, 0x20, 0x60,
  0x00, 0xC0, 0xC0, 0x01, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x07, 0xC0, 0x03, 0xFE, 0x00, 0xC0, 0x60,
  0x30, 0x06, 0x0C, 0x00, 0xC3, 0x00, 0x08, 0x60, 0x01, 0x8C, 0x00, 0x31,
  0x80, 0x06, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x98, 0x00, 0x33, 0x00, 0x06, 0x60,
  0x00, 0x8C, 0x00, 0x30, 0xC0, 0x0C, 0x18, 0x03, 0x81, 0xC1, 0xC0, 0x1F,
  0xF0, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x01, 0xF8, 0x00, 0x30, 0xC0, 0x02, 0x04, 0x00, 0x60, 0x40, 0xC4,
  0x04, 0x08, 0x40, 0x41, 0x84, 0x0C, 0x30, 0xC0, 0xC2, 0x04, 0x08, 0x60,
  0x41, 0x8C, 0x06, 0x30, 0x80, 0x3E, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0xC3, 0x80, 0x18, 0x7C, 0x01, 0x0C, 0x60, 0x31,
  0x82, 0x06, 0x10, 0x30, 0x43, 0x03, 0x08, 0x30, 0x31, 0x82, 0x02, 0x30,
  0x20, 0x22, 0x02, 0x06, 0x00, 0x30, 0x40, 0x01, 0x0C, 0x00, 0x1F, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0xE0, 0x01, 0x83, 0x00, 0x30, 0x30, 0x06, 0x03,
  0x00, 0x60, 0x30, 0x06, 0x03, 0x00, 0x60, 0x20, 0x06, 0x06, 0x00, 0x60,
  0xC0, 0x06, 0x18, 0x00, 0x37, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x07,
  0x80, 0x00, 0xEC, 0x00, 0x18, 0x60, 0x33, 0x06, 0x02, 0x60, 0x30, 0x66,
  0x01, 0x86, 0xC0, 0x18, 0x4C, 0x00, 0xCC, 0xC0, 0x0C, 0x8C, 0x00, 0x78,
  0xC0, 0x03, 0x0C, 0x00, 0x70, 0x60, 0x1D, 0x83, 0x87, 0x8C, 0x1F, 0xE0,
  0xE0, 0x69, 0x6D, 0xA4, 0x00, 0x10, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03,
  0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03,
  0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08,
  0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x20, 0x02, 0x00, 0x20, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02,
  0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C,
  0x00, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x03, 0x06, 0x1F, 0xF3, 0x3E, 0x1F,
  0xF0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0x98, 0x00, 0xC4, 0x00, 0xC3, 0x00,
  0xC0, 0xC1, 0xC0, 0x70, 0x40, 0x10, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x19,
  0x8C, 0x62, 0x31, 0x18, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x7F, 0xC0, 0x30, 0x38, 0x18, 0x06, 0x0C, 0x00, 0xC6, 0x00, 0x31,
  0x00, 0x04, 0xC0, 0x01, 0x30, 0x00, 0xC8, 0x00, 0xF6, 0x00, 0x65, 0x80,
  0x31, 0x60, 0x18, 0xD0, 0x0C, 0x34, 0x06, 0x0F, 0x06, 0x03, 0xC3, 0x00,
  0xB1, 0x80, 0x2C, 0xC0, 0x1B, 0x60, 0x06, 0xF0, 0x01, 0xB0, 0x00, 0xCC,
  0x00, 0x33, 0x00, 0x08, 0xC0, 0x06, 0x18, 0x03, 0x06, 0x01, 0x80, 0xE1,
  0xC0, 0x1F, 0xE0, 0x00, 0x00, 0xE0, 0x78, 0x7B, 0x3C, 0x6C, 0x0C, 0x01,
  0x80, 0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xE0,
  0x0C, 0x06, 0x03, 0x00, 0x60, 0xC0, 0x0C, 0x30, 0x00, 0xC6, 0x00, 0x18,
  0x80, 0x03, 0x30, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x7F,
  0xFF, 0xCF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x3F, 0xF0, 0x0E, 0x07, 0x03,
  0x00, 0x20, 0xC0, 0x06, 0x18, 0x00, 0xC6, 0x00, 0x08, 0xC0, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x09, 0x80, 0x01, 0x30, 0x00, 0x66, 0x00,
  0x0C, 0x40, 0x03, 0x0C, 0x00, 0x60, 0xC0, 0x38, 0x1E, 0x1E, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x6C, 0x00,
  0x0C, 0xC0, 0x00, 0xC8, 0x00, 0x18, 0x80, 0x03, 0x18, 0x00, 0x61, 0x80,
  0x0C, 0x18, 0x01, 0x81, 0x80, 0x18, 0x10, 0x03, 0x01, 0x00, 0x60, 0x30,
  0x0C, 0x03, 0x01, 0x80, 0x30, 0x18, 0x02, 0x03, 0x00, 0x20, 0x60, 0x06,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x03,
  0xFF, 0xF0, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x19, 0xF8, 0x01, 0xFF, 0xE0, 0x1C, 0x07, 0x01, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x8C, 0x00, 0x10, 0x40, 0x03, 0x06, 0x00, 0x30, 0x60,
  0x06, 0x03, 0x00, 0xC0, 0x1C, 0x38, 0x00, 0xFF, 0x00, 0x00, 0x03, 0x80,
  0x07, 0xE0, 0x07, 0x80, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x07, 0x00, 0xCF, 0xF8,
  0x36, 0x07, 0x0B, 0x00, 0xC7, 0x00, 0x19, 0x80, 0x02, 0x60, 0x00, 0x98,
  0x00, 0x34, 0x00, 0x0D, 0x00, 0x03, 0x40, 0x00, 0x90, 0x00, 0x64, 0x00,
  0x19, 0x80, 0x04, 0x60, 0x03, 0x0C, 0x01, 0x83, 0x00, 0xC0, 0x70, 0xE0,
  0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x01,
  0xC0, 0xC0, 0x30, 0x06, 0x06, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30,
  0x80, 0x03, 0x08, 0x00, 0x30, 0x80, 0x02, 0x0C, 0x00, 0x60, 0xC0, 0x0C,
  0x06, 0x01, 0x80, 0x3C, 0xF0, 0x01, 0xFC, 0x00, 0x78, 0xF0, 0x0C, 0x01,
  0x83, 0x80, 0x08, 0x30, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0x44, 0x00,
  0x04, 0x40, 0x00, 0xC4, 0x00, 0x0C, 0x60, 0x01, 0x86, 0x00, 0x38, 0x30,
  0x07, 0x01, 0xC1, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0xF0, 0x03, 0xFE, 0x03,
  0x81, 0x83, 0x00, 0x63, 0x00, 0x31, 0x80, 0x0D, 0x80, 0x06, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0C, 0xC0, 0x0E, 0x60, 0x0F, 0x18, 0x1D, 0x87, 0xF8, 0x80,
  0xF0, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x70, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x0C, 0x71, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x8E, 0x38,
  0x07, 0x07, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0xC0,
  0x80, 0x00, 0x00, 0x40, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x08, 0x7F, 0xFF, 0xDF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0,
  0x10, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x03, 0x00, 0x00,
  0x03, 0xE0, 0x1F, 0xF0, 0x70, 0x71, 0x80, 0x66, 0x00, 0x6C, 0x00, 0xF0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF,
  0x80, 0x0E, 0x03, 0x00, 0x60, 0x06, 0x03, 0x00, 0x08, 0x18, 0x00, 0x30,
  0xC0, 0xE0, 0x46, 0x0F, 0xC1, 0x18, 0x61, 0x84, 0xC3, 0x06, 0x12, 0x08,
  0x10, 0x48, 0x60, 0x41, 0x61, 0x03, 0x05, 0x0C, 0x08, 0x34, 0x20, 0x20,
  0xF0, 0x80, 0x82, 0xC2, 0x06, 0x0A, 0x18, 0x10, 0x28, 0x60, 0xC1, 0xA1,
  0x83, 0x04, 0x86, 0x14, 0x33, 0x08, 0xD1, 0x8C, 0x3C, 0x3C, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x20, 0x07, 0x07, 0x80,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x05, 0x00, 0x00,
  0xD0, 0x00, 0x09, 0x00, 0x01, 0x90, 0x00, 0x11, 0x80, 0x03, 0x18, 0x00,
  0x21, 0x80, 0x06, 0x18, 0x00, 0x40, 0x80, 0x0C, 0x08, 0x00, 0x80, 0x80,
  0x18, 0x0C, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0xC0, 0x60, 0x04,
  0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x08, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00,
  0x63, 0x00, 0x06, 0x30, 0x00, 0x26, 0x00, 0x02, 0x60, 0x00, 0x2C, 0x00,
  0x03, 0x07, 0xFF, 0x00, 0xC0, 0x3C, 0x0C, 0x00, 0xC0, 0xC0, 0x06, 0x0C,
  0x00, 0x20, 0x80, 0x02, 0x08, 0x00, 0x21, 0x80, 0x02, 0x18, 0x00, 0x61,
  0x80, 0x06, 0x18, 0x00, 0xC1, 0x00, 0x38, 0x10, 0x1E, 0x03, 0xFF, 0xC0,
  0x30, 0x07, 0x03, 0x00, 0x18, 0x30, 0x00, 0xC2, 0x00, 0x0C, 0x20, 0x00,
  0x46, 0x00, 0x04, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x40, 0x00, 0xC4, 0x00,
  0x18, 0xC0, 0x03, 0x0C, 0x00, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x00,
  0x3E, 0x00, 0x0F, 0xF8, 0x01, 0x81, 0xC0, 0x70, 0x06, 0x06, 0x00, 0x60,
  0xC0, 0x03, 0x18, 0x00, 0x31, 0x80, 0x03, 0x30, 0x00, 0x33, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0xC4, 0x00, 0x0C, 0x40, 0x00, 0x86, 0x00, 0x18, 0x60,
  0x03, 0x02, 0x00, 0x70, 0x30, 0x0E, 0x01, 0xC3, 0xC0, 0x0F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0xC0, 0x78, 0x0C, 0x01, 0xC0, 0x80, 0x0C, 0x08, 0x00,
  0x61, 0x80, 0x06, 0x18, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x31, 0x00,
  0x03, 0x10, 0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x33, 0x00, 0x03, 0x30,
  0x00, 0x22, 0x00, 0x02, 0x20, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x46,
  0x00, 0x0C, 0x40, 0x00, 0xC4, 0x00, 0x18, 0xC0, 0x03, 0x0C, 0x00, 0x70,
  0xC0, 0x0E, 0x0C, 0x03, 0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x07, 0xFF,
  0xF8, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF8, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x03, 0x81, 0xC0, 0x70, 0x06,
  0x06, 0x00, 0x60, 0xC0, 0x03, 0x18, 0x00, 0x31, 0x80, 0x03, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x3F, 0xEC, 0x00, 0x06, 0xC0,
  0x00, 0x4C, 0x00, 0x04, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0x40, 0x00, 0xC6,
  0x00, 0x0C, 0x60, 0x00, 0x83, 0x00, 0x18, 0x38, 0x03, 0x01, 0xC1, 0xE0,
  0x07, 0xF8, 0x00, 0x06, 0x00, 0x0C, 0x10, 0x00, 0x30, 0x40, 0x00, 0xC3,
  0x00, 0x02, 0x0C, 0x00, 0x08, 0x30, 0x00, 0x60, 0x80, 0x01, 0x82, 0x00,
  0x06, 0x08, 0x00, 0x10, 0x60, 0x00, 0x41, 0x80, 0x01, 0x06, 0x00, 0x0C,
  0x10, 0x00, 0x30, 0x7F, 0xFF, 0xC1, 0x00, 0x02, 0x0C, 0x00, 0x08, 0x30,
  0x00, 0x60, 0xC0, 0x01, 0x82, 0x00, 0x06, 0x08, 0x00, 0x18, 0x60, 0x00,
  0x41, 0x80, 0x01, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x40, 0x00, 0xC1,
  0x00, 0x03, 0x0C, 0x00, 0x08, 0x30, 0x00, 0x60, 0x07, 0xFF, 0xF0, 0x81,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x84, 0x00,
  0x08, 0x20, 0x00, 0xC1, 0x00, 0x06, 0x0C, 0x00, 0x60, 0x60, 0x06, 0x01,
  0x80, 0x70, 0x07, 0x0E, 0x00, 0x1F, 0xE0, 0x00, 0x06, 0x00, 0x1C, 0x10,
  0x00, 0xC0, 0xC0, 0x06, 0x03, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x0C,
  0x00, 0x80, 0x60, 0x02, 0x03, 0x00, 0x18, 0x18, 0x00, 0x60, 0xC0, 0x01,
  0x86, 0x00, 0x06, 0x30, 0x00, 0x11, 0x80, 0x00, 0x4F, 0x00, 0x03, 0x66,
  0x00, 0x0F, 0x18, 0x00, 0x38, 0x30, 0x00, 0xC0, 0xC0, 0x02, 0x01, 0x80,
  0x08, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x06, 0x00, 0x60, 0x10,
  0x00, 0xC0, 0x40, 0x03, 0x03, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00,
  0x30, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x03, 0xC1, 0x40, 0x0F,
  0x0D, 0x00, 0x68, 0x36, 0x01, 0x20, 0xD8, 0x0C, 0x82, 0x60, 0x26, 0x08,
  0x81, 0x98, 0x22, 0x0C, 0x61, 0x88, 0x31, 0x06, 0x31, 0x84, 0x18, 0xC6,
  0x30, 0x43, 0x30, 0xC1, 0x04, 0x83, 0x0C, 0x16, 0x0C, 0x30, 0x70, 0x20,
  0xC1, 0xC0, 0x83, 0x06, 0x06, 0x08, 0x00, 0x18, 0x20, 0x00, 0x61, 0x80,
  0x01, 0x86, 0x00, 0x04, 0x18, 0x00, 0x10, 0x60, 0x00, 0xC1, 0x00, 0x03,
  0x04, 0x00, 0x0C, 0x30, 0x00, 0x20, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30,
  0x70, 0x00, 0x83, 0x40, 0x02, 0x0D, 0x80, 0x18, 0x36, 0x00, 0x60, 0xC8,
  0x01, 0x82, 0x30, 0x06, 0x08, 0xC0, 0x10, 0x61, 0x00, 0x41, 0x86, 0x03,
  0x06, 0x18, 0x0C, 0x18, 0x20, 0x30, 0x40, 0xC0, 0xC1, 0x01, 0x02, 0x0C,
  0x06, 0x08, 0x30, 0x18, 0x60, 0xC0, 0x21, 0x83, 0x00, 0xC6, 0x08, 0x03,
  0x18, 0x20, 0x04, 0x41, 0x80, 0x19, 0x06, 0x00, 0x6C, 0x18, 0x00, 0xB0,
  0x40, 0x03, 0xC1, 0x00, 0x07, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0x00,
  0x3E, 0x00, 0x0F, 0xF8, 0x03, 0x81, 0xC0, 0x70, 0x0C, 0x06, 0x00, 0x60,
  0xC0, 0x06, 0x18, 0x00, 0x21, 0x80, 0x03, 0x30, 0x00, 0x33, 0x00, 0x03,
  0x30, 0x00, 0x32, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x02, 0x60, 0x00,
  0x26, 0x00, 0x06, 0x40, 0x00, 0x64, 0x00, 0x06, 0xC0, 0x00, 0x4C, 0x00,
  0x0C, 0xC0, 0x00, 0xC4, 0x00, 0x08, 0x40, 0x01, 0x86, 0x00, 0x10, 0x60,
  0x03, 0x02, 0x00, 0x60, 0x30, 0x0C, 0x01, 0xC7, 0x80, 0x0F, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x30, 0x07, 0x01, 0x00, 0x1C, 0x08, 0x00, 0x60, 0xC0,
  0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x03, 0x08, 0x00, 0x18,
  0x40, 0x00, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x06, 0x08, 0x00,
  0xE0, 0x40, 0x3E, 0x07, 0xFF, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x03, 0x81, 0xC0, 0x70, 0x06,
  0x0C, 0x00, 0x60, 0xC0, 0x02, 0x18, 0x00, 0x31, 0x00, 0x03, 0x30, 0x00,
  0x12, 0x00, 0x01, 0x60, 0x00, 0x16, 0x00, 0x01, 0x60, 0x00, 0x34, 0x00,
  0x03, 0x40, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x2C, 0x00, 0x02, 0xC0,
  0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x4C, 0x00, 0x0C, 0xC0, 0x00, 0x84,
  0x00, 0x18, 0x60, 0x03, 0x06, 0x00, 0x60, 0x30, 0x0C, 0x01, 0xC3, 0x80,
  0x0F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x07, 0xFF, 0x00, 0x40, 0x1C, 0x0C, 0x00, 0xE0, 0xC0,
  0x06, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x08, 0x00, 0x30, 0x80, 0x03, 0x18,
  0x00, 0x31, 0x80, 0x02, 0x18, 0x00, 0x61, 0x80, 0x0C, 0x10, 0x01, 0xC1,
  0x00, 0x30, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x30, 0x18, 0x03, 0x00, 0xC0,
  0x20, 0x0C, 0x02, 0x00, 0x40, 0x60, 0x06, 0x06, 0x00, 0x60, 0x60, 0x02,
  0x04, 0x00, 0x30, 0x40, 0x03, 0x04, 0x00, 0x10, 0xC0, 0x01, 0x8C, 0x00,
  0x18, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x03, 0x80, 0xC0, 0x60, 0x06, 0x0C,
  0x00, 0x30, 0x80, 0x03, 0x18, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xCC, 0x00, 0x04, 0xC0, 0x00, 0xCC, 0x00,
  0x0C, 0x40, 0x00, 0x86, 0x00, 0x18, 0x30, 0x07, 0x01, 0xE1, 0xE0, 0x0F,
  0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x18,
  0x40, 0x00, 0xC2, 0x00, 0x06, 0x30, 0x00, 0x21, 0x80, 0x01, 0x0C, 0x00,
  0x18, 0x40, 0x00, 0xC2, 0x00, 0x06, 0x10, 0x00, 0x31, 0x80, 0x01, 0x0C,
  0x00, 0x08, 0x60, 0x00, 0xC2, 0x00, 0x06, 0x10, 0x00, 0x31, 0x80, 0x01,
  0x0C, 0x00, 0x08, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x10, 0x00, 0x30, 0x80,
  0x01, 0x84, 0x00, 0x08, 0x20, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x60,
  0x20, 0x06, 0x01, 0x80, 0x60, 0x07, 0x0E, 0x00, 0x1F, 0xE0, 0x00, 0xC0,
  0x00, 0x34, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x0C, 0x60, 0x00, 0xC6,
  0x00, 0x18, 0x20, 0x01, 0x82, 0x00, 0x30, 0x30, 0x03, 0x03, 0x00, 0x60,
  0x30, 0x06, 0x03, 0x00, 0x40, 0x30, 0x0C, 0x01, 0x00, 0x80, 0x10, 0x18,
  0x01, 0x81, 0x00, 0x18, 0x30, 0x01, 0x83, 0x00, 0x18, 0x60, 0x00, 0x86,
  0x00, 0x08, 0xC0, 0x00, 0xCC, 0x00, 0x0D, 0x80, 0x00, 0xD8, 0x00, 0x0D,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x20, 0x1E,
  0x03, 0x00, 0xB0, 0x18, 0x0D, 0x80, 0xC0, 0x6C, 0x0F, 0x02, 0x60, 0x58,
  0x13, 0x06, 0xC1, 0x98, 0x36, 0x0C, 0xC1, 0x30, 0x46, 0x19, 0x86, 0x30,
  0xCC, 0x31, 0x84, 0x61, 0x0C, 0x63, 0x18, 0x63, 0x18, 0xC3, 0x10, 0xC4,
  0x19, 0x86, 0x20, 0xCC, 0x33, 0x06, 0x41, 0x98, 0x36, 0x0C, 0x81, 0xB0,
  0x6C, 0x0D, 0x01, 0x60, 0x78, 0x0A, 0x03, 0xC0, 0x70, 0x1C, 0x03, 0x80,
  0xE0, 0x18, 0x07, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x00, 0x06,
  0x00, 0x07, 0x03, 0x00, 0x06, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x30, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x60, 0x00, 0x60, 0xC0, 0x00,
  0x61, 0x80, 0x00, 0x21, 0x80, 0x00, 0x33, 0x00, 0x00, 0x16, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x66, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xC3, 0x00, 0x01, 0x83, 0x00, 0x03,
  0x01, 0x00, 0x06, 0x01, 0x80, 0x06, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x18,
  0x00, 0xC0, 0x30, 0x00, 0x60, 0x70, 0x00, 0x60, 0xE0, 0x00, 0x30, 0xE0,
  0x00, 0x76, 0x00, 0x06, 0x60, 0x00, 0xC3, 0x00, 0x18, 0x30, 0x01, 0x83,
  0x00, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x00, 0x81, 0x80,
  0x0C, 0x18, 0x00, 0xC3, 0x00, 0x04, 0x60, 0x00, 0x66, 0x00, 0x06, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x07, 0xFF, 0xF8,
  0x40, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x00, 0x03,
  0xF0, 0x3F, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04,
  0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xFC, 0x00, 0xC0, 0xC0,
  0x40, 0x40, 0x60, 0x60, 0x60, 0x20, 0x20, 0x30, 0x30, 0x30, 0x10, 0x10,
  0x18, 0x18, 0x18, 0x08, 0x08, 0x0C, 0x0C, 0x0C, 0x04, 0x04, 0x06, 0x06,
  0x06, 0x02, 0x02, 0x03, 0x03, 0xF0, 0x7F, 0x00, 0x20, 0x02, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00,
  0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0xFC, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x1E, 0x00, 0x48, 0x03, 0x20,
  0x18, 0xC0, 0x63, 0x03, 0x0C, 0x08, 0x10, 0x60, 0x41, 0x01, 0x8C, 0x06,
  0x60, 0x09, 0x80, 0x2C, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC6,
  0x63, 0x10, 0x00, 0x30, 0x00, 0x7F, 0x80, 0x70, 0x38, 0x30, 0x06, 0x18,
  0x00, 0xC6, 0x00, 0x31, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x3F, 0xF8, 0x3E, 0x02, 0x38, 0x01, 0x9C, 0x00, 0x66, 0x00, 0x1B,
  0x00, 0x06, 0xC0, 0x01, 0x30, 0x00, 0xCC, 0x00, 0x71, 0x80, 0x7C, 0x70,
  0x73, 0x07, 0xF0, 0xC0, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x10,
  0x02, 0x3F, 0x81, 0xB8, 0x30, 0x78, 0x06, 0x1C, 0x00, 0x86, 0x00, 0x31,
  0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0x80,
  0x03, 0x20, 0x00, 0xD8, 0x00, 0x26, 0x00, 0x19, 0x80, 0x06, 0x60, 0x01,
  0x18, 0x00, 0xC6, 0x00, 0x63, 0xC0, 0x30, 0xDC, 0x38, 0x31, 0xFC, 0x00,
  0x00, 0x20, 0x01, 0xFE, 0x01, 0xC1, 0xC1, 0x80, 0x61, 0x80, 0x19, 0x80,
  0x0C, 0x80, 0x02, 0xC0, 0x01, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x03,
  0x60, 0x03, 0x18, 0x01, 0x8C, 0x03, 0x83, 0x87, 0x80, 0x7F, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x40, 0xC0, 0x7F, 0x18, 0x38,
  0x3B, 0x0E, 0x01, 0x41, 0x80, 0x38, 0x60, 0x03, 0x18, 0x00, 0x63, 0x00,
  0x0C, 0x40, 0x01, 0x98, 0x00, 0x23, 0x00, 0x04, 0x60, 0x01, 0x8C, 0x00,
  0x31, 0x00, 0x06, 0x20, 0x00, 0xC6, 0x00, 0x10, 0xC0, 0x02, 0x18, 0x00,
  0xC1, 0x00, 0x38, 0x30, 0x0F, 0x03, 0x87, 0x60, 0x3F, 0x88, 0x00, 0x00,
  0x10, 0x00, 0x3F, 0xC0, 0x0E, 0x0C, 0x03, 0x00, 0xC0, 0xC0, 0x0C, 0x30,
  0x01, 0x8C, 0x00, 0x11, 0x80, 0x02, 0x20, 0x00, 0x6C, 0x00, 0x09, 0xFF,
  0xFF, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x04, 0x0C, 0x03, 0x81, 0xC1,
  0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x03, 0xFC, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x03, 0xFF, 0xFC, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x0F, 0xE3, 0x03,
  0xC3, 0xB0, 0x70, 0x0A, 0x06, 0x00, 0xE0, 0xC0, 0x06, 0x18, 0x00, 0x61,
  0x80, 0x06, 0x10, 0x00, 0x63, 0x00, 0x04, 0x30, 0x00, 0x43, 0x00, 0x0C,
  0x30, 0x00, 0xC2, 0x00, 0x0C, 0x20, 0x00, 0xC3, 0x00, 0x08, 0x30, 0x00,
  0x83, 0x00, 0x18, 0x10, 0x03, 0x81, 0x80, 0x78, 0x0E, 0x1D, 0x80, 0x7F,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0xC0,
  0x0C, 0x06, 0x01, 0xC0, 0x38, 0x78, 0x01, 0xFE, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x08, 0x08, 0x06, 0x3F, 0xC1, 0x9C, 0x38, 0x6C, 0x03,
  0x14, 0x00, 0xC6, 0x00, 0x33, 0x80, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0xCC,
  0x00, 0x33, 0x00, 0x0C, 0x80, 0x03, 0x60, 0x00, 0x98, 0x00, 0x26, 0x00,
  0x19, 0x80, 0x06, 0x40, 0x01, 0x90, 0x00, 0x4C, 0x00, 0x13, 0x00, 0x0C,
  0xC0, 0x03, 0x30, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x10, 0xC0, 0x06, 0x0C, 0x01,
  0xC0, 0x80, 0x30, 0x18, 0x06, 0x01, 0x81, 0xC0, 0x18, 0x38, 0x01, 0x86,
  0x00, 0x10, 0xC0, 0x01, 0x38, 0x00, 0x37, 0x80, 0x03, 0xEC, 0x00, 0x38,
  0xC0, 0x03, 0x06, 0x00, 0x20, 0x30, 0x02, 0x03, 0x00, 0x60, 0x18, 0x06,
  0x00, 0xC0, 0x60, 0x0C, 0x06, 0x00, 0x60, 0x40, 0x03, 0x0C, 0x00, 0x38,
  0x07, 0xFE, 0x03, 0xFE, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x07,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x40, 0x20, 0x37, 0xE3, 0xF0, 0x58, 0x6C,
  0x30, 0xE0, 0xF0, 0x21, 0x80, 0xC0, 0x46, 0x01, 0x00, 0x8C, 0x06, 0x01,
  0x18, 0x0C, 0x02, 0x30, 0x18, 0x0C, 0x40, 0x30, 0x18, 0x80, 0x40, 0x33,
  0x00, 0x80, 0x46, 0x03, 0x00, 0x8C, 0x06, 0x01, 0x18, 0x0C, 0x06, 0x20,
  0x18, 0x0C, 0x40, 0x20, 0x19, 0x80, 0x40, 0x23, 0x01, 0x80, 0x46, 0x03,
  0x01, 0x88, 0x06, 0x03, 0x10, 0x08, 0x06, 0x00, 0x00, 0x08, 0x06, 0x3F,
  0xC1, 0x9C, 0x38, 0x6C, 0x06, 0x14, 0x00, 0xC6, 0x00, 0x33, 0x80, 0x0C,
  0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x32, 0x00, 0x0C, 0x80, 0x02, 0x60,
  0x00, 0x98, 0x00, 0x66, 0x00, 0x19, 0x80, 0x06, 0x40, 0x01, 0x90, 0x00,
  0x4C, 0x00, 0x13, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x3F, 0xC0, 0x1C, 0x1C, 0x07, 0x00, 0xC1, 0x80, 0x0C, 0x30, 0x01,
  0x8C, 0x00, 0x11, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x0D, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x05, 0x80, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x0C,
  0x40, 0x01, 0x8C, 0x00, 0x61, 0x80, 0x1C, 0x18, 0x07, 0x01, 0xC3, 0x80,
  0x1F, 0xE0, 0x00, 0x00, 0x08, 0x01, 0x8F, 0xE0, 0x37, 0x0E, 0x07, 0x80,
  0x60, 0xE0, 0x0C, 0x18, 0x00, 0xC2, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00,
  0x63, 0x00, 0x0C, 0x60, 0x01, 0x88, 0x00, 0x31, 0x00, 0x06, 0x60, 0x00,
  0x8C, 0x00, 0x31, 0x80, 0x06, 0x30, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x0C,
  0x3C, 0x03, 0x06, 0xE1, 0xC0, 0xC7, 0xF0, 0x18, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0xFE, 0x30, 0xF0, 0xEC, 0x70, 0x0A,
  0x18, 0x03, 0x8C, 0x00, 0x66, 0x00, 0x19, 0x80, 0x06, 0x40, 0x01, 0xB0,
  0x00, 0x4C, 0x00, 0x13, 0x00, 0x0C, 0xC0, 0x03, 0x20, 0x00, 0xC8, 0x00,
  0x33, 0x00, 0x08, 0xC0, 0x02, 0x30, 0x01, 0x84, 0x00, 0xE1, 0x80, 0x78,
  0x38, 0x76, 0x07, 0xF1, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x00,
  0x02, 0x04, 0x3F, 0xC6, 0x78, 0x03, 0x60, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20,
  0x00, 0xFF, 0x80, 0xE0, 0x70, 0x60, 0x06, 0x10, 0x00, 0x8C, 0x00, 0x33,
  0x00, 0x0C, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x80, 0x01,
  0x30, 0x00, 0xCC, 0x00, 0x31, 0x80, 0x38, 0x38, 0x3C, 0x07, 0xFC, 0x00,
  0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x3F,
  0xFF, 0x81, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x1F, 0xC0, 0x30, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x03,
  0x20, 0x00, 0x88, 0x00, 0x66, 0x00, 0x19, 0x80, 0x06, 0x60, 0x01, 0x98,
  0x00, 0x44, 0x00, 0x11, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00,
  0x33, 0x00, 0x18, 0xC0, 0x06, 0x10, 0x03, 0x86, 0x01, 0xE0, 0xC3, 0xD8,
  0x1F, 0xC6, 0x00, 0x80, 0x00, 0xF8, 0x00, 0x1B, 0x00, 0x06, 0x20, 0x00,
  0xC6, 0x00, 0x30, 0xC0, 0x04, 0x18, 0x01, 0x81, 0x00, 0x60, 0x30, 0x0C,
  0x06, 0x03, 0x00, 0xC0, 0x60, 0x08, 0x18, 0x01, 0x82, 0x00, 0x30, 0xC0,
  0x06, 0x30, 0x00, 0x46, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x3C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x60, 0x1E, 0x03, 0x00, 0xB0, 0x18,
  0x0D, 0x81, 0xC0, 0x6C, 0x0A, 0x06, 0x60, 0xD0, 0x33, 0x04, 0xC1, 0x18,
  0x26, 0x18, 0xC3, 0x30, 0xC6, 0x11, 0x84, 0x31, 0x8C, 0x61, 0x88, 0x62,
  0x04, 0xC1, 0x30, 0x26, 0x09, 0x81, 0x20, 0x48, 0x0B, 0x02, 0xC0, 0x50,
  0x14, 0x03, 0x80, 0xA0, 0x18, 0x07, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x18, 0x20, 0x01, 0x81, 0x80, 0x18, 0x06, 0x01, 0x80,
  0x30, 0x18, 0x00, 0xC1, 0x80, 0x02, 0x18, 0x00, 0x19, 0x80, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0D, 0x80, 0x00,
  0xC6, 0x00, 0x0C, 0x30, 0x00, 0xC0, 0xC0, 0x0C, 0x03, 0x00, 0xC0, 0x18,
  0x0C, 0x00, 0x60, 0xC0, 0x03, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x03,
  0x04, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x0C,
  0x03, 0x00, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01, 0x00, 0x60,
  0x01, 0x80, 0x60, 0x01, 0x80, 0xC0, 0x01, 0x81, 0x80, 0x00, 0x81, 0x80,
  0x00, 0xC3, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x46, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0F, 0xFF, 0xF1, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x06, 0x0C, 0x18, 0x20, 0x40, 0x83, 0x06, 0x0C, 0x10, 0x20,
  0x41, 0x83, 0x06, 0x0C, 0x10, 0x20, 0x41, 0x83, 0x06, 0x08, 0x10, 0x20,
  0xC1, 0x83, 0x06, 0x08, 0x10, 0x20, 0xC1, 0x80, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x1E, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x1F, 0x80, 0x09, 0xCE, 0x00, 0x58, 0x18, 0x06, 0x80, 0x60,
  0x2C, 0x01, 0xC7, 0x40, 0x07, 0xF0, 0x00, 0x04, 0x00,
};

const GFXglyph RobotoMono_ExtraLightItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 7, 28, 23, 8, -28 },
  { 26, 8, 8, 23, 10, -30 },
  { 34, 23, 28, 23, 1, -28 },
  { 115, 19, 37, 23, 3, -33 },
  { 203, 20, 29, 23, 2, -29 },
  { 276, 20, 29, 23, 2, -29 },
  { 349, 3, 8, 23, 12, -30 },
  { 352, 12, 41, 23, 7, -32 },
  { 414, 12, 41, 23, 4, -32 },
  { 476, 17, 16, 23, 5, -28 },
  { 510, 20, 21, 23, 2, -24 },
  { 563, 5, 8, 23, 5, -3 },
  { 568, 14, 2, 23, 5, -14 },
  { 572, 3, 3, 23, 9, -3 },
  { 574, 19, 30, 23, 3, -28 },
  { 646, 18, 29, 23, 3, -29 },
  { 712, 11, 28, 23, 6, -28 },
  { 751, 19, 29, 23, 1, -29 },
  { 820, 19, 29, 23, 1, -29 },
  { 889, 20, 28, 23, 1, -28 },
  { 959, 20, 28, 23, 3, -28 },
  { 1029, 18, 29, 23, 2, -29 },
  { 1095, 18, 28, 23, 5, -28 },
  { 1158, 20, 29, 23, 2, -29 },
  { 1231, 17, 29, 23, 4, -29 },
  { 1293, 6, 20, 23, 10, -20 },
  { 1308, 8, 25, 23, 8, -20 },
  { 1333, 18, 16, 23, 3, -21 },
  { 1369, 18, 10, 23, 3, -18 },
  { 1392, 18, 16, 23, 2, -21 },
  { 1428, 15, 29, 23, 6, -29 },
  { 1483, 22, 29, 23, 1, -29 },
  { 1563, 20, 28, 23, 0, -28 },
  { 1633, 20, 28, 23, 2, -28 },
  { 1703, 20, 29, 23, 2, -29 },
  { 1776, 20, 28, 23, 2, -28 },
  { 1846, 21, 28, 23, 2, -28 },
  { 1920, 21, 28, 23, 2, -28 },
  { 1994, 20, 29, 23, 2, -29 },
  { 2067, 22, 28, 23, 1, -28 },
  { 2144, 20, 28, 23, 2, -28 },
  { 2214, 21, 28, 23, 1, -28 },
  { 2288, 22, 28, 23, 2, -28 },
  { 2365, 17, 28, 23, 2, -28 },
  { 2425, 22, 28, 23, 1, -28 },
  { 2502, 22, 28, 23, 1, -28 },
  { 2579, 20, 29, 23, 2, -29 },
  { 2652, 21, 28, 23, 2, -28 },
  { 2726, 20, 34, 23, 2, -29 },
  { 2811, 20, 28, 23, 2, -28 },
  { 2881, 20, 29, 23, 2, -29 },
  { 2954, 19, 28, 23, 5, -28 },
  { 3021, 21, 28, 23, 2, -28 },
  { 3095, 20, 28, 23, 4, -28 },
  { 3165, 21, 28, 23, 4, -28 },
  { 3239, 24, 28, 23, 0, -28 },
  { 3323, 20, 28, 23, 4, -28 },
  { 3393, 21, 28, 23, 1, -28 },
  { 3467, 12, 39, 23, 6, -33 },
  { 3526, 8, 30, 23, 8, -28 },
  { 3556, 12, 39, 23, 6, -33 },
  { 3615, 14, 15, 23, 5, -28 },
  { 3642, 17, 2, 23, 1, 0 },
  { 3647, 4, 5, 23, 12, -29 },
  { 3650, 18, 22, 23, 2, -22 },
  { 3700, 18, 30, 23, 2, -30 },
  { 3768, 17, 22, 23, 3, -22 },
  { 3815, 19, 30, 23, 3, -30 },
  { 3887, 19, 22, 23, 2, -22 },
  { 3940, 19, 31, 23, 5, -31 },
  { 4014, 20, 30, 23, 1, -22 },
  { 4089, 18, 30, 23, 2, -30 },
  { 4157, 17, 29, 23, 2, -29 },
  { 4219, 18, 38, 23, 0, -29 },
  { 4305, 20, 30, 23, 2, -30 },
  { 4380, 17, 30, 23, 2, -30 },
  { 4444, 23, 22, 23, 0, -22 },
  { 4508, 18, 22, 23, 2, -22 },
  { 4558, 19, 22, 23, 2, -22 },
  { 4611, 19, 30, 23, 1, -22 },
  { 4683, 18, 30, 23, 3, -22 },
  { 4751, 17, 22, 23, 5, -22 },
  { 4798, 18, 22, 23, 3, -22 },
  { 4848, 15, 27, 23, 5, -27 },
  { 4899, 18, 21, 23, 3, -21 },
  { 4947, 19, 21, 23, 4, -21 },
  { 4997, 21, 21, 23, 3, -21 },
  { 5053, 21, 21, 23, 1, -21 },
  { 5109, 24, 30, 23, -1, -21 },
  { 5199, 20, 21, 23, 1, -21 },
  { 5252, 16, 39, 23, 6, -31 },
  { 5330, 7, 34, 23, 8, -28 },
  { 5360, 16, 39, 23, 3, -31 },
  { 5438, 21, 7, 23, 1, -15 },
};

const GFXfont RobotoMono_ExtraLightItalic40pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic40pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic40pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC40PT7B_H_
