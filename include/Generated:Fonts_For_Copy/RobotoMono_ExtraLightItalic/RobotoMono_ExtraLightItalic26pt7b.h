#ifndef _ROBOTOMONO_EXTRALIGHTITALIC26PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0x84, 0x21, 0x08, 0xC4, 0x21, 0x08, 0x46, 0x00, 0x00, 0x46,
  0x00, 0x45, 0x24, 0x92, 0x8A, 0x20, 0x00, 0x84, 0x01, 0x08, 0x04, 0x20,
  0x08, 0x40, 0x20, 0x87, 0xFF, 0xC0, 0x84, 0x02, 0x08, 0x04, 0x20, 0x08,
  0x40, 0x21, 0x80, 0x42, 0x0F, 0xFF, 0x82, 0x10, 0x04, 0x20, 0x08, 0x40,
  0x21, 0x00, 0x42, 0x00, 0x00, 0x80, 0x10, 0x03, 0x80, 0xC6, 0x10, 0x23,
  0x01, 0x20, 0x12, 0x01, 0x20, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x02, 0x80, 0x28, 0x06, 0x80, 0x44, 0x08, 0x3F, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x30, 0x04, 0x80, 0x84, 0x08, 0x42, 0x84, 0x48,
  0x48, 0x88, 0x89, 0x90, 0x62, 0x00, 0x60, 0x04, 0x00, 0x8E, 0x11, 0x11,
  0x21, 0x22, 0x14, 0x21, 0xC2, 0x10, 0x22, 0x01, 0xC0, 0x03, 0x80, 0x32,
  0x02, 0x08, 0x10, 0x41, 0x86, 0x04, 0x20, 0x22, 0x01, 0x60, 0x06, 0x00,
  0x60, 0x04, 0x80, 0x46, 0x14, 0x11, 0xA0, 0x4A, 0x02, 0x50, 0x0C, 0x40,
  0x63, 0x05, 0x0F, 0xC4, 0x55, 0x70, 0x01, 0x01, 0x02, 0x04, 0x08, 0x18,
  0x10, 0x30, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0xC0,
  0x40, 0x40, 0x40, 0x40, 0x40, 0x20, 0x20, 0x10, 0x18, 0x08, 0x04, 0x06,
  0x02, 0x02, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x03, 0x02, 0x02, 0x02, 0x04, 0x04, 0x0C, 0x08, 0x10, 0x30, 0x60, 0x80,
  0x02, 0x00, 0x40, 0x08, 0x71, 0x33, 0xFC, 0x08, 0x02, 0x80, 0x88, 0x21,
  0x0C, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0xFF,
  0xF0, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x24, 0xAC,
  0xFF, 0x80, 0xF0, 0x00, 0x30, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08,
  0x01, 0x00, 0x10, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00,
  0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x03, 0x80, 0xC4,
  0x10, 0x22, 0x01, 0x20, 0x14, 0x03, 0x40, 0x74, 0x09, 0x41, 0x18, 0x23,
  0x8C, 0x29, 0x82, 0xA0, 0x2C, 0x02, 0x80, 0x48, 0x04, 0x80, 0x84, 0x10,
  0x3E, 0x00, 0x0E, 0x6B, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x03, 0x80, 0xCE, 0x10, 0x22, 0x01,
  0x20, 0x14, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xFF, 0xE0, 0x03,
  0x80, 0xC6, 0x10, 0x32, 0x01, 0x20, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00,
  0xC0, 0xF0, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x02, 0x80, 0x28, 0x06, 0x80,
  0x44, 0x08, 0x3F, 0x00, 0x00, 0x30, 0x06, 0x00, 0xA0, 0x12, 0x03, 0x20,
  0x62, 0x04, 0x40, 0x84, 0x10, 0x42, 0x04, 0x60, 0x44, 0x0C, 0xFF, 0xF0,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x0F, 0xF8, 0x40, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x10, 0x00, 0x9C, 0x07, 0x38, 0x20, 0x40, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x40, 0x12, 0x01, 0x08, 0x18, 0x61, 0x81, 0xF8,
  0x00, 0x00, 0x40, 0x70, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x10, 0x02, 0x7C,
  0xF0, 0xD8, 0x0A, 0x01, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x14, 0x02, 0x80,
  0x88, 0x30, 0xF8, 0x00, 0xFF, 0xF0, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x01, 0x00, 0x30, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x18, 0x01,
  0x00, 0x20, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x03, 0x80, 0xC6, 0x10, 0x33,
  0x01, 0x20, 0x12, 0x01, 0x20, 0x12, 0x02, 0x10, 0xC0, 0xF0, 0x30, 0xC4,
  0x06, 0x80, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x44, 0x08, 0x3F, 0x00,
  0x07, 0x07, 0x31, 0x81, 0x20, 0x28, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x50, 0x0A, 0x03, 0x21, 0xA3, 0xCC, 0x01, 0x00, 0x60, 0x08, 0x02, 0x01,
  0x83, 0xC0, 0x00, 0x13, 0x00, 0x00, 0x00, 0x00, 0x04, 0xE0, 0x08, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x42, 0x31, 0x10, 0x00, 0x10, 0x07, 0x03,
  0x80, 0xE0, 0x30, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0x40, 0x7F, 0xF7, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x40, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x40, 0x70, 0x38, 0x18,
  0x1C, 0x02, 0x00, 0x00, 0x0E, 0x0C, 0x64, 0x0B, 0x03, 0x80, 0x40, 0x20,
  0x08, 0x06, 0x03, 0x01, 0x80, 0x80, 0x60, 0x10, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x06, 0x00, 0x00, 0xC0, 0x1C, 0xC0, 0x80, 0x84, 0x01, 0x21,
  0xC4, 0x89, 0x94, 0x44, 0x52, 0x11, 0x88, 0x46, 0x21, 0x19, 0x08, 0x64,
  0x22, 0x91, 0x8A, 0x46, 0x48, 0xEF, 0x20, 0x00, 0xC0, 0x01, 0x82, 0x03,
  0xF0, 0x00, 0x00, 0x40, 0x06, 0x00, 0x28, 0x02, 0x40, 0x12, 0x01, 0x10,
  0x08, 0x80, 0x84, 0x04, 0x20, 0x40, 0x82, 0x04, 0x20, 0x21, 0xFF, 0x10,
  0x08, 0x80, 0x48, 0x02, 0x40, 0x0C, 0x00, 0x40, 0x1F, 0xE0, 0x80, 0x84,
  0x02, 0x20, 0x11, 0x00, 0x90, 0x0C, 0x80, 0x44, 0x0C, 0x3F, 0xC1, 0x03,
  0x08, 0x04, 0x80, 0x24, 0x01, 0x20, 0x09, 0x00, 0xC8, 0x04, 0xC0, 0xC7,
  0xF8, 0x00, 0x03, 0x80, 0xCE, 0x10, 0x22, 0x01, 0x60, 0x14, 0x01, 0x40,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x02, 0x80,
  0x28, 0x04, 0x80, 0xC4, 0x18, 0x3E, 0x00, 0x1F, 0xE0, 0x81, 0x84, 0x04,
  0x20, 0x12, 0x00, 0x90, 0x04, 0x80, 0x24, 0x01, 0x20, 0x0B, 0x00, 0x50,
  0x02, 0x80, 0x24, 0x01, 0x20, 0x19, 0x00, 0x98, 0x18, 0x81, 0x87, 0xF0,
  0x00, 0x1F, 0xFC, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02,
  0x00, 0x08, 0x00, 0x3F, 0xE0, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x3F,
  0xE0, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x31, 0x82, 0x06, 0x20, 0x13,
  0x00, 0x90, 0x04, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x7E, 0x80,
  0x2C, 0x01, 0x20, 0x09, 0x00, 0x48, 0x02, 0x60, 0x31, 0x03, 0x07, 0xE0,
  0x10, 0x04, 0x40, 0x12, 0x00, 0x88, 0x02, 0x20, 0x08, 0x80, 0x22, 0x00,
  0x88, 0x02, 0x7F, 0xF1, 0x00, 0x44, 0x01, 0x10, 0x04, 0x40, 0x11, 0x00,
  0x48, 0x02, 0x20, 0x08, 0x80, 0x22, 0x00, 0x80, 0x1F, 0xFC, 0x06, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x03, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01,
  0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40,
  0x02, 0x40, 0x12, 0x01, 0x18, 0x18, 0x41, 0x81, 0xF8, 0x00, 0x18, 0x0E,
  0x20, 0x30, 0x40, 0xC0, 0x83, 0x01, 0x0C, 0x06, 0x30, 0x08, 0xC0, 0x13,
  0x00, 0x2E, 0x00, 0x74, 0x00, 0x84, 0x03, 0x08, 0x04, 0x08, 0x08, 0x18,
  0x10, 0x10, 0x20, 0x30, 0x40, 0x21, 0x80, 0x20, 0x10, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0xC0,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x3F, 0xF0, 0x18, 0x0C, 0x60, 0x31, 0x81,
  0x4A, 0x0E, 0x28, 0x28, 0x91, 0x22, 0x44, 0x89, 0x22, 0x64, 0x89, 0x14,
  0x44, 0x31, 0x10, 0x84, 0x40, 0x11, 0x00, 0x4C, 0x03, 0x20, 0x08, 0x80,
  0x22, 0x00, 0x80, 0x10, 0x04, 0x60, 0x13, 0x80, 0x8A, 0x02, 0x24, 0x08,
  0x90, 0x22, 0x20, 0x88, 0x86, 0x62, 0x11, 0x04, 0x44, 0x11, 0x10, 0x44,
  0x40, 0x91, 0x02, 0xC8, 0x0A, 0x20, 0x18, 0x80, 0x62, 0x00, 0x80, 0x03,
  0x80, 0xCC, 0x10, 0x22, 0x01, 0x60, 0x14, 0x01, 0x40, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x02, 0x80, 0x28, 0x02, 0x80, 0x48, 0x04, 0x80,
  0x84, 0x10, 0x3E, 0x00, 0x1F, 0xE1, 0x00, 0x88, 0x06, 0x40, 0x12, 0x00,
  0x90, 0x05, 0x80, 0x48, 0x02, 0x40, 0x63, 0xFE, 0x10, 0x00, 0x80, 0x0C,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x00, 0x01, 0xC0,
  0x33, 0x82, 0x04, 0x20, 0x12, 0x00, 0x90, 0x05, 0x80, 0x28, 0x01, 0x40,
  0x0A, 0x00, 0x50, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0B, 0x00, 0x48, 0x04,
  0x40, 0x61, 0x06, 0x07, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x30, 0x1F, 0xE0,
  0x80, 0x84, 0x02, 0x20, 0x11, 0x00, 0x98, 0x04, 0x80, 0x64, 0x02, 0x20,
  0x61, 0xFE, 0x08, 0x20, 0xC1, 0x04, 0x0C, 0x20, 0x21, 0x01, 0x08, 0x0C,
  0x40, 0x26, 0x01, 0x80, 0x01, 0xC0, 0x71, 0x86, 0x06, 0x20, 0x13, 0x00,
  0x90, 0x04, 0xC0, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40,
  0x01, 0x00, 0x0A, 0x00, 0x58, 0x02, 0x40, 0x21, 0x03, 0x07, 0xE0, 0xFF,
  0xF8, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x00, 0x20, 0x09, 0x00, 0x50, 0x04, 0x80, 0x24,
  0x01, 0x20, 0x09, 0x00, 0x48, 0x02, 0x80, 0x24, 0x01, 0x20, 0x09, 0x00,
  0x48, 0x02, 0x40, 0x22, 0x01, 0x10, 0x10, 0x41, 0x81, 0xF0, 0x00, 0x80,
  0x0C, 0x00, 0xA0, 0x0D, 0x00, 0x44, 0x02, 0x20, 0x21, 0x01, 0x08, 0x10,
  0x40, 0x82, 0x08, 0x18, 0x40, 0x44, 0x02, 0x20, 0x12, 0x00, 0x90, 0x05,
  0x80, 0x28, 0x00, 0xC0, 0x04, 0x00, 0x82, 0x0C, 0x30, 0x61, 0x85, 0x0C,
  0x28, 0xA1, 0x45, 0x12, 0x28, 0x92, 0x44, 0x92, 0x64, 0x92, 0x28, 0x91,
  0x44, 0x8A, 0x28, 0x61, 0x43, 0x0A, 0x18, 0x60, 0x81, 0x04, 0x08, 0x00,
  0x18, 0x01, 0x08, 0x02, 0x08, 0x04, 0x04, 0x08, 0x04, 0x18, 0x02, 0x10,
  0x02, 0x20, 0x01, 0x40, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x02, 0xC0,
  0x04, 0x40, 0x0C, 0x40, 0x08, 0x20, 0x10, 0x20, 0x20, 0x10, 0x60, 0x10,
  0xC0, 0x18, 0x80, 0x0C, 0x00, 0x90, 0x08, 0x80, 0xC4, 0x04, 0x10, 0x40,
  0x86, 0x04, 0x20, 0x12, 0x00, 0xB0, 0x05, 0x00, 0x10, 0x00, 0x80, 0x0C,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x1F, 0xF8, 0x00,
  0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x40, 0x06, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x03, 0x00, 0x10, 0x01, 0x00, 0x18, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x07, 0xFF, 0x00, 0x0F, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x30,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40,
  0xC0, 0x80, 0x80, 0xF0, 0x84, 0x10, 0x84, 0x21, 0x04, 0x21, 0x08, 0x41,
  0x08, 0x42, 0x10, 0x42, 0x10, 0x80, 0x1F, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x06, 0x04, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0xF0, 0x06, 0x03, 0x02, 0x41, 0x21,
  0x10, 0x88, 0x84, 0xC1, 0x40, 0xC0, 0x40, 0xFF, 0xE0, 0x89, 0x80, 0x07,
  0xC1, 0x82, 0x10, 0x12, 0x01, 0x00, 0x10, 0x01, 0x07, 0xF3, 0x82, 0x60,
  0x24, 0x02, 0xC0, 0x2C, 0x06, 0x41, 0xA3, 0xE2, 0x08, 0x01, 0x80, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x13, 0xC2, 0xC6, 0x30, 0x32, 0x01, 0x20,
  0x12, 0x01, 0x20, 0x14, 0x01, 0x40, 0x14, 0x02, 0x40, 0x24, 0x04, 0x60,
  0xC9, 0xF0, 0x0F, 0x83, 0x08, 0x80, 0xA0, 0x14, 0x03, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x01, 0x40, 0x64, 0x18, 0x7E, 0x00, 0x00, 0x18,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x3C, 0xC2, 0x1C, 0x20,
  0x62, 0x01, 0x10, 0x09, 0x00, 0x48, 0x06, 0x40, 0x22, 0x01, 0x10, 0x08,
  0x80, 0x44, 0x06, 0x10, 0x60, 0x7D, 0x00, 0x0F, 0x83, 0x08, 0x80, 0xA0,
  0x14, 0x03, 0x00, 0x7F, 0xFC, 0x00, 0x80, 0x10, 0x02, 0x00, 0x60, 0x26,
  0x08, 0x7E, 0x00, 0x00, 0xF8, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04,
  0x03, 0xFF, 0x81, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x00,
  0x07, 0x88, 0x43, 0x84, 0x0C, 0x40, 0x22, 0x01, 0x20, 0x09, 0x00, 0xC8,
  0x04, 0x40, 0x22, 0x01, 0x10, 0x08, 0x80, 0xC2, 0x0E, 0x0F, 0xA0, 0x01,
  0x00, 0x08, 0x80, 0x86, 0x0C, 0x1D, 0x80, 0x10, 0x00, 0x08, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x13, 0xC2, 0x42, 0x28, 0x13, 0x01,
  0x20, 0x12, 0x01, 0x60, 0x14, 0x01, 0x40, 0x24, 0x02, 0x40, 0x24, 0x02,
  0xC0, 0x28, 0x06, 0x00, 0x80, 0x60, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x30,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x0F, 0xFC, 0x00, 0x20, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30,
  0x02, 0x09, 0xC0, 0x60, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x32, 0x06, 0x20, 0x86, 0x30, 0x46, 0x04, 0xC0, 0x58,
  0x06, 0xC0, 0x44, 0x08, 0x20, 0x83, 0x08, 0x10, 0x80, 0x88, 0x04, 0x1F,
  0x87, 0xE0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x43, 0xFF,
  0x2F, 0x3C, 0x62, 0x88, 0x82, 0x19, 0x04, 0x14, 0x10, 0x48, 0x20, 0x90,
  0x41, 0x20, 0x82, 0x41, 0x04, 0x86, 0x0A, 0x08, 0x24, 0x10, 0x48, 0x20,
  0x90, 0x41, 0x00, 0x33, 0xC2, 0x42, 0x28, 0x13, 0x01, 0x20, 0x12, 0x01,
  0x60, 0x14, 0x01, 0x40, 0x24, 0x02, 0x40, 0x24, 0x02, 0xC0, 0x28, 0x06,
  0x07, 0xC0, 0x43, 0x04, 0x0C, 0x40, 0x26, 0x01, 0x20, 0x09, 0x00, 0x58,
  0x02, 0xC0, 0x16, 0x00, 0x90, 0x08, 0x80, 0xC2, 0x0C, 0x0F, 0x80, 0x09,
  0xE0, 0xB1, 0x86, 0x06, 0x20, 0x11, 0x00, 0x88, 0x04, 0x40, 0x24, 0x01,
  0x20, 0x19, 0x00, 0x88, 0x04, 0x40, 0x47, 0x06, 0x27, 0xC1, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x30, 0x00, 0x0F, 0x11, 0x0E, 0x20, 0x64, 0x02,
  0x40, 0x28, 0x02, 0x80, 0x68, 0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x0C,
  0x41, 0x83, 0xE8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x11,
  0xE6, 0xC0, 0xA0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x00, 0x0F, 0x86, 0x0C, 0x80, 0xA0,
  0x14, 0x00, 0x40, 0x07, 0x00, 0x1C, 0x00, 0xC0, 0x0A, 0x01, 0x40, 0x2C,
  0x0C, 0x7E, 0x00, 0x04, 0x03, 0x00, 0x83, 0xFF, 0x08, 0x02, 0x00, 0x80,
  0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x03, 0x00, 0x40, 0x1F,
  0x00, 0x20, 0x14, 0x03, 0x40, 0x24, 0x02, 0x40, 0x24, 0x02, 0x40, 0x28,
  0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x0C, 0x41, 0x47, 0xE8, 0xC0, 0x1A,
  0x00, 0x90, 0x08, 0x80, 0x46, 0x04, 0x10, 0x20, 0x82, 0x04, 0x30, 0x31,
  0x00, 0x90, 0x04, 0x80, 0x28, 0x01, 0xC0, 0x04, 0x00, 0x82, 0x0E, 0x08,
  0x28, 0x60, 0xA1, 0x84, 0x86, 0x12, 0x24, 0xC8, 0x92, 0x24, 0x48, 0x91,
  0x42, 0x85, 0x0A, 0x14, 0x28, 0x60, 0xC1, 0x81, 0x04, 0x00, 0x20, 0x08,
  0x80, 0x86, 0x08, 0x10, 0x80, 0x4C, 0x02, 0xC0, 0x0C, 0x00, 0xE0, 0x05,
  0x00, 0x44, 0x04, 0x20, 0x40, 0x84, 0x06, 0x40, 0x18, 0x20, 0x02, 0x60,
  0x08, 0x40, 0x10, 0x80, 0x41, 0x01, 0x81, 0x02, 0x02, 0x08, 0x04, 0x10,
  0x0C, 0x40, 0x09, 0x80, 0x12, 0x00, 0x28, 0x00, 0x70, 0x00, 0x40, 0x01,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x03, 0xC0, 0x04, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x7F, 0xF8, 0x00, 0xC0,
  0x40, 0x20, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80,
  0xC0, 0xC0, 0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x20,
  0x0C, 0x01, 0x00, 0x60, 0x0C, 0x00, 0x08, 0x84, 0x21, 0x08, 0x42, 0x21,
  0x08, 0x42, 0x11, 0x08, 0x42, 0x10, 0x88, 0x40, 0x0C, 0x00, 0x80, 0x30,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x30, 0x06, 0x00,
  0x40, 0x60, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x01,
  0x80, 0xC0, 0xC0, 0x00, 0x38, 0x05, 0x18, 0x28, 0x30, 0xA0, 0x7C, 0x00,
  0x40,
};

const GFXglyph RobotoMono_ExtraLightItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 5, 18, 15, 5, -18 },
  { 13, 6, 6, 15, 6, -20 },
  { 18, 15, 18, 15, 0, -18 },
  { 52, 12, 24, 15, 2, -21 },
  { 88, 12, 19, 15, 2, -19 },
  { 117, 13, 19, 15, 1, -19 },
  { 148, 2, 6, 15, 7, -20 },
  { 150, 8, 27, 15, 4, -21 },
  { 177, 8, 27, 15, 2, -21 },
  { 204, 11, 10, 15, 3, -18 },
  { 218, 12, 13, 15, 2, -15 },
  { 238, 3, 5, 15, 3, -2 },
  { 240, 9, 1, 15, 3, -9 },
  { 242, 2, 2, 15, 6, -2 },
  { 243, 12, 20, 15, 2, -18 },
  { 273, 12, 19, 15, 2, -19 },
  { 302, 7, 18, 15, 4, -18 },
  { 318, 12, 19, 15, 1, -19 },
  { 347, 12, 19, 15, 1, -19 },
  { 376, 12, 18, 15, 1, -18 },
  { 403, 13, 18, 15, 2, -18 },
  { 433, 11, 19, 15, 2, -19 },
  { 460, 12, 18, 15, 3, -18 },
  { 487, 12, 19, 15, 2, -19 },
  { 516, 11, 19, 15, 3, -19 },
  { 543, 4, 13, 15, 6, -13 },
  { 550, 5, 16, 15, 5, -13 },
  { 560, 12, 11, 15, 2, -14 },
  { 577, 12, 7, 15, 2, -12 },
  { 588, 11, 11, 15, 2, -14 },
  { 604, 10, 19, 15, 4, -19 },
  { 628, 14, 19, 15, 1, -19 },
  { 662, 13, 18, 15, 0, -18 },
  { 692, 13, 18, 15, 1, -18 },
  { 722, 12, 19, 15, 2, -19 },
  { 751, 13, 18, 15, 1, -18 },
  { 781, 14, 18, 15, 1, -18 },
  { 813, 14, 18, 15, 1, -18 },
  { 845, 13, 19, 15, 1, -19 },
  { 876, 14, 18, 15, 1, -18 },
  { 908, 14, 18, 15, 1, -18 },
  { 940, 13, 18, 15, 1, -18 },
  { 970, 15, 18, 15, 1, -18 },
  { 1004, 10, 18, 15, 2, -18 },
  { 1027, 14, 18, 15, 1, -18 },
  { 1059, 14, 18, 15, 1, -18 },
  { 1091, 12, 19, 15, 2, -19 },
  { 1120, 13, 18, 15, 2, -18 },
  { 1150, 13, 22, 15, 1, -19 },
  { 1186, 13, 18, 15, 1, -18 },
  { 1216, 13, 19, 15, 1, -19 },
  { 1247, 13, 18, 15, 3, -18 },
  { 1277, 13, 18, 15, 2, -18 },
  { 1307, 13, 19, 15, 3, -19 },
  { 1338, 13, 18, 15, 3, -18 },
  { 1368, 16, 19, 15, 0, -19 },
  { 1406, 13, 19, 15, 3, -19 },
  { 1437, 13, 18, 15, 1, -18 },
  { 1467, 8, 25, 15, 4, -21 },
  { 1492, 5, 21, 15, 5, -19 },
  { 1506, 8, 25, 15, 4, -21 },
  { 1531, 9, 10, 15, 3, -18 },
  { 1543, 11, 1, 15, 1, 0 },
  { 1545, 3, 3, 15, 8, -19 },
  { 1547, 12, 14, 15, 1, -14 },
  { 1568, 12, 20, 15, 1, -20 },
  { 1598, 11, 14, 15, 2, -14 },
  { 1618, 13, 20, 15, 2, -20 },
  { 1651, 11, 14, 15, 2, -14 },
  { 1671, 13, 20, 15, 3, -20 },
  { 1704, 13, 20, 15, 1, -14 },
  { 1737, 12, 20, 15, 1, -20 },
  { 1767, 10, 19, 15, 2, -19 },
  { 1791, 12, 25, 15, 0, -19 },
  { 1829, 12, 20, 15, 2, -20 },
  { 1859, 10, 20, 15, 2, -20 },
  { 1884, 15, 14, 15, 0, -14 },
  { 1911, 12, 14, 15, 1, -14 },
  { 1932, 13, 14, 15, 1, -14 },
  { 1955, 13, 19, 15, 0, -14 },
  { 1986, 12, 19, 15, 2, -14 },
  { 2015, 11, 14, 15, 3, -14 },
  { 2035, 11, 14, 15, 2, -14 },
  { 2055, 10, 17, 15, 3, -17 },
  { 2077, 12, 14, 15, 2, -14 },
  { 2098, 13, 14, 15, 2, -14 },
  { 2121, 14, 14, 15, 2, -14 },
  { 2146, 13, 14, 15, 1, -14 },
  { 2169, 15, 20, 15, 0, -14 },
  { 2207, 13, 14, 15, 1, -14 },
  { 2230, 10, 25, 15, 4, -20 },
  { 2262, 5, 22, 15, 5, -18 },
  { 2276, 10, 25, 15, 2, -20 },
  { 2308, 14, 5, 15, 1, -10 },
};

const GFXfont RobotoMono_ExtraLightItalic26pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic26pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic26pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC26PT7B_H_
