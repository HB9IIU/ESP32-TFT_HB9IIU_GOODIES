#ifndef _ROBOTOMONO_EXTRALIGHTITALIC19PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x92, 0x92, 0x48, 0x01, 0x00, 0xB6, 0xD0, 0x02, 0x20, 0x48,
  0x11, 0x02, 0x23, 0xFE, 0x11, 0x02, 0x20, 0x88, 0x11, 0x1B, 0xF8, 0x88,
  0x11, 0x02, 0x40, 0x88, 0x00, 0x02, 0x01, 0x03, 0x82, 0x32, 0x09, 0x04,
  0x80, 0x40, 0x18, 0x03, 0x00, 0x40, 0x28, 0x14, 0x09, 0x04, 0x7C, 0x10,
  0x08, 0x00, 0x30, 0x24, 0x22, 0x31, 0x28, 0xA4, 0xA1, 0x90, 0x10, 0x13,
  0x8A, 0x49, 0x28, 0x94, 0x48, 0x38, 0x0C, 0x09, 0x08, 0x44, 0x22, 0x20,
  0xA0, 0x60, 0x50, 0x48, 0xC2, 0x60, 0xB0, 0x68, 0x33, 0xEC, 0x56, 0x04,
  0x21, 0x08, 0x21, 0x04, 0x10, 0x42, 0x08, 0x20, 0x82, 0x08, 0x20, 0x41,
  0x02, 0x00, 0x10, 0x40, 0x82, 0x08, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08,
  0x41, 0x08, 0x21, 0x08, 0x00, 0x04, 0x04, 0x02, 0x1D, 0x71, 0xC0, 0xC0,
  0x90, 0x84, 0x04, 0x02, 0x02, 0x01, 0x0F, 0xF8, 0x40, 0x20, 0x10, 0x10,
  0x08, 0x00, 0x29, 0x28, 0xFE, 0xC0, 0x00, 0x80, 0x40, 0x40, 0x20, 0x20,
  0x10, 0x10, 0x08, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x03, 0x00, 0x0E,
  0x08, 0x88, 0x24, 0x14, 0x0A, 0x1D, 0x12, 0x91, 0x90, 0xD0, 0x70, 0x50,
  0x24, 0x21, 0xE0, 0x09, 0xF2, 0x21, 0x08, 0x42, 0x11, 0x08, 0x42, 0x10,
  0x06, 0x0C, 0xC8, 0x24, 0x10, 0x08, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04,
  0x04, 0x04, 0x07, 0xFC, 0x07, 0x06, 0x22, 0x04, 0x81, 0x00, 0x40, 0x20,
  0x30, 0x38, 0x01, 0x00, 0x28, 0x09, 0x04, 0x41, 0x0F, 0x80, 0x00, 0x80,
  0x60, 0x18, 0x0A, 0x04, 0x82, 0x41, 0x10, 0x84, 0x21, 0x10, 0x4B, 0xFC,
  0x08, 0x02, 0x00, 0x80, 0x3F, 0x90, 0x08, 0x08, 0x04, 0x02, 0xC1, 0x98,
  0x04, 0x01, 0x00, 0xA0, 0x90, 0x48, 0x43, 0xC0, 0x03, 0x0C, 0x10, 0x20,
  0x40, 0x5E, 0x61, 0x41, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C, 0xFF, 0x80,
  0x40, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04,
  0x06, 0x00, 0x0E, 0x08, 0xC8, 0x24, 0x12, 0x09, 0x04, 0x4C, 0x7C, 0x41,
  0x40, 0x60, 0x30, 0x24, 0x13, 0xF0, 0x1C, 0x22, 0x41, 0x81, 0x81, 0x81,
  0x81, 0x83, 0x45, 0x3A, 0x02, 0x04, 0x08, 0xF0, 0x60, 0x00, 0x00, 0x80,
  0x30, 0x00, 0x00, 0x04, 0x44, 0x88, 0x01, 0x0E, 0x30, 0xC0, 0xC0, 0x30,
  0x0C, 0x02, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x30, 0xE1, 0x81, 0x00, 0x38, 0x8A, 0x0C, 0x10, 0x20, 0x82, 0x08, 0x20,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x03, 0x81, 0x88, 0x40, 0x91, 0x92, 0xCA,
  0x92, 0x54, 0x4A, 0x89, 0x92, 0x32, 0x4A, 0x76, 0x20, 0x04, 0x00, 0x7C,
  0x00, 0x01, 0x01, 0x80, 0xC0, 0xA0, 0x50, 0x48, 0x24, 0x21, 0x10, 0x9F,
  0xC8, 0x28, 0x14, 0x0C, 0x04, 0x3E, 0x10, 0x88, 0x24, 0x14, 0x0A, 0x05,
  0x0C, 0xFC, 0x41, 0x20, 0x60, 0x30, 0x28, 0x37, 0xE0, 0x0E, 0x04, 0x62,
  0x09, 0x02, 0x40, 0x50, 0x08, 0x02, 0x00, 0x80, 0x20, 0x28, 0x12, 0x04,
  0x42, 0x0F, 0x00, 0x3C, 0x11, 0x88, 0x28, 0x14, 0x0A, 0x05, 0x02, 0x81,
  0x40, 0xC0, 0x60, 0x50, 0x28, 0x67, 0xC0, 0x3F, 0xC8, 0x02, 0x00, 0x80,
  0x40, 0x10, 0x04, 0x01, 0xFC, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x3F,
  0xC0, 0x3F, 0xC8, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0xFC, 0x40,
  0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x00, 0x0E, 0x04, 0x62, 0x09, 0x01,
  0x40, 0x10, 0x08, 0x02, 0x00, 0x87, 0xA0, 0x28, 0x0A, 0x04, 0x41, 0x0F,
  0x80, 0x20, 0x48, 0x14, 0x05, 0x01, 0x40, 0x90, 0x24, 0x09, 0xFE, 0x80,
  0xA0, 0x48, 0x12, 0x04, 0x81, 0x20, 0x40, 0x3F, 0xC1, 0x00, 0x40, 0x10,
  0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x3F,
  0x80, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01,
  0x00, 0x48, 0x12, 0x08, 0x82, 0x1F, 0x00, 0x20, 0x24, 0x08, 0x86, 0x11,
  0x84, 0x40, 0x90, 0x14, 0x03, 0x40, 0x44, 0x08, 0x82, 0x08, 0x41, 0x08,
  0x11, 0x03, 0x00, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40,
  0x40, 0x40, 0x80, 0x80, 0xFF, 0x20, 0x48, 0x35, 0x0D, 0x45, 0x51, 0x94,
  0xA5, 0x29, 0x52, 0x88, 0xA2, 0x28, 0x12, 0x04, 0x81, 0x20, 0x40, 0x20,
  0x48, 0x15, 0x05, 0x42, 0x50, 0x92, 0x24, 0x89, 0x22, 0x84, 0xA1, 0x48,
  0x52, 0x0C, 0x83, 0x20, 0x40, 0x0E, 0x08, 0x88, 0x28, 0x14, 0x0A, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x50, 0x24, 0x21, 0xE0, 0x3E, 0x08, 0x62,
  0x04, 0x81, 0x20, 0x50, 0x14, 0x09, 0x1C, 0x78, 0x10, 0x04, 0x02, 0x00,
  0x80, 0x20, 0x00, 0x0E, 0x04, 0x42, 0x09, 0x01, 0x40, 0x60, 0x18, 0x06,
  0x02, 0x80, 0xA0, 0x28, 0x0A, 0x04, 0x42, 0x0F, 0x00, 0x20, 0x0C, 0x3E,
  0x10, 0x88, 0x24, 0x12, 0x0A, 0x05, 0x04, 0xF4, 0x44, 0x21, 0x20, 0x90,
  0x48, 0x14, 0x08, 0x0E, 0x04, 0x62, 0x09, 0x01, 0x40, 0x08, 0x01, 0x80,
  0x18, 0x01, 0x00, 0x28, 0x0A, 0x04, 0x41, 0x0F, 0x80, 0xFF, 0xC2, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x20, 0x08, 0x00, 0x20, 0x48, 0x14, 0x05, 0x01, 0x40, 0x90, 0x24, 0x09,
  0x02, 0x80, 0xA0, 0x48, 0x12, 0x04, 0x42, 0x0F, 0x00, 0x80, 0xC0, 0x60,
  0x30, 0x24, 0x12, 0x11, 0x08, 0x88, 0x44, 0x24, 0x0A, 0x06, 0x03, 0x01,
  0x00, 0x88, 0x62, 0x18, 0x8A, 0x52, 0x94, 0xA5, 0x4A, 0x52, 0x94, 0xA5,
  0x31, 0x8C, 0x63, 0x18, 0x84, 0x21, 0x00, 0x20, 0x22, 0x04, 0x41, 0x04,
  0x40, 0x90, 0x0A, 0x01, 0x80, 0x30, 0x0A, 0x01, 0x40, 0x44, 0x10, 0x84,
  0x09, 0x81, 0x00, 0x80, 0xC0, 0x50, 0x48, 0x44, 0x21, 0x20, 0xA0, 0x50,
  0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x1F, 0xC0, 0x10, 0x08, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x10, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x3F,
  0xE0, 0x3C, 0x82, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10, 0x42, 0x08,
  0x20, 0x83, 0x80, 0x88, 0x88, 0x84, 0x44, 0x44, 0x22, 0x22, 0x30, 0x38,
  0x42, 0x10, 0x84, 0x42, 0x10, 0x84, 0x21, 0x10, 0x84, 0x27, 0x00, 0x08,
  0x10, 0x50, 0xA2, 0x44, 0x90, 0xC1, 0xFE, 0xB0, 0x1F, 0x10, 0x90, 0x20,
  0x21, 0xF3, 0x0A, 0x05, 0x02, 0x83, 0x3E, 0x80, 0x20, 0x10, 0x08, 0x04,
  0x05, 0xE3, 0x09, 0x02, 0x81, 0x40, 0xA0, 0xA0, 0x50, 0x2C, 0x25, 0xE0,
  0x1F, 0x10, 0x90, 0x28, 0x08, 0x04, 0x02, 0x01, 0x02, 0x42, 0x1E, 0x00,
  0x00, 0x40, 0x20, 0x08, 0x02, 0x1E, 0x88, 0x64, 0x09, 0x04, 0x81, 0x20,
  0x48, 0x12, 0x04, 0x42, 0x0F, 0x80, 0x1F, 0x10, 0x90, 0x28, 0x1F, 0xFC,
  0x02, 0x01, 0x00, 0x41, 0x1F, 0x00, 0x01, 0xC1, 0x80, 0x80, 0x40, 0x10,
  0x3F, 0xC1, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04,
  0x00, 0x1E, 0x90, 0xD0, 0x28, 0x28, 0x14, 0x0A, 0x05, 0x02, 0x42, 0x1F,
  0x00, 0x80, 0x48, 0x43, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x05, 0xF3, 0x09,
  0x02, 0x81, 0x41, 0x20, 0xA0, 0x50, 0x28, 0x14, 0x08, 0x02, 0x06, 0x00,
  0x00, 0x3C, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0xFF, 0x00,
  0x80, 0xC0, 0x00, 0x01, 0xF0, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x20, 0x10, 0x08, 0x08, 0x78, 0x00, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x19, 0x11, 0x10, 0x90, 0x70, 0x24, 0x11, 0x10, 0x88, 0x24, 0x08,
  0x3E, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08,
  0x08, 0xFF, 0x5D, 0xCC, 0xC5, 0x10, 0xA2, 0x14, 0x45, 0x08, 0xA1, 0x14,
  0x42, 0x88, 0x51, 0x08, 0x5F, 0x30, 0x90, 0x28, 0x14, 0x12, 0x0A, 0x05,
  0x02, 0x81, 0x40, 0x80, 0x1E, 0x10, 0x90, 0x30, 0x18, 0x0C, 0x06, 0x05,
  0x02, 0x42, 0x1E, 0x00, 0x2F, 0x0C, 0x22, 0x04, 0x81, 0x20, 0x48, 0x24,
  0x09, 0x02, 0x61, 0x17, 0x84, 0x01, 0x00, 0x80, 0x20, 0x00, 0x1E, 0x90,
  0xD0, 0x28, 0x28, 0x14, 0x0A, 0x05, 0x02, 0x42, 0x1F, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x2F, 0x30, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80,
  0x1F, 0x10, 0x50, 0x24, 0x01, 0x80, 0x30, 0x05, 0x02, 0x41, 0x3F, 0x00,
  0x08, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x1C, 0x40, 0xA0, 0x50, 0x28, 0x14, 0x12, 0x0A, 0x05, 0x02, 0x43, 0x3E,
  0x80, 0x81, 0xC0, 0xA0, 0x88, 0x44, 0x42, 0x21, 0x20, 0x50, 0x30, 0x10,
  0x00, 0x84, 0x63, 0x18, 0xCA, 0x52, 0x94, 0x95, 0x46, 0x51, 0x94, 0x42,
  0x10, 0x80, 0x20, 0x62, 0x10, 0x24, 0x05, 0x00, 0x40, 0x08, 0x02, 0x80,
  0x88, 0x21, 0x18, 0x10, 0x60, 0x24, 0x08, 0x81, 0x10, 0x41, 0x10, 0x22,
  0x04, 0x80, 0x50, 0x0C, 0x01, 0x00, 0x20, 0x08, 0x02, 0x01, 0x80, 0x00,
  0x3F, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x3F,
  0xE0, 0x02, 0x08, 0x20, 0x81, 0x02, 0x04, 0x08, 0x21, 0x81, 0x01, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x60, 0x24, 0x92, 0x92, 0x49, 0x29, 0x24,
  0x80, 0x30, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x0C, 0x20, 0x81,
  0x02, 0x04, 0x10, 0x20, 0x82, 0x00, 0x78, 0x28, 0x8A, 0x0E, 0x00,
};

const GFXglyph RobotoMono_ExtraLightItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 14, 11, 4, -14 },
  { 7, 3, 4, 11, 5, -14 },
  { 9, 11, 14, 11, 0, -14 },
  { 29, 9, 18, 11, 1, -16 },
  { 50, 9, 14, 11, 1, -14 },
  { 66, 9, 14, 11, 1, -14 },
  { 82, 2, 4, 11, 5, -14 },
  { 83, 6, 19, 11, 3, -15 },
  { 98, 6, 19, 11, 2, -15 },
  { 113, 9, 8, 11, 2, -14 },
  { 122, 9, 10, 11, 1, -11 },
  { 134, 3, 5, 11, 2, -2 },
  { 136, 7, 1, 11, 2, -7 },
  { 137, 2, 1, 11, 4, -1 },
  { 138, 9, 15, 11, 1, -14 },
  { 155, 9, 14, 11, 1, -14 },
  { 171, 5, 14, 11, 3, -14 },
  { 180, 9, 14, 11, 0, -14 },
  { 196, 10, 14, 11, 0, -14 },
  { 214, 10, 14, 11, 0, -14 },
  { 232, 9, 14, 11, 2, -14 },
  { 248, 8, 14, 11, 1, -14 },
  { 262, 9, 14, 11, 2, -14 },
  { 278, 9, 14, 11, 1, -14 },
  { 294, 8, 14, 11, 2, -14 },
  { 308, 3, 9, 11, 5, -9 },
  { 312, 4, 12, 11, 4, -9 },
  { 318, 8, 8, 11, 2, -10 },
  { 326, 9, 4, 11, 1, -8 },
  { 331, 9, 8, 11, 1, -10 },
  { 340, 7, 14, 11, 3, -14 },
  { 353, 11, 14, 11, 0, -14 },
  { 373, 9, 14, 11, 0, -14 },
  { 389, 9, 14, 11, 1, -14 },
  { 405, 10, 14, 11, 1, -14 },
  { 423, 9, 14, 11, 1, -14 },
  { 439, 10, 14, 11, 1, -14 },
  { 457, 10, 14, 11, 1, -14 },
  { 475, 10, 14, 11, 1, -14 },
  { 493, 10, 14, 11, 1, -14 },
  { 511, 10, 14, 11, 1, -14 },
  { 529, 10, 14, 11, 1, -14 },
  { 547, 11, 14, 11, 1, -14 },
  { 567, 8, 14, 11, 1, -14 },
  { 581, 10, 14, 11, 1, -14 },
  { 599, 10, 14, 11, 1, -14 },
  { 617, 9, 14, 11, 1, -14 },
  { 633, 10, 14, 11, 1, -14 },
  { 651, 10, 16, 11, 1, -14 },
  { 671, 9, 14, 11, 1, -14 },
  { 687, 10, 14, 11, 1, -14 },
  { 705, 10, 14, 11, 2, -14 },
  { 723, 10, 14, 11, 1, -14 },
  { 741, 9, 14, 11, 2, -14 },
  { 757, 10, 14, 11, 2, -14 },
  { 775, 11, 14, 11, 0, -14 },
  { 795, 9, 14, 11, 2, -14 },
  { 811, 10, 14, 11, 0, -14 },
  { 829, 6, 18, 11, 3, -15 },
  { 843, 4, 15, 11, 4, -14 },
  { 851, 5, 18, 11, 3, -15 },
  { 863, 7, 8, 11, 2, -14 },
  { 870, 7, 1, 11, 1, 0 },
  { 871, 2, 2, 11, 6, -14 },
  { 872, 9, 10, 11, 1, -10 },
  { 884, 9, 14, 11, 1, -14 },
  { 900, 9, 10, 11, 1, -10 },
  { 912, 10, 14, 11, 1, -14 },
  { 930, 9, 10, 11, 1, -10 },
  { 942, 10, 15, 11, 2, -15 },
  { 961, 9, 14, 11, 1, -10 },
  { 977, 9, 14, 11, 1, -14 },
  { 993, 8, 14, 11, 1, -14 },
  { 1007, 9, 18, 11, 0, -14 },
  { 1028, 9, 14, 11, 1, -14 },
  { 1044, 8, 14, 11, 1, -14 },
  { 1058, 11, 10, 11, 0, -10 },
  { 1072, 9, 10, 11, 1, -10 },
  { 1084, 9, 10, 11, 1, -10 },
  { 1096, 10, 14, 11, 0, -10 },
  { 1114, 9, 14, 11, 1, -10 },
  { 1130, 8, 10, 11, 2, -10 },
  { 1140, 9, 10, 11, 1, -10 },
  { 1152, 8, 13, 11, 2, -13 },
  { 1165, 9, 10, 11, 1, -10 },
  { 1177, 9, 10, 11, 2, -10 },
  { 1189, 10, 10, 11, 1, -10 },
  { 1202, 11, 10, 11, 0, -10 },
  { 1216, 11, 14, 11, 0, -10 },
  { 1236, 10, 10, 11, 0, -10 },
  { 1249, 7, 19, 11, 3, -15 },
  { 1266, 3, 17, 11, 4, -14 },
  { 1273, 7, 19, 11, 2, -15 },
  { 1290, 11, 3, 11, 0, -7 },
};

const GFXfont RobotoMono_ExtraLightItalic19pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic19pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic19pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC19PT7B_H_
