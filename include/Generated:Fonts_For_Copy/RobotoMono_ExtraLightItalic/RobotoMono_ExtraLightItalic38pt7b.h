#ifndef _ROBOTOMONO_EXTRALIGHTITALIC38PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x30, 0xC3, 0x08, 0x21, 0x86, 0x18, 0x61, 0x04, 0x30, 0xC3,
  0x0C, 0x20, 0x86, 0x00, 0x00, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x63, 0x63,
  0x63, 0x42, 0x42, 0x42, 0xC6, 0xC6, 0x00, 0x0C, 0x18, 0x00, 0x10, 0x20,
  0x00, 0x60, 0x40, 0x00, 0x81, 0x80, 0x03, 0x02, 0x00, 0x06, 0x04, 0x00,
  0x08, 0x18, 0x00, 0x30, 0x20, 0x0F, 0xFF, 0xFE, 0x00, 0x81, 0x80, 0x03,
  0x02, 0x00, 0x04, 0x0C, 0x00, 0x08, 0x18, 0x00, 0x30, 0x20, 0x00, 0x40,
  0xC0, 0x00, 0x81, 0x80, 0x03, 0x02, 0x00, 0x04, 0x0C, 0x01, 0xFF, 0xFF,
  0x84, 0x30, 0x20, 0x00, 0x40, 0xC0, 0x01, 0x81, 0x00, 0x03, 0x02, 0x00,
  0x04, 0x0C, 0x00, 0x18, 0x10, 0x00, 0x30, 0x20, 0x00, 0x40, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x0F, 0xF0,
  0x03, 0x87, 0x01, 0xC0, 0x30, 0x30, 0x06, 0x0C, 0x00, 0x41, 0x80, 0x08,
  0x20, 0x01, 0x84, 0x00, 0x20, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x62, 0x00, 0x0C, 0x40, 0x01, 0x88,
  0x00, 0x21, 0x80, 0x0C, 0x30, 0x01, 0x83, 0x00, 0xE0, 0x38, 0x78, 0x03,
  0xFC, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x1F, 0x00, 0x06, 0x30, 0x00, 0x82, 0x00, 0x30, 0x60, 0x44, 0x0C, 0x18,
  0x81, 0x06, 0x30, 0x20, 0x86, 0x04, 0x20, 0xC1, 0x8C, 0x08, 0x23, 0x01,
  0xD8, 0x40, 0x1E, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x0C, 0x3C, 0x01, 0x1D, 0xC0, 0x42, 0x08, 0x18, 0xC1, 0x06, 0x10, 0x30,
  0x82, 0x04, 0x30, 0xC0, 0x8C, 0x18, 0x11, 0x03, 0x06, 0x00, 0x60, 0x80,
  0x06, 0x30, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x63, 0x80, 0x30, 0x60,
  0x18, 0x08, 0x06, 0x02, 0x01, 0x01, 0x80, 0x40, 0x60, 0x10, 0x30, 0x04,
  0x18, 0x01, 0x8C, 0x00, 0x26, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x01, 0xE0,
  0x01, 0xCC, 0x00, 0xE3, 0x01, 0x30, 0x60, 0x58, 0x08, 0x3C, 0x03, 0x0F,
  0x00, 0x66, 0xC0, 0x09, 0xA0, 0x03, 0xCC, 0x00, 0x63, 0x00, 0x38, 0x60,
  0x1B, 0x0C, 0x1C, 0x61, 0xFC, 0x1C, 0x6D, 0xA5, 0xB4, 0x00, 0x20, 0x18,
  0x06, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0,
  0x18, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x30, 0x06, 0x00, 0x40, 0x08, 0x01, 0x80, 0x18, 0x01, 0x00,
  0x10, 0x02, 0x00, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06,
  0x00, 0x20, 0x02, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02,
  0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18,
  0x03, 0x00, 0x30, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80,
  0xC0, 0x83, 0xF9, 0x9F, 0x1F, 0xF8, 0x03, 0x80, 0x03, 0x80, 0x06, 0xC0,
  0x0C, 0x60, 0x18, 0x60, 0x30, 0x30, 0x60, 0x18, 0x20, 0x10, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x3F, 0xFF, 0xF8, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x33, 0x32, 0x66, 0xC8,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7D, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x03, 0x83, 0x03, 0x80, 0xC1, 0x80, 0x31, 0x80, 0x19, 0x80,
  0x04, 0xC0, 0x02, 0x40, 0x03, 0x60, 0x03, 0xB0, 0x06, 0x50, 0x06, 0x28,
  0x06, 0x34, 0x06, 0x1E, 0x06, 0x0F, 0x0C, 0x07, 0x8C, 0x02, 0x8C, 0x01,
  0x4C, 0x01, 0xAC, 0x00, 0xDC, 0x00, 0x48, 0x00, 0x64, 0x00, 0x33, 0x00,
  0x30, 0x80, 0x30, 0x60, 0x38, 0x18, 0x38, 0x07, 0xF0, 0x00, 0x00, 0xC0,
  0xF1, 0xE9, 0xE2, 0xC1, 0xA0, 0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30,
  0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x80, 0x60, 0x10, 0x04,
  0x01, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x01, 0xFE, 0x00, 0xE1,
  0xC0, 0x60, 0x18, 0x30, 0x06, 0x18, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x0C,
  0xC0, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFE, 0x00,
  0xE0, 0xE0, 0x60, 0x18, 0x30, 0x03, 0x08, 0x00, 0x46, 0x00, 0x11, 0x80,
  0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x18,
  0x01, 0x7C, 0x00, 0x7E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x04, 0xC0, 0x01, 0x30, 0x00, 0xCC, 0x00,
  0x31, 0x80, 0x18, 0x60, 0x0C, 0x0E, 0x0E, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xD8, 0x00, 0x32,
  0x00, 0x0C, 0x40, 0x03, 0x08, 0x00, 0x43, 0x00, 0x18, 0x60, 0x06, 0x0C,
  0x01, 0x81, 0x00, 0x60, 0x20, 0x18, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x30,
  0x30, 0x06, 0x0C, 0x00, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x18, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x4F, 0xE0, 0x0F, 0x8E, 0x03, 0x80, 0x60, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x0C, 0x10, 0x01, 0x83, 0x00, 0x60,
  0x60, 0x18, 0x07, 0x0E, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x18, 0x78, 0x0C, 0xFF, 0x05, 0xC0, 0xC7, 0x80, 0x33,
  0x80, 0x19, 0x80, 0x04, 0x80, 0x03, 0x40, 0x01, 0xA0, 0x00, 0xF0, 0x00,
  0x58, 0x00, 0x2C, 0x00, 0x32, 0x00, 0x19, 0x80, 0x18, 0xC0, 0x08, 0x30,
  0x1C, 0x0E, 0x1C, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x38, 0x70, 0x1C, 0x03, 0x03,
  0x00, 0x20, 0xC0, 0x06, 0x10, 0x00, 0xC2, 0x00, 0x18, 0xC0, 0x03, 0x18,
  0x00, 0x41, 0x00, 0x18, 0x30, 0x06, 0x03, 0x01, 0x80, 0x3F, 0xE0, 0x07,
  0xF8, 0x03, 0x81, 0x80, 0xC0, 0x18, 0x30, 0x01, 0x8C, 0x00, 0x31, 0x80,
  0x02, 0x20, 0x00, 0x4C, 0x00, 0x19, 0x80, 0x03, 0x10, 0x00, 0x43, 0x00,
  0x18, 0x70, 0x06, 0x07, 0x07, 0x80, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x0E,
  0x1C, 0x18, 0x06, 0x30, 0x06, 0x60, 0x03, 0x60, 0x03, 0x40, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0,
  0x06, 0x40, 0x0A, 0x60, 0x16, 0x38, 0xE6, 0x1F, 0xC4, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x01, 0x80, 0x1F,
  0x00, 0x7C, 0x00, 0x0C, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x63, 0x86, 0x00, 0x03, 0x07, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x10,
  0x10, 0x30, 0x30, 0x60, 0x60, 0xC0, 0x00, 0x00, 0x80, 0x03, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x7F, 0xFF, 0xBF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x10, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0x00, 0x00, 0x0F, 0xE0, 0x70, 0xE3, 0x01, 0x98,
  0x03, 0xC0, 0x0F, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x30, 0x00, 0x80, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0x07, 0x00,
  0x60, 0x0C, 0x06, 0x00, 0x20, 0x60, 0x01, 0x86, 0x06, 0x0C, 0x60, 0xF8,
  0x22, 0x08, 0x21, 0x30, 0x83, 0x09, 0x0C, 0x10, 0x58, 0x40, 0x82, 0x86,
  0x04, 0x14, 0x20, 0x61, 0xE1, 0x02, 0x0B, 0x18, 0x10, 0x50, 0x80, 0x82,
  0x84, 0x0C, 0x34, 0x20, 0xC1, 0x21, 0x06, 0x19, 0x0C, 0x50, 0x8C, 0x3C,
  0x78, 0x60, 0x81, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x04, 0x00,
  0xE0, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x05, 0x00, 0x01, 0xA0, 0x00, 0x26, 0x00, 0x0C, 0xC0, 0x01, 0x18,
  0x00, 0x61, 0x00, 0x08, 0x20, 0x03, 0x04, 0x00, 0x40, 0x80, 0x18, 0x18,
  0x02, 0x03, 0x00, 0xC0, 0x60, 0x10, 0x04, 0x06, 0x00, 0x80, 0x80, 0x10,
  0x3F, 0xFE, 0x04, 0x00, 0x61, 0x80, 0x0C, 0x20, 0x01, 0x8C, 0x00, 0x31,
  0x00, 0x02, 0x60, 0x00, 0x48, 0x00, 0x0B, 0x00, 0x01, 0x80, 0x0F, 0xFC,
  0x01, 0x83, 0xE0, 0x30, 0x06, 0x04, 0x00, 0x60, 0x80, 0x04, 0x30, 0x00,
  0x86, 0x00, 0x10, 0xC0, 0x02, 0x18, 0x00, 0xC2, 0x00, 0x10, 0x40, 0x06,
  0x18, 0x03, 0x83, 0xFF, 0xC0, 0x7F, 0xF8, 0x0C, 0x01, 0xC1, 0x00, 0x18,
  0x20, 0x01, 0x8C, 0x00, 0x11, 0x80, 0x02, 0x30, 0x00, 0x44, 0x00, 0x18,
  0x80, 0x03, 0x10, 0x00, 0xC6, 0x00, 0x30, 0xC0, 0x0E, 0x18, 0x1F, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x70, 0x70, 0x1C, 0x06, 0x02, 0x00,
  0x60, 0xC0, 0x04, 0x30, 0x00, 0xC4, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0xCC, 0x00, 0x18, 0x80, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x30,
  0x30, 0x0C, 0x03, 0x07, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x40,
  0xF0, 0x04, 0x01, 0x80, 0x40, 0x0C, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x0C,
  0x00, 0x20, 0x80, 0x03, 0x08, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x31,
  0x80, 0x03, 0x18, 0x00, 0x31, 0x00, 0x03, 0x10, 0x00, 0x23, 0x00, 0x02,
  0x30, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0x42, 0x00, 0x0C, 0x20, 0x01,
  0x86, 0x00, 0x18, 0x60, 0x03, 0x06, 0x00, 0x60, 0x40, 0x1C, 0x04, 0x1F,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xFF,
  0x03, 0xFF, 0xF0, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0xFF, 0xF0, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x78,
  0x70, 0x1C, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x06, 0x30, 0x00, 0xC4, 0x00,
  0x19, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x0F, 0xF6, 0x03, 0xFE, 0xC0, 0x00,
  0x98, 0x00, 0x13, 0x00, 0x02, 0x60, 0x00, 0xCC, 0x00, 0x18, 0x80, 0x03,
  0x18, 0x00, 0x63, 0x00, 0x08, 0x30, 0x07, 0x03, 0x83, 0x80, 0x3F, 0xC0,
  0x00, 0x04, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x04, 0x18, 0x00, 0x20,
  0xC0, 0x01, 0x04, 0x00, 0x18, 0x20, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00,
  0x20, 0xC0, 0x01, 0x04, 0x00, 0x08, 0x20, 0x00, 0xC1, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF0, 0xC0, 0x01, 0x06, 0x00, 0x08, 0x20, 0x00, 0x41, 0x00, 0x06,
  0x08, 0x00, 0x30, 0xC0, 0x01, 0x06, 0x00, 0x08, 0x30, 0x00, 0x41, 0x00,
  0x06, 0x08, 0x00, 0x30, 0x40, 0x01, 0x86, 0x00, 0x08, 0x30, 0x00, 0x40,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x1F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x04, 0x00, 0x30,
  0x40, 0x02, 0x06, 0x00, 0x60, 0x30, 0x0C, 0x03, 0x83, 0x80, 0x0F, 0xE0,
  0x00, 0x04, 0x00, 0x18, 0x60, 0x01, 0x83, 0x00, 0x38, 0x18, 0x03, 0x80,
  0x80, 0x38, 0x04, 0x03, 0x80, 0x60, 0x38, 0x03, 0x03, 0x80, 0x18, 0x38,
  0x00, 0xC3, 0x00, 0x04, 0x30, 0x00, 0x23, 0x00, 0x03, 0x38, 0x00, 0x1B,
  0x60, 0x00, 0xF3, 0x00, 0x07, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x01, 0x80,
  0x18, 0x04, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x20, 0x06, 0x01, 0x00,
  0x18, 0x08, 0x00, 0xC0, 0xC0, 0x03, 0x06, 0x00, 0x08, 0x30, 0x00, 0x60,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0x06, 0x00, 0x18, 0x30, 0x01, 0xC3,
  0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x0D, 0x04, 0x80, 0x68, 0x24, 0x06,
  0x41, 0x20, 0x26, 0x19, 0x83, 0x30, 0xCC, 0x11, 0x06, 0x21, 0x88, 0x21,
  0x08, 0x41, 0x08, 0xC6, 0x08, 0x6C, 0x30, 0xC3, 0x41, 0x86, 0x1E, 0x08,
  0x30, 0x60, 0x41, 0x03, 0x02, 0x08, 0x10, 0x30, 0x40, 0x01, 0x86, 0x00,
  0x0C, 0x30, 0x00, 0x41, 0x80, 0x02, 0x08, 0x00, 0x30, 0x40, 0x01, 0x82,
  0x00, 0x0C, 0x30, 0x00, 0x60, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC3, 0x80,
  0x04, 0x1E, 0x00, 0x20, 0xF0, 0x03, 0x04, 0x80, 0x18, 0x26, 0x00, 0xC1,
  0x10, 0x06, 0x18, 0x80, 0x20, 0xC6, 0x01, 0x06, 0x10, 0x18, 0x20, 0xC0,
  0xC1, 0x06, 0x06, 0x18, 0x10, 0x30, 0xC0, 0xC1, 0x06, 0x06, 0x08, 0x30,
  0x10, 0xC1, 0x00, 0xC6, 0x08, 0x02, 0x30, 0xC0, 0x11, 0x06, 0x00, 0xC8,
  0x30, 0x02, 0x41, 0x00, 0x1E, 0x08, 0x00, 0xF0, 0x40, 0x03, 0x86, 0x00,
  0x18, 0x30, 0x00, 0xC0, 0x00, 0xFE, 0x00, 0x78, 0x60, 0x1C, 0x06, 0x06,
  0x00, 0x60, 0xC0, 0x0C, 0x30, 0x00, 0x84, 0x00, 0x11, 0x80, 0x03, 0x30,
  0x00, 0x64, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x26, 0x00, 0x04, 0x80,
  0x00, 0x90, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x13, 0x00,
  0x06, 0x60, 0x00, 0xCC, 0x00, 0x10, 0x80, 0x06, 0x18, 0x01, 0x83, 0x00,
  0x20, 0x30, 0x1C, 0x03, 0x0F, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x40, 0x78, 0x0C, 0x00, 0xC0, 0xC0, 0x06, 0x0C, 0x00, 0x20, 0xC0, 0x03,
  0x08, 0x00, 0x30, 0x80, 0x03, 0x18, 0x00, 0x31, 0x80, 0x02, 0x18, 0x00,
  0x61, 0x00, 0x0C, 0x10, 0x01, 0xC1, 0x00, 0x38, 0x3F, 0xFE, 0x03, 0xFF,
  0x80, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x78, 0x70, 0x18, 0x06,
  0x06, 0x00, 0x60, 0x80, 0x04, 0x30, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x01,
  0x20, 0x00, 0x2C, 0x00, 0x05, 0x80, 0x00, 0xA0, 0x00, 0x34, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x02, 0xC0, 0x00, 0xD8, 0x00, 0x1B,
  0x00, 0x03, 0x60, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x06, 0x10, 0x00, 0x83,
  0x00, 0x30, 0x30, 0x0C, 0x03, 0x07, 0x00, 0x3F, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x07, 0xFC, 0x01,
  0x81, 0xE0, 0x30, 0x06, 0x06, 0x00, 0x60, 0x80, 0x04, 0x10, 0x00, 0xC6,
  0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x08, 0x40, 0x03, 0x08,
  0x00, 0xC3, 0x00, 0x30, 0x60, 0x0C, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x20,
  0x18, 0x04, 0x03, 0x01, 0x80, 0x20, 0x30, 0x06, 0x06, 0x00, 0xC0, 0x80,
  0x08, 0x10, 0x01, 0x82, 0x00, 0x30, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00,
  0x0C, 0x00, 0x00, 0xFF, 0x00, 0x70, 0x70, 0x18, 0x03, 0x06, 0x00, 0x61,
  0x80, 0x06, 0x30, 0x00, 0xC4, 0x00, 0x18, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x4C, 0x00, 0x09, 0x80, 0x03, 0x30, 0x00, 0x63, 0x00, 0x18, 0x70,
  0x06, 0x07, 0x83, 0x80, 0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x21, 0x80, 0x02, 0x18, 0x00,
  0x21, 0x00, 0x06, 0x10, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0x43, 0x00,
  0x04, 0x20, 0x00, 0x42, 0x00, 0x0C, 0x20, 0x00, 0xC6, 0x00, 0x0C, 0x60,
  0x00, 0x86, 0x00, 0x08, 0x40, 0x01, 0x84, 0x00, 0x18, 0x40, 0x01, 0x8C,
  0x00, 0x10, 0xC0, 0x03, 0x04, 0x00, 0x30, 0x60, 0x06, 0x06, 0x00, 0x60,
  0x30, 0x1C, 0x01, 0x83, 0x80, 0x0F, 0xE0, 0x00, 0xC0, 0x00, 0x78, 0x00,
  0x19, 0x00, 0x03, 0x20, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x06, 0x18, 0x00,
  0xC3, 0x00, 0x10, 0x20, 0x06, 0x04, 0x00, 0x80, 0x80, 0x30, 0x18, 0x04,
  0x03, 0x01, 0x80, 0x60, 0x20, 0x04, 0x0C, 0x00, 0x81, 0x00, 0x10, 0x60,
  0x03, 0x0C, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x98, 0x00, 0x13, 0x00,
  0x02, 0x40, 0x00, 0x58, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x60, 0x3C, 0x06, 0x02, 0xC0, 0xE0, 0x6C, 0x0E, 0x06, 0xC0,
  0xE0, 0x4C, 0x1E, 0x04, 0xC1, 0x60, 0xC8, 0x16, 0x08, 0x83, 0x60, 0x88,
  0x26, 0x18, 0x82, 0x21, 0x88, 0x62, 0x10, 0x84, 0x23, 0x08, 0x42, 0x30,
  0x8C, 0x22, 0x08, 0x82, 0x20, 0x98, 0x26, 0x09, 0x82, 0x40, 0x90, 0x24,
  0x0B, 0x02, 0xC0, 0xB0, 0x28, 0x0A, 0x02, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x00, 0x06,
  0x04, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x18, 0x01, 0x80, 0x18, 0x02, 0x00,
  0x30, 0x0C, 0x00, 0x30, 0x30, 0x00, 0x60, 0xC0, 0x00, 0x41, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x98, 0x00, 0x01, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x36, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x0C,
  0x00, 0x06, 0x18, 0x00, 0x18, 0x18, 0x00, 0x60, 0x30, 0x00, 0x80, 0x20,
  0x03, 0x00, 0x60, 0x0C, 0x00, 0x40, 0x30, 0x00, 0xC0, 0xC0, 0x01, 0x83,
  0x80, 0x01, 0x80, 0xC0, 0x00, 0x6C, 0x00, 0x19, 0x80, 0x06, 0x30, 0x00,
  0x82, 0x00, 0x30, 0x60, 0x0C, 0x0C, 0x01, 0x00, 0x80, 0x60, 0x18, 0x18,
  0x03, 0x02, 0x00, 0x20, 0xC0, 0x06, 0x30, 0x00, 0xC4, 0x00, 0x09, 0x80,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0xFC, 0x18, 0x02, 0x00, 0x40, 0x08,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x7E, 0x0F, 0xC0, 0x81, 0x03, 0x06, 0x04, 0x08,
  0x10, 0x30, 0x60, 0x40, 0x81, 0x03, 0x06, 0x04, 0x08, 0x10, 0x30, 0x60,
  0x40, 0x81, 0x03, 0x06, 0x04, 0x08, 0x10, 0x30, 0x60, 0x03, 0xF0, 0x3F,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04,
  0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x04, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x50, 0x06, 0x80,
  0x24, 0x03, 0x30, 0x31, 0x81, 0x04, 0x18, 0x20, 0x81, 0x8C, 0x0C, 0x40,
  0x26, 0x01, 0x60, 0x0E, 0x00, 0x60, 0xFF, 0xFF, 0xC6, 0x23, 0x10, 0x03,
  0xFC, 0x03, 0x83, 0x83, 0x00, 0xC3, 0x00, 0x31, 0x00, 0x19, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x83, 0xFF, 0x87, 0x00, 0x46, 0x00,
  0x66, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x0C, 0xC0, 0x0E, 0x30,
  0x0D, 0x1C, 0x1D, 0x87, 0xF8, 0xC0, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x0C, 0xFE, 0x06, 0xC1, 0x82, 0x80, 0x61, 0x80, 0x10, 0xC0, 0x0C,
  0xC0, 0x06, 0x60, 0x03, 0x30, 0x00, 0x90, 0x00, 0xC8, 0x00, 0x64, 0x00,
  0x36, 0x00, 0x1B, 0x00, 0x09, 0x80, 0x0C, 0x80, 0x06, 0x40, 0x06, 0x70,
  0x06, 0x3C, 0x07, 0x1B, 0x07, 0x0C, 0xFE, 0x00, 0x03, 0xF8, 0x0E, 0x0E,
  0x18, 0x06, 0x30, 0x03, 0x30, 0x01, 0x60, 0x01, 0x40, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x06, 0xC0, 0x04, 0xC0, 0x0C, 0x60, 0x18, 0x30, 0x70, 0x1F, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x81, 0xFE, 0x60, 0xE1,
  0xD8, 0x60, 0x14, 0x30, 0x03, 0x08, 0x00, 0xC6, 0x00, 0x31, 0x00, 0x0C,
  0xC0, 0x03, 0x30, 0x00, 0x8C, 0x00, 0x22, 0x00, 0x18, 0x80, 0x06, 0x20,
  0x01, 0x88, 0x00, 0x62, 0x00, 0x10, 0xC0, 0x0C, 0x30, 0x03, 0x06, 0x03,
  0xC0, 0xC3, 0xB0, 0x1F, 0xCC, 0x00, 0x01, 0xFC, 0x01, 0xC1, 0xC0, 0xE0,
  0x30, 0x60, 0x06, 0x18, 0x00, 0x8C, 0x00, 0x22, 0x00, 0x09, 0x80, 0x02,
  0x7F, 0xFF, 0x9F, 0xFF, 0xE4, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x02, 0x0C, 0x01, 0x81, 0xC1,
  0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x1F, 0x70, 0x0C, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x3F,
  0xFF, 0x80, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFE, 0x60,
  0x70, 0xEC, 0x18, 0x05, 0x06, 0x00, 0x60, 0x80, 0x0C, 0x30, 0x01, 0x84,
  0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0x86, 0x00, 0x10, 0x80, 0x06, 0x10,
  0x00, 0xC2, 0x00, 0x18, 0x40, 0x03, 0x08, 0x00, 0x41, 0x80, 0x18, 0x30,
  0x03, 0x03, 0x01, 0xE0, 0x30, 0xEC, 0x03, 0xF9, 0x80, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0xC0, 0x1C, 0x0C, 0x07, 0x00, 0xF3,
  0x80, 0x07, 0xE0, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x7F, 0x04, 0xE0, 0xC2, 0xC0, 0x31, 0x40, 0x19, 0xC0, 0x0C, 0xC0, 0x02,
  0x60, 0x01, 0x30, 0x01, 0x90, 0x00, 0xC8, 0x00, 0x6C, 0x00, 0x26, 0x00,
  0x13, 0x00, 0x09, 0x00, 0x0C, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0x30,
  0x00, 0x98, 0x00, 0xC8, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x10, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x43, 0xC0,
  0x3F, 0x80, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x1C, 0x20, 0x0E, 0x0C, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x30,
  0x04, 0x1C, 0x00, 0x86, 0x00, 0x31, 0x80, 0x06, 0x60, 0x00, 0xFE, 0x00,
  0x1C, 0xC0, 0x03, 0x0C, 0x00, 0x40, 0xC0, 0x18, 0x18, 0x03, 0x01, 0x80,
  0x60, 0x18, 0x0C, 0x03, 0x01, 0x00, 0x30, 0x20, 0x03, 0x0C, 0x00, 0x30,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x1B, 0xF3,
  0xF0, 0xB1, 0xB0, 0xC6, 0x07, 0x02, 0x20, 0x30, 0x13, 0x01, 0x80, 0x98,
  0x08, 0x04, 0x80, 0x40, 0x64, 0x02, 0x03, 0x20, 0x30, 0x1B, 0x01, 0x80,
  0x98, 0x0C, 0x04, 0xC0, 0x40, 0x24, 0x02, 0x03, 0x20, 0x30, 0x19, 0x01,
  0x80, 0xD8, 0x0C, 0x04, 0xC0, 0x40, 0x26, 0x02, 0x01, 0x20, 0x10, 0x19,
  0x01, 0x80, 0xC0, 0x18, 0xFE, 0x09, 0xC3, 0x85, 0x80, 0x63, 0x80, 0x33,
  0x80, 0x19, 0x80, 0x04, 0xC0, 0x06, 0x40, 0x03, 0x20, 0x01, 0x90, 0x00,
  0xD8, 0x00, 0x4C, 0x00, 0x26, 0x00, 0x32, 0x00, 0x19, 0x00, 0x0D, 0x80,
  0x06, 0xC0, 0x02, 0x60, 0x01, 0x30, 0x01, 0x90, 0x00, 0xC0, 0x01, 0xFC,
  0x01, 0xC1, 0x80, 0xC0, 0x30, 0x60, 0x06, 0x30, 0x01, 0x88, 0x00, 0x26,
  0x00, 0x0D, 0x80, 0x03, 0x40, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0B, 0x00,
  0x02, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x31, 0x00, 0x08, 0x60, 0x06,
  0x0C, 0x03, 0x03, 0x83, 0x80, 0x3F, 0x80, 0x06, 0x7F, 0x00, 0xD8, 0x30,
  0x14, 0x03, 0x03, 0x00, 0x20, 0xC0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x18,
  0x60, 0x03, 0x08, 0x00, 0x61, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x31,
  0x80, 0x04, 0x30, 0x01, 0x84, 0x00, 0x30, 0x80, 0x0C, 0x38, 0x03, 0x07,
  0x80, 0xE0, 0xD8, 0x38, 0x19, 0xFC, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x07, 0xF9, 0x87, 0x06, 0xC6, 0x01, 0x46, 0x00, 0x62, 0x00,
  0x33, 0x00, 0x19, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x02, 0x60, 0x01, 0x20,
  0x01, 0x90, 0x00, 0xC8, 0x00, 0x64, 0x00, 0x32, 0x00, 0x11, 0x80, 0x18,
  0xC0, 0x0C, 0x30, 0x1E, 0x0C, 0x3B, 0x03, 0xF9, 0x80, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x18, 0x7F, 0x19, 0xC0, 0x13, 0x00, 0x14, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x07, 0xFC, 0x07, 0x07, 0x06, 0x00,
  0xC6, 0x00, 0x23, 0x00, 0x19, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x09, 0x00, 0x0C, 0xC0, 0x06, 0x60, 0x06, 0x1C, 0x0E, 0x03, 0xFC,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x03, 0xFF, 0xF0,
  0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x10, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x07, 0xF0, 0x30, 0x01, 0x98,
  0x00, 0xC8, 0x00, 0x64, 0x00, 0x26, 0x00, 0x13, 0x00, 0x19, 0x80, 0x0C,
  0xC0, 0x06, 0x40, 0x03, 0x20, 0x01, 0x30, 0x00, 0x98, 0x00, 0xCC, 0x00,
  0x66, 0x00, 0x33, 0x00, 0x19, 0x80, 0x18, 0xC0, 0x1C, 0x30, 0x1A, 0x1C,
  0x3B, 0x07, 0xF1, 0x80, 0xC0, 0x00, 0xD0, 0x00, 0x36, 0x00, 0x19, 0x80,
  0x04, 0x20, 0x03, 0x08, 0x00, 0x83, 0x00, 0x60, 0xC0, 0x30, 0x10, 0x0C,
  0x06, 0x06, 0x01, 0x81, 0x00, 0x60, 0xC0, 0x08, 0x20, 0x03, 0x18, 0x00,
  0xCC, 0x00, 0x33, 0x00, 0x05, 0x80, 0x01, 0x40, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x80, 0x40, 0x38, 0x0C, 0x02, 0x80, 0xE0, 0x68, 0x0E, 0x04, 0xC1,
  0xE0, 0xCC, 0x16, 0x0C, 0xC3, 0x60, 0x8C, 0x22, 0x18, 0xC2, 0x21, 0x0C,
  0x62, 0x30, 0xC4, 0x23, 0x0C, 0xC2, 0x20, 0xC8, 0x26, 0x0D, 0x82, 0x40,
  0xD0, 0x24, 0x05, 0x02, 0xC0, 0x70, 0x28, 0x06, 0x03, 0x80, 0x60, 0x30,
  0x04, 0x03, 0x00, 0x1C, 0x00, 0x30, 0xC0, 0x06, 0x06, 0x00, 0xC0, 0x60,
  0x18, 0x03, 0x03, 0x00, 0x18, 0x60, 0x01, 0x8C, 0x00, 0x0D, 0x80, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x01, 0x98, 0x00,
  0x31, 0x80, 0x06, 0x0C, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x00, 0x30,
  0x60, 0x01, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x18, 0x10,
  0x00, 0x30, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x00, 0x40, 0x06, 0x00, 0xC0,
  0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0xC0, 0x02, 0x01, 0x00, 0x06, 0x06,
  0x00, 0x0C, 0x18, 0x00, 0x08, 0x30, 0x00, 0x10, 0xC0, 0x00, 0x31, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x58, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x02, 0x70, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x03,
  0xC0, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x10, 0x00, 0x04, 0x10, 0xC3, 0x0C, 0x20, 0x82, 0x08, 0x61, 0x84, 0x10,
  0x41, 0x0C, 0x30, 0xC2, 0x08, 0x21, 0x86, 0x18, 0x41, 0x04, 0x10, 0xC3,
  0x0C, 0x20, 0x80, 0x02, 0x00, 0x07, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x78, 0x00, 0xF0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0x00, 0x3F, 0x80, 0x17, 0x1C, 0x01, 0x60, 0x60, 0x3C, 0x03,
  0x06, 0x80, 0x1F, 0xC0, 0x00, 0xF8,
};

const GFXglyph RobotoMono_ExtraLightItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 6, 27, 22, 8, -27 },
  { 22, 8, 8, 22, 9, -29 },
  { 30, 23, 27, 22, 0, -27 },
  { 108, 19, 35, 22, 2, -31 },
  { 192, 19, 27, 22, 2, -27 },
  { 257, 18, 27, 22, 2, -27 },
  { 318, 3, 8, 22, 11, -29 },
  { 321, 11, 39, 22, 7, -30 },
  { 375, 12, 39, 22, 3, -30 },
  { 434, 16, 16, 22, 5, -27 },
  { 466, 19, 19, 22, 2, -22 },
  { 512, 4, 8, 22, 5, -3 },
  { 516, 14, 2, 22, 4, -13 },
  { 520, 3, 3, 22, 8, -3 },
  { 522, 18, 29, 22, 3, -27 },
  { 588, 17, 27, 22, 3, -27 },
  { 646, 10, 27, 22, 6, -27 },
  { 680, 18, 27, 22, 1, -27 },
  { 741, 18, 27, 22, 1, -27 },
  { 802, 19, 27, 22, 1, -27 },
  { 867, 19, 27, 22, 3, -27 },
  { 932, 17, 27, 22, 2, -27 },
  { 990, 17, 27, 22, 5, -27 },
  { 1048, 19, 27, 22, 2, -27 },
  { 1113, 16, 27, 22, 4, -27 },
  { 1167, 6, 19, 22, 9, -19 },
  { 1182, 8, 24, 22, 7, -19 },
  { 1206, 17, 15, 22, 3, -20 },
  { 1238, 17, 9, 22, 3, -17 },
  { 1258, 17, 15, 22, 2, -20 },
  { 1290, 14, 27, 22, 6, -27 },
  { 1338, 21, 27, 22, 1, -27 },
  { 1409, 19, 27, 22, 0, -27 },
  { 1474, 19, 27, 22, 2, -27 },
  { 1539, 19, 27, 22, 2, -27 },
  { 1604, 20, 27, 22, 1, -27 },
  { 1672, 20, 27, 22, 2, -27 },
  { 1740, 20, 27, 22, 2, -27 },
  { 1808, 19, 27, 22, 2, -27 },
  { 1873, 21, 27, 22, 1, -27 },
  { 1944, 19, 27, 22, 2, -27 },
  { 2009, 20, 27, 22, 1, -27 },
  { 2077, 21, 27, 22, 2, -27 },
  { 2148, 16, 27, 22, 2, -27 },
  { 2202, 21, 27, 22, 1, -27 },
  { 2273, 21, 27, 22, 1, -27 },
  { 2344, 19, 27, 22, 2, -27 },
  { 2409, 20, 27, 22, 2, -27 },
  { 2477, 19, 32, 22, 2, -27 },
  { 2553, 19, 27, 22, 2, -27 },
  { 2618, 19, 27, 22, 2, -27 },
  { 2683, 19, 27, 22, 4, -27 },
  { 2748, 20, 27, 22, 2, -27 },
  { 2816, 19, 27, 22, 4, -27 },
  { 2881, 20, 27, 22, 4, -27 },
  { 2949, 23, 27, 22, 0, -27 },
  { 3027, 19, 27, 22, 4, -27 },
  { 3092, 20, 27, 22, 1, -27 },
  { 3160, 11, 37, 22, 6, -31 },
  { 3211, 7, 29, 22, 8, -27 },
  { 3237, 12, 37, 22, 5, -31 },
  { 3293, 13, 15, 22, 5, -27 },
  { 3318, 16, 1, 22, 1, 0 },
  { 3320, 4, 5, 22, 11, -28 },
  { 3323, 17, 20, 22, 2, -20 },
  { 3366, 17, 29, 22, 2, -29 },
  { 3428, 16, 20, 22, 3, -20 },
  { 3468, 18, 29, 22, 3, -29 },
  { 3534, 18, 20, 22, 2, -20 },
  { 3579, 18, 29, 22, 5, -29 },
  { 3645, 19, 28, 22, 1, -20 },
  { 3712, 17, 29, 22, 2, -29 },
  { 3774, 16, 27, 22, 2, -27 },
  { 3828, 17, 35, 22, 0, -27 },
  { 3903, 19, 29, 22, 2, -29 },
  { 3972, 16, 29, 22, 2, -29 },
  { 4030, 21, 20, 22, 0, -20 },
  { 4083, 17, 20, 22, 2, -20 },
  { 4126, 18, 20, 22, 2, -20 },
  { 4171, 19, 28, 22, 0, -20 },
  { 4238, 17, 28, 22, 3, -20 },
  { 4298, 16, 20, 22, 5, -20 },
  { 4338, 17, 20, 22, 3, -20 },
  { 4381, 14, 25, 22, 5, -25 },
  { 4425, 17, 20, 22, 3, -20 },
  { 4468, 18, 20, 22, 3, -20 },
  { 4513, 20, 20, 22, 3, -20 },
  { 4563, 20, 20, 22, 1, -20 },
  { 4613, 23, 28, 22, -1, -20 },
  { 4694, 19, 20, 22, 1, -20 },
  { 4742, 15, 38, 22, 6, -30 },
  { 4814, 6, 33, 22, 8, -27 },
  { 4839, 15, 38, 22, 3, -30 },
  { 4911, 20, 6, 22, 1, -14 },
};

const GFXfont RobotoMono_ExtraLightItalic38pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic38pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic38pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC38PT7B_H_
