#ifndef _ROBOTOMONO_EXTRALIGHTITALIC72PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x0F,
  0x00, 0xF8, 0x0F, 0x00, 0xF0, 0x00, 0x1C, 0x0E, 0x30, 0x1C, 0xE0, 0x39,
  0xC0, 0x63, 0x80, 0xC7, 0x03, 0x8E, 0x07, 0x18, 0x0E, 0x70, 0x1C, 0xE0,
  0x31, 0xC0, 0x63, 0x81, 0xC6, 0x03, 0x8C, 0x07, 0x38, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x03, 0x00,
  0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x00, 0xC0,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x18, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFC,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x81, 0xC0, 0x0E, 0x00, 0x18, 0x70, 0x01, 0xC0, 0x07, 0x0E,
  0x00, 0x38, 0x01, 0xC1, 0xC0, 0x07, 0x00, 0x70, 0x30, 0x00, 0xE0, 0x0E,
  0x06, 0x00, 0x1C, 0x03, 0x80, 0xC0, 0x03, 0x00, 0xE0, 0x38, 0x00, 0xE0,
  0x1C, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x60, 0x03, 0x81, 0xC0, 0x0C, 0x00,
  0xE0, 0x30, 0x01, 0xC0, 0x1C, 0x0E, 0x00, 0x38, 0x07, 0x03, 0x80, 0x03,
  0x83, 0xC0, 0xE0, 0x00, 0x3F, 0xF0, 0x1C, 0x00, 0x03, 0xFC, 0x07, 0x00,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x7F, 0xC0,
  0x00, 0x38, 0x1F, 0xFC, 0x00, 0x0E, 0x07, 0x83, 0xC0, 0x03, 0x81, 0xE0,
  0x38, 0x00, 0x70, 0x38, 0x03, 0x00, 0x1C, 0x0E, 0x00, 0x70, 0x07, 0x01,
  0xC0, 0x0E, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x38, 0x0E, 0x00, 0x38, 0x0E,
  0x01, 0xC0, 0x07, 0x03, 0x80, 0x30, 0x00, 0xE0, 0x70, 0x06, 0x00, 0x1C,
  0x1C, 0x01, 0xC0, 0x03, 0x07, 0x00, 0x38, 0x00, 0xE1, 0xE0, 0x07, 0x00,
  0x1C, 0x38, 0x00, 0xE0, 0x03, 0x82, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x03, 0x83, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x70, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x1E, 0x00,
  0x00, 0x38, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0x38, 0x0F,
  0x00, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x00, 0x1C, 0x7C, 0x00, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7D, 0xC0,
  0x00, 0x00, 0x0F, 0x9C, 0x00, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x07, 0x07, 0x80, 0x70, 0x00, 0x70, 0xF0, 0x03, 0x80, 0x0E,
  0x0E, 0x00, 0x3C, 0x00, 0xE1, 0xC0, 0x01, 0xC0, 0x0E, 0x3C, 0x00, 0x0E,
  0x01, 0xE3, 0x80, 0x00, 0xE0, 0x1C, 0x78, 0x00, 0x07, 0x01, 0xC7, 0x00,
  0x00, 0x78, 0x38, 0x70, 0x00, 0x03, 0x83, 0x87, 0x00, 0x00, 0x1C, 0x70,
  0x70, 0x00, 0x01, 0xEF, 0x07, 0x00, 0x00, 0x0E, 0xE0, 0x70, 0x00, 0x00,
  0xFC, 0x07, 0x00, 0x00, 0x07, 0xC0, 0x70, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x0F, 0xC0, 0x38, 0x00, 0x01, 0xFC, 0x03, 0xC0, 0x00, 0x7C, 0xE0,
  0x1F, 0x00, 0x1F, 0x0F, 0x00, 0xFC, 0x07, 0xE0, 0x70, 0x07, 0xFF, 0xF8,
  0x03, 0x80, 0x1F, 0xFE, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x39,
  0xCE, 0x73, 0x39, 0xCE, 0x73, 0x19, 0xCE, 0x73, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x40, 0x03, 0x80, 0x0D, 0xE0, 0x06, 0x00,
  0xFF, 0xF8, 0x0C, 0x0F, 0xF3, 0xFE, 0x18, 0xFF, 0x80, 0xFF, 0x77, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0x3C, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x80, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x07, 0x07, 0x0F, 0x0E, 0x0E, 0x0E,
  0x1E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0xE0, 0xE0, 0x40, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7B, 0xFF, 0xFE, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7E, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x0F, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x00, 0x60, 0xE0, 0x00,
  0x00, 0x7C, 0x38, 0x00, 0x00, 0x3F, 0x1C, 0x00, 0x00, 0x1F, 0xC7, 0x00,
  0x00, 0x0F, 0xF1, 0xC0, 0x00, 0x07, 0x38, 0x70, 0x00, 0x07, 0x8E, 0x38,
  0x00, 0x03, 0xC3, 0x8E, 0x00, 0x01, 0xE0, 0xE3, 0x80, 0x00, 0xF0, 0x38,
  0xE0, 0x00, 0x70, 0x0E, 0x38, 0x00, 0x78, 0x03, 0x8E, 0x00, 0x3C, 0x01,
  0xC7, 0x00, 0x1E, 0x00, 0x71, 0xC0, 0x0F, 0x00, 0x1C, 0x70, 0x07, 0x80,
  0x07, 0x1C, 0x03, 0x80, 0x01, 0xC7, 0x03, 0xC0, 0x00, 0x71, 0xC1, 0xE0,
  0x00, 0x38, 0xE0, 0xF0, 0x00, 0x0E, 0x38, 0x78, 0x00, 0x03, 0x8E, 0x38,
  0x00, 0x00, 0xE3, 0xBC, 0x00, 0x00, 0x78, 0xFE, 0x00, 0x00, 0x1C, 0x3F,
  0x00, 0x00, 0x07, 0x0F, 0x80, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x3F, 0xE0, 0x1F, 0xDC, 0x0F, 0xC3, 0x8F, 0xE0,
  0x73, 0xF0, 0x0E, 0xF0, 0x01, 0x98, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x07, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x07, 0xE0, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x04, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x07, 0xE0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x0F,
  0x38, 0x00, 0x00, 0x03, 0xC6, 0x00, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x01, 0xE0, 0xE0, 0x00,
  0x00, 0x78, 0x1C, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x01, 0x00, 0x00, 0x03, 0x87, 0xFF,
  0x00, 0x00, 0x77, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0xF0, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x07, 0x80, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x70, 0x00, 0x0E, 0x07, 0xFF, 0x00, 0x0E, 0x1F, 0xFF, 0xC0, 0x1C, 0x7F,
  0x07, 0xE0, 0x1C, 0xF0, 0x00, 0xF0, 0x1D, 0xE0, 0x00, 0x78, 0x3B, 0x80,
  0x00, 0x38, 0x3F, 0x00, 0x00, 0x1C, 0x3E, 0x00, 0x00, 0x1C, 0x3C, 0x00,
  0x00, 0x1E, 0x38, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x07, 0xC0, 0x0F, 0x80,
  0x0F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x07, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x38,
  0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x38,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x03, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x78, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x71,
  0xE0, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x79, 0xC0, 0x00,
  0x01, 0xF3, 0xC0, 0x00, 0x06, 0xE3, 0x80, 0x00, 0x1F, 0x87, 0x80, 0x00,
  0x77, 0x07, 0x80, 0x03, 0xCE, 0x07, 0x80, 0x1F, 0x18, 0x07, 0xF3, 0xFC,
  0x70, 0x07, 0xFF, 0xE0, 0xE0, 0x03, 0xFF, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x7C, 0x1F, 0x83,
  0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0xF8, 0x1F, 0x83, 0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x1F, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x78, 0x00, 0x78,
  0x1E, 0x00, 0x07, 0x07, 0x80, 0x00, 0x71, 0xE0, 0x00, 0x0E, 0x38, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x01, 0xC0,
  0x07, 0xE0, 0x06, 0x01, 0xC0, 0x1F, 0xF0, 0x06, 0x03, 0x80, 0x3F, 0xFC,
  0x07, 0x07, 0x00, 0x78, 0x1C, 0x07, 0x07, 0x00, 0xE0, 0x0C, 0x07, 0x0E,
  0x01, 0xC0, 0x1C, 0x07, 0x0E, 0x03, 0x80, 0x18, 0x07, 0x1C, 0x03, 0x00,
  0x18, 0x07, 0x1C, 0x07, 0x00, 0x18, 0x07, 0x18, 0x06, 0x00, 0x38, 0x07,
  0x38, 0x0E, 0x00, 0x30, 0x06, 0x38, 0x0C, 0x00, 0x30, 0x06, 0x30, 0x1C,
  0x00, 0x70, 0x06, 0x70, 0x1C, 0x00, 0x70, 0x06, 0x70, 0x18, 0x00, 0x60,
  0x0E, 0x60, 0x18, 0x00, 0x60, 0x0E, 0x60, 0x38, 0x00, 0xE0, 0x0C, 0xE0,
  0x38, 0x00, 0xC0, 0x0C, 0xE0, 0x30, 0x00, 0xC0, 0x0C, 0xE0, 0x30, 0x01,
  0xC0, 0x1C, 0xC0, 0x30, 0x01, 0xC0, 0x18, 0xC0, 0x70, 0x03, 0x80, 0x18,
  0xC0, 0x70, 0x03, 0x80, 0x38, 0xC0, 0x70, 0x07, 0x80, 0x30, 0xC0, 0x70,
  0x0F, 0x80, 0x70, 0xC0, 0x30, 0x0D, 0x80, 0x60, 0xC0, 0x30, 0x19, 0x80,
  0xE0, 0xE0, 0x38, 0x79, 0xC1, 0xC0, 0xE0, 0x3F, 0xF0, 0xFF, 0x80, 0xE0,
  0x1F, 0xC0, 0xFF, 0x00, 0x60, 0x0F, 0x80, 0x3C, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x40, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00,
  0x07, 0x18, 0x00, 0x00, 0x01, 0xE3, 0x00, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x00, 0x0F, 0x0E, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x78, 0x38,
  0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x00, 0x70,
  0x0C, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0x00, 0xE0, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x1C, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x03, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0x00, 0x01,
  0xF0, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x38, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00,
  0x78, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x07, 0x00,
  0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x07, 0x80, 0x70, 0x00,
  0x01, 0xF0, 0x07, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0xFC, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x60, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00,
  0x1E, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x3C, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xC0,
  0x00, 0xFC, 0x00, 0x0E, 0x00, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x38, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x70, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x78, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0x03, 0xE0, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x0F,
  0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x0E,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x3F,
  0xFF, 0xC7, 0x00, 0x03, 0xFF, 0xF8, 0xE0, 0x00, 0x3F, 0xFF, 0x8E, 0x00,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x60, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x03, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x07, 0x80, 0x00, 0x03,
  0x80, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x0F,
  0x80, 0x00, 0x00, 0x0E, 0x1F, 0x80, 0x00, 0x00, 0x0E, 0x3F, 0x80, 0x00,
  0x00, 0x0E, 0x7F, 0xC0, 0x00, 0x00, 0x0E, 0xF1, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x70,
  0x00, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0xEC,
  0x00, 0x00, 0xEE, 0x00, 0xEE, 0x00, 0x01, 0xEE, 0x00, 0xEE, 0x00, 0x01,
  0xCC, 0x00, 0xCE, 0x00, 0x03, 0xDC, 0x01, 0xCE, 0x00, 0x03, 0x9C, 0x01,
  0xC6, 0x00, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x01, 0xC7, 0x00,
  0x0E, 0x1C, 0x01, 0xC7, 0x00, 0x0E, 0x18, 0x01, 0x87, 0x00, 0x1C, 0x38,
  0x03, 0x83, 0x00, 0x3C, 0x38, 0x03, 0x83, 0x00, 0x38, 0x38, 0x03, 0x83,
  0x80, 0x78, 0x38, 0x03, 0x83, 0x80, 0x70, 0x38, 0x03, 0x83, 0x80, 0xE0,
  0x70, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x07, 0x01, 0x81, 0xC0, 0x70, 0x07,
  0x01, 0xC1, 0xC0, 0x70, 0x07, 0x01, 0xC3, 0x80, 0x70, 0x07, 0x01, 0xC7,
  0x80, 0x60, 0x07, 0x01, 0xC7, 0x00, 0xE0, 0x0E, 0x00, 0xCE, 0x00, 0xE0,
  0x0E, 0x00, 0xEE, 0x00, 0xE0, 0x0E, 0x00, 0xFC, 0x00, 0xE0, 0x0E, 0x00,
  0xFC, 0x00, 0xE0, 0x0E, 0x00, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01,
  0xC0, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x07, 0x00, 0x30, 0x00, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x07, 0xC0,
  0x00, 0x00, 0x70, 0x0F, 0xC0, 0x00, 0x00, 0xE0, 0x1F, 0x80, 0x00, 0x03,
  0x80, 0x3F, 0x00, 0x00, 0x07, 0x00, 0x77, 0x00, 0x00, 0x0E, 0x01, 0xCE,
  0x00, 0x00, 0x1C, 0x03, 0x8C, 0x00, 0x00, 0x38, 0x07, 0x1C, 0x00, 0x00,
  0x70, 0x0E, 0x38, 0x00, 0x01, 0xC0, 0x1C, 0x38, 0x00, 0x03, 0x80, 0x38,
  0x70, 0x00, 0x07, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0xE0, 0x00,
  0x1C, 0x03, 0x81, 0xC0, 0x00, 0x78, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x0E,
  0x03, 0x80, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x03, 0x80, 0x70, 0x06, 0x00,
  0x07, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x03,
  0x80, 0x1C, 0x00, 0x70, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0x70,
  0x01, 0xC0, 0x38, 0x00, 0x70, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x07, 0x00,
  0xE0, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x03,
  0x80, 0x70, 0x07, 0x00, 0x03, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x01, 0xC0,
  0x38, 0x00, 0x0E, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0xE0, 0x00,
  0x1C, 0x1C, 0x01, 0xC0, 0x00, 0x38, 0x38, 0x03, 0x00, 0x00, 0x38, 0x70,
  0x0E, 0x00, 0x00, 0x70, 0xE0, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x38, 0x00,
  0x00, 0xE7, 0x00, 0x70, 0x00, 0x01, 0xCE, 0x00, 0xE0, 0x00, 0x01, 0x9C,
  0x03, 0x80, 0x00, 0x03, 0xB8, 0x07, 0x00, 0x00, 0x07, 0x70, 0x0E, 0x00,
  0x00, 0x07, 0xE0, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x38, 0x00, 0x00, 0x1F,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x01, 0xF0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x38,
  0x0F, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00,
  0x07, 0x38, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x00, 0x1C, 0x18, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0xF0, 0x70,
  0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x1F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x38,
  0x00, 0x03, 0xF0, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x38, 0x00,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00,
  0xE0, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x1C, 0x01,
  0xE0, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x78, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0x77, 0x80, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x3C,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x0E, 0x00, 0x03, 0xF0, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x0E, 0x00, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x18, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x0E, 0x00,
  0x00, 0x7C, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x60, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0xE0, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x1E,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x00, 0xF0, 0x38, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0x0F, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7E, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x60, 0x00,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00,
  0x0E, 0x03, 0x00, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x3C, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3B, 0xC0,
  0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00,
  0x78, 0x70, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x03, 0xC0, 0xE0, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x00, 0x31, 0xE0, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1D, 0xC0, 0x01, 0xE0, 0x00, 0x67, 0x00, 0x07, 0x80, 0x03,
  0x9C, 0x00, 0x1E, 0x00, 0x0E, 0x70, 0x00, 0xF8, 0x00, 0x31, 0xC0, 0x03,
  0xE0, 0x01, 0xC6, 0x00, 0x0F, 0x80, 0x07, 0x18, 0x00, 0x7E, 0x00, 0x1C,
  0x60, 0x01, 0xF8, 0x00, 0xE1, 0x80, 0x06, 0xE0, 0x03, 0x86, 0x00, 0x3B,
  0x80, 0x0E, 0x18, 0x00, 0xEE, 0x00, 0x30, 0x60, 0x03, 0x38, 0x01, 0xC1,
  0x80, 0x1C, 0xE0, 0x07, 0x06, 0x00, 0x73, 0x80, 0x18, 0x18, 0x01, 0x86,
  0x00, 0xE0, 0x60, 0x0E, 0x18, 0x03, 0x81, 0x80, 0x38, 0x60, 0x0E, 0x06,
  0x00, 0xC1, 0x80, 0x70, 0x18, 0x07, 0x06, 0x01, 0xC0, 0x60, 0x1C, 0x18,
  0x07, 0x01, 0x80, 0xE0, 0x60, 0x18, 0x06, 0x03, 0x81, 0x80, 0xE0, 0x18,
  0x0E, 0x06, 0x03, 0x80, 0x60, 0x70, 0x18, 0x0C, 0x01, 0x81, 0xC0, 0x60,
  0x70, 0x06, 0x07, 0x01, 0x81, 0xC0, 0x18, 0x38, 0x07, 0x07, 0x00, 0x60,
  0xE0, 0x1C, 0x38, 0x01, 0x83, 0x80, 0x70, 0xE0, 0x06, 0x1C, 0x01, 0xC3,
  0x80, 0x18, 0x70, 0x07, 0x1C, 0x00, 0xE1, 0xC0, 0x1C, 0x70, 0x03, 0x8E,
  0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0xC6, 0x00, 0x38, 0xE0, 0x07, 0x38,
  0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x0E, 0x70,
  0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x1D, 0xC0,
  0x03, 0xB8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x00,
  0x39, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x00, 0x3C,
  0xE0, 0x00, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00,
  0x00, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xEE, 0x00, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x08, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x76, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x39, 0xC0, 0x00,
  0x3C, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00,
  0x0E, 0x07, 0x00, 0x07, 0x03, 0x80, 0x07, 0x00, 0xC0, 0x07, 0x80, 0x70,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x03,
  0x80, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0x70, 0x70, 0x00,
  0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x38, 0x00, 0x03, 0x9C, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0E,
  0x06, 0x07, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFC,
  0x00, 0x0E, 0x0F, 0xC0, 0x00, 0x1C, 0x1F, 0x00, 0x00, 0x1C, 0x3C, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0x78, 0xE0, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0xF8, 0xE0, 0x00,
  0x01, 0xF8, 0xF0, 0x00, 0x07, 0xB0, 0x78, 0x00, 0x0F, 0x70, 0x3C, 0x00,
  0x3E, 0x70, 0x3F, 0x01, 0xF8, 0x70, 0x0F, 0xFF, 0xF0, 0x78, 0x07, 0xFF,
  0x80, 0x78, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x3E, 0x00, 0x03, 0x81,
  0xFF, 0xC0, 0x03, 0x87, 0xFF, 0xE0, 0x03, 0x9F, 0x81, 0xF8, 0x03, 0x3C,
  0x00, 0x78, 0x07, 0x70, 0x00, 0x3C, 0x07, 0xE0, 0x00, 0x1E, 0x07, 0xC0,
  0x00, 0x0E, 0x07, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0F, 0x07, 0x00,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x1E, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x70, 0x78, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x03, 0xC0, 0xEE, 0x00,
  0x07, 0xC0, 0xE7, 0x80, 0x0F, 0x80, 0xE3, 0xE0, 0x7E, 0x00, 0xE1, 0xFF,
  0xFC, 0x00, 0xE0, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x1C, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x0E, 0x0F, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x03, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x7E, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x1C,
  0x00, 0x0F, 0xFE, 0x07, 0x80, 0x07, 0xFF, 0xF0, 0xE0, 0x01, 0xF8, 0x1F,
  0x1C, 0x00, 0x7C, 0x00, 0xF3, 0x80, 0x1E, 0x00, 0x07, 0x70, 0x07, 0x80,
  0x00, 0x6E, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x0E,
  0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x38,
  0x1E, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00,
  0x38, 0x1E, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x00, 0x38, 0x0F, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x1C,
  0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x38, 0x00, 0x07, 0xE0,
  0x07, 0x80, 0x01, 0xFC, 0x00, 0x78, 0x00, 0xF3, 0x80, 0x07, 0xC0, 0xFC,
  0x70, 0x00, 0x7F, 0xFF, 0x0C, 0x00, 0x03, 0xFF, 0x83, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x38, 0x07, 0x80, 0x00, 0x1E,
  0x03, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00,
  0x1C, 0xF0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x03, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEE, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x0F, 0x00, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0x00, 0x20, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x1C, 0x00, 0x3F,
  0xFF, 0x87, 0x00, 0x0F, 0xC0, 0xF8, 0xE0, 0x03, 0xE0, 0x03, 0x9C, 0x00,
  0xF0, 0x00, 0x3B, 0x80, 0x3C, 0x00, 0x03, 0x70, 0x0F, 0x00, 0x00, 0x7E,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x07, 0x83, 0x80, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x38,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00,
  0xF8, 0x01, 0xC0, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0x0F, 0xE0, 0x03, 0xC0,
  0x07, 0xDC, 0x00, 0x3E, 0x03, 0xE3, 0x80, 0x03, 0xFF, 0xF8, 0xE0, 0x00,
  0x1F, 0xFC, 0x1C, 0x00, 0x00, 0xF8, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x10, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x3F, 0x00, 0x01, 0xC0, 0x7F, 0xF0, 0x00, 0x60,
  0x7F, 0xFF, 0x00, 0x38, 0x3E, 0x07, 0xE0, 0x0E, 0x3C, 0x00, 0x7C, 0x03,
  0x9E, 0x00, 0x0F, 0x00, 0xEE, 0x00, 0x01, 0xC0, 0x3B, 0x00, 0x00, 0x38,
  0x0D, 0x80, 0x00, 0x0E, 0x07, 0xC0, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x00,
  0xE0, 0x78, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0xC1, 0xC0,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x70, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x38, 0x00, 0x00, 0xF0, 0x07,
  0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x38, 0x00, 0x07, 0xC0,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x3E,
  0x00, 0x03, 0x80, 0x0F, 0x80, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x7C, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x0E,
  0x07, 0x80, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x00, 0x70, 0xF8, 0x00, 0x00,
  0x0E, 0x3E, 0x00, 0x00, 0x01, 0xCF, 0xE0, 0x00, 0x00, 0x3B, 0xDC, 0x00,
  0x00, 0x07, 0xF1, 0xC0, 0x00, 0x01, 0xF8, 0x3C, 0x00, 0x00, 0x3E, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x38, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x0E, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x71, 0xFF, 0x01, 0xFF, 0x80, 0x18,
  0xFF, 0xE0, 0xFF, 0xF0, 0x0E, 0xF8, 0x7C, 0x78, 0x3C, 0x03, 0xB8, 0x07,
  0x38, 0x07, 0x80, 0xF8, 0x01, 0xFC, 0x00, 0xE0, 0x3C, 0x00, 0x3E, 0x00,
  0x38, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x80, 0x01, 0x81,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x00, 0x38, 0x1C, 0x00,
  0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x60, 0x00, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x00, 0x0C,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x0C, 0x00, 0x0E,
  0x00, 0x07, 0x07, 0x00, 0x03, 0x80, 0x01, 0x81, 0xC0, 0x00, 0xE0, 0x00,
  0xE0, 0x70, 0x00, 0x30, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x07,
  0x00, 0x07, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0xE0, 0x00,
  0x70, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x06, 0x00,
  0x07, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x70, 0x00, 0x38, 0x00, 0x18, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x07, 0x00,
  0x03, 0x00, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x70,
  0x00, 0x38, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x3F, 0xF8, 0x00, 0x60, 0x7F,
  0xFF, 0x00, 0x70, 0xFC, 0x0F, 0xC0, 0x38, 0xF0, 0x01, 0xE0, 0x1C, 0xF0,
  0x00, 0x78, 0x0E, 0xE0, 0x00, 0x1C, 0x07, 0xE0, 0x00, 0x07, 0x03, 0x60,
  0x00, 0x03, 0x83, 0xE0, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x00, 0xE0, 0xF0,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x1C, 0x3C,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0xE1,
  0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x0F, 0x80, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x78, 0x07,
  0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x07, 0x07, 0x80, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x01, 0xE1, 0xC0, 0x00,
  0x00, 0xE0, 0xF0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0xF0, 0x07, 0x80, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x07, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0x0F, 0xFF, 0x00,
  0x01, 0xC3, 0xFF, 0xF0, 0x00, 0x31, 0xF8, 0x1F, 0x00, 0x0E, 0x78, 0x00,
  0xF0, 0x01, 0xDC, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x00, 0xE0, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x38, 0x07,
  0x80, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0x1E, 0x03, 0x80, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x3C, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x77, 0x00, 0x03, 0xC0,
  0x0E, 0x70, 0x01, 0xF0, 0x01, 0xCF, 0xC0, 0xFC, 0x00, 0x38, 0x7F, 0xFF,
  0x00, 0x07, 0x03, 0xFF, 0x80, 0x01, 0xC0, 0x0F, 0x80, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x81, 0xC0, 0x0F, 0xFF, 0xE1,
  0xC0, 0x0F, 0xC0, 0xF8, 0xE0, 0x0F, 0x80, 0x0E, 0x70, 0x0F, 0x00, 0x03,
  0xB8, 0x0F, 0x00, 0x00, 0xFC, 0x0F, 0x00, 0x00, 0x7E, 0x0F, 0x00, 0x00,
  0x1E, 0x07, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x01, 0xC3, 0xC0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x60, 0xE0, 0x00,
  0x00, 0x70, 0xF0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x03, 0xE0, 0x1C, 0x00, 0x03, 0xF0, 0x0F, 0x00, 0x03, 0xF8,
  0x03, 0xC0, 0x07, 0xDC, 0x00, 0xF8, 0x0F, 0x8E, 0x00, 0x3F, 0xFF, 0x8E,
  0x00, 0x07, 0xFF, 0x07, 0x00, 0x00, 0x7C, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x03,
  0x80, 0x7F, 0xFC, 0x0E, 0x03, 0xFF, 0xF0, 0x1C, 0x1F, 0xE0, 0x60, 0x38,
  0x7C, 0x00, 0x00, 0x73, 0xE0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x7C, 0x03,
  0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0xF0,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x01, 0xE0, 0x3E,
  0x00, 0x07, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xF0, 0x08, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x0E, 0x1C, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x0E, 0x1C, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x07,
  0xE0, 0x70, 0x00, 0x0E, 0xC0, 0x78, 0x00, 0x1D, 0xC0, 0x3C, 0x00, 0x79,
  0xC0, 0x3F, 0x03, 0xF1, 0xC0, 0x1F, 0xFF, 0xC1, 0xC0, 0x07, 0xFF, 0x81,
  0xC0, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xEE, 0x00, 0x00,
  0x00, 0x79, 0xC0, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x07,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1F, 0x80, 0x01, 0xC0,
  0x00, 0xEE, 0x00, 0x07, 0x00, 0x03, 0xB8, 0x00, 0x3E, 0x00, 0x0E, 0x60,
  0x00, 0xF8, 0x00, 0x71, 0x80, 0x03, 0xE0, 0x01, 0xC6, 0x00, 0x1F, 0x80,
  0x06, 0x18, 0x00, 0x6E, 0x00, 0x38, 0x60, 0x03, 0xB8, 0x00, 0xE1, 0xC0,
  0x0E, 0xE0, 0x07, 0x07, 0x00, 0x33, 0x80, 0x1C, 0x1C, 0x01, 0xCE, 0x00,
  0x70, 0x70, 0x06, 0x18, 0x03, 0x81, 0xC0, 0x38, 0x60, 0x0E, 0x07, 0x00,
  0xE1, 0x80, 0x30, 0x1C, 0x07, 0x06, 0x01, 0xC0, 0x70, 0x1C, 0x18, 0x07,
  0x01, 0xC0, 0x60, 0x70, 0x38, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x1C, 0x0C,
  0x07, 0x03, 0x00, 0x70, 0x70, 0x1C, 0x1C, 0x01, 0xC1, 0xC0, 0x70, 0x70,
  0x07, 0x06, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x07, 0x0E, 0x00, 0x70, 0xC0,
  0x0C, 0x30, 0x00, 0xC7, 0x00, 0x31, 0xC0, 0x03, 0x1C, 0x00, 0xC7, 0x00,
  0x0C, 0xE0, 0x03, 0x18, 0x00, 0x33, 0x80, 0x0C, 0xE0, 0x00, 0xCC, 0x00,
  0x33, 0x00, 0x03, 0x70, 0x00, 0xDC, 0x00, 0x0D, 0x80, 0x03, 0x70, 0x00,
  0x3E, 0x00, 0x0D, 0x80, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x1D, 0xE0, 0x00, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x00, 0x07, 0x83, 0x80, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x38, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18,
  0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0C,
  0x3F, 0x3F, 0x80, 0x00, 0x38, 0x70, 0x0F, 0x80, 0x00, 0x71, 0xC0, 0x07,
  0x80, 0x01, 0xC7, 0x00, 0x07, 0x80, 0x03, 0x8E, 0x00, 0x07, 0x80, 0x0E,
  0x38, 0x00, 0x07, 0x80, 0x3C, 0x70, 0x00, 0x07, 0xC1, 0xF0, 0xC0, 0x00,
  0x07, 0xFF, 0xC3, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00,
};

const GFXglyph RobotoMono_ExtraLightItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 42, 0, -1 },
  { 1, 12, 51, 42, 15, -51 },
  { 78, 15, 15, 42, 17, -54 },
  { 107, 42, 51, 42, 1, -51 },
  { 375, 34, 66, 42, 5, -59 },
  { 656, 35, 53, 42, 4, -52 },
  { 888, 36, 53, 42, 3, -52 },
  { 1127, 5, 15, 42, 21, -54 },
  { 1137, 22, 73, 42, 12, -57 },
  { 1338, 22, 74, 42, 6, -57 },
  { 1542, 31, 29, 42, 9, -51 },
  { 1655, 35, 37, 42, 4, -42 },
  { 1817, 8, 16, 42, 9, -6 },
  { 1833, 25, 3, 42, 8, -25 },
  { 1843, 6, 5, 42, 16, -5 },
  { 1847, 33, 55, 42, 6, -51 },
  { 2074, 34, 53, 42, 5, -52 },
  { 2300, 19, 51, 42, 11, -51 },
  { 2422, 35, 52, 42, 1, -52 },
  { 2650, 35, 53, 42, 2, -52 },
  { 2882, 35, 51, 42, 2, -51 },
  { 3106, 35, 52, 42, 6, -51 },
  { 3334, 32, 53, 42, 4, -52 },
  { 3546, 32, 51, 42, 9, -51 },
  { 3750, 36, 53, 42, 4, -52 },
  { 3989, 31, 53, 42, 7, -52 },
  { 4195, 11, 36, 42, 18, -36 },
  { 4245, 15, 46, 42, 14, -36 },
  { 4332, 32, 29, 42, 6, -38 },
  { 4448, 33, 17, 42, 5, -32 },
  { 4519, 33, 29, 42, 4, -38 },
  { 4639, 27, 52, 42, 11, -52 },
  { 4815, 40, 52, 42, 2, -52 },
  { 5075, 35, 51, 42, 0, -51 },
  { 5299, 36, 51, 42, 3, -51 },
  { 5529, 36, 53, 42, 4, -52 },
  { 5768, 37, 51, 42, 3, -51 },
  { 6004, 37, 51, 42, 4, -51 },
  { 6240, 38, 51, 42, 4, -51 },
  { 6483, 36, 53, 42, 4, -52 },
  { 6722, 39, 51, 42, 2, -51 },
  { 6971, 37, 51, 42, 3, -51 },
  { 7207, 37, 52, 42, 3, -51 },
  { 7448, 40, 51, 42, 4, -51 },
  { 7703, 29, 51, 42, 4, -51 },
  { 7888, 40, 51, 42, 2, -51 },
  { 8143, 39, 51, 42, 2, -51 },
  { 8392, 35, 53, 42, 4, -52 },
  { 8624, 38, 51, 42, 4, -51 },
  { 8867, 36, 61, 42, 4, -52 },
  { 9142, 36, 51, 42, 4, -51 },
  { 9372, 36, 53, 42, 4, -52 },
  { 9611, 36, 51, 42, 8, -51 },
  { 9841, 37, 52, 42, 4, -51 },
  { 10082, 35, 51, 42, 8, -51 },
  { 10306, 38, 51, 42, 7, -51 },
  { 10549, 42, 51, 42, 1, -51 },
  { 10817, 35, 51, 42, 8, -51 },
  { 11041, 39, 51, 42, 1, -51 },
  { 11290, 22, 70, 42, 11, -59 },
  { 11483, 14, 55, 42, 14, -51 },
  { 11580, 22, 70, 42, 10, -59 },
  { 11773, 25, 28, 42, 9, -51 },
  { 11861, 30, 3, 42, 2, 0 },
  { 11873, 8, 9, 42, 21, -53 },
  { 11882, 32, 40, 42, 4, -39 },
  { 12042, 32, 55, 42, 4, -54 },
  { 12262, 32, 40, 42, 5, -39 },
  { 12422, 35, 55, 42, 5, -54 },
  { 12663, 33, 40, 42, 4, -39 },
  { 12828, 35, 55, 42, 9, -55 },
  { 13069, 35, 54, 42, 3, -39 },
  { 13306, 34, 54, 42, 3, -54 },
  { 13536, 30, 52, 42, 4, -52 },
  { 13731, 33, 67, 42, 0, -52 },
  { 14008, 35, 54, 42, 4, -54 },
  { 14245, 30, 54, 42, 4, -54 },
  { 14448, 42, 39, 42, -1, -39 },
  { 14653, 33, 39, 42, 3, -39 },
  { 14814, 33, 40, 42, 4, -39 },
  { 14979, 35, 54, 42, 1, -39 },
  { 15216, 33, 54, 42, 5, -39 },
  { 15439, 31, 39, 42, 9, -39 },
  { 15591, 32, 40, 42, 5, -39 },
  { 15751, 27, 49, 42, 9, -48 },
  { 15917, 32, 39, 42, 6, -38 },
  { 16073, 35, 38, 42, 6, -38 },
  { 16240, 38, 38, 42, 5, -38 },
  { 16421, 39, 38, 42, 1, -38 },
  { 16607, 43, 53, 42, -1, -38 },
  { 16892, 36, 38, 42, 2, -38 },
  { 17063, 28, 71, 42, 11, -56 },
  { 17312, 12, 62, 42, 15, -51 },
  { 17405, 28, 71, 42, 6, -56 },
  { 17654, 39, 12, 42, 1, -27 },
};

const GFXfont RobotoMono_ExtraLightItalic72pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic72pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic72pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC72PT7B_H_
