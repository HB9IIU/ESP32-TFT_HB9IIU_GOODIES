#ifndef _ROBOTOMONO_EXTRALIGHTITALIC49PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x03, 0x03, 0x03, 0x03, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0E,
  0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30,
  0x30, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0xE0,
  0x60, 0xD8, 0x36, 0x09, 0x86, 0x61, 0x98, 0x6C, 0x1B, 0x06, 0xC1, 0x30,
  0xCC, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x60, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x08, 0x06, 0x00, 0x01, 0x80,
  0x60, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x0C, 0x00,
  0x03, 0x00, 0x80, 0x00, 0x60, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60,
  0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x06, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x18, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x60, 0x10, 0x00, 0x04, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C,
  0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x0E, 0x07,
  0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x18, 0xE0, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x38, 0x60,
  0x00, 0x30, 0x70, 0x00, 0x70, 0x30, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x0F,
  0x1F, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1C,
  0xE0, 0x00, 0x30, 0x60, 0x00, 0x70, 0x30, 0x00, 0x60, 0x30, 0x08, 0x60,
  0x30, 0x1C, 0xC0, 0x30, 0x18, 0xC0, 0x30, 0x30, 0xC0, 0x30, 0x60, 0xC0,
  0x20, 0xE0, 0xC0, 0x60, 0xC0, 0xC0, 0x61, 0x80, 0x40, 0xC3, 0x00, 0x61,
  0x83, 0x00, 0x3F, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x20, 0x00, 0x61, 0xFC, 0x00,
  0xC3, 0x8C, 0x01, 0x87, 0x06, 0x01, 0x86, 0x06, 0x03, 0x0C, 0x02, 0x06,
  0x0C, 0x02, 0x0E, 0x0C, 0x02, 0x0C, 0x0C, 0x06, 0x18, 0x08, 0x06, 0x30,
  0x08, 0x06, 0x30, 0x08, 0x06, 0x20, 0x0C, 0x0C, 0x00, 0x0C, 0x1C, 0x00,
  0x06, 0x38, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x70, 0x70, 0x00, 0xC0, 0x30, 0x01, 0xC0, 0x30, 0x01,
  0x80, 0x30, 0x01, 0x80, 0x30, 0x01, 0x80, 0x30, 0x03, 0x80, 0x70, 0x01,
  0x80, 0x60, 0x01, 0x80, 0xC0, 0x01, 0x83, 0x80, 0x01, 0x87, 0x00, 0x00,
  0xCE, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x18, 0x00, 0x1C, 0x0C, 0x03, 0x18,
  0x0E, 0x03, 0x30, 0x06, 0x03, 0x70, 0x03, 0x06, 0x60, 0x03, 0x06, 0x60,
  0x01, 0x8E, 0x60, 0x01, 0xCC, 0xC0, 0x00, 0xDC, 0xE0, 0x00, 0x78, 0x60,
  0x00, 0x70, 0x60, 0x00, 0xF0, 0x70, 0x01, 0xD8, 0x38, 0x07, 0x9C, 0x1F,
  0x3E, 0x0C, 0x07, 0xFC, 0x0E, 0x33, 0x26, 0x66, 0x64, 0xCC, 0xC0, 0x00,
  0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01,
  0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x00, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x07,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x01, 0x00,
  0xC0, 0x2E, 0x06, 0x07, 0xFE, 0x31, 0xF8, 0x7D, 0xFE, 0x00, 0x7F, 0x80,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xCC, 0x00, 0x0C, 0x30, 0x00, 0xC1,
  0x80, 0x0E, 0x06, 0x00, 0xE0, 0x38, 0x0E, 0x00, 0xE0, 0x60, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x61, 0x86, 0x18, 0xE3, 0x1C, 0x63, 0x04, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x6F, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xE0, 0x07, 0x80,
  0xE0, 0x1C, 0x00, 0xE0, 0x30, 0x00, 0xC0, 0xC0, 0x01, 0x83, 0x80, 0x01,
  0x86, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x30, 0x00, 0x1C, 0x60, 0x00, 0x78,
  0xC0, 0x01, 0xF3, 0x00, 0x06, 0x66, 0x00, 0x18, 0xCC, 0x00, 0xE1, 0x98,
  0x03, 0x83, 0x30, 0x0E, 0x06, 0xC0, 0x30, 0x19, 0x80, 0xC0, 0x33, 0x07,
  0x00, 0x66, 0x1C, 0x00, 0xCC, 0x70, 0x01, 0x99, 0x80, 0x06, 0x36, 0x00,
  0x0C, 0xF8, 0x00, 0x18, 0xE0, 0x00, 0x31, 0x80, 0x00, 0xC3, 0x00, 0x01,
  0x86, 0x00, 0x06, 0x0C, 0x00, 0x1C, 0x0C, 0x00, 0x30, 0x18, 0x00, 0xC0,
  0x18, 0x07, 0x00, 0x1E, 0x7C, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x10, 0x07,
  0x03, 0xF0, 0xFB, 0x7C, 0x3F, 0x06, 0x80, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x07, 0x80, 0xE0, 0x1C,
  0x00, 0xE0, 0x70, 0x00, 0xC0, 0xC0, 0x00, 0xC3, 0x80, 0x01, 0x86, 0x00,
  0x03, 0x1C, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x06, 0x07, 0x00,
  0x07, 0x06, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x1C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x38, 0x60, 0x00,
  0x30, 0x70, 0x00, 0x70, 0x30, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x0F, 0x9F,
  0x80, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xCC, 0x00, 0x01,
  0xCC, 0x00, 0x03, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x06, 0x18, 0x00, 0x0C,
  0x18, 0x00, 0x18, 0x18, 0x00, 0x38, 0x18, 0x00, 0x70, 0x30, 0x00, 0x60,
  0x30, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x30, 0x03, 0x80, 0x30, 0x07, 0x00,
  0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x18, 0x00, 0x60, 0x30, 0x00,
  0x60, 0x70, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0xFF, 0x00, 0x0B, 0xFF, 0x80, 0x1F, 0x01,
  0xC0, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00,
  0x70, 0xC0, 0x00, 0x60, 0x60, 0x00, 0xE0, 0x60, 0x00, 0xC0, 0x30, 0x01,
  0x80, 0x38, 0x07, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x83, 0xE0, 0x18,
  0xFF, 0xC0, 0xCE, 0x07, 0x07, 0xC0, 0x0C, 0x6C, 0x00, 0x73, 0x80, 0x01,
  0x9C, 0x00, 0x0E, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xB0, 0x00, 0x0D,
  0x80, 0x00, 0x66, 0x00, 0x06, 0x30, 0x00, 0x71, 0xC0, 0x03, 0x06, 0x00,
  0x30, 0x1C, 0x07, 0x80, 0x79, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xE0, 0x1C, 0x01, 0xC0,
  0x0E, 0x03, 0x00, 0x06, 0x07, 0x00, 0x07, 0x06, 0x00, 0x03, 0x0C, 0x00,
  0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x0C, 0x00,
  0x06, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x1C, 0x07, 0x00, 0x38, 0x03, 0x80,
  0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xC1, 0xE0, 0x0E, 0x00,
  0x70, 0x1C, 0x00, 0x38, 0x30, 0x00, 0x18, 0x70, 0x00, 0x1C, 0x60, 0x00,
  0x0C, 0xE0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x18, 0xE0, 0x00, 0x38, 0x60, 0x00, 0x70, 0x70, 0x00,
  0xE0, 0x38, 0x03, 0xC0, 0x1F, 0x1F, 0x80, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x1F, 0xFC, 0x01, 0xC0, 0x70, 0x1C, 0x00, 0xC1, 0xC0, 0x07, 0x1C,
  0x00, 0x18, 0xC0, 0x00, 0xCE, 0x00, 0x07, 0x60, 0x00, 0x1B, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x37, 0x00, 0x03, 0x98, 0x00, 0x3C,
  0xE0, 0x03, 0x63, 0x80, 0x76, 0x0E, 0x0F, 0x30, 0x3F, 0xE1, 0x80, 0x30,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x03, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x04, 0x0F, 0x0F, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0xF0, 0xF0, 0x60, 0x00, 0x80, 0x38, 0x07, 0x80,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0xC0,
  0x38, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x10, 0x3F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xC0, 0x10, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0x81, 0xC0, 0x70, 0xE0,
  0x0E, 0x70, 0x01, 0x98, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3C, 0x03, 0x80, 0x07, 0x00,
  0x1C, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60,
  0x60, 0x1E, 0x06, 0x06, 0x07, 0xF0, 0x20, 0xC0, 0xC1, 0x82, 0x18, 0x18,
  0x18, 0x21, 0x83, 0x01, 0x02, 0x10, 0x60, 0x10, 0x23, 0x06, 0x03, 0x02,
  0x30, 0x40, 0x30, 0x26, 0x0C, 0x02, 0x06, 0x60, 0xC0, 0x60, 0x66, 0x08,
  0x06, 0x06, 0x41, 0x80, 0x60, 0x44, 0x18, 0x04, 0x04, 0xC1, 0x80, 0xC0,
  0xCC, 0x10, 0x0C, 0x0C, 0xC1, 0x01, 0xC0, 0x8C, 0x10, 0x38, 0x18, 0xC1,
  0x82, 0x83, 0x0C, 0x18, 0x6C, 0x30, 0xC1, 0xFC, 0xFE, 0x04, 0x0F, 0x07,
  0x80, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xB0, 0x00, 0x03, 0xB0, 0x00, 0x03, 0x30, 0x00,
  0x03, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x10, 0x00, 0x0C, 0x18, 0x00,
  0x0C, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x30, 0x18, 0x00,
  0x30, 0x18, 0x00, 0x60, 0x08, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x0C, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C,
  0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0xC0, 0x0F, 0x00, 0x60, 0x01, 0xC0,
  0x30, 0x00, 0x70, 0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06,
  0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC1, 0x80, 0x00,
  0xE0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x60, 0x30, 0x00, 0xE0, 0x18, 0x01,
  0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x06, 0x00, 0x1C, 0x03, 0x00,
  0x03, 0x01, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x60,
  0x00, 0x0C, 0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x06,
  0x00, 0x01, 0x86, 0x00, 0x01, 0xC3, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xE0,
  0xC0, 0x01, 0xE0, 0x60, 0x03, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF0, 0x01, 0xE0, 0x38, 0x03, 0x80,
  0x0C, 0x03, 0x00, 0x0E, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x07, 0x0C, 0x00,
  0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x60, 0x70, 0x00, 0xE0, 0x30, 0x01,
  0xC0, 0x18, 0x03, 0x80, 0x0F, 0x1F, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x40,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0xC0, 0x1E, 0x00, 0xC0,
  0x03, 0x80, 0x60, 0x00, 0xE0, 0x30, 0x00, 0x30, 0x18, 0x00, 0x1C, 0x0C,
  0x00, 0x06, 0x0E, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x06,
  0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x86, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x18, 0xC0, 0x00,
  0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x0E, 0x18, 0x00, 0x06, 0x18, 0x00,
  0x07, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x03, 0x03, 0x00, 0x03, 0x01, 0x80,
  0x03, 0x81, 0xC0, 0x07, 0x80, 0xC0, 0x0F, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC1, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xF0, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x0C, 0x07,
  0x00, 0x06, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x18,
  0x00, 0x03, 0x38, 0x00, 0x03, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x0F, 0xFE, 0xC0,
  0x0F, 0xFC, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x60,
  0x00, 0x18, 0x60, 0x00, 0x18, 0x70, 0x00, 0x38, 0x38, 0x00, 0x70, 0x1C,
  0x01, 0xE0, 0x0F, 0x9F, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x30, 0x30, 0x00, 0x0C, 0x04, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x30,
  0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x06,
  0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x0C, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0,
  0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x30, 0x00,
  0x06, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x06, 0x06,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x02, 0x03, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x00, 0x03, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x0C,
  0x18, 0x00, 0x06, 0x0C, 0x00, 0x07, 0x06, 0x00, 0x03, 0x01, 0x80, 0x03,
  0x00, 0xE0, 0x03, 0x00, 0x38, 0x07, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x38, 0x18, 0x00, 0x0E,
  0x03, 0x00, 0x03, 0x80, 0x60, 0x00, 0xE0, 0x0C, 0x00, 0x38, 0x03, 0x00,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00,
  0x30, 0x1C, 0x00, 0x06, 0x07, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x30, 0x70,
  0x00, 0x06, 0x1C, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x19, 0xE0, 0x00, 0x03,
  0x7E, 0x00, 0x00, 0xDC, 0xC0, 0x00, 0x1F, 0x0C, 0x00, 0x03, 0xC1, 0xC0,
  0x00, 0x70, 0x18, 0x00, 0x0C, 0x03, 0x80, 0x03, 0x80, 0x30, 0x00, 0x60,
  0x07, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xE0,
  0x06, 0x00, 0x0C, 0x01, 0x80, 0x01, 0xC0, 0x30, 0x00, 0x18, 0x06, 0x00,
  0x03, 0x80, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x38,
  0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x6C, 0x0F, 0x00,
  0x0D, 0x81, 0x30, 0x03, 0x20, 0x66, 0x00, 0x6C, 0x0C, 0xC0, 0x19, 0x81,
  0x98, 0x07, 0x30, 0x33, 0x00, 0xC6, 0x06, 0x20, 0x38, 0xC1, 0x86, 0x06,
  0x30, 0x30, 0xC1, 0x86, 0x06, 0x18, 0x30, 0xC0, 0xC3, 0x0C, 0x18, 0x18,
  0x61, 0x83, 0x03, 0x06, 0x60, 0x60, 0xC0, 0xDC, 0x18, 0x18, 0x1B, 0x03,
  0x03, 0x03, 0xE0, 0x60, 0x60, 0x78, 0x0C, 0x0C, 0x06, 0x01, 0x81, 0x80,
  0xC0, 0x70, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30,
  0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00,
  0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x03, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x60, 0x70, 0x00, 0x0C, 0x0E,
  0x00, 0x01, 0x81, 0xE0, 0x00, 0x30, 0x3C, 0x00, 0x0C, 0x07, 0x80, 0x01,
  0x81, 0x98, 0x00, 0x30, 0x33, 0x00, 0x06, 0x06, 0x20, 0x00, 0xC0, 0xC6,
  0x00, 0x18, 0x18, 0xC0, 0x06, 0x03, 0x0C, 0x00, 0xC0, 0xC1, 0x80, 0x18,
  0x18, 0x30, 0x03, 0x03, 0x03, 0x00, 0x60, 0x60, 0x60, 0x1C, 0x0C, 0x0C,
  0x03, 0x03, 0x80, 0xC0, 0x60, 0x60, 0x18, 0x0C, 0x0C, 0x01, 0x81, 0x81,
  0x80, 0x30, 0x30, 0x30, 0x06, 0x0C, 0x06, 0x00, 0x61, 0x81, 0x80, 0x0C,
  0x30, 0x30, 0x01, 0x86, 0x06, 0x00, 0x18, 0xC0, 0xC0, 0x03, 0x18, 0x18,
  0x00, 0x66, 0x03, 0x00, 0x06, 0xC0, 0xC0, 0x00, 0xD8, 0x18, 0x00, 0x0F,
  0x03, 0x00, 0x01, 0xE0, 0x60, 0x00, 0x3C, 0x0C, 0x00, 0x03, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xE0, 0x38,
  0x03, 0x80, 0x1C, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x06,
  0x0C, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x03, 0x30, 0x00, 0x03,
  0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0xE0, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x38,
  0xC0, 0x00, 0x30, 0x60, 0x00, 0x70, 0x60, 0x00, 0x60, 0x70, 0x00, 0xC0,
  0x30, 0x01, 0x80, 0x18, 0x07, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xC0, 0x07, 0x00, 0xC0, 0x00,
  0xC0, 0x60, 0x00, 0x30, 0x30, 0x00, 0x1C, 0x18, 0x00, 0x06, 0x0C, 0x00,
  0x03, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x30, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x60, 0x00, 0x1C, 0x30,
  0x00, 0x1C, 0x18, 0x00, 0x1C, 0x0C, 0x00, 0x3C, 0x06, 0x00, 0xFC, 0x03,
  0xFF, 0xF8, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x3C, 0x07, 0x00,
  0x38, 0x00, 0xC0, 0x38, 0x00, 0x70, 0x38, 0x00, 0x18, 0x18, 0x00, 0x0C,
  0x1C, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00,
  0x06, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x0D, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x07, 0x18,
  0x00, 0x03, 0x0C, 0x00, 0x03, 0x86, 0x00, 0x01, 0x81, 0x80, 0x01, 0x80,
  0xC0, 0x01, 0xC0, 0x30, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x07, 0xEF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x07,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x06, 0x00, 0x78, 0x06, 0x00, 0x1C, 0x06,
  0x00, 0x0E, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x0C,
  0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18,
  0x00, 0x06, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x18,
  0x00, 0x30, 0x18, 0x00, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x30,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x80, 0x60,
  0x01, 0x80, 0x60, 0x01, 0x80, 0x60, 0x01, 0xC0, 0x60, 0x00, 0xC0, 0x60,
  0x00, 0xC0, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x38, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x38, 0x07, 0x80, 0x38, 0x00, 0xE0, 0x30, 0x00, 0x30,
  0x38, 0x00, 0x1C, 0x18, 0x00, 0x06, 0x1C, 0x00, 0x03, 0x0C, 0x00, 0x01,
  0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x01, 0xC6,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x60, 0x70, 0x00, 0x60,
  0x1C, 0x00, 0xE0, 0x07, 0xEF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x86, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x30, 0x40,
  0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0C,
  0x00, 0x01, 0x86, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x0C,
  0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00,
  0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x06, 0x00,
  0x07, 0x03, 0x00, 0x03, 0x01, 0x80, 0x03, 0x00, 0x60, 0x03, 0x00, 0x38,
  0x07, 0x80, 0x0F, 0x9F, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x60, 0x00, 0x07, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x0C,
  0x60, 0x00, 0x0C, 0x70, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x30,
  0x30, 0x00, 0x30, 0x30, 0x00, 0x70, 0x30, 0x00, 0x60, 0x30, 0x00, 0xE0,
  0x18, 0x00, 0xC0, 0x18, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x03, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x06, 0x00,
  0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00,
  0x0C, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x70, 0x00, 0x06, 0x60, 0x00,
  0x06, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x0C, 0x01, 0xF0, 0x03, 0x00,
  0x6C, 0x01, 0xC0, 0x1B, 0x00, 0x70, 0x06, 0xC0, 0x3C, 0x03, 0x30, 0x0F,
  0x00, 0xCC, 0x03, 0xC0, 0x33, 0x01, 0xB0, 0x18, 0xC0, 0x6C, 0x06, 0x30,
  0x1B, 0x01, 0x8C, 0x0C, 0xC0, 0xC3, 0x03, 0x30, 0x30, 0xC0, 0xCC, 0x0C,
  0x30, 0x63, 0x03, 0x0C, 0x18, 0xC1, 0x83, 0x06, 0x30, 0x60, 0xC3, 0x04,
  0x18, 0x30, 0xC1, 0x0C, 0x0C, 0x30, 0x43, 0x03, 0x18, 0x10, 0xC0, 0xC6,
  0x04, 0x60, 0x31, 0x81, 0x18, 0x0C, 0xC0, 0x66, 0x03, 0x30, 0x19, 0x80,
  0xCC, 0x06, 0xC0, 0x36, 0x01, 0xB0, 0x0D, 0x80, 0x6C, 0x03, 0x60, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x06, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x07, 0x00,
  0x30, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x06,
  0x00, 0x38, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x18, 0x03, 0x80, 0x00, 0xE0, 0x06, 0x00, 0x07, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x07, 0x00, 0x01, 0x80,
  0x38, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0xE0, 0x00, 0x03, 0xB0, 0x00, 0x03, 0x9C, 0x00, 0x01, 0x86, 0x00, 0x01,
  0x83, 0x00, 0x01, 0xC1, 0x80, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x30, 0x00,
  0xE0, 0x18, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x60, 0x01, 0x80,
  0x70, 0x00, 0x60, 0x30, 0x00, 0x30, 0x30, 0x00, 0x18, 0x38, 0x00, 0x06,
  0x18, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFE, 0x01, 0xFC,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x3F, 0xC0,
  0x00, 0xC0, 0x60, 0x30, 0x18, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0x60, 0x30, 0x18, 0x0C, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x3F, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0D, 0x00, 0x0E, 0xC0,
  0x06, 0x60, 0x06, 0x30, 0x03, 0x18, 0x03, 0x06, 0x01, 0x83, 0x01, 0x81,
  0x81, 0xC0, 0xC0, 0xC0, 0x60, 0xC0, 0x18, 0x60, 0x0C, 0x60, 0x06, 0x30,
  0x03, 0x30, 0x00, 0xF8, 0x00, 0x60, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xE1, 0xC3, 0x0E, 0x18, 0x30, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x80, 0x78,
  0x07, 0x03, 0x80, 0x0E, 0x0C, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x1F, 0xFE, 0x03, 0xFF, 0xF8, 0x3E, 0x00, 0xE3, 0xC0, 0x03, 0x1C, 0x00,
  0x0C, 0x60, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x18,
  0xC0, 0x00, 0xE3, 0x00, 0x07, 0x8E, 0x00, 0x36, 0x1C, 0x03, 0x98, 0x3E,
  0x7C, 0x60, 0x7F, 0xC1, 0x80, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0xFE, 0x00, 0x67, 0xFF, 0x01, 0x98, 0x07,
  0x03, 0x60, 0x06, 0x07, 0x80, 0x0E, 0x0E, 0x00, 0x0C, 0x18, 0x00, 0x18,
  0x30, 0x00, 0x38, 0xE0, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC6,
  0x00, 0x01, 0x8C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0,
  0x00, 0x31, 0x80, 0x00, 0xE3, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00,
  0x0C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x60, 0xF0, 0x01, 0x81, 0xB0, 0x0F,
  0x03, 0x3E, 0xF8, 0x0E, 0x3F, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x07, 0xFF, 0x80, 0x38, 0x07, 0x01, 0xC0, 0x0E, 0x0E, 0x00, 0x18,
  0x70, 0x00, 0x71, 0x80, 0x00, 0xCE, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x60, 0xC0, 0x03, 0x83, 0x00,
  0x1C, 0x07, 0x00, 0xE0, 0x0F, 0xBF, 0x00, 0x1F, 0xF0, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x7F,
  0x0E, 0x01, 0xFF, 0xCC, 0x03, 0x80, 0xEC, 0x07, 0x00, 0x2C, 0x0E, 0x00,
  0x3C, 0x1C, 0x00, 0x1C, 0x18, 0x00, 0x1C, 0x30, 0x00, 0x18, 0x30, 0x00,
  0x18, 0x70, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00,
  0x30, 0x60, 0x00, 0x30, 0xE0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00,
  0x60, 0x60, 0x00, 0xE0, 0x30, 0x01, 0xE0, 0x38, 0x07, 0x60, 0x1F, 0x3E,
  0xC0, 0x07, 0xF8, 0xC0, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x3C, 0x07,
  0x01, 0xC0, 0x0E, 0x0E, 0x00, 0x18, 0x70, 0x00, 0x71, 0x80, 0x00, 0xCC,
  0x00, 0x03, 0x30, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x83, 0x80, 0x0E, 0x07, 0x00, 0x70, 0x0F, 0x8F,
  0x80, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x3F, 0x83, 0x00, 0xFF,
  0xE6, 0x01, 0xC0, 0x76, 0x03, 0x80, 0x1E, 0x07, 0x00, 0x1E, 0x0E, 0x00,
  0x0E, 0x0C, 0x00, 0x0E, 0x1C, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00,
  0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x1C, 0x30, 0x00,
  0x18, 0x70, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x70, 0x00,
  0x18, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x38, 0x00,
  0x70, 0x18, 0x00, 0xF0, 0x1C, 0x03, 0xB0, 0x0F, 0x9F, 0x60, 0x03, 0xFC,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0xC0, 0x03, 0x80, 0xE0, 0x07, 0x00, 0x70, 0x0E,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x7F, 0x00, 0xC3, 0xFF, 0x81, 0x9C, 0x03, 0x03,
  0x70, 0x03, 0x06, 0x80, 0x06, 0x0E, 0x00, 0x0E, 0x18, 0x00, 0x0C, 0x70,
  0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0xE3, 0x00, 0x01, 0x86, 0x00,
  0x03, 0x0C, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00,
  0x71, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x03, 0x18, 0x00, 0x06,
  0x30, 0x00, 0x0C, 0x60, 0x00, 0x38, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC7,
  0x00, 0x01, 0x8C, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x30, 0xF8, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x0F, 0x0C, 0x00, 0x1C, 0x0C, 0x00, 0x38, 0x0C, 0x00, 0xE0, 0x0C,
  0x01, 0xC0, 0x0C, 0x03, 0x80, 0x18, 0x07, 0x00, 0x18, 0x1C, 0x00, 0x18,
  0x38, 0x00, 0x18, 0x70, 0x00, 0x18, 0xE0, 0x00, 0x1B, 0xC0, 0x00, 0x37,
  0xE0, 0x00, 0x3E, 0x60, 0x00, 0x3C, 0x30, 0x00, 0x30, 0x38, 0x00, 0x30,
  0x18, 0x00, 0x70, 0x0C, 0x00, 0x60, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x60,
  0x03, 0x00, 0x60, 0x03, 0x80, 0x60, 0x01, 0xC0, 0xE0, 0x00, 0xC0, 0xC0,
  0x00, 0xE0, 0xC0, 0x00, 0x70, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0C, 0xFE, 0x1F, 0xC0, 0xDF, 0xE3, 0xFE, 0x0B, 0x07, 0x60,
  0x61, 0xE0, 0x3C, 0x06, 0x1C, 0x03, 0x80, 0x61, 0x80, 0x30, 0x02, 0x18,
  0x03, 0x00, 0x61, 0x80, 0x30, 0x06, 0x18, 0x03, 0x00, 0x63, 0x00, 0x30,
  0x06, 0x30, 0x06, 0x00, 0x63, 0x00, 0x60, 0x06, 0x30, 0x06, 0x00, 0xC3,
  0x00, 0x60, 0x0C, 0x20, 0x06, 0x00, 0xC6, 0x00, 0x60, 0x0C, 0x60, 0x0C,
  0x00, 0xC6, 0x00, 0xC0, 0x0C, 0x60, 0x0C, 0x01, 0x86, 0x00, 0xC0, 0x18,
  0x40, 0x0C, 0x01, 0x8C, 0x00, 0xC0, 0x18, 0xC0, 0x18, 0x01, 0x8C, 0x01,
  0x80, 0x10, 0xC0, 0x18, 0x03, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x0F, 0xE0,
  0x18, 0x7F, 0xF0, 0x33, 0x80, 0x60, 0x6E, 0x00, 0x60, 0xF0, 0x00, 0xC1,
  0xC0, 0x01, 0x83, 0x00, 0x01, 0x8E, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30,
  0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC6, 0x00,
  0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00,
  0x30, 0xC0, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x06,
  0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0xE0, 0x00, 0x31, 0x80, 0x00, 0x60,
  0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x78, 0x07, 0x03, 0x80, 0x0C, 0x0C,
  0x00, 0x18, 0x60, 0x00, 0x73, 0x80, 0x00, 0xCC, 0x00, 0x03, 0x60, 0x00,
  0x0D, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1B, 0x00,
  0x00, 0x6C, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xE0, 0x00, 0x61, 0x80, 0x03,
  0x87, 0x00, 0x1C, 0x0E, 0x01, 0xE0, 0x1F, 0x3E, 0x00, 0x1F, 0xF0, 0x00,
  0x04, 0x00, 0x00, 0x03, 0x1F, 0xE0, 0x02, 0x3F, 0xF8, 0x06, 0xE0, 0x1C,
  0x07, 0xC0, 0x0C, 0x07, 0x80, 0x0E, 0x07, 0x00, 0x06, 0x06, 0x00, 0x06,
  0x06, 0x00, 0x06, 0x0C, 0x00, 0x07, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03,
  0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x1C, 0x00, 0x06, 0x18, 0x00, 0x06,
  0x18, 0x00, 0x06, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C,
  0x38, 0x00, 0x18, 0x38, 0x00, 0x38, 0x38, 0x00, 0x30, 0x3C, 0x00, 0x60,
  0x36, 0x01, 0xC0, 0x33, 0xCF, 0x80, 0x71, 0xFF, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x06, 0x03, 0xFF, 0x98, 0x0E, 0x03, 0xB0,
  0x38, 0x01, 0xE0, 0xE0, 0x03, 0xC3, 0x80, 0x03, 0x86, 0x00, 0x07, 0x1C,
  0x00, 0x0C, 0x30, 0x00, 0x18, 0xE0, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00,
  0x00, 0xC6, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x38, 0x00, 0x0C, 0x60, 0x00,
  0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x61, 0x80, 0x01, 0x83, 0x00, 0x03,
  0x06, 0x00, 0x06, 0x0E, 0x00, 0x1C, 0x0C, 0x00, 0x78, 0x1C, 0x03, 0xB0,
  0x1F, 0x3E, 0xC0, 0x0F, 0xF1, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x06,
  0x0F, 0xF8, 0x61, 0xFF, 0xC3, 0x1C, 0x00, 0x19, 0x80, 0x00, 0xD8, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x07,
  0xFF, 0xC0, 0x78, 0x03, 0x83, 0x80, 0x06, 0x0C, 0x00, 0x0C, 0x70, 0x00,
  0x31, 0x80, 0x00, 0xC6, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0xB0, 0x00, 0x0C, 0xE0, 0x00, 0x31, 0x80, 0x00, 0xC7, 0x00, 0x06, 0x0E,
  0x00, 0x70, 0x1F, 0x9F, 0x80, 0x1F, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x30,
  0x01, 0xFE, 0x00, 0x02, 0x00, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x33, 0x00,
  0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x01,
  0x8C, 0x00, 0x06, 0x60, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x18,
  0x00, 0x0C, 0x60, 0x00, 0x33, 0x80, 0x00, 0xCC, 0x00, 0x06, 0x30, 0x00,
  0x18, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x38,
  0xC0, 0x01, 0xC3, 0x00, 0x07, 0x06, 0x00, 0x7C, 0x1C, 0x03, 0xB0, 0x3E,
  0xF8, 0xC0, 0x7F, 0xC7, 0x00, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x0C, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x30, 0x00, 0x38, 0x30,
  0x00, 0x30, 0x30, 0x00, 0x60, 0x18, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x18,
  0x00, 0xC0, 0x18, 0x01, 0x80, 0x0C, 0x03, 0x80, 0x0C, 0x03, 0x00, 0x0C,
  0x06, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06,
  0x18, 0x00, 0x06, 0x38, 0x00, 0x03, 0x30, 0x00, 0x03, 0x60, 0x00, 0x03,
  0x60, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x18, 0x01, 0xE0, 0x0C, 0x00, 0xF0, 0x06, 0x00, 0xD8, 0x07, 0x00, 0x6C,
  0x03, 0xC0, 0x36, 0x03, 0x60, 0x33, 0x01, 0xB0, 0x19, 0x80, 0x98, 0x18,
  0xC0, 0xCC, 0x0C, 0x60, 0x66, 0x06, 0x30, 0x63, 0x06, 0x18, 0x31, 0x83,
  0x0C, 0x30, 0xC1, 0x06, 0x18, 0x61, 0x83, 0x08, 0x30, 0xC1, 0x8C, 0x08,
  0xC0, 0xC6, 0x04, 0x60, 0x66, 0x02, 0x30, 0x33, 0x01, 0x30, 0x09, 0x00,
  0xD8, 0x05, 0x80, 0x78, 0x02, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0,
  0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x70, 0x06, 0x00, 0x18, 0x01, 0xC0,
  0x0C, 0x00, 0x30, 0x06, 0x00, 0x0E, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x30, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x63, 0x80, 0x00, 0x30, 0x60, 0x00, 0x1C, 0x0C, 0x00, 0x0E,
  0x03, 0x80, 0x07, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x03, 0x00,
  0xE0, 0x00, 0x60, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x80, 0x06, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x1C, 0x03, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x03, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x60, 0x00, 0x60, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x30, 0x03, 0x80, 0x00, 0xE0, 0x0C, 0x00, 0x01,
  0x80, 0x70, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x05, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC2, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x01,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x02, 0x06, 0x06, 0x06, 0x06, 0x06, 0x04,
  0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x10, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x20, 0x60, 0x60, 0x60, 0x60,
  0x60, 0x40, 0xC0, 0xC0, 0xC0, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x0C, 0x71, 0xE0, 0x03, 0x18, 0x0E, 0x00,
  0x66, 0x00, 0xE0, 0x18, 0xC0, 0x0E, 0x07, 0x30, 0x00, 0xF1, 0xC6, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x30, 0x00,
};

const GFXglyph RobotoMono_ExtraLightItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 8, 35, 29, 10, -35 },
  { 36, 10, 11, 29, 12, -37 },
  { 50, 28, 35, 29, 1, -35 },
  { 173, 24, 45, 29, 3, -40 },
  { 308, 24, 36, 29, 3, -35 },
  { 416, 24, 35, 29, 2, -35 },
  { 521, 4, 11, 29, 14, -37 },
  { 527, 15, 50, 29, 8, -39 },
  { 621, 15, 50, 29, 4, -39 },
  { 715, 21, 20, 29, 6, -35 },
  { 768, 23, 26, 29, 3, -29 },
  { 843, 6, 11, 29, 6, -4 },
  { 852, 17, 2, 29, 6, -17 },
  { 857, 4, 4, 29, 11, -4 },
  { 859, 22, 38, 29, 4, -35 },
  { 964, 23, 35, 29, 3, -35 },
  { 1065, 12, 35, 29, 8, -35 },
  { 1118, 23, 35, 29, 1, -35 },
  { 1219, 24, 35, 29, 1, -35 },
  { 1324, 24, 35, 29, 1, -35 },
  { 1429, 24, 36, 29, 4, -35 },
  { 1537, 21, 36, 29, 3, -35 },
  { 1632, 22, 35, 29, 6, -35 },
  { 1729, 24, 35, 29, 3, -35 },
  { 1834, 21, 35, 29, 5, -35 },
  { 1926, 8, 25, 29, 12, -25 },
  { 1951, 11, 32, 29, 9, -25 },
  { 1995, 22, 20, 29, 4, -26 },
  { 2050, 23, 12, 29, 3, -22 },
  { 2085, 22, 20, 29, 3, -26 },
  { 2140, 18, 35, 29, 8, -35 },
  { 2219, 28, 35, 29, 1, -35 },
  { 2342, 24, 35, 29, 0, -35 },
  { 2447, 25, 35, 29, 2, -35 },
  { 2557, 24, 36, 29, 3, -35 },
  { 2665, 25, 35, 29, 2, -35 },
  { 2775, 26, 35, 29, 2, -35 },
  { 2889, 25, 35, 29, 3, -35 },
  { 2999, 24, 36, 29, 3, -35 },
  { 3107, 27, 35, 29, 1, -35 },
  { 3226, 25, 35, 29, 2, -35 },
  { 3336, 25, 35, 29, 2, -35 },
  { 3446, 27, 35, 29, 3, -35 },
  { 3565, 20, 35, 29, 3, -35 },
  { 3653, 27, 35, 29, 2, -35 },
  { 3772, 27, 35, 29, 1, -35 },
  { 3891, 24, 35, 29, 3, -35 },
  { 3996, 25, 35, 29, 3, -35 },
  { 4106, 25, 41, 29, 2, -35 },
  { 4235, 24, 35, 29, 3, -35 },
  { 4340, 25, 35, 29, 2, -35 },
  { 4450, 24, 35, 29, 6, -35 },
  { 4555, 25, 35, 29, 3, -35 },
  { 4665, 24, 35, 29, 5, -35 },
  { 4770, 26, 35, 29, 5, -35 },
  { 4884, 30, 35, 29, 0, -35 },
  { 5016, 25, 35, 29, 5, -35 },
  { 5126, 26, 35, 29, 1, -35 },
  { 5240, 15, 47, 29, 7, -40 },
  { 5329, 9, 38, 29, 10, -35 },
  { 5372, 15, 47, 29, 7, -40 },
  { 5461, 17, 19, 29, 6, -35 },
  { 5502, 21, 2, 29, 1, 0 },
  { 5508, 6, 6, 29, 14, -36 },
  { 5513, 22, 27, 29, 3, -26 },
  { 5588, 23, 38, 29, 2, -37 },
  { 5698, 22, 27, 29, 3, -26 },
  { 5773, 24, 37, 29, 3, -37 },
  { 5884, 22, 26, 29, 3, -26 },
  { 5956, 24, 37, 29, 6, -37 },
  { 6067, 24, 36, 29, 2, -26 },
  { 6175, 23, 37, 29, 2, -37 },
  { 6282, 20, 35, 29, 3, -35 },
  { 6370, 22, 45, 29, 0, -35 },
  { 6494, 24, 37, 29, 3, -37 },
  { 6605, 20, 37, 29, 3, -37 },
  { 6698, 28, 26, 29, 0, -26 },
  { 6789, 23, 26, 29, 2, -26 },
  { 6864, 22, 27, 29, 3, -26 },
  { 6939, 24, 36, 29, 1, -26 },
  { 7047, 23, 36, 29, 3, -26 },
  { 7151, 21, 26, 29, 6, -26 },
  { 7220, 22, 26, 29, 3, -26 },
  { 7292, 19, 34, 29, 6, -33 },
  { 7373, 22, 26, 29, 4, -26 },
  { 7445, 24, 26, 29, 4, -26 },
  { 7523, 25, 26, 29, 4, -26 },
  { 7605, 26, 26, 29, 1, -26 },
  { 7690, 30, 36, 29, -1, -26 },
  { 7825, 25, 26, 29, 1, -26 },
  { 7907, 18, 48, 29, 8, -38 },
  { 8015, 8, 42, 29, 10, -35 },
  { 8057, 19, 48, 29, 4, -38 },
  { 8171, 27, 9, 29, 1, -19 },
};

const GFXfont RobotoMono_ExtraLightItalic49pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic49pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic49pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC49PT7B_H_
