#ifndef _ROBOTOMONO_EXTRALIGHTITALIC55PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x80,
  0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x70, 0x3C,
  0x06, 0x00, 0x30, 0x73, 0x06, 0x30, 0x63, 0x06, 0x70, 0x66, 0x0C, 0x60,
  0xC6, 0x0C, 0x60, 0xC6, 0x0C, 0xC1, 0xC0, 0x00, 0x00, 0xE0, 0x18, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x03, 0x80, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x0C, 0x03, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x18, 0x07, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x70, 0x0C, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00,
  0xE0, 0x18, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01,
  0xC0, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFD, 0xF8, 0x00, 0xF0, 0x0F,
  0x00, 0x70, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x06, 0x06, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0C,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x70, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x01,
  0xC0, 0x1E, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x18,
  0x02, 0x18, 0x03, 0x00, 0xE3, 0x00, 0x60, 0x18, 0x60, 0x0C, 0x06, 0x0C,
  0x01, 0x81, 0x83, 0x00, 0x60, 0x70, 0x60, 0x0C, 0x0C, 0x0C, 0x01, 0x83,
  0x00, 0xC0, 0x60, 0xE0, 0x18, 0x0C, 0x18, 0x03, 0x87, 0x06, 0x00, 0x3F,
  0xC1, 0xC0, 0x03, 0xF0, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xC1, 0xF8, 0x00, 0x30, 0x7F, 0x80, 0x0C, 0x18, 0x18, 0x03, 0x06, 0x03,
  0x00, 0xE0, 0xC0, 0x70, 0x18, 0x30, 0x06, 0x06, 0x06, 0x00, 0xC1, 0xC0,
  0xC0, 0x18, 0x30, 0x18, 0x07, 0x0C, 0x06, 0x00, 0xC3, 0x80, 0xC0, 0x18,
  0xE0, 0x18, 0x03, 0x08, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x06, 0x00, 0xE0, 0x00, 0xE0, 0x06,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x0E, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0xC0, 0x1C, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x38, 0x00, 0x0C, 0x07,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x06, 0x38, 0x00, 0x00, 0x67, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3C, 0xE0, 0x00, 0x07, 0x06, 0x00, 0x00, 0xE0, 0x70, 0x07,
  0x1C, 0x03, 0x00, 0x61, 0x80, 0x38, 0x06, 0x38, 0x01, 0xC0, 0xE3, 0x00,
  0x0C, 0x0C, 0x70, 0x00, 0xE0, 0xC6, 0x00, 0x07, 0x1C, 0x60, 0x00, 0x33,
  0x86, 0x00, 0x03, 0xB0, 0x60, 0x00, 0x1F, 0x06, 0x00, 0x01, 0xE0, 0x70,
  0x00, 0x1E, 0x03, 0x00, 0x03, 0xE0, 0x38, 0x00, 0x77, 0x01, 0xC0, 0x1E,
  0x38, 0x0F, 0xFF, 0x81, 0x80, 0x3F, 0xE0, 0x1C, 0x00, 0x30, 0x00, 0x00,
  0x33, 0x76, 0x66, 0x66, 0xCC, 0xC0, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x60, 0x18, 0x06, 0xF8, 0x18,
  0x3E, 0x7F, 0x18, 0xFD, 0x0F, 0xDF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xCC, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x87,
  0x00, 0x07, 0x03, 0x00, 0x0E, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x38, 0x01,
  0xC0, 0x30, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x31, 0xC7, 0x18, 0x63, 0x8C, 0x71, 0x8E, 0x30,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x77, 0xFC, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0x9F, 0x00, 0x1C,
  0x01, 0xC0, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x18, 0x1C, 0x00, 0x0C, 0x0C,
  0x00, 0x03, 0x0E, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x71, 0x80, 0x00, 0x79, 0xC0, 0x00, 0x7C, 0xC0, 0x00, 0x66,
  0x60, 0x00, 0xE3, 0x30, 0x00, 0xE1, 0xB8, 0x00, 0xE0, 0xDC, 0x00, 0xE0,
  0x6C, 0x00, 0xC0, 0x76, 0x01, 0xC0, 0x33, 0x01, 0xC0, 0x19, 0x81, 0xC0,
  0x0D, 0xC1, 0xC0, 0x06, 0xE1, 0x80, 0x07, 0x63, 0x80, 0x03, 0xB3, 0x80,
  0x01, 0x9B, 0x80, 0x00, 0xCF, 0x80, 0x00, 0xE7, 0x80, 0x00, 0x63, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x18, 0x30, 0x00, 0x1C, 0x18,
  0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x1C, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x7C, 0x03, 0xF0, 0x1F, 0x61, 0xF0, 0xCF, 0x81, 0x9C, 0x07, 0x40,
  0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xF7, 0xE0, 0x03, 0xC0,
  0x3C, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0x60, 0x30, 0x00, 0x1C, 0x1C,
  0x00, 0x07, 0x06, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x0C,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFE, 0xFC, 0x00, 0x3C, 0x03, 0xC0,
  0x0E, 0x00, 0x1C, 0x03, 0x80, 0x01, 0x80, 0xE0, 0x00, 0x30, 0x18, 0x00,
  0x07, 0x07, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x84,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x38, 0x60, 0x00,
  0x06, 0x0C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x30, 0x1C, 0x00, 0x0E, 0x03,
  0xC0, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xD8, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x03, 0x18, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0x38, 0x60, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x60,
  0x60, 0x00, 0x1C, 0x0C, 0x00, 0x07, 0x01, 0x80, 0x01, 0xC0, 0x30, 0x00,
  0x70, 0x06, 0x00, 0x0C, 0x01, 0xC0, 0x03, 0x00, 0x30, 0x00, 0xE0, 0x06,
  0x00, 0x38, 0x00, 0xC0, 0x0E, 0x00, 0x18, 0x03, 0x80, 0x07, 0x00, 0x60,
  0x00, 0xE0, 0x18, 0x00, 0x18, 0x07, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x60,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x0F, 0xC0, 0x00, 0x6F, 0xFE, 0x00, 0x1F,
  0xE3, 0xF0, 0x03, 0xE0, 0x0F, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x38, 0x30, 0x00,
  0x07, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x01,
  0x80, 0x03, 0x80, 0x18, 0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x0F, 0x00, 0x18, 0x7F, 0xE0, 0x19, 0xF9, 0xF8, 0x3B,
  0xC0, 0x3C, 0x37, 0x00, 0x1C, 0x3C, 0x00, 0x0E, 0x38, 0x00, 0x06, 0x70,
  0x00, 0x07, 0x70, 0x00, 0x07, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x0E, 0x60, 0x00, 0x0C, 0x70,
  0x00, 0x1C, 0x30, 0x00, 0x38, 0x38, 0x00, 0x70, 0x1C, 0x00, 0xF0, 0x0E,
  0x01, 0xE0, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x10, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFE, 0xFC, 0x00,
  0x3C, 0x03, 0xC0, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x01, 0x80, 0xE0, 0x00,
  0x38, 0x18, 0x00, 0x03, 0x07, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x0C, 0x18,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x0E, 0x0C, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x03, 0xC1, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xC0, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x00, 0x30, 0x1C, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xC6,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x07, 0x18, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x38,
  0x00, 0x0E, 0x03, 0x80, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0xF0, 0x03, 0xC0, 0x38, 0x07, 0x00, 0x1C, 0x0E,
  0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x06, 0x38, 0x00, 0x07, 0x30,
  0x00, 0x07, 0x30, 0x00, 0x03, 0x70, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x07, 0x60,
  0x00, 0x07, 0x60, 0x00, 0x06, 0x60, 0x00, 0x0E, 0x70, 0x00, 0x1E, 0x70,
  0x00, 0x36, 0x38, 0x00, 0x7E, 0x1C, 0x00, 0xEC, 0x1E, 0x03, 0xCC, 0x0F,
  0xFF, 0x1C, 0x03, 0xFC, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x06, 0x0F, 0x0F, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xF0, 0xF0, 0xE0,
  0x00, 0x60, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80,
  0x30, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE0, 0x08, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x81,
  0xE0, 0x1C, 0x38, 0x00, 0xE7, 0x00, 0x06, 0x60, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7C, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xC0,
  0x07, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x01, 0x80, 0x70, 0x00, 0x03, 0x01,
  0xC0, 0x00, 0x06, 0x03, 0x00, 0xFC, 0x06, 0x0C, 0x07, 0xFC, 0x0C, 0x18,
  0x1C, 0x1C, 0x18, 0x60, 0x70, 0x10, 0x30, 0xC0, 0xC0, 0x60, 0x63, 0x03,
  0x00, 0xC0, 0xC6, 0x0C, 0x01, 0x01, 0x98, 0x18, 0x06, 0x03, 0x30, 0x30,
  0x0C, 0x06, 0x60, 0xC0, 0x18, 0x09, 0x81, 0x80, 0x20, 0x33, 0x03, 0x00,
  0xC0, 0x66, 0x0C, 0x01, 0x80, 0xCC, 0x18, 0x03, 0x01, 0x98, 0x30, 0x0C,
  0x06, 0x60, 0x60, 0x18, 0x0C, 0xC0, 0xC0, 0x70, 0x19, 0x81, 0x80, 0xE0,
  0x63, 0x03, 0x03, 0xC0, 0xC6, 0x06, 0x0D, 0x83, 0x0C, 0x0C, 0x33, 0x0C,
  0x0C, 0x0F, 0xC3, 0xF8, 0x18, 0x1F, 0x07, 0xC0, 0x30, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x80, 0x00, 0xF0, 0x07, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xD8,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x70, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x0C, 0x0C, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x18,
  0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x01, 0x80,
  0x06, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0x60, 0x06, 0x00,
  0x0C, 0x01, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x30, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x30, 0x60, 0x00, 0x06, 0x1C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0xE0,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x18, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0C,
  0x00, 0x7C, 0x01, 0x80, 0x03, 0xC0, 0x30, 0x00, 0x1C, 0x0E, 0x00, 0x03,
  0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x07, 0x06, 0x00, 0x00, 0xE0, 0xC0,
  0x00, 0x18, 0x38, 0x00, 0x03, 0x07, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x1C,
  0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x38, 0x1C, 0x00,
  0x1E, 0x03, 0x80, 0x1F, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01,
  0x80, 0x03, 0xC0, 0x30, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x18, 0x30, 0x00, 0x03, 0x86, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x06, 0x18,
  0x00, 0x00, 0xC7, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x38, 0x60, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0xF0, 0x60, 0x00, 0x3C, 0x0C, 0x00, 0x3F, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFD, 0xF8, 0x00, 0x3C, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x03, 0x80, 0x03,
  0x80, 0xE0, 0x00, 0x30, 0x38, 0x00, 0x07, 0x06, 0x00, 0x00, 0x61, 0xC0,
  0x00, 0x0C, 0x30, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0x30, 0x60, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x70, 0x1C, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x03, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0x80, 0x1E, 0x00, 0x38, 0x00,
  0x78, 0x03, 0x00, 0x03, 0x80, 0x30, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xE0,
  0x30, 0x00, 0x06, 0x07, 0x00, 0x00, 0x60, 0x70, 0x00, 0x07, 0x06, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03,
  0x0E, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x71, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x18,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x0C, 0x38, 0x00, 0x01, 0xC3, 0x00, 0x00,
  0x1C, 0x30, 0x00, 0x03, 0x83, 0x00, 0x00, 0x30, 0x30, 0x00, 0x07, 0x07,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x06, 0x00, 0x03, 0xC0, 0x60, 0x00,
  0x78, 0x06, 0x00, 0x1E, 0x00, 0x60, 0x07, 0xC0, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x3C, 0x03, 0xC0, 0x0E, 0x00, 0x38,
  0x03, 0x80, 0x03, 0x80, 0xE0, 0x00, 0x30, 0x38, 0x00, 0x07, 0x06, 0x00,
  0x00, 0x61, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0xFF,
  0xF7, 0x00, 0x1F, 0xFC, 0xE0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x06,
  0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x0E, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0,
  0x1C, 0x00, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x03, 0x81, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x03, 0x80, 0x00, 0x1C, 0x0C,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x18, 0x1C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x81, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03,
  0x03, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x70, 0x30, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x60, 0x70,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0C, 0x0E, 0x00, 0x00,
  0x70, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x1C, 0x06, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x03, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x01, 0xC0, 0x18,
  0x00, 0x07, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x70, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x70, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x30, 0x07, 0x00, 0x00, 0xE0, 0x3C,
  0x00, 0x01, 0x80, 0xF0, 0x00, 0x03, 0x03, 0xC0, 0x00, 0x06, 0x0F, 0x00,
  0x00, 0x0C, 0x3C, 0x00, 0x00, 0x18, 0xF0, 0x00, 0x00, 0x73, 0xE0, 0x00,
  0x00, 0xCE, 0xE0, 0x00, 0x01, 0xB8, 0xC0, 0x00, 0x03, 0xE1, 0xC0, 0x00,
  0x07, 0x81, 0x80, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x60, 0x07, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x01, 0x80, 0x06, 0x00, 0x03,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x60, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x38, 0x01, 0x80,
  0x00, 0x30, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0xE0, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0xC0,
  0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF8, 0x0D, 0x80, 0x03, 0x60, 0x76,
  0x00, 0x1D, 0x81, 0x98, 0x00, 0x66, 0x06, 0x60, 0x03, 0x38, 0x19, 0x80,
  0x1C, 0xC0, 0x67, 0x00, 0x63, 0x01, 0x8C, 0x03, 0x8C, 0x0E, 0x30, 0x0C,
  0x30, 0x30, 0xC0, 0x71, 0xC0, 0xC3, 0x01, 0x87, 0x03, 0x0E, 0x0E, 0x18,
  0x0C, 0x18, 0x30, 0x60, 0x30, 0x61, 0x81, 0x81, 0xC1, 0x8E, 0x06, 0x06,
  0x06, 0x30, 0x38, 0x18, 0x19, 0xC0, 0xC0, 0x60, 0x36, 0x03, 0x01, 0x80,
  0xF8, 0x0C, 0x0E, 0x03, 0xC0, 0x30, 0x38, 0x0F, 0x01, 0xC0, 0xC0, 0x38,
  0x07, 0x03, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01,
  0x81, 0xC0, 0x00, 0x06, 0x07, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x38,
  0x00, 0x00, 0xC0, 0xE0, 0x00, 0x07, 0x03, 0x00, 0x00, 0x1C, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x60, 0x3C,
  0x00, 0x01, 0x80, 0xF0, 0x00, 0x06, 0x03, 0xC0, 0x00, 0x18, 0x1F, 0x80,
  0x00, 0xE0, 0x76, 0x00, 0x03, 0x01, 0x98, 0x00, 0x0C, 0x06, 0x30, 0x00,
  0x30, 0x18, 0xC0, 0x00, 0xC0, 0x63, 0x00, 0x07, 0x03, 0x86, 0x00, 0x1C,
  0x0E, 0x18, 0x00, 0x60, 0x30, 0x70, 0x01, 0x80, 0xC0, 0xC0, 0x06, 0x03,
  0x03, 0x00, 0x18, 0x0C, 0x0E, 0x00, 0xE0, 0x70, 0x18, 0x03, 0x81, 0x80,
  0x60, 0x0C, 0x06, 0x00, 0xC0, 0x30, 0x18, 0x03, 0x00, 0xC0, 0x60, 0x0E,
  0x03, 0x01, 0x80, 0x18, 0x1C, 0x0E, 0x00, 0x60, 0x70, 0x30, 0x01, 0xC1,
  0x80, 0xC0, 0x03, 0x06, 0x03, 0x00, 0x0C, 0x18, 0x0C, 0x00, 0x38, 0x60,
  0x70, 0x00, 0x63, 0x81, 0xC0, 0x01, 0x8E, 0x06, 0x00, 0x03, 0x30, 0x18,
  0x00, 0x0C, 0xC0, 0x60, 0x00, 0x3B, 0x01, 0x80, 0x00, 0x6C, 0x0E, 0x00,
  0x01, 0xF0, 0x38, 0x00, 0x07, 0x80, 0xC0, 0x00, 0x0E, 0x03, 0x00, 0x00,
  0x38, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3C, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x03,
  0x80, 0x03, 0x00, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x06, 0x06, 0x00, 0x00,
  0xC1, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x06, 0x30, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03,
  0x30, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0x38, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x73,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x33, 0x80, 0x00,
  0x06, 0x70, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x0E, 0x18,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x70, 0x60, 0x00, 0x0C, 0x0E, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x1C,
  0x07, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x60, 0x01, 0xF0,
  0x07, 0x00, 0x03, 0x80, 0x30, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x38, 0x0C,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x01, 0xC1, 0x80, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x18, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x0C,
  0x00, 0x00, 0xE0, 0x60, 0x00, 0x0E, 0x03, 0x00, 0x00, 0xE0, 0x18, 0x00,
  0x1E, 0x01, 0xC0, 0x0F, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0x80,
  0x70, 0x01, 0xE0, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xC0,
  0x70, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x1C, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x06, 0x38, 0x00, 0x00, 0x73, 0x00, 0x00, 0x07,
  0x30, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x03, 0x0E,
  0x00, 0x00, 0x70, 0x60, 0x00, 0x0E, 0x06, 0x00, 0x00, 0xC0, 0x70, 0x00,
  0x1C, 0x03, 0x80, 0x03, 0x80, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x1E, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xC0, 0x0C, 0x00, 0x3C, 0x01, 0x80, 0x01, 0xC0, 0x30, 0x00,
  0x1C, 0x06, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x06,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x30, 0xE0, 0x00, 0x0E, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x70, 0x60,
  0x00, 0x0C, 0x0C, 0x00, 0x03, 0x81, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x38,
  0x0C, 0x00, 0x1E, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x06, 0x00,
  0x70, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x1C, 0x00,
  0xC0, 0x01, 0x80, 0x18, 0x00, 0x30, 0x03, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x60, 0x1C, 0x00, 0x0E, 0x03, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x18, 0x0C,
  0x00, 0x03, 0x81, 0x80, 0x00, 0x70, 0x70, 0x00, 0x06, 0x0E, 0x00, 0x00,
  0xE1, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0x00, 0x78, 0x01, 0xC0,
  0x01, 0xC0, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x06, 0x07, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x03, 0x07, 0x00, 0x00, 0x38, 0x30, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18,
  0x38, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0xC1, 0xC0, 0x00,
  0x0E, 0x0C, 0x00, 0x00, 0x70, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x70, 0x60,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x70, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x38,
  0x0C, 0x00, 0x01, 0x80, 0x70, 0x00, 0x1C, 0x01, 0x80, 0x01, 0xC0, 0x0E,
  0x00, 0x1C, 0x00, 0x30, 0x01, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x19, 0x80, 0x00, 0x07, 0x30, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x38, 0xC0, 0x00, 0x06, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x30,
  0x70, 0x00, 0x0E, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x70, 0x18, 0x00,
  0x0E, 0x03, 0x00, 0x01, 0x80, 0x70, 0x00, 0x70, 0x0E, 0x00, 0x0C, 0x00,
  0xC0, 0x03, 0x80, 0x18, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03,
  0x00, 0x0C, 0x00, 0xE0, 0x01, 0xC0, 0x18, 0x00, 0x18, 0x07, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x60, 0x38, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x38, 0x30, 0x00, 0x07, 0x06, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x0C,
  0x30, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x70, 0x00,
  0x00, 0xEC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x3C, 0x00, 0x60, 0x03, 0xC0, 0x0E, 0x00, 0x6C, 0x00, 0xE0, 0x06, 0xC0,
  0x1E, 0x00, 0x6C, 0x01, 0xE0, 0x0E, 0xC0, 0x1E, 0x00, 0xCC, 0x03, 0xE0,
  0x0C, 0xC0, 0x36, 0x00, 0xCC, 0x03, 0x60, 0x18, 0xC0, 0x76, 0x01, 0x8C,
  0x06, 0x60, 0x18, 0xC0, 0x63, 0x03, 0x0C, 0x0E, 0x30, 0x30, 0xC0, 0xC3,
  0x03, 0x0C, 0x0C, 0x30, 0x70, 0xC1, 0xC3, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x30, 0x30, 0xC0, 0xC3, 0x03, 0x0C, 0x0C, 0x30,
  0x30, 0xC0, 0xC6, 0x03, 0x18, 0x0C, 0x60, 0x31, 0x80, 0xC6, 0x03, 0x18,
  0x0C, 0xC0, 0x33, 0x80, 0xCC, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0xD8,
  0x03, 0x30, 0x0D, 0x80, 0x36, 0x00, 0xD8, 0x03, 0x60, 0x0F, 0x00, 0x36,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0xC0, 0x0E,
  0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x38, 0x00, 0xC0, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x01, 0x80, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0xC0, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x30,
  0x01, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x18, 0x07, 0x00, 0x00, 0x1C,
  0x06, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x06,
  0x38, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1C,
  0x60, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x00, 0xC0, 0xE0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x06,
  0x38, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x70, 0x70, 0x00, 0x0C, 0x0E, 0x00,
  0x03, 0x80, 0xC0, 0x00, 0xE0, 0x18, 0x00, 0x18, 0x03, 0x80, 0x07, 0x00,
  0x30, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xE0, 0x0E, 0x00, 0x0C, 0x03,
  0x80, 0x01, 0x80, 0x60, 0x00, 0x38, 0x18, 0x00, 0x03, 0x07, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x1C, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0xFF, 0x00, 0xFF,
  0x00, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1B, 0x00, 0x07,
  0x60, 0x00, 0xCC, 0x00, 0x39, 0x80, 0x06, 0x38, 0x01, 0x83, 0x00, 0x30,
  0x60, 0x0C, 0x0C, 0x03, 0x81, 0xC0, 0x60, 0x18, 0x1C, 0x03, 0x03, 0x00,
  0x60, 0xC0, 0x0C, 0x38, 0x01, 0xC6, 0x00, 0x19, 0xC0, 0x03, 0x30, 0x00,
  0x6E, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE1, 0x87, 0x0C,
  0x38, 0x60, 0xC3, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xBF,
  0x00, 0x78, 0x03, 0xC0, 0x78, 0x00, 0x70, 0x38, 0x00, 0x38, 0x38, 0x00,
  0x0C, 0x18, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0xFC, 0x0F, 0xF8, 0x0C, 0x0F, 0x00, 0x06, 0x1E, 0x00, 0x03, 0x0E,
  0x00, 0x01, 0x8E, 0x00, 0x01, 0xC6, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x38, 0xC0, 0x00, 0x3C, 0x70, 0x00, 0x36,
  0x1C, 0x00, 0x77, 0x0F, 0x00, 0xF3, 0x83, 0xFF, 0xF1, 0xC0, 0x7F, 0xE0,
  0xE0, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x61, 0xFF, 0x00, 0x73, 0xFF, 0xC0,
  0x33, 0x80, 0x70, 0x1B, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x07, 0x00, 0x03,
  0x83, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x61, 0xC0, 0x00, 0x38, 0xC0, 0x00,
  0x1C, 0x60, 0x00, 0x0E, 0x30, 0x00, 0x07, 0x18, 0x00, 0x03, 0x9C, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x38, 0xC0, 0x00, 0x18, 0xE0, 0x00, 0x0C, 0x60, 0x00, 0x0E, 0x30,
  0x00, 0x06, 0x18, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x07, 0x80, 0x07, 0x07,
  0xC0, 0x07, 0x83, 0x38, 0x07, 0x81, 0x8F, 0xFF, 0x00, 0xC1, 0xFF, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xF8, 0x03, 0xC0, 0x3C, 0x07, 0x00, 0x0C, 0x0E, 0x00, 0x0E, 0x0C, 0x00,
  0x06, 0x1C, 0x00, 0x07, 0x38, 0x00, 0x03, 0x30, 0x00, 0x03, 0x70, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0xE0, 0x00,
  0x1C, 0x60, 0x00, 0x18, 0x60, 0x00, 0x38, 0x70, 0x00, 0x70, 0x38, 0x00,
  0xE0, 0x1C, 0x03, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x06, 0x01, 0xC0, 0x07, 0xFC, 0x38, 0x03, 0xFF, 0xC6,
  0x00, 0xF0, 0x0C, 0xC0, 0x38, 0x00, 0xD8, 0x0E, 0x00, 0x0F, 0x03, 0x80,
  0x01, 0xE0, 0x60, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60,
  0xE0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x0E, 0x1C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x38, 0x30, 0x00, 0x07, 0x06, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x03, 0x03, 0x80, 0x00, 0xE0, 0x30,
  0x00, 0x3C, 0x07, 0x00, 0x0F, 0x80, 0x60, 0x03, 0xE0, 0x0F, 0x01, 0xEC,
  0x00, 0xFF, 0xF1, 0x80, 0x07, 0xFC, 0x30, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x3C, 0x03, 0xC0,
  0x3C, 0x00, 0x60, 0x38, 0x00, 0x38, 0x38, 0x00, 0x0C, 0x1C, 0x00, 0x07,
  0x1C, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x37, 0x00, 0x00, 0x1B, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x08, 0x1C, 0x00, 0x06, 0x07, 0x00, 0x0E, 0x01,
  0xE0, 0x1E, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7C, 0x04, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x80, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFE, 0x1C,
  0x01, 0xFF, 0xE3, 0x80, 0x78, 0x06, 0x60, 0x1C, 0x00, 0x6C, 0x07, 0x00,
  0x07, 0x81, 0xC0, 0x00, 0xF0, 0x30, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x30, 0x70, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x18, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x30,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x1C, 0x18, 0x00, 0x03,
  0x83, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x81, 0xC0,
  0x00, 0x70, 0x18, 0x00, 0x1E, 0x03, 0x80, 0x07, 0xC0, 0x30, 0x01, 0xF0,
  0x07, 0x80, 0xF6, 0x00, 0x7F, 0xFC, 0xC0, 0x03, 0xFE, 0x18, 0x00, 0x08,
  0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x20, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x01, 0xE0, 0x00, 0xF9, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x07, 0x07, 0xFC, 0x01, 0x87, 0xFF,
  0x80, 0x63, 0x80, 0x70, 0x19, 0x80, 0x0E, 0x06, 0xC0, 0x01, 0x81, 0xE0,
  0x00, 0x60, 0xF0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x06, 0x1C, 0x00, 0x01,
  0x87, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x60, 0x00, 0x0E, 0x18, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30,
  0x00, 0x03, 0x0C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x18,
  0x70, 0x00, 0x06, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x38, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x41, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x1E, 0x0C, 0x00,
  0x07, 0x01, 0x80, 0x03, 0xC0, 0x30, 0x00, 0xE0, 0x06, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x38, 0x07, 0x80, 0x06, 0x01, 0xC0, 0x00, 0xC0, 0x70,
  0x00, 0x18, 0x1C, 0x00, 0x03, 0x0F, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C,
  0xF0, 0x00, 0x03, 0x3E, 0x00, 0x00, 0x7E, 0xE0, 0x00, 0x0F, 0x0E, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0x80,
  0x18, 0x00, 0x30, 0x03, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00,
  0x38, 0x00, 0x70, 0x06, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00,
  0x0E, 0x03, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x06, 0x00, 0x20, 0x07,
  0x3F, 0xC3, 0xFC, 0x06, 0x7F, 0xC7, 0xFE, 0x06, 0xC0, 0xEE, 0x06, 0x07,
  0x80, 0x78, 0x07, 0x07, 0x00, 0x70, 0x03, 0x06, 0x00, 0x70, 0x03, 0x0E,
  0x00, 0x60, 0x03, 0x0C, 0x00, 0x60, 0x07, 0x0C, 0x00, 0x60, 0x07, 0x0C,
  0x00, 0xE0, 0x06, 0x0C, 0x00, 0xE0, 0x06, 0x0C, 0x00, 0xC0, 0x06, 0x1C,
  0x00, 0xC0, 0x06, 0x18, 0x00, 0xC0, 0x0E, 0x18, 0x00, 0xC0, 0x0E, 0x18,
  0x01, 0xC0, 0x0C, 0x18, 0x01, 0x80, 0x0C, 0x38, 0x01, 0x80, 0x0C, 0x30,
  0x01, 0x80, 0x0C, 0x30, 0x01, 0x80, 0x1C, 0x30, 0x01, 0x80, 0x18, 0x30,
  0x03, 0x80, 0x18, 0x30, 0x03, 0x00, 0x18, 0x70, 0x03, 0x00, 0x18, 0x60,
  0x03, 0x00, 0x18, 0x60, 0x03, 0x00, 0x38, 0x60, 0x03, 0x00, 0x30, 0x60,
  0x07, 0x00, 0x30, 0xE0, 0x06, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x01, 0xC1,
  0xFF, 0x00, 0x61, 0xFF, 0xE0, 0x18, 0xE0, 0x1C, 0x06, 0x60, 0x03, 0x81,
  0xB0, 0x00, 0x60, 0x78, 0x00, 0x18, 0x3C, 0x00, 0x07, 0x0E, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x06, 0x0C, 0x00,
  0x01, 0x87, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0E, 0x18,
  0x00, 0x03, 0x86, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x0C,
  0x30, 0x00, 0x03, 0x0C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0x18, 0x70, 0x00, 0x06, 0x1C, 0x00, 0x01, 0x86, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x38, 0x60, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0x80, 0x70, 0x03, 0x80,
  0x0E, 0x01, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x30, 0x70, 0x00, 0x0E, 0x18,
  0x00, 0x01, 0x8E, 0x00, 0x00, 0x63, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x06,
  0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x1B, 0x80, 0x00,
  0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x3B, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x01, 0x86, 0x00, 0x00, 0xE1,
  0x80, 0x00, 0x30, 0x70, 0x00, 0x1C, 0x0C, 0x00, 0x0E, 0x03, 0x80, 0x0F,
  0x00, 0x78, 0x07, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x30, 0xFF, 0x80, 0x0E, 0x7F, 0xF8,
  0x01, 0x9C, 0x03, 0x80, 0x36, 0x00, 0x38, 0x07, 0x80, 0x03, 0x00, 0xE0,
  0x00, 0x70, 0x18, 0x00, 0x06, 0x07, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18,
  0x18, 0x00, 0x03, 0x83, 0x00, 0x00, 0x70, 0x60, 0x00, 0x0E, 0x1C, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x18, 0x30, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xC1, 0xC0, 0x00,
  0x18, 0x30, 0x00, 0x07, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x38, 0x1C,
  0x00, 0x0E, 0x07, 0x80, 0x03, 0x80, 0xF8, 0x00, 0xF0, 0x19, 0xC0, 0x3C,
  0x03, 0x1F, 0xFE, 0x00, 0x61, 0xFF, 0x80, 0x0C, 0x02, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x3F, 0xE1, 0xC0, 0x7F, 0xFC, 0xC0, 0x78, 0x06, 0x60, 0x70, 0x01,
  0xB0, 0x70, 0x00, 0x78, 0x70, 0x00, 0x3C, 0x30, 0x00, 0x0E, 0x38, 0x00,
  0x06, 0x18, 0x00, 0x03, 0x1C, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x31, 0x80, 0x00, 0x18, 0xC0,
  0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x07, 0x18, 0x00, 0x03, 0x8C,
  0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x70,
  0x60, 0x00, 0x78, 0x38, 0x00, 0x3C, 0x0C, 0x00, 0x7C, 0x07, 0x80, 0xF6,
  0x01, 0xFF, 0xF3, 0x00, 0x3F, 0xE1, 0x80, 0x02, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x0C, 0x0F, 0xFC,
  0x18, 0x7F, 0xF8, 0x31, 0xE0, 0x00, 0xE7, 0x00, 0x01, 0xD8, 0x00, 0x03,
  0x60, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xFC, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x0E,
  0x0C, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x18, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x1C,
  0xE0, 0x00, 0x18, 0x70, 0x00, 0x78, 0x3C, 0x01, 0xF0, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x01, 0x8E, 0x00, 0x01, 0xC6, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x30, 0xC0, 0x00, 0x18, 0xE0, 0x00, 0x0C, 0x70, 0x00, 0x0E, 0x30,
  0x00, 0x07, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC7,
  0x00, 0x00, 0x63, 0x80, 0x00, 0x71, 0x80, 0x00, 0x38, 0xC0, 0x00, 0x18,
  0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x38, 0x00, 0x03, 0x1C, 0x00, 0x03,
  0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xC3, 0x80, 0x00, 0xE0, 0xC0, 0x00,
  0xF0, 0x60, 0x00, 0xD8, 0x38, 0x00, 0xFC, 0x0E, 0x01, 0xEC, 0x03, 0xFF,
  0xC6, 0x00, 0xFF, 0x83, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x39, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x06,
  0x1C, 0x00, 0x03, 0x83, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x70, 0x38, 0x00,
  0x18, 0x0E, 0x00, 0x0E, 0x01, 0x80, 0x03, 0x00, 0x60, 0x01, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x30, 0x00, 0xC0, 0x1C, 0x00, 0x30, 0x06, 0x00,
  0x0E, 0x03, 0x80, 0x03, 0x80, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x18, 0x38,
  0x00, 0x07, 0x0C, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C,
  0xE0, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x3E, 0x00,
  0x30, 0x01, 0xB0, 0x03, 0xC0, 0x0D, 0x80, 0x1E, 0x00, 0xEC, 0x00, 0xF0,
  0x06, 0x60, 0x0D, 0x80, 0x73, 0x00, 0x6C, 0x03, 0x1C, 0x06, 0x60, 0x18,
  0xE0, 0x33, 0x01, 0xC7, 0x01, 0x98, 0x0C, 0x18, 0x18, 0xC0, 0x60, 0xC0,
  0xC6, 0x06, 0x06, 0x0C, 0x30, 0x30, 0x30, 0x61, 0x83, 0x81, 0x87, 0x0C,
  0x18, 0x0C, 0x30, 0x60, 0xC0, 0x61, 0x81, 0x0C, 0x03, 0x18, 0x0C, 0x60,
  0x18, 0xC0, 0x67, 0x00, 0xCC, 0x03, 0x30, 0x06, 0x60, 0x19, 0x80, 0x33,
  0x00, 0xD8, 0x01, 0xB0, 0x06, 0xC0, 0x0D, 0x80, 0x36, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x01,
  0xC0, 0x18, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80,
  0x01, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0C, 0x03, 0x80, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x73, 0x00,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0, 0x30, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x18, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x01, 0x80, 0x07, 0x00, 0x00, 0x03, 0x81, 0x80,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x18,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x06, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x0E, 0x00,
  0x00, 0x30, 0x0E, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x06, 0x07, 0x00,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x0E, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x02, 0x7E, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x31, 0xE3, 0xC0, 0x01, 0x8E, 0x03, 0x80, 0x06,
  0x30, 0x07, 0x00, 0x39, 0x80, 0x0E, 0x00, 0xC6, 0x00, 0x1E, 0x0E, 0x30,
  0x00, 0x3F, 0xF0, 0xC0, 0x00, 0x3F, 0x80,
};

const GFXglyph RobotoMono_ExtraLightItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 10, 39, 32, 11, -39 },
  { 50, 12, 11, 32, 13, -41 },
  { 67, 32, 39, 32, 1, -39 },
  { 223, 26, 51, 32, 4, -45 },
  { 389, 27, 41, 32, 3, -40 },
  { 528, 28, 41, 32, 2, -40 },
  { 672, 4, 11, 32, 16, -41 },
  { 678, 17, 57, 32, 9, -44 },
  { 800, 17, 57, 32, 5, -44 },
  { 922, 24, 22, 32, 7, -39 },
  { 988, 27, 28, 32, 3, -32 },
  { 1083, 6, 12, 32, 7, -5 },
  { 1092, 20, 2, 32, 6, -19 },
  { 1097, 5, 4, 32, 12, -4 },
  { 1100, 26, 42, 32, 4, -39 },
  { 1237, 25, 41, 32, 4, -40 },
  { 1366, 15, 39, 32, 8, -39 },
  { 1440, 26, 40, 32, 1, -40 },
  { 1570, 27, 41, 32, 1, -40 },
  { 1709, 27, 39, 32, 1, -39 },
  { 1841, 27, 40, 32, 5, -39 },
  { 1976, 24, 41, 32, 3, -40 },
  { 2099, 25, 39, 32, 7, -39 },
  { 2221, 27, 41, 32, 3, -40 },
  { 2360, 24, 40, 32, 5, -40 },
  { 2480, 8, 28, 32, 14, -28 },
  { 2508, 12, 35, 32, 10, -28 },
  { 2561, 25, 22, 32, 4, -29 },
  { 2630, 25, 13, 32, 4, -24 },
  { 2671, 25, 22, 32, 3, -29 },
  { 2740, 20, 40, 32, 9, -40 },
  { 2840, 31, 39, 32, 1, -39 },
  { 2992, 27, 39, 32, 0, -39 },
  { 3124, 27, 39, 32, 3, -39 },
  { 3256, 27, 41, 32, 3, -40 },
  { 3395, 28, 39, 32, 2, -39 },
  { 3532, 28, 39, 32, 3, -39 },
  { 3669, 29, 39, 32, 3, -39 },
  { 3811, 27, 41, 32, 3, -40 },
  { 3950, 30, 39, 32, 2, -39 },
  { 4097, 29, 39, 32, 2, -39 },
  { 4239, 28, 40, 32, 2, -39 },
  { 4379, 31, 39, 32, 3, -39 },
  { 4531, 23, 39, 32, 3, -39 },
  { 4644, 30, 39, 32, 2, -39 },
  { 4791, 30, 39, 32, 2, -39 },
  { 4938, 27, 41, 32, 3, -40 },
  { 5077, 29, 39, 32, 3, -39 },
  { 5219, 28, 47, 32, 3, -40 },
  { 5384, 27, 39, 32, 3, -39 },
  { 5516, 28, 41, 32, 3, -40 },
  { 5660, 27, 39, 32, 6, -39 },
  { 5792, 29, 40, 32, 3, -39 },
  { 5937, 27, 39, 32, 6, -39 },
  { 6069, 28, 39, 32, 6, -39 },
  { 6206, 32, 39, 32, 1, -39 },
  { 6362, 27, 39, 32, 6, -39 },
  { 6494, 29, 39, 32, 1, -39 },
  { 6636, 17, 53, 32, 8, -45 },
  { 6749, 11, 42, 32, 11, -39 },
  { 6807, 16, 53, 32, 8, -45 },
  { 6913, 19, 21, 32, 7, -39 },
  { 6963, 22, 2, 32, 2, 0 },
  { 6969, 6, 8, 32, 16, -41 },
  { 6975, 25, 31, 32, 3, -30 },
  { 7072, 25, 42, 32, 3, -41 },
  { 7204, 24, 31, 32, 4, -30 },
  { 7297, 27, 42, 32, 4, -41 },
  { 7439, 25, 31, 32, 3, -30 },
  { 7536, 26, 42, 32, 7, -42 },
  { 7673, 27, 42, 32, 2, -30 },
  { 7815, 26, 41, 32, 2, -41 },
  { 7949, 23, 39, 32, 3, -39 },
  { 8062, 25, 51, 32, 0, -39 },
  { 8222, 27, 41, 32, 3, -41 },
  { 8361, 23, 41, 32, 3, -41 },
  { 8479, 32, 30, 32, -1, -30 },
  { 8599, 26, 30, 32, 2, -30 },
  { 8697, 26, 31, 32, 3, -30 },
  { 8798, 27, 41, 32, 1, -30 },
  { 8937, 25, 41, 32, 4, -30 },
  { 9066, 23, 30, 32, 7, -30 },
  { 9153, 24, 31, 32, 4, -30 },
  { 9246, 21, 38, 32, 7, -37 },
  { 9346, 25, 30, 32, 4, -29 },
  { 9440, 26, 29, 32, 5, -29 },
  { 9535, 29, 29, 32, 4, -29 },
  { 9641, 30, 29, 32, 1, -29 },
  { 9750, 33, 41, 32, -1, -29 },
  { 9920, 28, 29, 32, 1, -29 },
  { 10022, 21, 54, 32, 9, -43 },
  { 10164, 10, 47, 32, 11, -39 },
  { 10223, 21, 54, 32, 5, -43 },
  { 10365, 30, 9, 32, 1, -21 },
};

const GFXfont RobotoMono_ExtraLightItalic55pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic55pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic55pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC55PT7B_H_
