#ifndef _ROBOTOMONO_EXTRALIGHTITALIC39PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x08, 0x10, 0x60, 0xC1, 0x83, 0x04, 0x08, 0x30, 0x60, 0xC1,
  0x82, 0x0C, 0x18, 0x30, 0x60, 0x81, 0x00, 0x00, 0x00, 0x00, 0x00, 0x83,
  0x86, 0x00, 0x21, 0x61, 0x63, 0x63, 0x43, 0x42, 0x42, 0xC6, 0x00, 0x18,
  0x18, 0x00, 0x40, 0x40, 0x01, 0x03, 0x00, 0x0C, 0x08, 0x00, 0x20, 0x20,
  0x00, 0x81, 0x80, 0x06, 0x04, 0x00, 0x10, 0x30, 0x1F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF0, 0x08, 0x18, 0x00, 0x60, 0x60, 0x01, 0x81, 0x00, 0x04, 0x0C,
  0x00, 0x30, 0x30, 0x00, 0x80, 0x80, 0x02, 0x06, 0x00, 0x18, 0x10, 0x00,
  0x40, 0x40, 0x3F, 0xFF, 0xF8, 0x0C, 0x08, 0x00, 0x20, 0x20, 0x00, 0x81,
  0x80, 0x06, 0x04, 0x00, 0x10, 0x10, 0x00, 0xC0, 0xC0, 0x03, 0x02, 0x00,
  0x08, 0x18, 0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0xFE, 0x00, 0xFB, 0xC0, 0x70, 0x18, 0x30, 0x06, 0x08, 0x00, 0xC6,
  0x00, 0x31, 0x80, 0x0C, 0x40, 0x03, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0xC0, 0x01, 0x20,
  0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0x40, 0x06, 0x18, 0x03, 0x03, 0x83,
  0x80, 0x7F, 0x80, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x0F, 0x00, 0x03, 0x30, 0x00, 0xC3, 0x00, 0x30, 0x60, 0x44, 0x0C, 0x0C,
  0x81, 0x83, 0x10, 0x30, 0xC6, 0x06, 0x10, 0xC0, 0x86, 0x08, 0x31, 0x81,
  0x8C, 0x20, 0x1F, 0x08, 0x00, 0x83, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x01, 0x87, 0xC0, 0x21, 0x88, 0x0C, 0x41, 0x83, 0x18, 0x10,
  0xC3, 0x02, 0x10, 0x40, 0x46, 0x08, 0x19, 0x81, 0x03, 0x20, 0x20, 0x40,
  0x04, 0x18, 0x00, 0xC6, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x3D, 0xC0,
  0x0C, 0x18, 0x01, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x00, 0x80,
  0x20, 0x30, 0x06, 0x0C, 0x00, 0xC3, 0x00, 0x18, 0xC0, 0x01, 0xF0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x03, 0xA0, 0x00, 0xC6, 0x00, 0x30, 0x60, 0x66,
  0x04, 0x0D, 0x80, 0xC1, 0x60, 0x0C, 0x6C, 0x01, 0x8D, 0x80, 0x1B, 0x30,
  0x01, 0xC6, 0x00, 0x38, 0xC0, 0x07, 0x0C, 0x03, 0xA0, 0xE1, 0xC6, 0x0F,
  0xE0, 0x60, 0x2D, 0xB4, 0xB6, 0x00, 0x20, 0x07, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x20, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30,
  0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0xE0, 0x04, 0x00, 0xC0, 0x08,
  0x01, 0x80, 0x10, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x10, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0,
  0x10, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x02, 0x04,
  0x0B, 0xC2, 0x1E, 0x7D, 0x7C, 0x07, 0xE0, 0x00, 0xC0, 0x00, 0xF0, 0x00,
  0xCC, 0x00, 0xC6, 0x00, 0xC1, 0x80, 0xC0, 0x60, 0xC0, 0x30, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x33, 0x33,
  0x66, 0xC8, 0xFF, 0xFC, 0xDF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0xF3, 0xC0, 0x60, 0x30, 0x30, 0x06, 0x18,
  0x00, 0x86, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x03, 0x20, 0x01, 0xD8, 0x01,
  0xF6, 0x00, 0xCD, 0x80, 0x63, 0x40, 0x30, 0x90, 0x18, 0x2C, 0x0C, 0x0B,
  0x0C, 0x06, 0xC6, 0x01, 0xB3, 0x00, 0x69, 0x80, 0x12, 0xC0, 0x0C, 0xC0,
  0x03, 0x20, 0x00, 0x8C, 0x00, 0x63, 0x00, 0x10, 0x40, 0x0C, 0x18, 0x06,
  0x03, 0x87, 0x00, 0x7F, 0x00, 0x00, 0x40, 0x70, 0xFC, 0xF3, 0xE0, 0xA0,
  0x20, 0x08, 0x06, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30,
  0x0C, 0x02, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x00, 0xFC, 0x00, 0xF3, 0xC0, 0x70, 0x18, 0x30,
  0x03, 0x08, 0x00, 0xC6, 0x00, 0x31, 0x00, 0x04, 0xC0, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0B, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x3C, 0xF0,
  0x0C, 0x07, 0x03, 0x00, 0x60, 0xC0, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x18,
  0xC0, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x03, 0x30,
  0x00, 0x46, 0x00, 0x18, 0x60, 0x06, 0x0E, 0x01, 0xC0, 0xE0, 0xE0, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0x40,
  0x00, 0x48, 0x00, 0x1B, 0x00, 0x06, 0x60, 0x01, 0x8C, 0x00, 0x61, 0x00,
  0x18, 0x20, 0x03, 0x04, 0x00, 0xC1, 0x80, 0x30, 0x30, 0x0C, 0x06, 0x03,
  0x00, 0x80, 0x40, 0x10, 0x18, 0x06, 0x06, 0x00, 0xC1, 0x80, 0x18, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x63, 0x80, 0x0F,
  0xFE, 0x01, 0xE0, 0xE0, 0x70, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x11, 0x80,
  0x06, 0x30, 0x00, 0xC2, 0x00, 0x30, 0x60, 0x06, 0x06, 0x03, 0x80, 0xE0,
  0xE0, 0x07, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x1F, 0x80, 0x38, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x0C, 0x7F, 0x06, 0xF1, 0xC2, 0xC0, 0x33, 0xC0, 0x19, 0xC0, 0x06,
  0xC0, 0x03, 0x60, 0x01, 0xA0, 0x00, 0xD0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1A, 0x00, 0x09, 0x00, 0x0C, 0xC0, 0x04, 0x60, 0x06, 0x18, 0x06, 0x07,
  0x0E, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0x78, 0x03, 0x80, 0xC0,
  0x60, 0x06, 0x04, 0x00, 0x60, 0xC0, 0x02, 0x08, 0x00, 0x20, 0x80, 0x02,
  0x08, 0x00, 0x60, 0x80, 0x06, 0x0C, 0x00, 0xC0, 0xC0, 0x18, 0x07, 0x07,
  0x00, 0x1F, 0xC0, 0x07, 0xFE, 0x00, 0xC0, 0x30, 0x18, 0x01, 0x83, 0x00,
  0x08, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x40, 0x00, 0xCC, 0x00, 0x0C, 0xC0,
  0x01, 0x84, 0x00, 0x18, 0x60, 0x03, 0x03, 0x00, 0x60, 0x3C, 0x1C, 0x00,
  0xFF, 0x00, 0x03, 0xF0, 0x03, 0xCE, 0x07, 0x01, 0x83, 0x00, 0x43, 0x00,
  0x33, 0x00, 0x09, 0x80, 0x05, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x58, 0x00, 0x2C, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x1C, 0xC0, 0x1E,
  0x70, 0x3A, 0x1F, 0xF3, 0x03, 0xE1, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x00, 0x18, 0x71, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x0E, 0x30, 0x03, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0xC0, 0xC0, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x18, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0xFF, 0xFF, 0x00, 0x20, 0x00, 0x06, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x03, 0x00, 0x00, 0x07, 0xE0, 0x3E, 0xF0, 0xE0,
  0x73, 0x00, 0x66, 0x00, 0x58, 0x00, 0xB0, 0x01, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0xE0, 0x01, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x01, 0xF7, 0x80, 0x1C, 0x03, 0x00, 0xC0, 0x06, 0x06,
  0x00, 0x18, 0x30, 0x00, 0x20, 0x81, 0xE0, 0x86, 0x1C, 0xC3, 0x10, 0xC1,
  0x0C, 0xC2, 0x04, 0x32, 0x18, 0x30, 0xD8, 0x40, 0x82, 0x43, 0x02, 0x09,
  0x08, 0x08, 0x2C, 0x20, 0x60, 0xB1, 0x81, 0x06, 0x86, 0x04, 0x12, 0x18,
  0x30, 0x48, 0x40, 0xC3, 0x21, 0x87, 0x08, 0x86, 0x24, 0x63, 0x0F, 0x1F,
  0x0C, 0x10, 0x20, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x10, 0x01,
  0xC1, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xB0, 0x00, 0x36, 0x00, 0x04, 0x40, 0x01, 0x88,
  0x00, 0x21, 0x00, 0x0C, 0x30, 0x01, 0x06, 0x00, 0x60, 0xC0, 0x08, 0x18,
  0x03, 0x01, 0x00, 0x40, 0x20, 0x18, 0x04, 0x02, 0x00, 0xC0, 0xC0, 0x18,
  0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0x80, 0x04, 0x30, 0x00, 0x84, 0x00, 0x11,
  0x80, 0x03, 0x20, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01, 0xE0, 0x00, 0x10,
  0x07, 0xF8, 0x01, 0xFF, 0xE0, 0x30, 0x06, 0x06, 0x00, 0x60, 0xC0, 0x06,
  0x10, 0x00, 0xC2, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x18,
  0x40, 0x03, 0x08, 0x00, 0xC3, 0x00, 0xE0, 0x7F, 0xF0, 0x0C, 0x07, 0x81,
  0x80, 0x18, 0x20, 0x01, 0x84, 0x00, 0x11, 0x80, 0x03, 0x30, 0x00, 0x66,
  0x00, 0x0C, 0xC0, 0x01, 0x10, 0x00, 0x62, 0x00, 0x0C, 0xC0, 0x03, 0x18,
  0x01, 0xC3, 0xFF, 0xF0, 0x7F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x1E, 0x78,
  0x03, 0x00, 0xC0, 0x60, 0x0C, 0x0C, 0x00, 0x60, 0x80, 0x06, 0x18, 0x00,
  0x21, 0x00, 0x02, 0x30, 0x00, 0x33, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x04, 0xC0, 0x00, 0x84,
  0x00, 0x18, 0x40, 0x01, 0x06, 0x00, 0x30, 0x60, 0x06, 0x03, 0x00, 0xC0,
  0x1C, 0x38, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF8, 0x01, 0x80,
  0x60, 0x08, 0x01, 0x80, 0x40, 0x06, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC1,
  0x80, 0x06, 0x0C, 0x00, 0x10, 0x40, 0x00, 0x82, 0x00, 0x04, 0x30, 0x00,
  0x21, 0x80, 0x01, 0x0C, 0x00, 0x08, 0x40, 0x00, 0xC2, 0x00, 0x06, 0x30,
  0x00, 0x31, 0x80, 0x01, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC2, 0x00, 0x0C,
  0x10, 0x00, 0x61, 0x80, 0x06, 0x0C, 0x00, 0x60, 0x60, 0x06, 0x03, 0x00,
  0xE0, 0x10, 0x7E, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x03, 0xFF, 0xF0, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x78, 0x03, 0x00, 0xC0, 0x60,
  0x06, 0x0C, 0x00, 0x61, 0x80, 0x02, 0x18, 0x00, 0x33, 0x00, 0x03, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x03, 0xFC, 0xC0, 0x3F, 0xCC, 0x00, 0x0C,
  0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0x84, 0x00, 0x08, 0x40, 0x01,
  0x86, 0x00, 0x18, 0x20, 0x01, 0x83, 0x00, 0x30, 0x1C, 0x1E, 0x00, 0xFF,
  0x80, 0x04, 0x00, 0x08, 0x20, 0x00, 0x41, 0x00, 0x06, 0x18, 0x00, 0x30,
  0xC0, 0x01, 0x86, 0x00, 0x0C, 0x20, 0x00, 0x41, 0x00, 0x02, 0x18, 0x00,
  0x30, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x00, 0x02, 0x0F,
  0xFF, 0xF0, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x02,
  0x08, 0x00, 0x10, 0x40, 0x00, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80,
  0x03, 0x08, 0x00, 0x10, 0x40, 0x00, 0x82, 0x00, 0x04, 0x30, 0x00, 0x61,
  0x80, 0x03, 0x00, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x04, 0x00, 0x18, 0x60, 0x00, 0xC1, 0x00,
  0x0C, 0x0C, 0x00, 0x60, 0x60, 0x06, 0x01, 0x80, 0x60, 0x06, 0x0E, 0x00,
  0x1F, 0xC0, 0x00, 0x04, 0x00, 0x1C, 0x10, 0x00, 0xE0, 0xC0, 0x07, 0x03,
  0x00, 0x38, 0x0C, 0x01, 0xC0, 0x20, 0x0E, 0x00, 0x80, 0x60, 0x02, 0x03,
  0x00, 0x18, 0x18, 0x00, 0x60, 0xC0, 0x01, 0x86, 0x00, 0x04, 0x30, 0x00,
  0x11, 0x80, 0x00, 0xCE, 0x00, 0x03, 0x6C, 0x00, 0x0F, 0x18, 0x00, 0x38,
  0x60, 0x00, 0xC0, 0xC0, 0x02, 0x03, 0x00, 0x18, 0x06, 0x00, 0x60, 0x08,
  0x01, 0x80, 0x30, 0x06, 0x00, 0x60, 0x10, 0x01, 0x80, 0x40, 0x03, 0x03,
  0x00, 0x0C, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x1C, 0x18, 0x00, 0x70, 0x70, 0x03,
  0x81, 0xC0, 0x0A, 0x0F, 0x00, 0x78, 0x34, 0x01, 0x60, 0xD0, 0x0D, 0x82,
  0x60, 0x64, 0x09, 0x81, 0x90, 0x66, 0x0C, 0x41, 0x88, 0x23, 0x06, 0x21,
  0x8C, 0x18, 0xC4, 0x30, 0x43, 0x30, 0x81, 0x0C, 0x82, 0x0C, 0x16, 0x18,
  0x30, 0x70, 0x60, 0xC1, 0xC1, 0x83, 0x06, 0x06, 0x08, 0x00, 0x10, 0x20,
  0x00, 0x41, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x00,
  0xC1, 0x00, 0x02, 0x04, 0x00, 0x08, 0x30, 0x00, 0x60, 0x06, 0x00, 0x08,
  0x30, 0x00, 0x41, 0x80, 0x06, 0x1E, 0x00, 0x30, 0xF0, 0x01, 0x86, 0x80,
  0x08, 0x26, 0x00, 0x41, 0x10, 0x02, 0x08, 0xC0, 0x30, 0xC6, 0x01, 0x86,
  0x10, 0x0C, 0x30, 0xC0, 0x41, 0x06, 0x02, 0x08, 0x10, 0x10, 0x40, 0xC1,
  0x86, 0x02, 0x0C, 0x30, 0x10, 0x61, 0x80, 0xC2, 0x08, 0x02, 0x10, 0x40,
  0x19, 0x86, 0x00, 0xCC, 0x30, 0x02, 0x61, 0x80, 0x1B, 0x0C, 0x00, 0xD0,
  0x40, 0x02, 0x82, 0x00, 0x1C, 0x30, 0x00, 0x61, 0x80, 0x03, 0x00, 0x00,
  0x7E, 0x00, 0x3E, 0xE0, 0x0C, 0x06, 0x03, 0x00, 0x60, 0xC0, 0x04, 0x10,
  0x00, 0xC6, 0x00, 0x18, 0x80, 0x03, 0x30, 0x00, 0x26, 0x00, 0x04, 0x80,
  0x00, 0xB0, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xD0, 0x00, 0x1A, 0x00,
  0x02, 0xC0, 0x00, 0x58, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x4C, 0x00,
  0x18, 0x80, 0x03, 0x10, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x06, 0x06, 0x01,
  0x80, 0x71, 0xE0, 0x07, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x01,
  0x00, 0x38, 0x18, 0x00, 0xC0, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00,
  0x41, 0x00, 0x02, 0x08, 0x00, 0x10, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x30,
  0x00, 0xC1, 0x80, 0x06, 0x08, 0x00, 0xE0, 0x40, 0x1E, 0x07, 0xFF, 0xC0,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F,
  0x78, 0x03, 0x01, 0xC0, 0x60, 0x0C, 0x0C, 0x00, 0x61, 0x80, 0x06, 0x18,
  0x00, 0x23, 0x00, 0x03, 0x30, 0x00, 0x32, 0x00, 0x03, 0x60, 0x00, 0x36,
  0x00, 0x03, 0x40, 0x00, 0x24, 0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00, 0x06,
  0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x4C, 0x00, 0x0C, 0xC0, 0x00,
  0xCC, 0x00, 0x18, 0xC0, 0x01, 0x86, 0x00, 0x30, 0x60, 0x06, 0x03, 0x00,
  0xC0, 0x1C, 0x38, 0x00, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x02, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xE0,
  0x30, 0x07, 0x06, 0x00, 0x60, 0xC0, 0x06, 0x18, 0x00, 0xC2, 0x00, 0x08,
  0x40, 0x01, 0x18, 0x00, 0x23, 0x00, 0x0C, 0x60, 0x01, 0x88, 0x00, 0x61,
  0x00, 0x18, 0x20, 0x06, 0x0C, 0x03, 0x81, 0xFF, 0xC0, 0x30, 0x18, 0x04,
  0x03, 0x00, 0x80, 0x20, 0x30, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x0C, 0x18,
  0x01, 0x82, 0x00, 0x30, 0x40, 0x03, 0x18, 0x00, 0x63, 0x00, 0x04, 0x60,
  0x00, 0xC0, 0x00, 0x7E, 0x00, 0x1F, 0x78, 0x07, 0x00, 0xC0, 0xE0, 0x06,
  0x0C, 0x00, 0x61, 0x80, 0x02, 0x18, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0x8C,
  0x00, 0x18, 0x60, 0x03, 0x03, 0x00, 0x70, 0x1C, 0x1C, 0x00, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x10, 0x80, 0x01, 0x08, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x31, 0x80,
  0x03, 0x10, 0x00, 0x21, 0x00, 0x02, 0x30, 0x00, 0x63, 0x00, 0x06, 0x30,
  0x00, 0x63, 0x00, 0x06, 0x20, 0x00, 0x42, 0x00, 0x04, 0x60, 0x00, 0xC6,
  0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x40, 0x00, 0x84, 0x00, 0x18,
  0x40, 0x01, 0x84, 0x00, 0x18, 0x40, 0x03, 0x06, 0x00, 0x30, 0x60, 0x06,
  0x03, 0x00, 0xC0, 0x1C, 0x38, 0x00, 0xFE, 0x00, 0xC0, 0x00, 0x68, 0x00,
  0x0D, 0x00, 0x01, 0x30, 0x00, 0x66, 0x00, 0x08, 0xC0, 0x03, 0x18, 0x00,
  0x43, 0x00, 0x18, 0x20, 0x02, 0x04, 0x00, 0xC0, 0xC0, 0x18, 0x18, 0x06,
  0x03, 0x00, 0xC0, 0x60, 0x30, 0x04, 0x06, 0x00, 0x81, 0x80, 0x10, 0x30,
  0x03, 0x04, 0x00, 0x61, 0x80, 0x0C, 0x20, 0x00, 0x8C, 0x00, 0x11, 0x00,
  0x02, 0x60, 0x00, 0x68, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x60, 0x1C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x0E,
  0x02, 0xC0, 0xE0, 0x6C, 0x0A, 0x06, 0xC1, 0xA0, 0x4C, 0x1A, 0x04, 0xC1,
  0x20, 0xCC, 0x32, 0x0C, 0xC3, 0x20, 0x8C, 0x22, 0x18, 0xC6, 0x21, 0x8C,
  0x62, 0x10, 0xC4, 0x23, 0x0C, 0xC2, 0x30, 0xC8, 0x32, 0x0C, 0x83, 0x20,
  0xD8, 0x36, 0x0D, 0x03, 0x60, 0xD0, 0x34, 0x0B, 0x03, 0xC0, 0xA0, 0x3C,
  0x0A, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0x06, 0x00, 0x06, 0x04, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x18, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x30, 0x18, 0x00, 0x60, 0x60,
  0x00, 0x41, 0x80, 0x00, 0xC2, 0x00, 0x00, 0x8C, 0x00, 0x01, 0xB0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x6C, 0x00, 0x01, 0x8C, 0x00, 0x02, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x30,
  0x30, 0x00, 0xC0, 0x20, 0x01, 0x00, 0x60, 0x06, 0x00, 0x40, 0x18, 0x00,
  0xC0, 0x60, 0x01, 0x80, 0x80, 0x01, 0x87, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x6C, 0x00, 0x0D, 0x80, 0x03, 0x30, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x06,
  0x0C, 0x01, 0x80, 0x80, 0x30, 0x18, 0x0C, 0x03, 0x03, 0x00, 0x20, 0x60,
  0x06, 0x18, 0x00, 0xC6, 0x00, 0x08, 0x80, 0x01, 0xB0, 0x00, 0x3C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF8, 0x03, 0xF0, 0x3F, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80,
  0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xFC, 0x0F, 0xC0,
  0x81, 0x83, 0x06, 0x04, 0x08, 0x18, 0x30, 0x60, 0x40, 0x81, 0x83, 0x06,
  0x04, 0x08, 0x18, 0x30, 0x60, 0x40, 0x81, 0x83, 0x06, 0x04, 0x08, 0x18,
  0x30, 0x60, 0x40, 0x03, 0xF0, 0x3F, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x7E, 0x0F, 0xC0,
  0x00, 0xC0, 0x06, 0x00, 0x70, 0x02, 0xC0, 0x36, 0x03, 0x30, 0x18, 0x81,
  0x84, 0x08, 0x30, 0xC1, 0x84, 0x04, 0x60, 0x26, 0x01, 0xB0, 0x0F, 0x00,
  0x60, 0xFF, 0xFF, 0xC3, 0x08, 0x61, 0x80, 0x00, 0xFC, 0x00, 0xFF, 0xC0,
  0xE0, 0x38, 0x30, 0x06, 0x18, 0x00, 0x8C, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x3F, 0xE0, 0xFF, 0xF8, 0x70, 0x06, 0x30, 0x01,
  0x18, 0x00, 0x4C, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x07, 0x30, 0x03, 0xC6,
  0x01, 0xB1, 0xC1, 0xCC, 0x1F, 0xC3, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x18, 0x7C, 0x06, 0x7F, 0x81, 0xF0, 0x30, 0x50, 0x06, 0x18, 0x01,
  0x84, 0x00, 0x23, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x32,
  0x00, 0x08, 0x80, 0x02, 0x60, 0x01, 0x98, 0x00, 0x66, 0x00, 0x11, 0x00,
  0x0C, 0x60, 0x02, 0x18, 0x01, 0x8F, 0x00, 0xC3, 0x70, 0xE0, 0xCF, 0xF0,
  0x00, 0x01, 0xF8, 0x03, 0xFE, 0x03, 0x01, 0x83, 0x00, 0x63, 0x00, 0x11,
  0x00, 0x0D, 0x80, 0x06, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x04, 0xC0,
  0x06, 0x20, 0x06, 0x18, 0x06, 0x07, 0x0E, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x01, 0xF0, 0x80, 0xFF, 0x90, 0x30, 0x16,
  0x0C, 0x01, 0xC3, 0x00, 0x38, 0x40, 0x03, 0x18, 0x00, 0x42, 0x00, 0x08,
  0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x40, 0x01, 0x08, 0x00, 0x21,
  0x00, 0x0C, 0x20, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x01, 0x81,
  0x80, 0x70, 0x1C, 0x32, 0x01, 0xFC, 0xC0, 0x00, 0xFC, 0x00, 0xFF, 0x80,
  0x70, 0x30, 0x30, 0x06, 0x18, 0x00, 0xC4, 0x00, 0x33, 0x00, 0x0C, 0x80,
  0x03, 0x60, 0x00, 0xDF, 0xFF, 0xF4, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC3,
  0x00, 0x60, 0x70, 0x70, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xFC,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7C, 0x20, 0x3F, 0xE4,
  0x0C, 0x07, 0x83, 0x00, 0x70, 0xC0, 0x0E, 0x10, 0x00, 0xC6, 0x00, 0x10,
  0x80, 0x02, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x10, 0x00, 0x62,
  0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01, 0x86,
  0x00, 0x60, 0x60, 0x1C, 0x07, 0x0C, 0x80, 0x7F, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x18, 0x01, 0x81, 0x80, 0x60, 0x1C,
  0x38, 0x01, 0xFC, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x7C,
  0x06, 0x7F, 0xC1, 0xB0, 0x18, 0x58, 0x06, 0x1C, 0x00, 0xCE, 0x00, 0x33,
  0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0x88, 0x00, 0x22, 0x00, 0x19, 0x80,
  0x06, 0x60, 0x01, 0x98, 0x00, 0x66, 0x00, 0x11, 0x00, 0x04, 0x40, 0x03,
  0x30, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38,
  0x03, 0xFC, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x61, 0x00, 0x38, 0x20, 0x0E, 0x0C, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x70,
  0x06, 0x1C, 0x00, 0x86, 0x00, 0x11, 0x80, 0x06, 0xE0, 0x00, 0xFE, 0x00,
  0x1C, 0x60, 0x03, 0x04, 0x00, 0x40, 0xC0, 0x08, 0x0C, 0x03, 0x00, 0xC0,
  0x60, 0x18, 0x0C, 0x01, 0x81, 0x00, 0x18, 0x20, 0x03, 0x0C, 0x00, 0x30,
  0x07, 0xFC, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x19, 0xE0,
  0xF0, 0x5F, 0xCF, 0xE1, 0xC1, 0xE0, 0xC6, 0x07, 0x03, 0x30, 0x18, 0x0C,
  0xC0, 0x60, 0x33, 0x01, 0x80, 0xCC, 0x04, 0x02, 0x20, 0x10, 0x08, 0x80,
  0x40, 0x26, 0x03, 0x01, 0x98, 0x0C, 0x06, 0x60, 0x30, 0x19, 0x00, 0x80,
  0x44, 0x02, 0x01, 0x10, 0x08, 0x04, 0xC0, 0x60, 0x33, 0x01, 0x80, 0xCC,
  0x06, 0x03, 0x20, 0x10, 0x08, 0x80, 0x40, 0x20, 0x18, 0x7E, 0x06, 0x7F,
  0xC1, 0x30, 0x18, 0x58, 0x06, 0x1C, 0x00, 0x8E, 0x00, 0x33, 0x00, 0x0C,
  0xC0, 0x03, 0x30, 0x00, 0x88, 0x00, 0x22, 0x00, 0x19, 0x80, 0x06, 0x60,
  0x01, 0x98, 0x00, 0x66, 0x00, 0x11, 0x00, 0x04, 0x40, 0x03, 0x30, 0x00,
  0xCC, 0x00, 0x33, 0x00, 0x08, 0xC0, 0x02, 0x00, 0x00, 0xFC, 0x00, 0xFF,
  0x80, 0x60, 0x30, 0x30, 0x06, 0x18, 0x00, 0x8C, 0x00, 0x32, 0x00, 0x0D,
  0x80, 0x03, 0x60, 0x00, 0x50, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x2C, 0x00, 0x1B, 0x00, 0x04, 0x40, 0x03, 0x18, 0x01,
  0x83, 0x00, 0xC0, 0x60, 0xE0, 0x0F, 0xE0, 0x00, 0x06, 0x3F, 0x00, 0x67,
  0xF8, 0x07, 0x80, 0xC0, 0x70, 0x06, 0x06, 0x00, 0x60, 0x40, 0x02, 0x0C,
  0x00, 0x20, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0x80, 0x02, 0x08, 0x00, 0x20,
  0x80, 0x02, 0x18, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0x41, 0x00, 0x0C,
  0x10, 0x01, 0x83, 0x80, 0x18, 0x3C, 0x03, 0x03, 0x60, 0xE0, 0x33, 0xF8,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x83,
  0xFE, 0x43, 0x01, 0xE3, 0x00, 0x73, 0x00, 0x39, 0x00, 0x0D, 0x80, 0x04,
  0x80, 0x02, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xD0, 0x00, 0x48, 0x00,
  0x24, 0x00, 0x12, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x06, 0x18,
  0x07, 0x06, 0x0C, 0x81, 0xFC, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x18,
  0x3F, 0x18, 0xFF, 0x1B, 0x80, 0x1E, 0x00, 0x14, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x07, 0x00, 0xC3,
  0x00, 0x33, 0x00, 0x19, 0x80, 0x04, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x0D, 0x00, 0x06, 0x80, 0x03, 0x60, 0x03, 0x38, 0x03, 0x0E, 0x07, 0x01,
  0xFF, 0x00, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x1F,
  0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x0F, 0xE0, 0x30, 0x00, 0xCC, 0x00, 0x23, 0x00, 0x08, 0xC0, 0x06,
  0x20, 0x01, 0x88, 0x00, 0x66, 0x00, 0x19, 0x80, 0x04, 0x60, 0x01, 0x10,
  0x00, 0xC4, 0x00, 0x31, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0x8C, 0x00,
  0x23, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x03, 0x86, 0x03, 0x41, 0xC3, 0x90,
  0x3F, 0xCC, 0x00, 0xC0, 0x00, 0x68, 0x00, 0x09, 0x80, 0x03, 0x30, 0x00,
  0xC2, 0x00, 0x18, 0x40, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x30, 0x10, 0x04,
  0x03, 0x01, 0x80, 0x60, 0x20, 0x0C, 0x0C, 0x00, 0x83, 0x00, 0x18, 0x60,
  0x03, 0x18, 0x00, 0x62, 0x00, 0x04, 0xC0, 0x00, 0xD0, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x80, 0x60, 0x18, 0x06, 0x03, 0xC0, 0x60,
  0x3C, 0x0A, 0x02, 0xC0, 0xA0, 0x6C, 0x1A, 0x04, 0xC1, 0x20, 0xCC, 0x32,
  0x0C, 0xC3, 0x20, 0x8C, 0x22, 0x18, 0xC6, 0x21, 0x0C, 0x42, 0x30, 0xCC,
  0x33, 0x0C, 0x83, 0x20, 0x48, 0x36, 0x05, 0x83, 0x40, 0x50, 0x14, 0x07,
  0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x00, 0x18, 0x00,
  0x38, 0x60, 0x01, 0x81, 0x80, 0x18, 0x0C, 0x01, 0x80, 0x30, 0x18, 0x00,
  0x81, 0x80, 0x06, 0x18, 0x00, 0x19, 0x80, 0x00, 0xD8, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0xCC, 0x00, 0x0C,
  0x30, 0x00, 0xC0, 0x80, 0x0C, 0x06, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0xC0,
  0xC0, 0x03, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x06,
  0x04, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x02, 0x00, 0x18,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x01, 0x00, 0xC0,
  0x01, 0x80, 0xC0, 0x01, 0x81, 0x80, 0x01, 0x81, 0x00, 0x00, 0x83, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x68, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x03,
  0xC0, 0x07, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x3C, 0x00,
  0x10, 0x00, 0x06, 0x08, 0x10, 0x20, 0x41, 0x83, 0x06, 0x08, 0x10, 0x20,
  0xC1, 0x83, 0x04, 0x08, 0x10, 0x60, 0xC1, 0x82, 0x04, 0x08, 0x10, 0x60,
  0xC1, 0x82, 0x04, 0x08, 0x30, 0x60, 0xC1, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0xF0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFC,
  0x00, 0xD8, 0x38, 0x04, 0x80, 0xE0, 0x6C, 0x03, 0x86, 0x40, 0x0F, 0xE0,
  0x00, 0x1E, 0x00,
};

const GFXglyph RobotoMono_ExtraLightItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 7, 28, 23, 8, -28 },
  { 26, 8, 8, 23, 9, -29 },
  { 34, 22, 28, 23, 1, -28 },
  { 111, 18, 36, 23, 3, -32 },
  { 192, 19, 28, 23, 2, -28 },
  { 259, 19, 28, 23, 2, -28 },
  { 326, 3, 8, 23, 11, -29 },
  { 329, 12, 40, 23, 7, -31 },
  { 389, 11, 40, 23, 4, -31 },
  { 444, 17, 16, 23, 5, -28 },
  { 478, 19, 20, 23, 2, -23 },
  { 526, 4, 8, 23, 5, -3 },
  { 530, 14, 1, 23, 4, -13 },
  { 532, 3, 3, 23, 9, -3 },
  { 534, 18, 30, 23, 3, -28 },
  { 602, 18, 28, 23, 3, -28 },
  { 665, 10, 28, 23, 6, -28 },
  { 700, 18, 28, 23, 1, -28 },
  { 763, 19, 28, 23, 1, -28 },
  { 830, 19, 28, 23, 1, -28 },
  { 897, 19, 28, 23, 3, -28 },
  { 964, 17, 28, 23, 2, -28 },
  { 1024, 17, 28, 23, 5, -28 },
  { 1084, 20, 28, 23, 2, -28 },
  { 1154, 17, 28, 23, 4, -28 },
  { 1214, 6, 20, 23, 10, -20 },
  { 1229, 9, 25, 23, 7, -20 },
  { 1258, 18, 16, 23, 3, -21 },
  { 1294, 18, 9, 23, 3, -17 },
  { 1315, 18, 16, 23, 2, -21 },
  { 1351, 15, 28, 23, 6, -28 },
  { 1404, 22, 28, 23, 1, -28 },
  { 1481, 19, 28, 23, 0, -28 },
  { 1548, 19, 28, 23, 2, -28 },
  { 1615, 20, 28, 23, 2, -28 },
  { 1685, 21, 28, 23, 1, -28 },
  { 1759, 20, 28, 23, 2, -28 },
  { 1829, 20, 28, 23, 2, -28 },
  { 1899, 20, 28, 23, 2, -28 },
  { 1969, 21, 28, 23, 1, -28 },
  { 2043, 20, 28, 23, 2, -28 },
  { 2113, 21, 28, 23, 1, -28 },
  { 2187, 22, 28, 23, 2, -28 },
  { 2264, 16, 28, 23, 2, -28 },
  { 2320, 22, 28, 23, 1, -28 },
  { 2397, 21, 28, 23, 1, -28 },
  { 2471, 19, 28, 23, 2, -28 },
  { 2538, 21, 28, 23, 2, -28 },
  { 2612, 20, 33, 23, 2, -28 },
  { 2695, 19, 28, 23, 2, -28 },
  { 2762, 20, 28, 23, 2, -28 },
  { 2832, 20, 28, 23, 4, -28 },
  { 2902, 20, 28, 23, 2, -28 },
  { 2972, 19, 28, 23, 4, -28 },
  { 3039, 20, 28, 23, 4, -28 },
  { 3109, 23, 28, 23, 0, -28 },
  { 3190, 19, 28, 23, 4, -28 },
  { 3257, 20, 28, 23, 1, -28 },
  { 3327, 12, 38, 23, 6, -32 },
  { 3384, 7, 30, 23, 8, -28 },
  { 3411, 12, 38, 23, 5, -32 },
  { 3468, 13, 15, 23, 5, -28 },
  { 3493, 16, 1, 23, 1, 0 },
  { 3495, 5, 5, 23, 11, -29 },
  { 3499, 18, 21, 23, 2, -21 },
  { 3547, 18, 29, 23, 2, -29 },
  { 3613, 17, 21, 23, 3, -21 },
  { 3658, 19, 29, 23, 3, -29 },
  { 3727, 18, 21, 23, 2, -21 },
  { 3775, 19, 30, 23, 5, -30 },
  { 3847, 19, 29, 23, 1, -21 },
  { 3916, 18, 29, 23, 2, -29 },
  { 3982, 16, 28, 23, 2, -28 },
  { 4038, 18, 36, 23, 0, -28 },
  { 4119, 19, 29, 23, 2, -29 },
  { 4188, 16, 29, 23, 2, -29 },
  { 4246, 22, 21, 23, 0, -21 },
  { 4304, 18, 21, 23, 2, -21 },
  { 4352, 18, 21, 23, 2, -21 },
  { 4400, 20, 29, 23, 0, -21 },
  { 4473, 17, 29, 23, 3, -21 },
  { 4535, 16, 21, 23, 5, -21 },
  { 4577, 17, 21, 23, 3, -21 },
  { 4622, 15, 26, 23, 5, -26 },
  { 4671, 18, 21, 23, 3, -21 },
  { 4719, 19, 21, 23, 3, -21 },
  { 4769, 20, 21, 23, 3, -21 },
  { 4822, 21, 21, 23, 1, -21 },
  { 4878, 24, 29, 23, -1, -21 },
  { 4965, 20, 21, 23, 1, -21 },
  { 5018, 15, 38, 23, 6, -30 },
  { 5090, 7, 34, 23, 8, -28 },
  { 5120, 15, 38, 23, 3, -30 },
  { 5192, 21, 7, 23, 1, -15 },
};

const GFXfont RobotoMono_ExtraLightItalic39pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic39pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic39pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC39PT7B_H_
