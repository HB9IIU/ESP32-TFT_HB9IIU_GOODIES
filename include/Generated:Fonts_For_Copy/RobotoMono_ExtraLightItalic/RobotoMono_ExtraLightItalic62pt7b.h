#ifndef _ROBOTOMONO_EXTRALIGHTITALIC62PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x60,
  0x18, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x3C, 0x0F, 0x03, 0x80, 0x38, 0x39, 0x81, 0x8C,
  0x0C, 0x60, 0x67, 0x03, 0x38, 0x39, 0x81, 0xCC, 0x0C, 0x60, 0x63, 0x03,
  0x38, 0x19, 0x81, 0xCC, 0x0C, 0x60, 0x60, 0x00, 0x00, 0x38, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x06, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x38, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x07, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x06, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x06, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0xF8, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x38, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x30, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0xC0, 0x00,
  0x06, 0x07, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x60, 0x70, 0x00, 0x01,
  0x81, 0xC0, 0x00, 0x06, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0xF0, 0x07, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x38, 0x0C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x06, 0x00, 0x60,
  0x06, 0x18, 0x01, 0x80, 0x38, 0xE0, 0x06, 0x00, 0xC3, 0x80, 0x18, 0x06,
  0x0C, 0x00, 0xE0, 0x38, 0x30, 0x03, 0x81, 0xC0, 0xC0, 0x0C, 0x06, 0x03,
  0x00, 0x30, 0x38, 0x0C, 0x01, 0xC1, 0xC0, 0x30, 0x06, 0x06, 0x00, 0xE0,
  0x38, 0x38, 0x01, 0xC1, 0xC1, 0xC0, 0x03, 0xFE, 0x06, 0x00, 0x07, 0xF0,
  0x30, 0x00, 0x02, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x01, 0xC0, 0xFE, 0x00, 0x0E, 0x0F, 0xFC, 0x00, 0x30, 0x70, 0x38,
  0x01, 0x81, 0x80, 0x60, 0x0E, 0x0E, 0x01, 0x80, 0x70, 0x30, 0x06, 0x01,
  0x81, 0xC0, 0x1C, 0x0E, 0x06, 0x00, 0x60, 0x70, 0x18, 0x01, 0x81, 0x80,
  0x60, 0x06, 0x0C, 0x01, 0x80, 0x18, 0x70, 0x0E, 0x00, 0x61, 0x80, 0x38,
  0x03, 0x8C, 0x00, 0xE0, 0x0C, 0x10, 0x01, 0x80, 0x70, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x01,
  0xC0, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x38, 0x00, 0x60, 0x00, 0xE0,
  0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x30, 0x01,
  0xC0, 0x00, 0xC0, 0x07, 0x00, 0x03, 0x00, 0x38, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x60, 0xF0, 0x00, 0x01, 0xC7, 0x80, 0x00,
  0x07, 0x38, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x03, 0xC7,
  0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0xC7, 0x00, 0x70,
  0x07, 0x3C, 0x01, 0xC0, 0x1C, 0xE0, 0x03, 0x80, 0x67, 0x00, 0x07, 0x03,
  0x9C, 0x00, 0x1C, 0x0E, 0x60, 0x00, 0x38, 0x33, 0x80, 0x00, 0x71, 0xCE,
  0x00, 0x01, 0xCE, 0x38, 0x00, 0x03, 0xB8, 0xE0, 0x00, 0x0F, 0xC3, 0x80,
  0x00, 0x1E, 0x0E, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x03, 0xE0, 0x70, 0x00,
  0x1F, 0xC0, 0xE0, 0x01, 0xE3, 0x81, 0xE0, 0x1F, 0x0E, 0x03, 0xFF, 0xF0,
  0x1C, 0x03, 0xFF, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x00, 0x39, 0x8C, 0x67,
  0x39, 0xCC, 0x63, 0x39, 0x8C, 0x60, 0x00, 0x00, 0x40, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x60, 0x06, 0x00, 0xDE,
  0x03, 0x81, 0xFF, 0xF0, 0xC3, 0xFC, 0x3F, 0xB3, 0xF8, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x18, 0x00, 0x0E, 0x07, 0x00, 0x07,
  0x00, 0xE0, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x00, 0xE0,
  0x18, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x07, 0x06, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C,
  0x1C, 0x38, 0x30, 0x70, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x27,
  0xBF, 0xEF, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x78, 0x07, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x30, 0x07, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x06, 0x03, 0x80, 0x00, 0x30, 0x38, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x0E, 0x1C, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x3C,
  0x70, 0x00, 0x07, 0xE3, 0x80, 0x00, 0x7B, 0x18, 0x00, 0x07, 0x39, 0xC0,
  0x00, 0x71, 0xCE, 0x00, 0x07, 0x0E, 0x70, 0x00, 0x70, 0x73, 0x80, 0x0F,
  0x03, 0x98, 0x00, 0xE0, 0x18, 0xC0, 0x0E, 0x00, 0xCE, 0x00, 0xE0, 0x0E,
  0x70, 0x0E, 0x00, 0x73, 0x81, 0xE0, 0x03, 0x9C, 0x1C, 0x00, 0x1C, 0xC1,
  0xC0, 0x00, 0xC6, 0x1C, 0x00, 0x06, 0x31, 0xC0, 0x00, 0x73, 0xBC, 0x00,
  0x03, 0x9F, 0xC0, 0x00, 0x18, 0xF8, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x0E,
  0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x30, 0x38,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x03, 0xC0, 0x38, 0x00,
  0x3C, 0x00, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x7C, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x1F,
  0x00, 0x7E, 0x01, 0xF6, 0x0F, 0xCE, 0x3F, 0x0E, 0xF8, 0x0E, 0xE0, 0x0E,
  0x80, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x03, 0x80, 0x01, 0xC0, 0x1C,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x18, 0x1C, 0x00,
  0x00, 0x60, 0x70, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xC0,
  0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x18, 0x1C,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x83, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x06,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x0E, 0x00, 0xF0,
  0x00, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3B, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x03, 0x83, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0x60, 0x00, 0x0E, 0x00, 0xC0,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x07, 0x00, 0x01, 0xC0, 0x0E, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x38, 0x00, 0x60, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x30, 0x07, 0x00,
  0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06,
  0x0F, 0xE0, 0x00, 0x0C, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7E,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x80, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0E,
  0x03, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0,
  0x1C, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0x1E, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x0F,
  0xE0, 0x03, 0x07, 0xFF, 0x00, 0xE3, 0xFB, 0xF8, 0x1D, 0xE0, 0x07, 0x83,
  0x70, 0x00, 0x70, 0xFC, 0x00, 0x07, 0x1F, 0x00, 0x00, 0xE3, 0xC0, 0x00,
  0x0E, 0x70, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x70,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x01, 0xB8, 0x00, 0x00,
  0x37, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x06, 0x70, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0E,
  0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x3C, 0x03, 0x80,
  0x0F, 0x00, 0x3C, 0x07, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x03, 0x80, 0x01,
  0xE0, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C,
  0x0C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x06,
  0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x70, 0x60, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x03, 0xC0, 0x38, 0x00,
  0x1E, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xE0, 0x0F, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x06, 0x38, 0x00,
  0x00, 0x18, 0xE0, 0x00, 0x00, 0x63, 0x80, 0x00, 0x01, 0x8E, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x78, 0x01, 0xF0, 0x0F, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x3C, 0x00, 0x70,
  0x0E, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0xF0, 0x00, 0x0E, 0x1C, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x03, 0x38, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x03, 0x70,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x03, 0x98, 0x00, 0x00,
  0xF3, 0x80, 0x00, 0x3E, 0x70, 0x00, 0x0D, 0x87, 0x00, 0x03, 0xB0, 0x70,
  0x01, 0xEE, 0x0F, 0x00, 0xF9, 0xC0, 0xFF, 0xFC, 0x30, 0x07, 0xFE, 0x0E,
  0x00, 0x3E, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0x00, 0xF0, 0x7C, 0x1F, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x78, 0x1E, 0x0F, 0x81, 0xC0, 0x00, 0x20, 0x03, 0x80, 0x3E,
  0x01, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C,
  0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x03, 0x80, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x10, 0x1F, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF0, 0x08, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7C,
  0x07, 0x81, 0xE0, 0x03, 0x87, 0x80, 0x03, 0x8E, 0x00, 0x07, 0x38, 0x00,
  0x06, 0xE0, 0x00, 0x0D, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0x80,
  0x78, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x06, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x30, 0x07, 0xE0, 0x1C, 0x0E, 0x03, 0xFF, 0x01,
  0x83, 0x80, 0xF0, 0x70, 0x30, 0x60, 0x38, 0x04, 0x06, 0x1C, 0x06, 0x01,
  0x80, 0xC3, 0x01, 0x80, 0x30, 0x18, 0xE0, 0x70, 0x06, 0x03, 0x18, 0x0C,
  0x01, 0x80, 0x63, 0x03, 0x80, 0x30, 0x0C, 0xE0, 0x60, 0x06, 0x01, 0x98,
  0x0C, 0x00, 0xC0, 0x63, 0x03, 0x00, 0x30, 0x0C, 0x60, 0x60, 0x06, 0x01,
  0x98, 0x0C, 0x00, 0xC0, 0x33, 0x03, 0x80, 0x18, 0x06, 0x60, 0x60, 0x06,
  0x01, 0x8C, 0x0C, 0x00, 0xC0, 0x31, 0x81, 0x80, 0x38, 0x06, 0x30, 0x30,
  0x07, 0x01, 0x86, 0x06, 0x01, 0xC0, 0x31, 0xC0, 0xC0, 0x38, 0x0E, 0x18,
  0x18, 0x0F, 0x01, 0x83, 0x03, 0x03, 0x70, 0x60, 0x60, 0x71, 0xC6, 0x1C,
  0x0C, 0x07, 0xF0, 0xFF, 0x01, 0x80, 0x7C, 0x0F, 0x80, 0x38, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x06, 0x00, 0x00,
  0xF8, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x03, 0x98, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x71, 0x80, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x07, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xE0,
  0x30, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x60, 0x0E,
  0x00, 0x03, 0x80, 0x18, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x70, 0x01, 0x80,
  0x01, 0x80, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x70, 0x01,
  0xC0, 0x01, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x38, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x30, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0xE0, 0x00,
  0x0E, 0x03, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x01,
  0x83, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x71,
  0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0x01, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x3F, 0x80, 0x0C, 0x00,
  0x07, 0x80, 0x18, 0x00, 0x07, 0x80, 0x30, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x1C,
  0x06, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0F, 0x00,
  0x70, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x03, 0x81, 0x80,
  0x00, 0x03, 0x07, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x0C, 0x1C, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xE0, 0xC0, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x38, 0x18, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x3E,
  0x01, 0xC0, 0x07, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0x00, 0xF8, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x01, 0xC0,
  0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x18, 0x1C,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x0C, 0x70, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x81, 0x80, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x70, 0x0C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xC0, 0x0F, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xC0,
  0x00, 0x70, 0x01, 0xC0, 0x00, 0x38, 0x01, 0x80, 0x00, 0x1C, 0x01, 0x80,
  0x00, 0x1C, 0x01, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x06, 0x03, 0x80, 0x00, 0x07, 0x03, 0x00, 0x00, 0x07, 0x03, 0x00,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0x07, 0x00,
  0x00, 0x03, 0x07, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x07, 0x06, 0x00,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x06, 0x0E, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0E, 0x0C, 0x00,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0C, 0x1C, 0x00,
  0x00, 0x1C, 0x18, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x38, 0x18, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0xE0, 0x30, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x07, 0x80, 0x70, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x70, 0x00,
  0x7C, 0x00, 0x60, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xC0, 0x1C,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x18, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x07,
  0xFF, 0xCC, 0x00, 0x1F, 0xFF, 0x30, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00,
  0x73, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x03, 0x07, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x03, 0x80, 0x78, 0x00,
  0x3C, 0x00, 0xF0, 0x07, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x06,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0x30, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x18, 0x06, 0x00,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x03, 0x80, 0x60, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x07, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0xE0, 0x18, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x70, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x01, 0x80, 0x0F, 0x00,
  0x00, 0x30, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x3C,
  0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x06, 0x03, 0xC0, 0x00, 0x00, 0xC0,
  0xF0, 0x00, 0x00, 0x18, 0x3C, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x00,
  0xE3, 0xE0, 0x00, 0x00, 0x1C, 0xFE, 0x00, 0x00, 0x03, 0x3D, 0xC0, 0x00,
  0x00, 0x6E, 0x1C, 0x00, 0x00, 0x0F, 0x83, 0x80, 0x00, 0x03, 0xE0, 0x38,
  0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x07, 0x00, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x18, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF0,
  0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xB0, 0x00, 0x0F,
  0x80, 0x6C, 0x00, 0x07, 0x60, 0x1B, 0x00, 0x01, 0xD8, 0x0E, 0xC0, 0x00,
  0xEE, 0x03, 0xB8, 0x00, 0x33, 0x80, 0xCE, 0x00, 0x1C, 0xC0, 0x31, 0x80,
  0x06, 0x30, 0x0C, 0x60, 0x03, 0x8C, 0x07, 0x18, 0x01, 0xC7, 0x01, 0xC7,
  0x00, 0x71, 0xC0, 0x71, 0xC0, 0x38, 0x70, 0x18, 0x30, 0x0E, 0x18, 0x06,
  0x0C, 0x07, 0x06, 0x01, 0x83, 0x01, 0x81, 0x80, 0xE0, 0xE0, 0xE0, 0xE0,
  0x38, 0x38, 0x30, 0x38, 0x0E, 0x06, 0x1C, 0x0E, 0x03, 0x01, 0x8E, 0x03,
  0x00, 0xC0, 0x63, 0x80, 0xC0, 0x30, 0x19, 0xC0, 0x70, 0x1C, 0x07, 0x70,
  0x1C, 0x07, 0x01, 0xF8, 0x07, 0x01, 0xC0, 0x3C, 0x01, 0xC0, 0x60, 0x0F,
  0x00, 0x60, 0x18, 0x03, 0x80, 0x18, 0x06, 0x00, 0xE0, 0x0E, 0x03, 0x80,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x60, 0x1E, 0x00, 0x00, 0x18, 0x07,
  0x80, 0x00, 0x0E, 0x01, 0xF0, 0x00, 0x03, 0x80, 0x7C, 0x00, 0x00, 0xE0,
  0x3B, 0x00, 0x00, 0x30, 0x0E, 0xE0, 0x00, 0x0C, 0x03, 0x98, 0x00, 0x03,
  0x00, 0xC6, 0x00, 0x01, 0xC0, 0x31, 0xC0, 0x00, 0x70, 0x1C, 0x30, 0x00,
  0x1C, 0x07, 0x0E, 0x00, 0x06, 0x01, 0xC3, 0x80, 0x01, 0x80, 0x70, 0x60,
  0x00, 0x60, 0x18, 0x1C, 0x00, 0x38, 0x06, 0x03, 0x00, 0x0E, 0x03, 0x80,
  0xC0, 0x03, 0x80, 0xE0, 0x38, 0x00, 0xC0, 0x38, 0x06, 0x00, 0x30, 0x0C,
  0x01, 0x80, 0x1C, 0x03, 0x00, 0x70, 0x07, 0x00, 0xC0, 0x0C, 0x01, 0xC0,
  0x70, 0x03, 0x80, 0x70, 0x1C, 0x00, 0xE0, 0x18, 0x07, 0x00, 0x18, 0x06,
  0x01, 0x80, 0x07, 0x03, 0x80, 0x60, 0x00, 0xC0, 0xE0, 0x18, 0x00, 0x30,
  0x38, 0x0E, 0x00, 0x0E, 0x0E, 0x03, 0x80, 0x01, 0x83, 0x00, 0xE0, 0x00,
  0x60, 0xC0, 0x30, 0x00, 0x1C, 0x70, 0x0C, 0x00, 0x03, 0x1C, 0x03, 0x00,
  0x00, 0xE7, 0x01, 0xC0, 0x00, 0x39, 0xC0, 0x70, 0x00, 0x06, 0x60, 0x1C,
  0x00, 0x01, 0xD8, 0x06, 0x00, 0x00, 0x3E, 0x01, 0x80, 0x00, 0x0F, 0x80,
  0xE0, 0x00, 0x03, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0C, 0x07,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x06, 0x1C, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x1C, 0xC0, 0x00, 0x00, 0x73, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x03, 0x81,
  0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x07, 0x80, 0x38,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x00, 0xF0, 0x1F, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0x80, 0x03, 0xF0, 0x01, 0x80,
  0x00, 0x78, 0x03, 0x80, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x0E, 0x03, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0E, 0x06, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x38, 0x0C, 0x00, 0x00, 0x78, 0x0C, 0x00, 0x00, 0xF0, 0x1C, 0x00,
  0x01, 0xE0, 0x1C, 0x00, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x18, 0x01, 0xC0,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x06, 0x1C, 0x00,
  0x00, 0x06, 0x1C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x06, 0x70, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x0E, 0x60, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x0C, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x70, 0x60, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0x00,
  0x1F, 0x80, 0x0E, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x07, 0x80, 0x30, 0x00,
  0x07, 0x80, 0x60, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x06, 0x03, 0x80, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00,
  0x70, 0x30, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03,
  0x03, 0x80, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x70,
  0x18, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x1E, 0x01,
  0xC0, 0x00, 0x78, 0x03, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x38, 0x00, 0x60, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0,
  0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x80, 0x06, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0xC0, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x38, 0x03, 0x00, 0x00,
  0x30, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x03,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xE0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x06, 0x07, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00,
  0x30, 0xE0, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00,
  0x60, 0x70, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0x80,
  0x60, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x71, 0x80, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x07, 0x03, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x60, 0x0E, 0x00, 0x03, 0x80,
  0x18, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x70, 0x01, 0x80, 0x01, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x70, 0x01, 0xC0, 0x01, 0xC0,
  0x07, 0x00, 0x03, 0x00, 0x38, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x30, 0x07,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x60, 0x70, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x37,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0xB0, 0x00, 0xE0, 0x01, 0x98, 0x00, 0x70, 0x01, 0xCC, 0x00, 0x78,
  0x00, 0xE6, 0x00, 0x3C, 0x00, 0x63, 0x00, 0x1E, 0x00, 0x71, 0x80, 0x1F,
  0x00, 0x38, 0xC0, 0x0D, 0x80, 0x18, 0x60, 0x06, 0xC0, 0x0C, 0x30, 0x07,
  0x60, 0x0E, 0x18, 0x03, 0x30, 0x06, 0x0C, 0x03, 0x98, 0x03, 0x06, 0x01,
  0xCC, 0x03, 0x83, 0x00, 0xC6, 0x01, 0xC1, 0x80, 0xE3, 0x00, 0xC0, 0xC0,
  0x71, 0x80, 0xE0, 0x60, 0x30, 0xC0, 0x70, 0x30, 0x38, 0x60, 0x30, 0x18,
  0x1C, 0x30, 0x18, 0x0C, 0x0C, 0x18, 0x1C, 0x06, 0x0E, 0x0C, 0x0C, 0x03,
  0x07, 0x07, 0x06, 0x01, 0x83, 0x03, 0x87, 0x01, 0xC3, 0x81, 0xC3, 0x80,
  0xE1, 0x80, 0xE1, 0x80, 0x70, 0xC0, 0x71, 0xC0, 0x38, 0xE0, 0x38, 0xE0,
  0x1C, 0x60, 0x1C, 0x60, 0x0E, 0x30, 0x0E, 0x30, 0x07, 0x38, 0x07, 0x38,
  0x03, 0x98, 0x03, 0x98, 0x01, 0xCC, 0x01, 0xCC, 0x00, 0xEE, 0x00, 0xEE,
  0x00, 0x76, 0x00, 0x37, 0x00, 0x3B, 0x00, 0x1B, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x03, 0x80, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0x03, 0x03, 0x80, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0x80,
  0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x60, 0x03,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x40,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x00,
  0x00, 0xE0, 0x06, 0x00, 0x60, 0x07, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x70, 0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x80, 0x38, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0,
  0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x70, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x3F, 0xE0, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xC6, 0x00, 0x0E, 0x30, 0x00,
  0x61, 0xC0, 0x07, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x01, 0x80, 0x38, 0x0C,
  0x01, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xC0, 0x0C, 0x0E, 0x00, 0x60, 0xE0,
  0x03, 0x86, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x00, 0x03, 0x38, 0x00, 0x19,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0,
  0xE0, 0xE1, 0xC1, 0xC1, 0x83, 0x83, 0x07, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x1E, 0x00, 0x1C, 0x03, 0xC0, 0x00,
  0xE0, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x60, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x0E, 0x0F, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x0C, 0x38, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x01, 0x8E, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x07, 0x86, 0x00, 0x00, 0xF8, 0x70, 0x00, 0x3F,
  0x87, 0x80, 0x07, 0xB8, 0x3E, 0x03, 0xE3, 0x81, 0xFF, 0xFC, 0x38, 0x07,
  0xFF, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x03, 0xFC, 0x00, 0x30,
  0xFF, 0xF0, 0x07, 0x3E, 0x0F, 0x80, 0x77, 0x00, 0x3C, 0x06, 0xE0, 0x01,
  0xC0, 0x7C, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x60, 0xF0, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x31,
  0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x71, 0x80, 0x00, 0x07, 0x18, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x06, 0x38, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E,
  0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x38, 0x78, 0x00, 0x07, 0x07, 0x80, 0x00, 0xF0, 0x7C, 0x00, 0x1E,
  0x06, 0xE0, 0x03, 0xC0, 0x67, 0x80, 0xF8, 0x0E, 0x3F, 0xFF, 0x00, 0xE0,
  0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0xF8, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x03, 0xC0, 0x01, 0xC0,
  0x78, 0x00, 0x0C, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x06, 0x1C, 0x00,
  0x00, 0x61, 0xC0, 0x00, 0x06, 0x38, 0x00, 0x00, 0x63, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x1E, 0x01,
  0xC0, 0x03, 0xC0, 0x0F, 0x00, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x07, 0xFC, 0x0C, 0x00, 0x3F, 0xFE, 0x18, 0x00, 0xF8, 0x1E, 0x70, 0x03,
  0xC0, 0x0E, 0xE0, 0x0E, 0x00, 0x0D, 0xC0, 0x38, 0x00, 0x0F, 0x80, 0xE0,
  0x00, 0x1E, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x03, 0x03, 0x80, 0x00, 0x06, 0x07, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00,
  0x38, 0x18, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x01,
  0x81, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0F, 0x00, 0x60, 0x00, 0x3E, 0x00,
  0xE0, 0x00, 0xFC, 0x00, 0xE0, 0x03, 0xB0, 0x01, 0xF0, 0x1E, 0x60, 0x01,
  0xFF, 0xF8, 0xC0, 0x00, 0xFF, 0xC3, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFC, 0x0F, 0x00, 0x1E, 0x00,
  0x38, 0x03, 0xC0, 0x01, 0xC0, 0x78, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x1C, 0x00, 0x07, 0x01, 0xE0, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x80, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x0C, 0x00,
  0x7F, 0xFC, 0x30, 0x03, 0xE0, 0x78, 0xC0, 0x1E, 0x00, 0x77, 0x00, 0xE0,
  0x00, 0xDC, 0x07, 0x00, 0x01, 0xF0, 0x38, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0xC1,
  0xC0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x70, 0x60,
  0x00, 0x01, 0x83, 0x80, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x18, 0x38, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E, 0x06, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x3C,
  0x03, 0x00, 0x01, 0xF0, 0x0E, 0x00, 0x0F, 0xC0, 0x1C, 0x00, 0x76, 0x00,
  0x7C, 0x07, 0x98, 0x00, 0xFF, 0xFC, 0x60, 0x00, 0xFF, 0xC3, 0x80, 0x00,
  0x60, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x10, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x3C, 0x01, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x1F, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x07, 0x01, 0xFF, 0x00, 0x70, 0x7F, 0xF8, 0x07, 0x1F, 0x03, 0xC0,
  0x63, 0x80, 0x1E, 0x06, 0x70, 0x00, 0xE0, 0x6C, 0x00, 0x07, 0x0F, 0x80,
  0x00, 0x70, 0xF0, 0x00, 0x03, 0x0F, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x71, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x63, 0x80, 0x00, 0x06, 0x38, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC7, 0x00, 0x00,
  0x0C, 0x70, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x01, 0xC6,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x80, 0x7C, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x3C, 0x07,
  0x00, 0x01, 0xE0, 0x1C, 0x00, 0x0F, 0x00, 0x60, 0x00, 0x70, 0x01, 0x80,
  0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x38, 0x01, 0xE0, 0x00, 0xE0, 0x0E,
  0x00, 0x03, 0x00, 0xF0, 0x00, 0x0C, 0x07, 0x80, 0x00, 0x30, 0x3C, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00,
  0x67, 0xE0, 0x00, 0x01, 0xBD, 0xC0, 0x00, 0x0F, 0xC7, 0x00, 0x00, 0x3E,
  0x0E, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x03, 0x80, 0x78, 0x00, 0x0C, 0x00,
  0xE0, 0x00, 0x30, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x78, 0x01, 0x80, 0x00, 0xE0,
  0x06, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0x0F, 0xE0, 0x3F, 0x80, 0x33, 0xFF, 0x0F, 0xFC, 0x03, 0x70, 0x79, 0xE1,
  0xE0, 0x3E, 0x03, 0xB8, 0x0E, 0x07, 0xC0, 0x1F, 0x00, 0x70, 0x78, 0x01,
  0xE0, 0x07, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC0, 0x07, 0x06,
  0x00, 0x18, 0x00, 0x70, 0xE0, 0x01, 0x80, 0x07, 0x0E, 0x00, 0x18, 0x00,
  0x60, 0xE0, 0x03, 0x80, 0x06, 0x0C, 0x00, 0x38, 0x00, 0x60, 0xC0, 0x03,
  0x80, 0x0E, 0x0C, 0x00, 0x30, 0x00, 0xE1, 0xC0, 0x03, 0x00, 0x0C, 0x1C,
  0x00, 0x70, 0x00, 0xC1, 0xC0, 0x07, 0x00, 0x0C, 0x18, 0x00, 0x70, 0x01,
  0xC1, 0x80, 0x06, 0x00, 0x1C, 0x18, 0x00, 0x60, 0x01, 0xC3, 0x80, 0x06,
  0x00, 0x18, 0x38, 0x00, 0xE0, 0x01, 0x83, 0x80, 0x0E, 0x00, 0x18, 0x30,
  0x00, 0xE0, 0x03, 0x83, 0x00, 0x0C, 0x00, 0x38, 0x30, 0x00, 0xC0, 0x03,
  0x87, 0x00, 0x0C, 0x00, 0x30, 0x70, 0x01, 0xC0, 0x03, 0x06, 0x00, 0x1C,
  0x00, 0x30, 0x60, 0x01, 0xC0, 0x07, 0x06, 0x00, 0x18, 0x00, 0x70, 0xE0,
  0x01, 0x80, 0x07, 0x00, 0x07, 0x01, 0xFE, 0x00, 0x70, 0x7F, 0xF8, 0x07,
  0x1F, 0x03, 0xC0, 0x63, 0x80, 0x1E, 0x06, 0x70, 0x00, 0xE0, 0x6C, 0x00,
  0x07, 0x0F, 0x80, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x30,
  0xE0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x71, 0x80, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x63, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0xC7, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x01, 0xC6, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x8E, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0x80, 0x3C, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x73, 0x00, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x07, 0x60, 0x00,
  0x00, 0x3B, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x39, 0x80, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x0C, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x03, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xC1, 0xFF, 0x00, 0x07, 0x1F, 0xFF, 0x00,
  0x1C, 0xF0, 0x3E, 0x00, 0x67, 0x00, 0x3C, 0x01, 0xB8, 0x00, 0x70, 0x07,
  0x80, 0x00, 0xE0, 0x1E, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x30, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x07, 0x03, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x01, 0x83, 0x80, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x07, 0x03, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x07, 0x80, 0x00,
  0xF0, 0x1F, 0x00, 0x07, 0x80, 0x6E, 0x00, 0x3C, 0x03, 0x9E, 0x03, 0xE0,
  0x0E, 0x3F, 0xFF, 0x00, 0x38, 0x3F, 0xF0, 0x00, 0xE0, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x30, 0x07, 0xFF, 0xC3, 0x00, 0xF8, 0x1E, 0x70, 0x1E, 0x00, 0x77, 0x03,
  0x80, 0x03, 0xF0, 0x70, 0x00, 0x1F, 0x0E, 0x00, 0x01, 0xE0, 0xE0, 0x00,
  0x0E, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x0C, 0x70, 0x00,
  0x01, 0xC6, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x18,
  0xE0, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03,
  0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x0F, 0x03, 0x00, 0x00, 0xF0, 0x38,
  0x00, 0x3F, 0x01, 0xC0, 0x07, 0x60, 0x1E, 0x01, 0xE6, 0x00, 0xFF, 0xFC,
  0x60, 0x03, 0xFF, 0x0E, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x07, 0x00, 0xFF, 0xC1, 0xC1, 0xFF, 0xF0, 0x70, 0xFC, 0x0C,
  0x1C, 0xF8, 0x00, 0x06, 0x78, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xF8, 0x0F,
  0x80, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x06, 0x0E,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x38, 0x70, 0x00, 0x07, 0x03, 0xC0, 0x01, 0xE0, 0x1F,
  0x00, 0x7C, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0x1E, 0x00, 0x0C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x61, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x0E, 0x18,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xC3, 0x80, 0x00,
  0x0C, 0x30, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x18, 0x70, 0x00, 0x01, 0x87, 0x00, 0x00, 0x38, 0x60, 0x00,
  0x03, 0x86, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x30,
  0xE0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1E,
  0x0E, 0x00, 0x03, 0xE0, 0x70, 0x00, 0x7E, 0x07, 0x80, 0x0E, 0xE0, 0x3C,
  0x07, 0xCE, 0x01, 0xFF, 0xF0, 0xC0, 0x0F, 0xFC, 0x0C, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x06, 0x0E, 0x00, 0x00, 0x70, 0x30, 0x00, 0x03, 0x01, 0xC0, 0x00,
  0x38, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1C, 0x01, 0x80, 0x01, 0xC0,
  0x0E, 0x00, 0x0C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x70, 0x00, 0x70, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0C, 0x03,
  0x80, 0x00, 0x60, 0x18, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x0C, 0x00,
  0x00, 0x60, 0xE0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x01, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x07, 0xC0, 0x03, 0x80,
  0x06, 0xC0, 0x07, 0x80, 0x0E, 0xC0, 0x07, 0x80, 0x0C, 0xC0, 0x07, 0x80,
  0x0C, 0xC0, 0x0D, 0x80, 0x1C, 0xC0, 0x0D, 0x80, 0x18, 0xC0, 0x1D, 0x80,
  0x38, 0xC0, 0x19, 0x80, 0x30, 0xC0, 0x39, 0x80, 0x30, 0xC0, 0x31, 0xC0,
  0x70, 0xE0, 0x31, 0xC0, 0x60, 0xE0, 0x71, 0xC0, 0xE0, 0xE0, 0x60, 0xC0,
  0xE0, 0xE0, 0xE0, 0xC0, 0xC0, 0xE0, 0xC0, 0xC1, 0xC0, 0xE0, 0xC0, 0xC1,
  0x80, 0xE1, 0x80, 0xC1, 0x80, 0xE1, 0x80, 0xC3, 0x80, 0x63, 0x80, 0xC3,
  0x00, 0x63, 0x00, 0xC7, 0x00, 0x67, 0x00, 0xC6, 0x00, 0x66, 0x00, 0xC6,
  0x00, 0x66, 0x00, 0xCE, 0x00, 0x6C, 0x00, 0xEC, 0x00, 0x6C, 0x00, 0x6C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x03, 0xC0, 0x03, 0x80,
  0x03, 0xC0, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00,
  0xE0, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x06, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00,
  0x06, 0x70, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0,
  0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18,
  0x06, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x07,
  0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0,
  0x38, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x30, 0xFF, 0xE0, 0x00, 0x1C, 0x78, 0x3E,
  0x00, 0x06, 0x38, 0x03, 0xC0, 0x03, 0x8E, 0x00, 0x78, 0x00, 0xC7, 0x00,
  0x0F, 0x00, 0x71, 0x80, 0x01, 0xE0, 0x38, 0x60, 0x00, 0x3F, 0xFC, 0x38,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00,
};

const GFXglyph RobotoMono_ExtraLightItalic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 36, 0, -1 },
  { 1, 10, 44, 36, 13, -44 },
  { 56, 13, 14, 36, 15, -47 },
  { 79, 36, 44, 36, 1, -44 },
  { 277, 30, 57, 36, 4, -51 },
  { 491, 30, 46, 36, 4, -45 },
  { 664, 30, 46, 36, 3, -45 },
  { 837, 5, 14, 36, 18, -47 },
  { 846, 19, 63, 36, 11, -49 },
  { 996, 19, 63, 36, 6, -49 },
  { 1146, 26, 25, 36, 8, -44 },
  { 1228, 29, 33, 36, 4, -37 },
  { 1348, 8, 13, 36, 7, -5 },
  { 1361, 22, 2, 36, 7, -21 },
  { 1367, 5, 5, 36, 14, -5 },
  { 1371, 29, 48, 36, 5, -44 },
  { 1545, 29, 46, 36, 4, -45 },
  { 1712, 16, 44, 36, 10, -44 },
  { 1800, 30, 45, 36, 1, -45 },
  { 1969, 30, 46, 36, 2, -45 },
  { 2142, 31, 44, 36, 1, -44 },
  { 2313, 31, 45, 36, 5, -44 },
  { 2488, 27, 46, 36, 4, -45 },
  { 2644, 28, 44, 36, 8, -44 },
  { 2798, 30, 46, 36, 4, -45 },
  { 2971, 27, 45, 36, 6, -45 },
  { 3123, 10, 32, 36, 15, -32 },
  { 3163, 13, 40, 36, 12, -32 },
  { 3228, 28, 26, 36, 5, -33 },
  { 3319, 29, 14, 36, 4, -27 },
  { 3370, 28, 25, 36, 4, -33 },
  { 3458, 23, 45, 36, 10, -45 },
  { 3588, 35, 44, 36, 1, -44 },
  { 3781, 30, 44, 36, 0, -44 },
  { 3946, 31, 44, 36, 3, -44 },
  { 4117, 30, 46, 36, 4, -45 },
  { 4290, 32, 44, 36, 2, -44 },
  { 4466, 32, 44, 36, 3, -44 },
  { 4642, 33, 44, 36, 3, -44 },
  { 4824, 30, 46, 36, 4, -45 },
  { 4997, 34, 44, 36, 2, -44 },
  { 5184, 32, 44, 36, 3, -44 },
  { 5360, 32, 45, 36, 2, -44 },
  { 5540, 35, 44, 36, 3, -44 },
  { 5733, 25, 44, 36, 4, -44 },
  { 5871, 34, 44, 36, 2, -44 },
  { 6058, 34, 44, 36, 2, -44 },
  { 6245, 30, 46, 36, 4, -45 },
  { 6418, 32, 44, 36, 4, -44 },
  { 6594, 32, 53, 36, 3, -45 },
  { 6806, 31, 44, 36, 3, -44 },
  { 6977, 32, 46, 36, 3, -45 },
  { 7161, 31, 44, 36, 7, -44 },
  { 7332, 32, 45, 36, 4, -44 },
  { 7512, 30, 44, 36, 7, -44 },
  { 7677, 33, 44, 36, 6, -44 },
  { 7859, 36, 44, 36, 1, -44 },
  { 8057, 30, 44, 36, 7, -44 },
  { 8222, 33, 44, 36, 1, -44 },
  { 8404, 19, 59, 36, 9, -50 },
  { 8545, 12, 48, 36, 12, -44 },
  { 8617, 18, 59, 36, 9, -50 },
  { 8750, 21, 24, 36, 8, -44 },
  { 8813, 26, 2, 36, 2, 0 },
  { 8820, 7, 8, 36, 18, -46 },
  { 8827, 28, 34, 36, 3, -33 },
  { 8946, 28, 48, 36, 3, -47 },
  { 9114, 28, 34, 36, 4, -33 },
  { 9233, 31, 48, 36, 4, -47 },
  { 9419, 28, 34, 36, 4, -33 },
  { 9538, 30, 47, 36, 8, -47 },
  { 9715, 30, 46, 36, 2, -33 },
  { 9888, 28, 47, 36, 3, -47 },
  { 10053, 25, 44, 36, 4, -44 },
  { 10191, 28, 57, 36, 0, -44 },
  { 10391, 30, 47, 36, 4, -47 },
  { 10568, 25, 47, 36, 4, -47 },
  { 10715, 36, 33, 36, -1, -33 },
  { 10864, 28, 33, 36, 3, -33 },
  { 10980, 29, 34, 36, 3, -33 },
  { 11104, 30, 46, 36, 1, -33 },
  { 11277, 28, 46, 36, 4, -33 },
  { 11438, 26, 33, 36, 8, -33 },
  { 11546, 28, 34, 36, 4, -33 },
  { 11665, 23, 42, 36, 8, -41 },
  { 11786, 28, 34, 36, 5, -33 },
  { 11905, 29, 33, 36, 6, -33 },
  { 12025, 32, 33, 36, 5, -33 },
  { 12157, 33, 33, 36, 1, -33 },
  { 12294, 37, 46, 36, -1, -33 },
  { 12507, 32, 33, 36, 1, -33 },
  { 12639, 23, 61, 36, 10, -48 },
  { 12815, 10, 53, 36, 13, -44 },
  { 12882, 24, 61, 36, 5, -48 },
  { 13065, 34, 11, 36, 1, -24 },
};

const GFXfont RobotoMono_ExtraLightItalic62pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic62pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic62pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC62PT7B_H_
