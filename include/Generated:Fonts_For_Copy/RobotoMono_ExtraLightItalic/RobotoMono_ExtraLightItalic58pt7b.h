#ifndef _ROBOTOMONO_EXTRALIGHTITALIC58PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03,
  0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x80,
  0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0xE0,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x0F, 0x03, 0xC0, 0xE0, 0x00, 0x30, 0x33, 0x07, 0x30, 0x73, 0x06, 0x70,
  0x66, 0x06, 0x60, 0x66, 0x0E, 0x60, 0xCE, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0,
  0xC0, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00,
  0x70, 0x06, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x30, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x18, 0x01, 0x81, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x1C, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0xE0,
  0x0C, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00,
  0x38, 0x03, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x70,
  0x06, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFB, 0xF0,
  0x00, 0x78, 0x03, 0x80, 0x1E, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x38,
  0x00, 0x0E, 0x03, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x03,
  0x0E, 0x00, 0x00, 0x70, 0x60, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x1C, 0x0C, 0x00, 0x07, 0x01, 0x80, 0x00, 0xC0, 0x38, 0x02, 0x18, 0x03,
  0x00, 0x66, 0x00, 0x60, 0x18, 0xC0, 0x0C, 0x07, 0x18, 0x03, 0x00, 0xC3,
  0x00, 0x60, 0x30, 0x60, 0x0C, 0x0E, 0x0C, 0x01, 0x81, 0x81, 0x80, 0x60,
  0x60, 0x30, 0x0C, 0x1C, 0x07, 0x03, 0x07, 0x00, 0x60, 0xE0, 0xC0, 0x0F,
  0xF8, 0x30, 0x00, 0x7C, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x38, 0x3F, 0x80, 0x0E, 0x0F, 0xF8, 0x01, 0x83, 0x83, 0x00, 0x60, 0xE0,
  0x30, 0x1C, 0x18, 0x06, 0x03, 0x07, 0x00, 0xC0, 0xC0, 0xC0, 0x18, 0x38,
  0x18, 0x03, 0x0E, 0x03, 0x00, 0x61, 0x80, 0xE0, 0x0C, 0x60, 0x18, 0x01,
  0x9C, 0x03, 0x00, 0x73, 0x00, 0x60, 0x0C, 0x40, 0x0E, 0x01, 0x80, 0x00,
  0xC0, 0x60, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xCF, 0x80, 0x00, 0x38, 0x0C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x38,
  0x01, 0x80, 0x01, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xE0, 0x03,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x30, 0x01, 0xC0, 0x01, 0x80, 0x1C, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x0C,
  0x1C, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x01, 0xBC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x07, 0x18, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x18, 0x70,
  0x0C, 0x00, 0xC7, 0x00, 0x70, 0x0E, 0x30, 0x01, 0xC0, 0x63, 0x80, 0x0E,
  0x03, 0x18, 0x00, 0x38, 0x39, 0xC0, 0x00, 0xC1, 0x8E, 0x00, 0x07, 0x1C,
  0x60, 0x00, 0x1D, 0xC3, 0x00, 0x00, 0x6E, 0x18, 0x00, 0x03, 0xE0, 0xE0,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x0F, 0xC0, 0xF0, 0x01,
  0xE7, 0x03, 0xC0, 0x3E, 0x38, 0x0F, 0xFF, 0xC0, 0xE0, 0x1F, 0xF8, 0x03,
  0x80, 0x0A, 0x00, 0x00, 0x33, 0x37, 0x66, 0x66, 0xEC, 0xCC, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x80, 0x18,
  0x03, 0xF0, 0x18, 0x0F, 0xFE, 0x18, 0x7F, 0x1F, 0x9B, 0xF8, 0x03, 0xFF,
  0xC0, 0x00, 0x7E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xCE,
  0x00, 0x03, 0x86, 0x00, 0x07, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x0E, 0x03,
  0x80, 0x1C, 0x01, 0xC0, 0x78, 0x00, 0xE0, 0x30, 0x00, 0xE0, 0x10, 0x00,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x1C,
  0x30, 0x60, 0xC3, 0x87, 0x0C, 0x38, 0xE1, 0x87, 0x04, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x77, 0xBD, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xF8, 0xF8,
  0x00, 0x78, 0x03, 0x80, 0x1E, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0xE0,
  0x00, 0x30, 0x38, 0x00, 0x06, 0x06, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C,
  0x30, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x71, 0x80, 0x00, 0x1E, 0x30, 0x00,
  0x07, 0xCE, 0x00, 0x03, 0x99, 0xC0, 0x00, 0xE7, 0x30, 0x00, 0x38, 0xE6,
  0x00, 0x0E, 0x1C, 0xC0, 0x03, 0x83, 0xB8, 0x00, 0xE0, 0x67, 0x00, 0x70,
  0x0C, 0xE0, 0x1C, 0x01, 0x98, 0x07, 0x00, 0x73, 0x01, 0xC0, 0x0E, 0x60,
  0x70, 0x01, 0xDC, 0x38, 0x00, 0x33, 0x8E, 0x00, 0x06, 0x73, 0x80, 0x01,
  0xCE, 0xE0, 0x00, 0x39, 0xF8, 0x00, 0x06, 0x3E, 0x00, 0x00, 0xC7, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x06, 0x1C, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x30,
  0x30, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x80, 0x60, 0x00, 0xE0, 0x0E, 0x00,
  0x38, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x7C, 0x03, 0xF8, 0x1F, 0x61,
  0xF8, 0xCF, 0x81, 0xBC, 0x03, 0x60, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0x80, 0x38, 0x00,
  0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x30, 0x00,
  0x06, 0x07, 0x00, 0x00, 0x60, 0x60, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x60,
  0xE0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0xF8, 0x03, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x30, 0x07, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x38, 0x00, 0x01,
  0x81, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x38, 0x60, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x03, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x1F,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x73, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x0C,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x38, 0x18, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x80, 0x60, 0x00, 0x18,
  0x03, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x0E,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0xE0, 0x00, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00,
  0x03, 0x80, 0x60, 0x00, 0x18, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE3, 0xFC,
  0x00, 0x0D, 0xFF, 0xF0, 0x00, 0xFE, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x78, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x3F, 0x80,
  0x1C, 0x7F, 0xF8, 0x06, 0x3E, 0x0F, 0x01, 0xBC, 0x00, 0xE0, 0xFC, 0x00,
  0x1C, 0x3E, 0x00, 0x03, 0x0F, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x39, 0xC0,
  0x00, 0x06, 0x70, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x06, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x39, 0x80, 0x00, 0x0E, 0x60, 0x00, 0x03, 0x1C, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x06, 0x00, 0x0F, 0x01,
  0xC0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x38, 0x07, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x38, 0x18, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x03, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01,
  0xC0, 0x60, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x00,
  0x78, 0x01, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0xF0, 0x00, 0xE0, 0x0F, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0x87,
  0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00,
  0x60, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x70, 0x03, 0xE0, 0x0F, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x7E, 0x7E, 0x00, 0x78, 0x07, 0x80, 0x70, 0x01, 0xC0, 0x70, 0x00,
  0x70, 0x70, 0x00, 0x18, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x38, 0x00,
  0x01, 0x9C, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x60,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x79, 0xC0, 0x00, 0x78, 0xE0, 0x00, 0x6C, 0x38, 0x00, 0xE6,
  0x0E, 0x01, 0xE7, 0x03, 0xFF, 0xE3, 0x00, 0xFF, 0xC3, 0x80, 0x04, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x1E,
  0x1F, 0x07, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0,
  0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x0E, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x30, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0x7E, 0x03, 0xC0, 0x3C, 0x1C, 0x00,
  0x70, 0xE0, 0x00, 0xE7, 0x00, 0x01, 0x9C, 0x00, 0x06, 0x60, 0x00, 0x1B,
  0x80, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xF0, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x18,
  0x01, 0xC0, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x03, 0x01, 0xC0, 0x3E, 0x01,
  0x80, 0xC0, 0x3F, 0xC0, 0xC0, 0xE0, 0x78, 0x70, 0x30, 0x60, 0x70, 0x18,
  0x18, 0x60, 0x30, 0x08, 0x0C, 0x30, 0x30, 0x0C, 0x06, 0x30, 0x38, 0x06,
  0x03, 0x18, 0x18, 0x03, 0x01, 0x1C, 0x1C, 0x01, 0x01, 0x8C, 0x0C, 0x01,
  0x80, 0xC6, 0x06, 0x00, 0xC0, 0x67, 0x06, 0x00, 0x60, 0x33, 0x03, 0x00,
  0x60, 0x19, 0x81, 0x80, 0x30, 0x08, 0xC0, 0xC0, 0x18, 0x0C, 0x60, 0xC0,
  0x0C, 0x06, 0x30, 0x60, 0x0C, 0x03, 0x30, 0x30, 0x06, 0x03, 0x18, 0x18,
  0x07, 0x01, 0x8C, 0x0C, 0x07, 0x81, 0x86, 0x06, 0x06, 0xC0, 0xC3, 0x83,
  0x87, 0x60, 0xC0, 0xC0, 0xE7, 0x38, 0xE0, 0x60, 0x7F, 0x0F, 0xC0, 0x30,
  0x0E, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x20, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x3B, 0x00, 0x00,
  0x01, 0x9C, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0E,
  0x18, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x38, 0x30,
  0x00, 0x01, 0x81, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x0E, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x07, 0x00, 0x60, 0x00, 0x30,
  0x03, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x18, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0xE0, 0x00, 0xC0, 0x06, 0x00, 0x06, 0x00,
  0x70, 0x00, 0x30, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0x80,
  0x00, 0x30, 0x1C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x0E, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x03, 0x07, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0x38, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF0, 0x03, 0x80, 0x0F, 0x80, 0x38, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xE0,
  0x30, 0x00, 0x07, 0x03, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x07, 0x00,
  0x00, 0x30, 0x70, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x07,
  0x06, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x1C, 0x0C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0xF0, 0x0C, 0x00, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xC0, 0x01, 0xE0, 0x18,
  0x00, 0x07, 0x01, 0x80, 0x00, 0x38, 0x18, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x38, 0x60, 0x00, 0x07, 0x06, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0xC0, 0xE0, 0x01, 0xF8, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x01, 0xC0,
  0x3C, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x06, 0x0E, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x71, 0x80, 0x00, 0x03,
  0x38, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x07, 0x0C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x06, 0x00, 0x00, 0xC0,
  0x70, 0x00, 0x1C, 0x03, 0x00, 0x03, 0x80, 0x38, 0x00, 0xF0, 0x01, 0xE0,
  0x1E, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x18, 0x00, 0xF8,
  0x00, 0x60, 0x00, 0xF0, 0x01, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0x80,
  0x38, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x38, 0x0C,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x1C, 0x18, 0x00, 0x00, 0x70, 0x60, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x61,
  0xC0, 0x00, 0x01, 0x87, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x38, 0x60,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x07, 0x06, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x60, 0xE0, 0x00, 0x03, 0x83, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00,
  0x70, 0x30, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x07, 0x80, 0x60, 0x00, 0x3C, 0x01, 0x80, 0x03, 0xC0, 0x06,
  0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xF8, 0x07, 0x80, 0x0F, 0x00,
  0x0E, 0x00, 0xF0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x06,
  0x07, 0x00, 0x00, 0x38, 0x30, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x3F, 0xFC, 0x60, 0x03,
  0xFF, 0xE7, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x63, 0x80, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x38, 0x60, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x03, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x70, 0x30,
  0x00, 0x00, 0xE0, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x03, 0x80,
  0x00, 0x06, 0x07, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x38, 0x18, 0x00,
  0x00, 0x70, 0x30, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x81, 0xC0, 0x00,
  0x03, 0x03, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0xC0,
  0xE0, 0x00, 0x03, 0x81, 0x80, 0x00, 0x07, 0x03, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x01, 0xC0, 0xC0, 0x00, 0x03, 0x81, 0x80, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x0C, 0x0E, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x83, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x00, 0xC0, 0xE0, 0x00, 0x07, 0x01, 0x80, 0x00, 0x18, 0x06, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0x30, 0x00, 0x38, 0x00, 0xE0, 0x01,
  0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0F, 0x01, 0x80, 0x00,
  0x1E, 0x01, 0x80, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x78, 0x03, 0x80, 0x00,
  0xF0, 0x03, 0x00, 0x01, 0xE0, 0x03, 0x00, 0x03, 0xC0, 0x03, 0x00, 0x07,
  0x80, 0x03, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x70, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x06, 0x01, 0xC0,
  0x00, 0x06, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x0C, 0x1C, 0x00, 0x00, 0x0C, 0x3C, 0x00, 0x00, 0x0C, 0x7C, 0x00,
  0x00, 0x0C, 0xEE, 0x00, 0x00, 0x1D, 0xCE, 0x00, 0x00, 0x1F, 0x87, 0x00,
  0x00, 0x1F, 0x03, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x18, 0x01, 0xC0,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x07, 0x00, 0x60, 0x00, 0x03,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x36,
  0x03, 0x60, 0x00, 0x76, 0x03, 0x60, 0x00, 0x6E, 0x03, 0x70, 0x00, 0xEC,
  0x03, 0x30, 0x00, 0xCC, 0x07, 0x30, 0x01, 0xCC, 0x07, 0x30, 0x03, 0x8C,
  0x06, 0x30, 0x03, 0x1C, 0x06, 0x38, 0x07, 0x1C, 0x06, 0x18, 0x06, 0x18,
  0x0E, 0x18, 0x0E, 0x18, 0x0E, 0x18, 0x0C, 0x18, 0x0E, 0x18, 0x1C, 0x18,
  0x0C, 0x1C, 0x18, 0x38, 0x0C, 0x1C, 0x38, 0x38, 0x0C, 0x0C, 0x70, 0x30,
  0x1C, 0x0C, 0x60, 0x30, 0x1C, 0x0C, 0xE0, 0x30, 0x1C, 0x0C, 0xC0, 0x70,
  0x18, 0x0F, 0xC0, 0x70, 0x18, 0x07, 0x80, 0x70, 0x18, 0x07, 0x80, 0x60,
  0x38, 0x07, 0x00, 0x60, 0x38, 0x06, 0x00, 0x60, 0x30, 0x00, 0x00, 0xE0,
  0x30, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0xC0,
  0x70, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0x80,
  0xE0, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x00, 0x06, 0x03, 0x80, 0x00, 0x0C, 0x0F, 0x00, 0x00, 0x38,
  0x1F, 0x00, 0x00, 0x70, 0x36, 0x00, 0x00, 0xE0, 0x6C, 0x00, 0x01, 0x80,
  0xDC, 0x00, 0x03, 0x01, 0x98, 0x00, 0x06, 0x07, 0x30, 0x00, 0x1C, 0x0E,
  0x70, 0x00, 0x38, 0x18, 0x60, 0x00, 0x60, 0x30, 0xC0, 0x00, 0xC0, 0x61,
  0xC0, 0x01, 0x81, 0xC1, 0x80, 0x03, 0x03, 0x83, 0x80, 0x0E, 0x07, 0x03,
  0x00, 0x1C, 0x0C, 0x06, 0x00, 0x30, 0x18, 0x0E, 0x00, 0x60, 0x30, 0x0C,
  0x00, 0xC0, 0xE0, 0x18, 0x01, 0x81, 0xC0, 0x38, 0x07, 0x03, 0x80, 0x30,
  0x0E, 0x06, 0x00, 0x60, 0x18, 0x0C, 0x00, 0x60, 0x30, 0x18, 0x00, 0xC0,
  0x60, 0x70, 0x01, 0xC1, 0xC0, 0xE0, 0x01, 0x83, 0x81, 0x80, 0x03, 0x07,
  0x03, 0x00, 0x07, 0x0C, 0x06, 0x00, 0x06, 0x18, 0x0C, 0x00, 0x0C, 0x30,
  0x38, 0x00, 0x1C, 0xE0, 0x70, 0x00, 0x19, 0xC0, 0xC0, 0x00, 0x3B, 0x81,
  0x80, 0x00, 0x36, 0x03, 0x00, 0x00, 0x6C, 0x06, 0x00, 0x00, 0xF8, 0x1C,
  0x00, 0x00, 0xF0, 0x38, 0x00, 0x01, 0xE0, 0x60, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xF0, 0x07, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0xF0, 0x00,
  0x70, 0x07, 0x00, 0x01, 0x80, 0x70, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x70,
  0x30, 0x00, 0x01, 0x83, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x61, 0xC0,
  0x00, 0x03, 0x0E, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x06, 0x38, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x67, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x0C,
  0x70, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x03, 0x83, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0x60, 0x00,
  0x1C, 0x03, 0x80, 0x01, 0xC0, 0x0C, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x01, 0xE0, 0x3C, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x06,
  0x00, 0x07, 0x80, 0x0C, 0x00, 0x03, 0x80, 0x18, 0x00, 0x03, 0x80, 0x30,
  0x00, 0x03, 0x00, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x00,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x38, 0x00,
  0x00, 0x60, 0x70, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x03, 0x81, 0x80, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x03, 0x80, 0x60, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x78,
  0x01, 0x80, 0x0F, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x06, 0x07,
  0x00, 0x00, 0x30, 0x70, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0xDC,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x03, 0xB0, 0x00,
  0x00, 0x1D, 0x80, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x73, 0x00, 0x00, 0x03, 0x1C, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x00,
  0x70, 0x01, 0xE0, 0x01, 0xE0, 0x3E, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x04, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x60, 0x01, 0xE0, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x38, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x70,
  0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x0C, 0x0E, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x0E, 0x03, 0x00, 0x00,
  0xE0, 0x18, 0x00, 0x0E, 0x00, 0xC0, 0x01, 0xE0, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x60, 0x03, 0x80, 0x03,
  0x80, 0x18, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x60, 0x06, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x60, 0x18, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x1C, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x0C, 0x1C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xF7, 0xE0, 0x00, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x30, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x06, 0x1C, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x1C, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x07, 0xFF,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x03, 0x86, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x06, 0x1C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x86, 0x00, 0x00,
  0x1C, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x30,
  0xE0, 0x00, 0x03, 0x86, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0xE1, 0x80,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x01, 0x87, 0x00, 0x00,
  0x1C, 0x30, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x01, 0x87, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0xE1, 0x80,
  0x00, 0x07, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x1C, 0x18, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x07, 0x80, 0x1C,
  0x00, 0x78, 0x00, 0x78, 0x0F, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3B, 0x00, 0x00,
  0x03, 0x98, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x03, 0x81, 0x80, 0x00, 0x18, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x0C, 0x03, 0x80, 0x00, 0xE0, 0x0C, 0x00, 0x06, 0x00, 0x60, 0x00, 0x70,
  0x03, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x07,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x0E, 0x00, 0x06, 0x00,
  0x70, 0x00, 0x30, 0x03, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x01, 0x80,
  0x00, 0x30, 0x1C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x0E, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x03, 0x07, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x03, 0x00, 0x0F, 0x80, 0x0C, 0x00, 0x7E, 0x00, 0x70, 0x01, 0xB0, 0x01,
  0xC0, 0x06, 0xC0, 0x0F, 0x00, 0x3B, 0x00, 0x3C, 0x00, 0xCC, 0x00, 0xF0,
  0x03, 0x30, 0x07, 0xE0, 0x0C, 0xC0, 0x1B, 0x80, 0x73, 0x00, 0x6E, 0x01,
  0x8C, 0x03, 0xB8, 0x06, 0x30, 0x0C, 0x60, 0x38, 0xC0, 0x31, 0x80, 0xC3,
  0x01, 0xC6, 0x03, 0x0C, 0x06, 0x18, 0x1C, 0x30, 0x18, 0x60, 0x60, 0xC0,
  0xE1, 0x81, 0x83, 0x03, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x38, 0x30, 0x70,
  0x60, 0xC0, 0xC1, 0x81, 0x83, 0x03, 0x06, 0x06, 0x1C, 0x0C, 0x38, 0x18,
  0x60, 0x30, 0xC0, 0x61, 0x80, 0xC3, 0x01, 0x8E, 0x03, 0x1C, 0x06, 0x30,
  0x0C, 0x60, 0x18, 0xC0, 0x31, 0x80, 0x63, 0x00, 0xCE, 0x01, 0x98, 0x03,
  0x30, 0x06, 0x60, 0x0D, 0xC0, 0x19, 0x80, 0x37, 0x00, 0x6E, 0x00, 0xD8,
  0x01, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x0F, 0x00, 0x1F, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x70, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x30, 0x0E, 0x00,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0xEC,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x70, 0x0C, 0x00,
  0x00, 0x38, 0x03, 0x80, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x0E, 0x00,
  0x00, 0x30, 0x07, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x38, 0x60, 0x00, 0x01, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x0C, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x0E,
  0x00, 0x60, 0x00, 0x60, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x60, 0x03, 0x00, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x60,
  0x18, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x03, 0x0E, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x70,
  0x06, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xB0, 0x00, 0x3B, 0x00, 0x03, 0x30, 0x00, 0x73,
  0x80, 0x06, 0x18, 0x00, 0xE1, 0x80, 0x1C, 0x18, 0x01, 0x81, 0x80, 0x38,
  0x1C, 0x03, 0x00, 0xC0, 0x70, 0x0C, 0x06, 0x00, 0xC0, 0xE0, 0x0E, 0x1C,
  0x00, 0x61, 0x80, 0x06, 0x38, 0x00, 0x63, 0x00, 0x07, 0x70, 0x00, 0x7E,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC1, 0xC1, 0x83,
  0x83, 0x03, 0x07, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0x81,
  0xF0, 0x07, 0x00, 0x1E, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x00, 0x70, 0xE0,
  0x00, 0x1C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x0F, 0xC0, 0x03, 0x87, 0x80,
  0x00, 0xE3, 0x80, 0x00, 0x31, 0xC0, 0x00, 0x0C, 0x70, 0x00, 0x03, 0x18,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x0E,
  0x38, 0x00, 0x07, 0x86, 0x00, 0x07, 0x61, 0xC0, 0x03, 0x98, 0x3C, 0x03,
  0xC6, 0x07, 0xFF, 0xE1, 0x80, 0xFF, 0xC0, 0x60, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x81, 0xFC, 0x00, 0x61, 0xFF, 0xC0,
  0x19, 0xE0, 0x78, 0x06, 0xE0, 0x07, 0x03, 0xF0, 0x00, 0xE0, 0xF0, 0x00,
  0x38, 0x3C, 0x00, 0x06, 0x0E, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x0C, 0x70, 0x00, 0x03, 0x1C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x18, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x1C, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x03, 0x8C, 0x00,
  0x00, 0xE3, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x06, 0x1C,
  0x00, 0x03, 0x87, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0xF0, 0xEC, 0x00, 0x78,
  0x3B, 0xC0, 0x7C, 0x0E, 0x7F, 0xFC, 0x03, 0x07, 0xFE, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0x03, 0xE0,
  0x0F, 0x00, 0x38, 0x07, 0x80, 0x07, 0x03, 0xC0, 0x00, 0xE0, 0xE0, 0x00,
  0x38, 0x70, 0x00, 0x06, 0x18, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x19, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x61, 0x80, 0x00, 0x38, 0x60, 0x00, 0x0C, 0x1C,
  0x00, 0x07, 0x03, 0x00, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x1E, 0x01, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0xE0,
  0x60, 0x03, 0xFF, 0xC3, 0x00, 0x3E, 0x0F, 0x38, 0x03, 0xC0, 0x1D, 0xC0,
  0x38, 0x00, 0x7E, 0x03, 0x80, 0x01, 0xE0, 0x18, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x06, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x03, 0x03, 0x80, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC1,
  0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xF0, 0x0E, 0x00, 0x0F, 0x80, 0x38,
  0x00, 0xFC, 0x00, 0xE0, 0x1E, 0xC0, 0x03, 0xFF, 0xC6, 0x00, 0x0F, 0xFC,
  0x30, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0x03, 0xE0, 0x0F, 0x00, 0x38, 0x07, 0x80, 0x07, 0x03, 0xC0,
  0x00, 0xE0, 0xE0, 0x00, 0x18, 0x70, 0x00, 0x06, 0x38, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1C, 0x00, 0x01, 0x03, 0x80, 0x01, 0xE0, 0x70, 0x00,
  0xF0, 0x0E, 0x00, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xE0,
  0x10, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x30, 0x03, 0xFF, 0xC3, 0x00, 0x7C, 0x1E, 0x30, 0x0F,
  0x00, 0x77, 0x01, 0xC0, 0x03, 0xF0, 0x38, 0x00, 0x1E, 0x03, 0x80, 0x00,
  0xE0, 0x70, 0x00, 0x0E, 0x06, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0C,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x0C, 0x18, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x18, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x38, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x30,
  0x18, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x1F, 0x00, 0xE0,
  0x03, 0xF0, 0x07, 0x00, 0xF7, 0x00, 0x3F, 0xFC, 0x60, 0x01, 0xFF, 0x86,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x06, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x07, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0xFF, 0x00, 0x60, 0xFF, 0xE0, 0x18, 0xF8, 0x3C, 0x0E,
  0x70, 0x03, 0x83, 0xB0, 0x00, 0x60, 0xD8, 0x00, 0x1C, 0x3C, 0x00, 0x03,
  0x0E, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x31, 0xC0, 0x00, 0x0C, 0x70, 0x00,
  0x03, 0x18, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x71, 0x80, 0x00, 0x1C, 0xE0,
  0x00, 0x07, 0x38, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x0E, 0x30, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x31, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x18, 0x00, 0x01, 0xC6, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x18, 0xE0, 0x00, 0x06, 0x38, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x38, 0x00, 0x00, 0x10, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x0F, 0x06, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x78, 0x0E,
  0x00, 0x0F, 0x00, 0xE0, 0x01, 0xC0, 0x0C, 0x00, 0x38, 0x00, 0xC0, 0x0F,
  0x00, 0x0C, 0x01, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x01,
  0xC1, 0xE0, 0x00, 0x18, 0x3C, 0x00, 0x01, 0x87, 0x00, 0x00, 0x18, 0xE0,
  0x00, 0x03, 0xBF, 0x00, 0x00, 0x3F, 0xB8, 0x00, 0x03, 0xE3, 0x80, 0x00,
  0x3C, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x30, 0x0E, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x70, 0x03, 0x80, 0x06, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0,
  0x06, 0x00, 0x0E, 0x00, 0x60, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x38, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x1C, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0x1F, 0xC0, 0xFE, 0x00, 0xCF, 0xF8, 0x7F, 0xC0, 0x7F, 0x0F,
  0x78, 0x78, 0x1B, 0x01, 0xD8, 0x06, 0x07, 0x80, 0x3C, 0x01, 0x81, 0xC0,
  0x0E, 0x00, 0x70, 0x60, 0x03, 0x80, 0x1C, 0x18, 0x00, 0xC0, 0x06, 0x0E,
  0x00, 0x30, 0x01, 0x83, 0x00, 0x1C, 0x00, 0x60, 0xC0, 0x07, 0x00, 0x18,
  0x30, 0x01, 0x80, 0x06, 0x0C, 0x00, 0x60, 0x03, 0x87, 0x00, 0x18, 0x00,
  0xE1, 0xC0, 0x06, 0x00, 0x30, 0x60, 0x03, 0x80, 0x0C, 0x18, 0x00, 0xE0,
  0x03, 0x06, 0x00, 0x30, 0x01, 0xC1, 0x80, 0x0C, 0x00, 0x70, 0xE0, 0x03,
  0x00, 0x18, 0x38, 0x00, 0xC0, 0x06, 0x0C, 0x00, 0x70, 0x01, 0x83, 0x00,
  0x1C, 0x00, 0x60, 0xC0, 0x06, 0x00, 0x38, 0x30, 0x01, 0x80, 0x0E, 0x1C,
  0x00, 0x60, 0x03, 0x07, 0x00, 0x18, 0x00, 0xC1, 0x80, 0x0E, 0x00, 0x30,
  0x60, 0x03, 0x80, 0x0C, 0x18, 0x00, 0xC0, 0x07, 0x0E, 0x00, 0x30, 0x01,
  0xC0, 0x06, 0x03, 0xFC, 0x01, 0x83, 0xFF, 0x80, 0x63, 0xC0, 0xF0, 0x39,
  0xC0, 0x0E, 0x0C, 0xC0, 0x01, 0x83, 0x60, 0x00, 0x70, 0xF0, 0x00, 0x1C,
  0x38, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x31, 0xC0, 0x00,
  0x0C, 0x60, 0x00, 0x03, 0x18, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x18, 0xE0, 0x00, 0x06, 0x38, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x38, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x1C, 0x00, 0x00,
  0xC7, 0x00, 0x00, 0x31, 0x80, 0x00, 0x1C, 0x60, 0x00, 0x07, 0x18, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x63, 0x80, 0x00, 0x18, 0xE0, 0x00, 0x06, 0x30,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xE0, 0x78, 0x00, 0xF0, 0x03, 0x80, 0x38, 0x00, 0x38, 0x0E,
  0x00, 0x03, 0x03, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x06, 0x1C, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x37, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x03, 0x70, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x07, 0x18, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x06, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x70, 0x0E, 0x00, 0x3C, 0x00, 0xE0, 0x1F, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x81, 0xFC, 0x00, 0x18, 0xFF,
  0xF0, 0x01, 0x9E, 0x07, 0x80, 0x1B, 0x80, 0x1C, 0x03, 0xF0, 0x00, 0xE0,
  0x3C, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x60, 0x38, 0x00, 0x07, 0x03, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x30, 0x70, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0xE0,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0C, 0x1C,
  0x00, 0x01, 0xC1, 0x80, 0x00, 0x18, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x70, 0x1E, 0x00, 0x0E, 0x03, 0xF0, 0x01, 0xE0, 0x3B, 0x80, 0x7C, 0x03,
  0x9F, 0xFF, 0x00, 0x30, 0x7F, 0xE0, 0x03, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0xC0, 0x3F, 0xFC, 0x30, 0x1F, 0x03, 0x8C, 0x0F,
  0x00, 0x77, 0x07, 0x00, 0x07, 0xC3, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x38,
  0x70, 0x00, 0x0E, 0x38, 0x00, 0x01, 0x8E, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x0C, 0x70, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x30, 0x60, 0x00, 0x1C, 0x1C, 0x00,
  0x0F, 0x07, 0x00, 0x07, 0xC0, 0xE0, 0x03, 0xF0, 0x1C, 0x03, 0xD8, 0x03,
  0xFF, 0xC6, 0x00, 0x7F, 0xE1, 0x80, 0x03, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x03, 0x00, 0xFF,
  0x83, 0x83, 0xFF, 0xC1, 0xC7, 0xE0, 0x40, 0xC7, 0x80, 0x00, 0x67, 0x00,
  0x00, 0x37, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0x01, 0xE0, 0x1E, 0x00, 0x1C, 0x07,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x73, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x06, 0x38, 0x00, 0x03, 0x87, 0x00,
  0x00, 0xE1, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0xF8, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0x40, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x00, 0xE1,
  0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x61, 0xC0, 0x00,
  0x1C, 0x38, 0x00, 0x03, 0x86, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x0C, 0x18,
  0x00, 0x01, 0x87, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0x38, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x18, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x1C,
  0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00,
  0x03, 0x83, 0x00, 0x00, 0x70, 0x60, 0x00, 0x1C, 0x0C, 0x00, 0x07, 0x81,
  0xC0, 0x01, 0xB0, 0x1C, 0x00, 0x76, 0x03, 0xC0, 0x3D, 0xC0, 0x3F, 0xFE,
  0x38, 0x01, 0xFF, 0x06, 0x00, 0x04, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x38, 0x30, 0x00, 0x03, 0x03, 0x80, 0x00, 0x70,
  0x38, 0x00, 0x0E, 0x01, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x1C, 0x01, 0xC0,
  0x01, 0x80, 0x1C, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70,
  0x00, 0xE0, 0x06, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x60, 0x1C, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x00, 0x00, 0x30, 0x70,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x03, 0x00,
  0x0F, 0xC0, 0x06, 0x00, 0x1B, 0x80, 0x0E, 0x00, 0x77, 0x00, 0x3C, 0x00,
  0xCE, 0x00, 0x78, 0x01, 0x8C, 0x01, 0xB0, 0x07, 0x18, 0x03, 0x60, 0x0C,
  0x30, 0x0E, 0xC0, 0x18, 0x60, 0x19, 0x80, 0x70, 0xC0, 0x33, 0x00, 0xC1,
  0x80, 0xC6, 0x03, 0x83, 0x01, 0x8C, 0x06, 0x06, 0x07, 0x18, 0x0C, 0x0C,
  0x0C, 0x30, 0x38, 0x18, 0x18, 0x60, 0x60, 0x30, 0x60, 0xC1, 0xC0, 0x60,
  0xC1, 0xC3, 0x00, 0xC3, 0x01, 0x86, 0x01, 0x86, 0x03, 0x1C, 0x03, 0x1C,
  0x06, 0x30, 0x06, 0x30, 0x0C, 0x60, 0x0C, 0x60, 0x19, 0x80, 0x19, 0x80,
  0x33, 0x00, 0x33, 0x00, 0x6E, 0x00, 0x6E, 0x00, 0xD8, 0x00, 0xD8, 0x01,
  0xB0, 0x01, 0xB0, 0x03, 0xC0, 0x01, 0xC0, 0x07, 0x80, 0x03, 0x80, 0x0F,
  0x00, 0x06, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x03, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x18, 0x07, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x39, 0x80, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x38, 0x07, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0xC0,
  0x00, 0x18, 0x07, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x03, 0x80, 0x06, 0x00, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x70, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x38, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x00, 0xCE, 0x00, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0x0F, 0xFC, 0x00, 0x06, 0x1E, 0x1E, 0x00, 0x06, 0x38, 0x07,
  0x00, 0x06, 0x30, 0x03, 0x80, 0x0C, 0x70, 0x01, 0xC0, 0x1C, 0x60, 0x00,
  0xF0, 0x38, 0xE0, 0x00, 0x7F, 0xF0, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0x80,
};

const GFXglyph RobotoMono_ExtraLightItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 10, 41, 34, 12, -41 },
  { 53, 12, 13, 34, 14, -44 },
  { 73, 34, 41, 34, 1, -41 },
  { 248, 28, 53, 34, 4, -47 },
  { 434, 27, 43, 34, 4, -42 },
  { 580, 29, 43, 34, 2, -42 },
  { 736, 4, 13, 34, 17, -44 },
  { 743, 18, 59, 34, 10, -46 },
  { 876, 18, 59, 34, 5, -46 },
  { 1009, 24, 24, 34, 8, -41 },
  { 1081, 28, 30, 34, 3, -34 },
  { 1186, 7, 13, 34, 7, -5 },
  { 1198, 20, 2, 34, 7, -20 },
  { 1203, 5, 4, 34, 13, -4 },
  { 1206, 27, 45, 34, 4, -41 },
  { 1358, 27, 43, 34, 4, -42 },
  { 1504, 15, 41, 34, 9, -41 },
  { 1581, 28, 42, 34, 1, -42 },
  { 1728, 29, 43, 34, 1, -42 },
  { 1884, 29, 41, 34, 1, -41 },
  { 2033, 28, 42, 34, 5, -41 },
  { 2180, 26, 43, 34, 3, -42 },
  { 2320, 26, 41, 34, 7, -41 },
  { 2454, 29, 43, 34, 3, -42 },
  { 2610, 25, 42, 34, 6, -42 },
  { 2742, 9, 29, 34, 14, -29 },
  { 2775, 12, 37, 34, 11, -29 },
  { 2831, 26, 24, 34, 5, -31 },
  { 2909, 27, 14, 34, 4, -26 },
  { 2957, 26, 24, 34, 3, -31 },
  { 3035, 22, 42, 34, 9, -42 },
  { 3151, 33, 42, 34, 1, -42 },
  { 3325, 29, 41, 34, 0, -41 },
  { 3474, 28, 41, 34, 3, -41 },
  { 3618, 28, 43, 34, 4, -42 },
  { 3769, 30, 41, 34, 2, -41 },
  { 3923, 30, 41, 34, 3, -41 },
  { 4077, 30, 41, 34, 3, -41 },
  { 4231, 29, 43, 34, 3, -42 },
  { 4387, 31, 41, 34, 2, -41 },
  { 4546, 29, 41, 34, 3, -41 },
  { 4695, 30, 42, 34, 2, -41 },
  { 4853, 32, 41, 34, 3, -41 },
  { 5017, 24, 41, 34, 3, -41 },
  { 5140, 32, 41, 34, 2, -41 },
  { 5304, 31, 41, 34, 2, -41 },
  { 5463, 29, 43, 34, 3, -42 },
  { 5619, 31, 41, 34, 3, -41 },
  { 5778, 29, 49, 34, 3, -42 },
  { 5956, 29, 41, 34, 3, -41 },
  { 6105, 29, 43, 34, 3, -42 },
  { 6261, 28, 41, 34, 7, -41 },
  { 6405, 29, 42, 34, 4, -41 },
  { 6558, 29, 41, 34, 6, -41 },
  { 6707, 30, 41, 34, 6, -41 },
  { 6861, 34, 41, 34, 1, -41 },
  { 7036, 29, 41, 34, 6, -41 },
  { 7185, 31, 41, 34, 1, -41 },
  { 7344, 17, 56, 34, 9, -47 },
  { 7463, 11, 45, 34, 12, -41 },
  { 7525, 18, 56, 34, 8, -47 },
  { 7651, 20, 22, 34, 7, -41 },
  { 7706, 24, 2, 34, 2, 0 },
  { 7712, 7, 8, 34, 17, -43 },
  { 7719, 26, 32, 34, 3, -31 },
  { 7823, 26, 45, 34, 3, -44 },
  { 7970, 26, 32, 34, 4, -31 },
  { 8074, 29, 45, 34, 4, -44 },
  { 8238, 26, 32, 34, 4, -31 },
  { 8342, 28, 44, 34, 7, -44 },
  { 8496, 28, 43, 34, 2, -31 },
  { 8647, 26, 44, 34, 3, -44 },
  { 8790, 24, 42, 34, 3, -42 },
  { 8916, 27, 54, 34, 0, -42 },
  { 9099, 28, 44, 34, 4, -44 },
  { 9253, 24, 44, 34, 3, -44 },
  { 9385, 34, 31, 34, -1, -31 },
  { 9517, 26, 31, 34, 3, -31 },
  { 9618, 27, 32, 34, 3, -31 },
  { 9726, 28, 43, 34, 1, -31 },
  { 9877, 26, 43, 34, 4, -31 },
  { 10017, 25, 31, 34, 7, -31 },
  { 10114, 26, 32, 34, 4, -31 },
  { 10218, 22, 40, 34, 7, -39 },
  { 10328, 27, 32, 34, 4, -31 },
  { 10436, 28, 31, 34, 5, -31 },
  { 10545, 31, 31, 34, 4, -31 },
  { 10666, 31, 31, 34, 1, -31 },
  { 10787, 35, 43, 34, -1, -31 },
  { 10976, 30, 31, 34, 1, -31 },
  { 11093, 22, 57, 34, 9, -45 },
  { 11250, 10, 50, 34, 12, -41 },
  { 11313, 22, 57, 34, 5, -45 },
  { 11470, 32, 10, 34, 1, -22 },
};

const GFXfont RobotoMono_ExtraLightItalic58pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic58pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic58pt7bGlyphs,
  0x20, 0x7E, 77
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC58PT7B_H_
