#ifndef _ROBOTOMONO_EXTRALIGHTITALIC9PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xF0, 0x2B, 0xD4, 0xAF, 0xD0, 0x69, 0x84, 0x29, 0xA4, 0x0D,
  0xE4, 0x7D, 0x70, 0x22, 0x94, 0x46, 0xCB, 0xE0, 0xC0, 0x6A, 0xAA, 0x80,
  0x44, 0x92, 0x52, 0x80, 0x2F, 0xE0, 0x44, 0xF4, 0xC0, 0xE0, 0x80, 0x12,
  0x24, 0x88, 0x80, 0x69, 0x9B, 0xD9, 0xE0, 0xE4, 0xA4, 0x80, 0x71, 0x12,
  0x4F, 0x78, 0x4C, 0x29, 0x78, 0x11, 0x95, 0x27, 0x88, 0x78, 0xE1, 0x9E,
  0x73, 0xDB, 0xC0, 0xF2, 0x24, 0x48, 0xF9, 0x69, 0x9E, 0xF9, 0x9E, 0x2C,
  0x40, 0x80, 0x40, 0xA0, 0x34, 0xC2, 0xFE, 0x86, 0x78, 0xF1, 0x24, 0x04,
  0x7D, 0xF7, 0xBB, 0x78, 0x13, 0x57, 0x99, 0x7A, 0x5C, 0x98, 0xF8, 0xF9,
  0x88, 0x9E, 0x7A, 0x53, 0x18, 0xF8, 0x7A, 0x1C, 0x88, 0x78, 0x7A, 0x1C,
  0x88, 0x40, 0xF8, 0x8B, 0x9E, 0x4A, 0x5F, 0x18, 0xC8, 0x79, 0x08, 0x42,
  0x78, 0x08, 0x42, 0x19, 0x78, 0x4D, 0x46, 0x18, 0x92, 0x20, 0x92, 0x49,
  0xC0, 0x4A, 0xD7, 0x58, 0xC4, 0x4A, 0x5B, 0x59, 0x48, 0xF9, 0x99, 0x9E,
  0xF9, 0x9E, 0x88, 0x7A, 0x63, 0x18, 0xB8, 0x40, 0x7A, 0x52, 0xE9, 0x48,
  0x7A, 0x08, 0x38, 0xB8, 0xF4, 0x44, 0x44, 0x99, 0x99, 0x9E, 0x99, 0xAA,
  0xC4, 0xCF, 0xAD, 0x4A, 0x50, 0x49, 0x88, 0x45, 0x44, 0x9A, 0x44, 0x44,
  0x78, 0x88, 0x44, 0x78, 0x69, 0x25, 0x26, 0xAA, 0x94, 0x24, 0x92, 0x96,
  0x2E, 0x80, 0xF0, 0xC0, 0x32, 0x5D, 0x2F, 0x00, 0x42, 0x1C, 0x94, 0xC7,
  0xC0, 0x69, 0x88, 0xE0, 0x11, 0x79, 0x9A, 0xE0, 0x69, 0xF8, 0xE0, 0x34,
  0xF4, 0x44, 0x80, 0x3A, 0x63, 0x27, 0x0B, 0x80, 0x42, 0x1C, 0x94, 0xC6,
  0x40, 0x39, 0x25, 0xC0, 0x13, 0x11, 0x22, 0x2C, 0x88, 0x9A, 0xCC, 0xA0,
  0x64, 0xA4, 0xB8, 0x7D, 0x6B, 0x5A, 0x80, 0x72, 0x53, 0x19, 0x00, 0x32,
  0x63, 0x17, 0x00, 0x72, 0x53, 0x1F, 0x42, 0x00, 0x79, 0x9A, 0xE2, 0x20,
  0x74, 0x88, 0x80, 0x69, 0x61, 0xE0, 0x4F, 0x44, 0x46, 0x99, 0x9A, 0xE0,
  0x99, 0xAA, 0x40, 0xDD, 0xAA, 0xA0, 0x4A, 0x88, 0xA9, 0x00, 0x8A, 0x54,
  0xA2, 0x22, 0x00, 0x78, 0x88, 0x8F, 0x00, 0x12, 0x24, 0x84, 0x44, 0x20,
  0xFE, 0x44, 0x92, 0x92, 0x80, 0xF8,
};

const GFXglyph RobotoMono_ExtraLightItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 2, 2, 5, 2, -7 },
  { 3, 5, 6, 5, 0, -6 },
  { 7, 4, 8, 5, 1, -7 },
  { 11, 4, 7, 5, 1, -7 },
  { 15, 5, 7, 5, 0, -7 },
  { 20, 1, 2, 5, 2, -7 },
  { 21, 2, 9, 5, 2, -7 },
  { 24, 3, 9, 5, 1, -7 },
  { 28, 4, 3, 5, 1, -6 },
  { 30, 4, 4, 5, 1, -5 },
  { 32, 1, 2, 5, 1, -1 },
  { 33, 3, 1, 5, 1, -3 },
  { 34, 1, 1, 5, 2, -1 },
  { 35, 4, 7, 5, 1, -6 },
  { 39, 4, 7, 5, 1, -7 },
  { 43, 3, 6, 5, 1, -6 },
  { 46, 4, 6, 5, 0, -6 },
  { 49, 5, 6, 5, 0, -6 },
  { 53, 5, 6, 5, 0, -6 },
  { 57, 4, 6, 5, 1, -6 },
  { 60, 3, 6, 5, 1, -6 },
  { 63, 4, 6, 5, 1, -6 },
  { 66, 4, 6, 5, 1, -6 },
  { 69, 4, 6, 5, 1, -6 },
  { 72, 2, 5, 5, 2, -5 },
  { 74, 2, 6, 5, 2, -5 },
  { 76, 4, 4, 5, 1, -5 },
  { 78, 4, 2, 5, 1, -4 },
  { 79, 4, 4, 5, 1, -5 },
  { 81, 4, 6, 5, 1, -6 },
  { 84, 5, 6, 5, 0, -6 },
  { 88, 4, 6, 5, 0, -6 },
  { 91, 5, 6, 5, 0, -6 },
  { 95, 4, 6, 5, 1, -6 },
  { 98, 5, 6, 5, 0, -6 },
  { 102, 5, 6, 5, 0, -6 },
  { 106, 5, 6, 5, 0, -6 },
  { 110, 4, 6, 5, 1, -6 },
  { 113, 5, 6, 5, 0, -6 },
  { 117, 5, 6, 5, 0, -6 },
  { 121, 5, 6, 5, 0, -6 },
  { 125, 6, 6, 5, 0, -6 },
  { 130, 3, 6, 5, 1, -6 },
  { 133, 5, 6, 5, 0, -6 },
  { 137, 5, 6, 5, 0, -6 },
  { 141, 4, 6, 5, 1, -6 },
  { 144, 4, 6, 5, 1, -6 },
  { 147, 5, 7, 5, 0, -6 },
  { 152, 5, 6, 5, 0, -6 },
  { 156, 5, 6, 5, 0, -6 },
  { 160, 4, 6, 5, 1, -6 },
  { 163, 4, 6, 5, 1, -6 },
  { 166, 4, 6, 5, 1, -6 },
  { 169, 5, 6, 5, 1, -6 },
  { 173, 5, 6, 5, 0, -6 },
  { 177, 4, 6, 5, 1, -6 },
  { 180, 5, 6, 5, 0, -6 },
  { 184, 3, 8, 5, 1, -7 },
  { 187, 2, 7, 5, 2, -6 },
  { 189, 3, 8, 5, 1, -7 },
  { 192, 3, 3, 5, 1, -6 },
  { 194, 4, 1, 5, 0, 0 },
  { 195, 1, 2, 5, 3, -7 },
  { 196, 5, 5, 5, 0, -5 },
  { 200, 5, 7, 5, 0, -7 },
  { 205, 4, 5, 5, 1, -5 },
  { 208, 4, 7, 5, 1, -7 },
  { 212, 4, 5, 5, 1, -5 },
  { 215, 4, 7, 5, 1, -7 },
  { 219, 5, 7, 5, 0, -5 },
  { 224, 5, 7, 5, 0, -7 },
  { 229, 3, 6, 5, 1, -6 },
  { 232, 4, 8, 5, 0, -6 },
  { 236, 4, 7, 5, 1, -7 },
  { 240, 3, 7, 5, 1, -7 },
  { 243, 5, 5, 5, 0, -5 },
  { 247, 5, 5, 5, 0, -5 },
  { 251, 5, 5, 5, 0, -5 },
  { 255, 5, 7, 5, 0, -5 },
  { 260, 4, 7, 5, 1, -5 },
  { 264, 4, 5, 5, 1, -5 },
  { 267, 4, 5, 5, 1, -5 },
  { 270, 4, 6, 5, 1, -6 },
  { 273, 4, 5, 5, 1, -5 },
  { 276, 4, 5, 5, 1, -5 },
  { 279, 4, 5, 5, 1, -5 },
  { 282, 5, 5, 5, 0, -5 },
  { 286, 5, 7, 5, 0, -5 },
  { 291, 5, 5, 5, 0, -5 },
  { 295, 4, 9, 5, 1, -7 },
  { 300, 1, 7, 5, 2, -6 },
  { 301, 3, 9, 5, 1, -7 },
  { 305, 5, 1, 5, 0, -3 },
};

const GFXfont RobotoMono_ExtraLightItalic9pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic9pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC9PT7B_H_
