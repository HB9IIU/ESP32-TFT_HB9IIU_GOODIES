#ifndef _ROBOTOMONO_EXTRALIGHTITALIC43PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x0C, 0x18, 0x30, 0x41, 0x83, 0x06, 0x0C, 0x18, 0x20, 0xC1,
  0x83, 0x06, 0x0C, 0x30, 0x60, 0xC1, 0x83, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x1C, 0x30, 0x00, 0x31, 0x90, 0xD8, 0x6C, 0x36, 0x13, 0x09,
  0x0C, 0x86, 0xC3, 0x00, 0x00, 0x04, 0x06, 0x00, 0x06, 0x02, 0x00, 0x03,
  0x03, 0x00, 0x01, 0x01, 0x80, 0x01, 0x80, 0x80, 0x00, 0xC0, 0xC0, 0x00,
  0xC0, 0x60, 0x00, 0x60, 0x20, 0x00, 0x20, 0x30, 0x0F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xC0, 0x08, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x06, 0x00,
  0x02, 0x03, 0x00, 0x03, 0x01, 0x00, 0x01, 0x81, 0x80, 0x00, 0x80, 0xC0,
  0x00, 0xC0, 0x40, 0x00, 0x60, 0x60, 0x00, 0x20, 0x30, 0x07, 0xFF, 0xFF,
  0xC0, 0x18, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x04, 0x00, 0x04, 0x06,
  0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x00, 0x01, 0x01, 0x80, 0x01, 0x80,
  0x80, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x03, 0x80, 0xE0, 0x70,
  0x06, 0x06, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x31, 0x80, 0x03, 0x18,
  0x00, 0x31, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0x60, 0x01, 0x86, 0x00,
  0x38, 0x30, 0x07, 0x01, 0xC3, 0xE0, 0x0F, 0xF8, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0F, 0x00, 0x03, 0xF8, 0x00,
  0x60, 0xC0, 0x06, 0x0C, 0x00, 0xC0, 0x40, 0x6C, 0x04, 0x0C, 0xC0, 0xC0,
  0x88, 0x0C, 0x18, 0x80, 0xC3, 0x08, 0x08, 0x60, 0xC1, 0x86, 0x0C, 0x30,
  0xC0, 0x7F, 0x18, 0x03, 0xC1, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x18, 0x01, 0x87, 0xE0, 0x30, 0xC3, 0x03, 0x18, 0x30,
  0x61, 0x01, 0x0C, 0x30, 0x10, 0x83, 0x01, 0x18, 0x30, 0x33, 0x02, 0x03,
  0x60, 0x20, 0x32, 0x02, 0x02, 0x00, 0x30, 0x60, 0x01, 0x8C, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x07, 0xF8, 0x00, 0x70, 0x60, 0x03, 0x03, 0x00,
  0x30, 0x0C, 0x01, 0x80, 0x40, 0x08, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x03,
  0x00, 0x10, 0x38, 0x00, 0xC3, 0x80, 0x06, 0x30, 0x00, 0x13, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x06, 0x60, 0x00, 0xE1, 0x80,
  0x06, 0x0C, 0x06, 0x60, 0x30, 0x36, 0x01, 0x81, 0x30, 0x06, 0x1B, 0x00,
  0x18, 0xD8, 0x00, 0xCC, 0xC0, 0x03, 0xE6, 0x00, 0x0E, 0x30, 0x00, 0x60,
  0xC0, 0x07, 0x87, 0x00, 0xEE, 0x1E, 0x1E, 0x30, 0x3F, 0xC0, 0xC0, 0x32,
  0x26, 0x66, 0x44, 0xC0, 0x00, 0x08, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x10,
  0x00, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x0C, 0x0C,
  0x0F, 0xC3, 0x1F, 0x3E, 0xBE, 0x01, 0xFC, 0x00, 0x1C, 0x00, 0x0D, 0x00,
  0x06, 0x60, 0x03, 0x0C, 0x01, 0x83, 0x00, 0xC0, 0x60, 0x70, 0x0C, 0x08,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x18, 0xC6, 0x31,
  0x18, 0xCC, 0xC2, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x1F, 0xF8, 0x03, 0x80, 0xC0, 0x70, 0x06, 0x0E, 0x00, 0x60,
  0xC0, 0x02, 0x18, 0x00, 0x31, 0x80, 0x03, 0x30, 0x00, 0x33, 0x00, 0x0F,
  0x30, 0x01, 0xF2, 0x00, 0x33, 0x60, 0x06, 0x36, 0x00, 0xC3, 0x60, 0x18,
  0x26, 0x07, 0x02, 0x40, 0xC0, 0x64, 0x18, 0x06, 0xC3, 0x00, 0x6C, 0x60,
  0x06, 0xDC, 0x00, 0x4F, 0x00, 0x0C, 0xE0, 0x00, 0xCC, 0x00, 0x08, 0xC0,
  0x01, 0x8C, 0x00, 0x10, 0x60, 0x03, 0x06, 0x00, 0x60, 0x30, 0x0C, 0x01,
  0xC7, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x20, 0x1C, 0x0F, 0x8F, 0x27, 0x8D,
  0x81, 0xA0, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x03, 0x80, 0xE0, 0x70, 0x06, 0x0E, 0x00,
  0x30, 0xC0, 0x03, 0x18, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00,
  0x70, 0x18, 0x06, 0x00, 0x60, 0x60, 0x03, 0x06, 0x00, 0x0C, 0x30, 0x00,
  0x63, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0xC6,
  0x00, 0x06, 0x18, 0x00, 0x60, 0xC0, 0x07, 0x03, 0x00, 0x70, 0x0F, 0x1F,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x40, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x19, 0x80, 0x01,
  0x8C, 0x00, 0x18, 0x40, 0x01, 0x82, 0x00, 0x0C, 0x30, 0x00, 0xC1, 0x80,
  0x0C, 0x0C, 0x00, 0xC0, 0x60, 0x0C, 0x02, 0x00, 0xE0, 0x30, 0x06, 0x01,
  0x80, 0x60, 0x0C, 0x06, 0x00, 0x60, 0x60, 0x03, 0x06, 0x00, 0x10, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x3F, 0xC0,
  0x1F, 0x87, 0x00, 0xE0, 0x0C, 0x02, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x10, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x18, 0x30, 0x00,
  0xC0, 0xC0, 0x0C, 0x07, 0x00, 0xC0, 0x1E, 0x3C, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0xC7, 0xF0, 0x67, 0xFE, 0x1B, 0x80, 0xC7, 0x80, 0x19, 0xC0, 0x06,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x64, 0x00,
  0x31, 0x80, 0x18, 0x30, 0x0C, 0x07, 0x0E, 0x00, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0xE0, 0x38,
  0x0E, 0x00, 0xE0, 0x60, 0x03, 0x06, 0x00, 0x18, 0x20, 0x00, 0x63, 0x00,
  0x03, 0x18, 0x00, 0x10, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0xC0,
  0xC0, 0x0C, 0x03, 0x00, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0x07,
  0x00, 0xE0, 0x0C, 0x0C, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x06, 0x60,
  0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0xC6, 0x00, 0x06,
  0x30, 0x00, 0x60, 0xC0, 0x07, 0x07, 0x00, 0x70, 0x1E, 0x1F, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1C, 0x0E, 0x06, 0x00, 0xC1,
  0x80, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x33, 0x00, 0x03, 0x60, 0x00, 0x68,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x05, 0x80, 0x01, 0xB0,
  0x00, 0x33, 0x00, 0x0E, 0x60, 0x03, 0xC6, 0x00, 0xD8, 0xE0, 0x32, 0x0F,
  0xFC, 0xC0, 0x7E, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x00, 0x1C, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x38, 0xE0, 0x03, 0x81, 0xC0, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x60,
  0x60, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x08,
  0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x10, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x08, 0x00, 0x00, 0x03, 0xF0,
  0x0F, 0xF8, 0x38, 0x0C, 0x30, 0x06, 0x60, 0x06, 0xC0, 0x02, 0xC0, 0x03,
  0xC0, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0x0C,
  0x03, 0x80, 0x06, 0x07, 0x00, 0x02, 0x06, 0x00, 0x03, 0x0C, 0x1F, 0x83,
  0x18, 0x38, 0xC3, 0x18, 0x60, 0x43, 0x30, 0x40, 0xC3, 0x30, 0xC0, 0x83,
  0x20, 0x80, 0x83, 0x61, 0x80, 0x83, 0x61, 0x01, 0x83, 0x41, 0x01, 0x02,
  0xC3, 0x01, 0x02, 0xC3, 0x03, 0x06, 0xC2, 0x03, 0x06, 0xC2, 0x06, 0x04,
  0xC2, 0x06, 0x0C, 0xC2, 0x0E, 0x08, 0xC3, 0x1A, 0x18, 0xC3, 0xF3, 0xF0,
  0xC1, 0xE1, 0xE0, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x38, 0x02, 0x00, 0x0E, 0x1F, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0D, 0x00, 0x00, 0x68, 0x00, 0x02,
  0x60, 0x00, 0x33, 0x00, 0x01, 0x18, 0x00, 0x18, 0xC0, 0x00, 0x86, 0x00,
  0x0C, 0x10, 0x00, 0x40, 0x80, 0x06, 0x06, 0x00, 0x20, 0x30, 0x03, 0x01,
  0x80, 0x18, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x00, 0xC0, 0x08, 0x06,
  0x00, 0x60, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x30, 0x00, 0xC1, 0x80, 0x06,
  0x18, 0x00, 0x30, 0xC0, 0x00, 0x8C, 0x00, 0x06, 0x60, 0x00, 0x36, 0x00,
  0x01, 0xB0, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x07, 0xFC, 0x00, 0x3F, 0xFC,
  0x01, 0x80, 0x78, 0x0C, 0x00, 0xE0, 0x40, 0x03, 0x86, 0x00, 0x0C, 0x30,
  0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC2, 0x00, 0x0C,
  0x30, 0x00, 0x61, 0x80, 0x06, 0x0C, 0x00, 0xE0, 0x7F, 0xFC, 0x03, 0xFF,
  0xE0, 0x10, 0x03, 0x81, 0x80, 0x06, 0x0C, 0x00, 0x18, 0x60, 0x00, 0x43,
  0x00, 0x03, 0x10, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x06, 0x60, 0x00,
  0x63, 0x00, 0x03, 0x18, 0x00, 0x30, 0x80, 0x03, 0x0C, 0x00, 0x70, 0x7F,
  0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFC, 0x00, 0xE0,
  0x30, 0x0E, 0x00, 0xC0, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x60, 0x00, 0x46,
  0x00, 0x03, 0x30, 0x00, 0x19, 0x80, 0x00, 0xD8, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x12, 0x00, 0x01, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00,
  0x0C, 0x10, 0x00, 0xC0, 0xC0, 0x0E, 0x03, 0x00, 0xE0, 0x0E, 0x1E, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x40, 0x3C, 0x03,
  0x00, 0x38, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x01, 0x83, 0x00,
  0x06, 0x08, 0x00, 0x08, 0x60, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00, 0x03,
  0x18, 0x00, 0x0C, 0x40, 0x00, 0x31, 0x00, 0x00, 0x8C, 0x00, 0x06, 0x30,
  0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x88, 0x00, 0x04, 0x60, 0x00,
  0x31, 0x80, 0x00, 0xC6, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0xC1,
  0x00, 0x06, 0x0C, 0x00, 0x38, 0x30, 0x01, 0xC0, 0xC0, 0x1C, 0x03, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x00, 0x1C,
  0x07, 0x00, 0xE0, 0x0C, 0x06, 0x00, 0x18, 0x38, 0x00, 0x60, 0xC0, 0x00,
  0xC6, 0x00, 0x03, 0x18, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x7F, 0xC4, 0x00, 0x03, 0x30, 0x00, 0x0C,
  0xC0, 0x00, 0x33, 0x00, 0x00, 0xC4, 0x00, 0x02, 0x18, 0x00, 0x08, 0x60,
  0x00, 0x61, 0x80, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x38, 0x18, 0x01,
  0xC0, 0x38, 0x3C, 0x00, 0x7F, 0xC0, 0x00, 0x02, 0x00, 0x03, 0x06, 0x00,
  0x03, 0x06, 0x00, 0x02, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06, 0x04, 0x00,
  0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x04, 0x0C, 0x00,
  0x0C, 0x08, 0x00, 0x0C, 0x08, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00,
  0x08, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x10, 0x00, 0x18, 0x10, 0x00,
  0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x10, 0x30, 0x00, 0x10, 0x30, 0x00,
  0x30, 0x20, 0x00, 0x30, 0x20, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00,
  0x20, 0x60, 0x00, 0x20, 0x60, 0x00, 0x60, 0x40, 0x00, 0x60, 0x40, 0x00,
  0x60, 0xC0, 0x00, 0x60, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x03,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x08, 0x00, 0x0C, 0x20, 0x00, 0x30,
  0xC0, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x30, 0x18, 0x01, 0x80, 0x70,
  0x0C, 0x00, 0xF1, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x03, 0x06,
  0x00, 0x06, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x06, 0x00, 0x30, 0x04,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x0C,
  0x0E, 0x00, 0x0C, 0x1C, 0x00, 0x08, 0x38, 0x00, 0x18, 0x70, 0x00, 0x18,
  0xE0, 0x00, 0x19, 0xC0, 0x00, 0x1B, 0xE0, 0x00, 0x17, 0x70, 0x00, 0x1E,
  0x30, 0x00, 0x38, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x30,
  0x0C, 0x00, 0x20, 0x06, 0x00, 0x60, 0x07, 0x00, 0x60, 0x03, 0x00, 0x60,
  0x01, 0x80, 0x60, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x40, 0x00, 0xC0, 0xC0,
  0x00, 0x60, 0xC0, 0x00, 0x70, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0x00, 0x07, 0x03, 0x00, 0x07, 0x07, 0x00, 0x0F, 0x07, 0x80, 0x0F, 0x07,
  0x80, 0x1A, 0x07, 0x80, 0x1E, 0x04, 0x80, 0x36, 0x0C, 0x80, 0x36, 0x0C,
  0xC0, 0x66, 0x0C, 0xC0, 0xC4, 0x0C, 0xC0, 0xC4, 0x0C, 0xC1, 0x8C, 0x08,
  0x41, 0x8C, 0x18, 0x63, 0x0C, 0x18, 0x63, 0x0C, 0x18, 0x66, 0x08, 0x18,
  0x64, 0x18, 0x18, 0x2C, 0x18, 0x10, 0x38, 0x18, 0x30, 0x38, 0x18, 0x30,
  0x30, 0x18, 0x30, 0x00, 0x10, 0x30, 0x00, 0x30, 0x20, 0x00, 0x30, 0x20,
  0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x20, 0x60,
  0x00, 0x60, 0x40, 0x00, 0x60, 0xC0, 0x00, 0x60, 0x02, 0x00, 0x03, 0x07,
  0x00, 0x03, 0x07, 0x00, 0x02, 0x07, 0x00, 0x06, 0x07, 0x80, 0x06, 0x05,
  0x80, 0x06, 0x04, 0xC0, 0x06, 0x0C, 0xC0, 0x06, 0x0C, 0xC0, 0x04, 0x0C,
  0x60, 0x0C, 0x0C, 0x60, 0x0C, 0x08, 0x20, 0x0C, 0x18, 0x30, 0x0C, 0x18,
  0x30, 0x08, 0x18, 0x10, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x10,
  0x0C, 0x18, 0x30, 0x0C, 0x18, 0x30, 0x04, 0x10, 0x30, 0x06, 0x30, 0x30,
  0x06, 0x30, 0x30, 0x02, 0x30, 0x20, 0x03, 0x30, 0x60, 0x03, 0x30, 0x60,
  0x01, 0x20, 0x60, 0x01, 0xE0, 0x60, 0x01, 0xE0, 0x60, 0x00, 0xE0, 0x40,
  0x00, 0xE0, 0xC0, 0x00, 0x60, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0x81,
  0xC0, 0x70, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x03, 0x18, 0x00, 0x33, 0x00,
  0x03, 0x30, 0x00, 0x12, 0x00, 0x01, 0x60, 0x00, 0x16, 0x00, 0x01, 0x60,
  0x00, 0x34, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x02, 0x80, 0x00, 0x68, 0x00, 0x06, 0x80, 0x00, 0x68, 0x00, 0x04,
  0x80, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0x40, 0x03,
  0x06, 0x00, 0x60, 0x30, 0x0C, 0x01, 0xC7, 0x80, 0x0F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x18, 0x01, 0xC0, 0x30, 0x00, 0xC0, 0x60,
  0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x01, 0x82, 0x00, 0x03, 0x0C, 0x00,
  0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x10, 0x60, 0x00, 0x60, 0x80, 0x00,
  0xC1, 0x00, 0x03, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x70, 0x18, 0x07, 0xC0,
  0x3F, 0xFE, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0x00, 0x1C,
  0x06, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x00,
  0x86, 0x00, 0x03, 0x18, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xC8,
  0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00,
  0x02, 0x40, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x06,
  0xC0, 0x00, 0x13, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x18, 0x40,
  0x00, 0x61, 0x80, 0x03, 0x06, 0x00, 0x18, 0x0C, 0x00, 0xE0, 0x38, 0x07,
  0x00, 0x78, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x07, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x60, 0x0E, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x18, 0x10, 0x00,
  0x60, 0xC0, 0x00, 0x83, 0x00, 0x03, 0x0C, 0x00, 0x08, 0x30, 0x00, 0x20,
  0xC0, 0x01, 0x82, 0x00, 0x06, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80,
  0x06, 0x06, 0x00, 0x70, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x30, 0x08,
  0x00, 0xC0, 0x60, 0x01, 0x01, 0x80, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00,
  0x30, 0x40, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x3F,
  0x80, 0x03, 0xFF, 0x80, 0x1C, 0x07, 0x01, 0xC0, 0x0E, 0x06, 0x00, 0x18,
  0x30, 0x00, 0x60, 0xC0, 0x00, 0xC2, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x31, 0x80, 0x01, 0x86, 0x00, 0x06,
  0x1C, 0x00, 0x30, 0x38, 0x03, 0x80, 0x7C, 0x7C, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x0C, 0x60, 0x00, 0x31, 0x80, 0x00, 0x86, 0x00, 0x06, 0x18, 0x00, 0x18,
  0x40, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x10, 0xC0,
  0x00, 0xC3, 0x00, 0x03, 0x08, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x00,
  0xC6, 0x00, 0x02, 0x18, 0x00, 0x18, 0x40, 0x00, 0x61, 0x00, 0x01, 0x8C,
  0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x43, 0x00, 0x03, 0x0C, 0x00,
  0x0C, 0x30, 0x00, 0x30, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x30,
  0x18, 0x01, 0x80, 0x30, 0x0C, 0x00, 0xF1, 0xE0, 0x00, 0xFF, 0x00, 0x00,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0xCC, 0x00,
  0x06, 0x20, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x83,
  0x00, 0x0C, 0x18, 0x00, 0xC0, 0x40, 0x06, 0x02, 0x00, 0x60, 0x18, 0x03,
  0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x18, 0x01, 0x80, 0xC0, 0x04,
  0x0C, 0x00, 0x30, 0x60, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x00,
  0x03, 0x18, 0x00, 0x08, 0x80, 0x00, 0x4C, 0x00, 0x03, 0x60, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x18,
  0x06, 0x80, 0x30, 0x09, 0x00, 0xE0, 0x32, 0x01, 0xC0, 0x64, 0x07, 0x80,
  0xC8, 0x0F, 0x01, 0x10, 0x16, 0x06, 0x20, 0x6C, 0x0C, 0x40, 0xD8, 0x10,
  0x81, 0x30, 0x61, 0x06, 0x60, 0xC2, 0x0C, 0xC1, 0x04, 0x11, 0x86, 0x08,
  0x63, 0x0C, 0x10, 0xC6, 0x18, 0x21, 0x0C, 0x20, 0x46, 0x18, 0xC1, 0x8C,
  0x31, 0x83, 0x10, 0x62, 0x06, 0x60, 0xCC, 0x0C, 0xC0, 0x98, 0x19, 0x01,
  0x20, 0x36, 0x02, 0xC0, 0x6C, 0x05, 0x80, 0xD0, 0x0B, 0x01, 0xE0, 0x14,
  0x03, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80,
  0x30, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x30,
  0x00, 0x30, 0x06, 0x00, 0x1C, 0x01, 0x80, 0x06, 0x00, 0x30, 0x03, 0x00,
  0x0C, 0x01, 0x80, 0x01, 0x80, 0xE0, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x18,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x46, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xE1, 0x80,
  0x00, 0x30, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x00,
  0xC0, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x30,
  0x00, 0x30, 0x0C, 0x00, 0x06, 0x0E, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0x98, 0x00, 0x1C, 0xC0, 0x00, 0xC6, 0x00, 0x0C, 0x10, 0x00,
  0xC0, 0xC0, 0x06, 0x06, 0x00, 0x60, 0x10, 0x06, 0x00, 0xC0, 0x30, 0x06,
  0x03, 0x00, 0x10, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x18, 0x00, 0x11, 0x80,
  0x00, 0xCC, 0x00, 0x06, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8,
  0x00, 0x01, 0xFC, 0x07, 0xE0, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80,
  0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x7E,
  0x03, 0xF8, 0x00, 0x80, 0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x60, 0x60, 0x60,
  0x60, 0x20, 0x30, 0x30, 0x30, 0x30, 0x10, 0x18, 0x18, 0x18, 0x18, 0x08,
  0x0C, 0x0C, 0x0C, 0x0C, 0x04, 0x06, 0x06, 0x06, 0x06, 0x02, 0x03, 0x03,
  0x03, 0x03, 0xF8, 0x1F, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x20,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x09, 0x00, 0x32, 0x00, 0xC6, 0x01,
  0x8C, 0x06, 0x18, 0x0C, 0x10, 0x30, 0x30, 0x40, 0x61, 0x80, 0xC6, 0x00,
  0x8C, 0x01, 0xB0, 0x03, 0xE0, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC6,
  0x18, 0xC3, 0x0C, 0x00, 0x7F, 0x00, 0x3F, 0xF8, 0x07, 0x00, 0xC0, 0xE0,
  0x06, 0x0C, 0x00, 0x61, 0x80, 0x03, 0x18, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0xFF, 0xE0, 0x7F, 0xFE, 0x1E, 0x00, 0x63,
  0x80, 0x04, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x40, 0x00, 0xCC, 0x00, 0x1C,
  0xC0, 0x01, 0xC6, 0x00, 0x68, 0x60, 0x0C, 0x83, 0xC7, 0x98, 0x1F, 0xE1,
  0x80, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC7, 0xF0, 0x0C, 0xFF, 0x80, 0xB8, 0x1C, 0x0E, 0x00, 0xE1, 0xC0, 0x06,
  0x18, 0x00, 0x61, 0x80, 0x03, 0x18, 0x00, 0x31, 0x00, 0x03, 0x30, 0x00,
  0x33, 0x00, 0x03, 0x30, 0x00, 0x23, 0x00, 0x06, 0x30, 0x00, 0x62, 0x00,
  0x06, 0x60, 0x00, 0x46, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x18, 0x70,
  0x03, 0x05, 0x80, 0x60, 0xCE, 0x1C, 0x0C, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x7F, 0xE0, 0x1C, 0x06, 0x06, 0x00, 0x61, 0x80, 0x0C, 0x60, 0x00, 0xCC,
  0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x01, 0x98, 0x00, 0x31, 0x80, 0x0C, 0x30, 0x03, 0x83, 0x00, 0xE0, 0x38,
  0x78, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x0F, 0xE1, 0x00, 0xFF, 0x98, 0x1C, 0x06, 0xC0,
  0xC0, 0x1E, 0x0C, 0x00, 0x70, 0xC0, 0x03, 0x86, 0x00, 0x08, 0x60, 0x00,
  0xC3, 0x00, 0x06, 0x18, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x60,
  0x00, 0x43, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x0C,
  0x30, 0x00, 0x60, 0x80, 0x06, 0x06, 0x00, 0x70, 0x18, 0x07, 0x80, 0xF1,
  0xEC, 0x01, 0xFC, 0x60, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1C, 0x06, 0x06,
  0x00, 0x61, 0x80, 0x0C, 0x60, 0x00, 0xCC, 0x00, 0x1B, 0x00, 0x03, 0x60,
  0x00, 0x78, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0xC3, 0x00, 0x70, 0x38, 0x3C, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xFE, 0x18, 0x0F, 0xF8, 0x81, 0xC0, 0x6C, 0x0C, 0x01,
  0xE0, 0xC0, 0x07, 0x0C, 0x00, 0x38, 0x60, 0x00, 0x86, 0x00, 0x0C, 0x30,
  0x00, 0x61, 0x80, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x04,
  0x30, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00,
  0x06, 0x08, 0x00, 0x60, 0x60, 0x07, 0x01, 0x80, 0x78, 0x0F, 0x1E, 0xC0,
  0x1F, 0xC6, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0x81, 0x00, 0x0C, 0x0C, 0x00, 0xC0, 0x30, 0x1C, 0x00, 0xFF, 0xC0, 0x03,
  0xF8, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC3, 0xF8, 0x08, 0xFF, 0xC1, 0x98, 0x0E, 0x1B, 0x00, 0x61, 0xE0,
  0x02, 0x1C, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x33, 0x00, 0x03, 0x30,
  0x00, 0x23, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x06, 0x20, 0x00, 0x66,
  0x00, 0x06, 0x60, 0x00, 0x46, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x0C,
  0x40, 0x00, 0xCC, 0x00, 0x08, 0xC0, 0x00, 0x8C, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x60, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xE7, 0xC0, 0x0F, 0xF0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x07, 0x18, 0x00, 0xE1, 0x80, 0x1C, 0x18, 0x03, 0x01, 0x80, 0xE0, 0x10,
  0x1C, 0x03, 0x03, 0x80, 0x30, 0x60, 0x03, 0x1C, 0x00, 0x33, 0x80, 0x03,
  0x78, 0x00, 0x2D, 0x80, 0x07, 0x8C, 0x00, 0x70, 0xE0, 0x06, 0x06, 0x00,
  0x60, 0x30, 0x06, 0x01, 0x80, 0x40, 0x18, 0x0C, 0x00, 0xC0, 0xC0, 0x06,
  0x0C, 0x00, 0x60, 0xC0, 0x03, 0x0C, 0x00, 0x18, 0x03, 0xFF, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x19, 0xF8, 0x7C, 0x1B,
  0xFC, 0xFE, 0x1E, 0x0D, 0x83, 0x1C, 0x0E, 0x03, 0x18, 0x0E, 0x03, 0x10,
  0x0C, 0x03, 0x30, 0x0C, 0x03, 0x30, 0x0C, 0x03, 0x30, 0x0C, 0x03, 0x30,
  0x0C, 0x02, 0x20, 0x08, 0x02, 0x20, 0x18, 0x06, 0x60, 0x18, 0x06, 0x60,
  0x18, 0x06, 0x60, 0x18, 0x06, 0x60, 0x10, 0x04, 0x40, 0x10, 0x04, 0x40,
  0x30, 0x0C, 0xC0, 0x30, 0x0C, 0xC0, 0x30, 0x0C, 0xC0, 0x30, 0x0C, 0xC0,
  0x20, 0x08, 0x80, 0x60, 0x18, 0x0C, 0x3F, 0x00, 0x8F, 0xFC, 0x19, 0x80,
  0xE1, 0xB0, 0x06, 0x1E, 0x00, 0x21, 0xC0, 0x03, 0x18, 0x00, 0x31, 0x80,
  0x03, 0x30, 0x00, 0x23, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x06, 0x30,
  0x00, 0x62, 0x00, 0x06, 0x60, 0x00, 0x46, 0x00, 0x0C, 0x60, 0x00, 0xC6,
  0x00, 0x0C, 0x60, 0x00, 0xC4, 0x00, 0x0C, 0xC0, 0x00, 0x8C, 0x00, 0x18,
  0xC0, 0x01, 0x80, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0x01, 0xC0, 0xE0,
  0x06, 0x1C, 0x00, 0x61, 0x80, 0x03, 0x30, 0x00, 0x33, 0x00, 0x03, 0x60,
  0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x34, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0x40, 0x00, 0x66, 0x00, 0x0C,
  0x60, 0x01, 0x83, 0x00, 0x38, 0x38, 0x07, 0x01, 0xE1, 0xC0, 0x07, 0xF8,
  0x00, 0x06, 0x3F, 0x80, 0x27, 0xFE, 0x01, 0x70, 0x38, 0x1E, 0x00, 0xC0,
  0xE0, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0x41, 0x80, 0x03, 0x08, 0x00,
  0x18, 0xC0, 0x00, 0xC6, 0x00, 0x04, 0x30, 0x00, 0x21, 0x80, 0x03, 0x08,
  0x00, 0x18, 0x40, 0x00, 0xC6, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x06,
  0x0C, 0x00, 0x30, 0x70, 0x03, 0x06, 0xC0, 0x30, 0x33, 0x8F, 0x01, 0x8F,
  0xF0, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x01, 0xFC, 0x20, 0x7F, 0xC4, 0x38, 0x0D, 0x86, 0x00, 0xF1, 0x80,
  0x0E, 0x60, 0x01, 0xCC, 0x00, 0x13, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00,
  0x1B, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x09, 0x80, 0x03, 0x30, 0x00,
  0x66, 0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00, 0x31, 0x00, 0x0C, 0x30, 0x03,
  0x83, 0x00, 0xF0, 0x78, 0xF6, 0x03, 0xF8, 0xC0, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x1F, 0xE1, 0x8F, 0xF8, 0x33, 0x80,
  0x06, 0xC0, 0x00, 0xB0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0xFF, 0xF0, 0x38, 0x07, 0x0E, 0x00, 0x71, 0x80, 0x06,
  0x20, 0x00, 0xCC, 0x00, 0x18, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x06, 0x70, 0x00, 0xC7,
  0x00, 0x70, 0x78, 0x3C, 0x03, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x03, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x80, 0x3F, 0xC0, 0x18, 0x00, 0x31,
  0x80, 0x03, 0x10, 0x00, 0x23, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x06,
  0x30, 0x00, 0x63, 0x00, 0x04, 0x20, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00,
  0xC6, 0x00, 0x0C, 0x60, 0x00, 0xC4, 0x00, 0x08, 0x40, 0x01, 0x8C, 0x00,
  0x18, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0x40, 0x03, 0x86, 0x00, 0x70, 0x70,
  0x1D, 0x03, 0x87, 0xB0, 0x1F, 0xE3, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x66, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x18, 0x60, 0x01,
  0x83, 0x00, 0x30, 0x30, 0x03, 0x03, 0x00, 0x60, 0x10, 0x04, 0x01, 0x80,
  0xC0, 0x18, 0x18, 0x01, 0x81, 0x80, 0x08, 0x30, 0x00, 0xC3, 0x00, 0x0C,
  0x60, 0x00, 0xC4, 0x00, 0x04, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x10, 0x07, 0x80, 0x60, 0x1B, 0x00,
  0xC0, 0x36, 0x03, 0x80, 0x4C, 0x05, 0x01, 0x98, 0x0A, 0x03, 0x30, 0x36,
  0x04, 0x60, 0x4C, 0x18, 0x41, 0x98, 0x20, 0x82, 0x30, 0xC1, 0x0C, 0x61,
  0x82, 0x18, 0xC2, 0x04, 0x21, 0x8C, 0x08, 0xC1, 0x18, 0x11, 0x02, 0x60,
  0x26, 0x04, 0xC0, 0x6C, 0x09, 0x00, 0xD0, 0x16, 0x01, 0xE0, 0x2C, 0x03,
  0x80, 0x50, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x0E, 0x0C, 0x00, 0x38, 0x18, 0x00, 0x60, 0x18, 0x01, 0x80,
  0x38, 0x06, 0x00, 0x30, 0x18, 0x00, 0x30, 0x60, 0x00, 0x61, 0x80, 0x00,
  0x66, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0D, 0x80, 0x00, 0x33, 0x80, 0x00, 0xC3, 0x00, 0x03, 0x03,
  0x00, 0x0C, 0x06, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x0E, 0x03, 0x00, 0x0C,
  0x0E, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x07, 0x00,
  0xC0, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x18,
  0x00, 0x60, 0x0E, 0x00, 0x18, 0x03, 0x00, 0x02, 0x01, 0x80, 0x00, 0xC0,
  0x60, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x1C, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x40, 0x02, 0x0C, 0x18,
  0x30, 0x40, 0x81, 0x06, 0x0C, 0x18, 0x30, 0x40, 0x83, 0x06, 0x0C, 0x18,
  0x20, 0x40, 0x83, 0x06, 0x0C, 0x18, 0x20, 0x41, 0x83, 0x06, 0x0C, 0x10,
  0x20, 0x41, 0x83, 0x06, 0x0C, 0x00, 0x02, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x1F, 0xC0, 0x02, 0x71,
  0xC0, 0x0D, 0x81, 0xC0, 0x13, 0x00, 0xC0, 0x6C, 0x00, 0xC1, 0x98, 0x00,
  0xFE, 0x00, 0x00, 0xF8, 0x00,
};

const GFXglyph RobotoMono_ExtraLightItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 7, 31, 25, 9, -31 },
  { 29, 9, 9, 25, 10, -32 },
  { 40, 25, 31, 25, 1, -31 },
  { 137, 20, 39, 25, 3, -35 },
  { 235, 20, 31, 25, 3, -31 },
  { 313, 21, 31, 25, 2, -31 },
  { 395, 4, 9, 25, 12, -32 },
  { 400, 14, 44, 25, 7, -34 },
  { 477, 13, 44, 25, 4, -34 },
  { 549, 18, 18, 25, 6, -31 },
  { 590, 20, 22, 25, 3, -25 },
  { 645, 5, 10, 25, 5, -4 },
  { 652, 15, 2, 25, 5, -15 },
  { 656, 3, 3, 25, 10, -3 },
  { 658, 20, 34, 25, 3, -31 },
  { 743, 20, 31, 25, 3, -31 },
  { 821, 11, 31, 25, 7, -31 },
  { 864, 20, 31, 25, 1, -31 },
  { 942, 21, 31, 25, 1, -31 },
  { 1024, 21, 31, 25, 1, -31 },
  { 1106, 21, 31, 25, 4, -31 },
  { 1188, 18, 31, 25, 3, -31 },
  { 1258, 20, 31, 25, 5, -31 },
  { 1336, 21, 31, 25, 3, -31 },
  { 1418, 19, 31, 25, 4, -31 },
  { 1492, 6, 21, 25, 11, -21 },
  { 1508, 9, 27, 25, 8, -21 },
  { 1539, 20, 18, 25, 3, -23 },
  { 1584, 20, 10, 25, 3, -19 },
  { 1609, 20, 18, 25, 2, -23 },
  { 1654, 16, 31, 25, 7, -31 },
  { 1716, 24, 31, 25, 1, -31 },
  { 1809, 21, 31, 25, 0, -31 },
  { 1891, 21, 31, 25, 2, -31 },
  { 1973, 21, 31, 25, 3, -31 },
  { 2055, 22, 31, 25, 2, -31 },
  { 2141, 23, 31, 25, 2, -31 },
  { 2231, 23, 31, 25, 2, -31 },
  { 2321, 22, 31, 25, 2, -31 },
  { 2407, 24, 31, 25, 1, -31 },
  { 2500, 22, 31, 25, 2, -31 },
  { 2586, 22, 31, 25, 2, -31 },
  { 2672, 24, 31, 25, 2, -31 },
  { 2765, 17, 31, 25, 3, -31 },
  { 2831, 24, 31, 25, 1, -31 },
  { 2924, 24, 31, 25, 1, -31 },
  { 3017, 20, 31, 25, 3, -31 },
  { 3095, 23, 31, 25, 2, -31 },
  { 3185, 22, 36, 25, 2, -31 },
  { 3284, 22, 31, 25, 2, -31 },
  { 3370, 22, 31, 25, 2, -31 },
  { 3456, 21, 31, 25, 5, -31 },
  { 3538, 22, 31, 25, 3, -31 },
  { 3624, 21, 31, 25, 5, -31 },
  { 3706, 23, 31, 25, 4, -31 },
  { 3796, 26, 31, 25, 0, -31 },
  { 3897, 21, 31, 25, 5, -31 },
  { 3979, 23, 31, 25, 1, -31 },
  { 4069, 14, 42, 25, 6, -35 },
  { 4143, 8, 34, 25, 9, -31 },
  { 4177, 13, 42, 25, 6, -35 },
  { 4246, 15, 17, 25, 5, -31 },
  { 4278, 18, 2, 25, 1, 0 },
  { 4283, 5, 6, 25, 13, -32 },
  { 4287, 20, 23, 25, 2, -23 },
  { 4345, 20, 32, 25, 2, -32 },
  { 4425, 19, 23, 25, 3, -23 },
  { 4480, 21, 32, 25, 3, -32 },
  { 4564, 19, 23, 25, 3, -23 },
  { 4619, 21, 33, 25, 5, -33 },
  { 4706, 21, 32, 25, 2, -23 },
  { 4790, 20, 32, 25, 2, -32 },
  { 4870, 18, 31, 25, 2, -31 },
  { 4940, 20, 40, 25, 0, -31 },
  { 5040, 20, 32, 25, 3, -32 },
  { 5120, 18, 32, 25, 2, -32 },
  { 5192, 24, 23, 25, 0, -23 },
  { 5261, 20, 23, 25, 2, -23 },
  { 5319, 20, 23, 25, 2, -23 },
  { 5377, 21, 32, 25, 1, -23 },
  { 5461, 19, 32, 25, 3, -23 },
  { 5537, 19, 23, 25, 5, -23 },
  { 5592, 19, 23, 25, 3, -23 },
  { 5647, 17, 29, 25, 5, -29 },
  { 5709, 20, 23, 25, 3, -23 },
  { 5767, 20, 23, 25, 4, -23 },
  { 5825, 23, 23, 25, 3, -23 },
  { 5892, 23, 23, 25, 1, -23 },
  { 5959, 26, 32, 25, -1, -23 },
  { 6063, 22, 23, 25, 1, -23 },
  { 6127, 16, 43, 25, 7, -34 },
  { 6213, 7, 37, 25, 9, -31 },
  { 6246, 16, 43, 25, 4, -34 },
  { 6332, 23, 7, 25, 1, -16 },
};

const GFXfont RobotoMono_ExtraLightItalic43pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic43pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic43pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC43PT7B_H_
