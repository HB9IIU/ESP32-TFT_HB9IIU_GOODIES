#ifndef _ROBOTOMONO_EXTRALIGHTITALIC41PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x41,
  0x83, 0x06, 0x0C, 0x10, 0x20, 0xC1, 0x83, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x07, 0x06, 0x00, 0x61, 0x63, 0x63, 0x43, 0x43, 0xC2, 0xC2, 0xC6, 0x86,
  0x00, 0x0C, 0x0C, 0x00, 0x30, 0x10, 0x00, 0x60, 0x60, 0x00, 0x80, 0x80,
  0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x08, 0x08, 0x00, 0x30, 0x30, 0x1F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x03, 0x03, 0x00, 0x04, 0x06, 0x00, 0x08,
  0x08, 0x00, 0x30, 0x30, 0x00, 0x40, 0x60, 0x01, 0x80, 0x80, 0x03, 0x03,
  0x00, 0x04, 0x04, 0x00, 0x18, 0x18, 0x07, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x04, 0x04, 0x00, 0x18, 0x18, 0x00,
  0x30, 0x30, 0x00, 0x40, 0x40, 0x01, 0x81, 0x80, 0x02, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x0F, 0xF0,
  0x07, 0x87, 0x01, 0xC0, 0x30, 0x70, 0x02, 0x0C, 0x00, 0x63, 0x00, 0x0C,
  0x60, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x98,
  0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x30, 0xC0, 0x06, 0x1C,
  0x03, 0x81, 0xE1, 0xE0, 0x0F, 0xF0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x01, 0xF8, 0x00, 0x18, 0xC0, 0x03,
  0x04, 0x00, 0x60, 0x40, 0x66, 0x06, 0x04, 0x40, 0x40, 0xC4, 0x04, 0x18,
  0x40, 0x43, 0x04, 0x0C, 0x20, 0x40, 0x86, 0x06, 0x18, 0xC0, 0x3F, 0x08,
  0x01, 0xC1, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x3C, 0x01, 0x87, 0xE0, 0x10, 0xC3, 0x03, 0x18, 0x10, 0x61, 0x01, 0x04,
  0x10, 0x10, 0xC3, 0x01, 0x18, 0x30, 0x33, 0x03, 0x03, 0x20, 0x30, 0x20,
  0x03, 0x06, 0x00, 0x18, 0xC0, 0x00, 0xF8, 0x00, 0x10, 0x00, 0x0F, 0xE0,
  0x01, 0xC3, 0x00, 0x38, 0x30, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x00, 0x60, 0x30, 0x06, 0x03, 0x00, 0x60, 0x60, 0x02, 0x0C, 0x00, 0x33,
  0x80, 0x03, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x0C,
  0x60, 0x01, 0x86, 0x03, 0x30, 0x30, 0x36, 0x03, 0x03, 0x60, 0x18, 0x6C,
  0x00, 0xC6, 0xC0, 0x0C, 0xCC, 0x00, 0x6C, 0xC0, 0x03, 0x8C, 0x00, 0x30,
  0x60, 0x07, 0x86, 0x00, 0xC8, 0x38, 0x78, 0xC1, 0xFE, 0x06, 0x6D, 0xA5,
  0xB6, 0x80, 0x00, 0x08, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08,
  0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00,
  0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0xC0,
  0x02, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00,
  0x20, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x10, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01,
  0x00, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x18, 0x03, 0x00, 0x60,
  0x08, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x10, 0x10, 0x3F, 0x8C, 0x7C, 0x7B, 0x78, 0x03, 0xF0, 0x00, 0x70,
  0x00, 0x36, 0x00, 0x18, 0x80, 0x0C, 0x30, 0x07, 0x06, 0x03, 0x81, 0x81,
  0xC0, 0x30, 0x20, 0x08, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x7F, 0xFF, 0xF8, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x8C,
  0x63, 0x31, 0x98, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x1F, 0xE0, 0x0E, 0x0E, 0x03, 0x00, 0x60, 0xC0, 0x0C,
  0x18, 0x00, 0x86, 0x00, 0x18, 0x80, 0x03, 0x30, 0x00, 0x66, 0x00, 0x1C,
  0x80, 0x0F, 0xB0, 0x03, 0x36, 0x00, 0xC6, 0xC0, 0x30, 0xD8, 0x0C, 0x12,
  0x07, 0x02, 0xC1, 0x80, 0xD8, 0x60, 0x1B, 0x18, 0x03, 0x66, 0x00, 0x4F,
  0x80, 0x09, 0xC0, 0x03, 0x30, 0x00, 0x66, 0x00, 0x18, 0xC0, 0x03, 0x08,
  0x00, 0xC1, 0x80, 0x30, 0x38, 0x0E, 0x03, 0x87, 0x80, 0x1F, 0xC0, 0x00,
  0x00, 0x60, 0x3C, 0x3D, 0x9E, 0x26, 0x05, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x10, 0x02, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x1F, 0xE0, 0x0E, 0x0E, 0x03,
  0x80, 0x60, 0xC0, 0x06, 0x18, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x10,
  0x00, 0x64, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0xFF,
  0xF9, 0xFF, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xF8, 0x01, 0xC1, 0xC0,
  0x30, 0x06, 0x06, 0x00, 0x60, 0xC0, 0x03, 0x0C, 0x00, 0x31, 0x80, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x01, 0x84, 0x00, 0x18, 0x60, 0x03, 0x03,
  0x00, 0x60, 0x1C, 0x3C, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x34, 0x00, 0x06, 0xC0, 0x00, 0xCC, 0x00, 0x18,
  0xC0, 0x01, 0x8C, 0x00, 0x30, 0x80, 0x06, 0x08, 0x00, 0xC1, 0x80, 0x18,
  0x18, 0x01, 0x81, 0x80, 0x30, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x18,
  0x03, 0x03, 0x00, 0x30, 0x30, 0x03, 0x06, 0x00, 0x30, 0xFF, 0xFF, 0xF0,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0x80, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x08,
  0x00, 0x37, 0xF8, 0x01, 0xF0, 0xF0, 0x0C, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x20, 0x00, 0xC1, 0x00, 0x06, 0x08, 0x00, 0x20, 0x60,
  0x03, 0x03, 0x00, 0x30, 0x0C, 0x03, 0x00, 0x38, 0x70, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x0F, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x0F, 0xC0, 0xCF, 0x3C, 0x3E, 0x03, 0x8E, 0x00, 0x67, 0x00, 0x0D, 0x80,
  0x03, 0x60, 0x00, 0xD8, 0x00, 0x34, 0x00, 0x0D, 0x00, 0x03, 0x40, 0x00,
  0xD0, 0x00, 0x34, 0x00, 0x19, 0x80, 0x06, 0x60, 0x03, 0x0C, 0x01, 0xC3,
  0x80, 0xE0, 0x70, 0xF0, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x03, 0xFC, 0x00, 0x78, 0x38,
  0x07, 0x00, 0xC0, 0x70, 0x03, 0x03, 0x00, 0x18, 0x30, 0x00, 0x41, 0x80,
  0x02, 0x0C, 0x00, 0x10, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00, 0xC0,
  0x60, 0x0C, 0x03, 0x81, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0x03,
  0x00, 0xE0, 0x0C, 0x0C, 0x00, 0x30, 0x60, 0x00, 0x86, 0x00, 0x06, 0x30,
  0x00, 0x31, 0x00, 0x01, 0x88, 0x00, 0x08, 0x40, 0x00, 0xC3, 0x00, 0x06,
  0x18, 0x00, 0x60, 0x60, 0x0E, 0x01, 0xE1, 0xE0, 0x07, 0xFC, 0x00, 0x00,
  0x20, 0x00, 0xFF, 0x00, 0x70, 0x60, 0x30, 0x0C, 0x18, 0x01, 0x8C, 0x00,
  0x66, 0x00, 0x09, 0x80, 0x02, 0x40, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x02, 0xC0, 0x00, 0xB0, 0x00, 0x6C, 0x00, 0x19, 0x00, 0x0E, 0x60,
  0x07, 0x9C, 0x03, 0x43, 0x83, 0xB0, 0x7F, 0x8C, 0x02, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x0C, 0x38, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x87,
  0x0E, 0x00, 0x03, 0x07, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x10, 0x30, 0x30,
  0x30, 0x60, 0x60, 0xC0, 0x80, 0x00, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x9F, 0xFF, 0xF0, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x40, 0x07, 0xF8, 0x1E, 0x1C, 0x38, 0x06, 0x30,
  0x06, 0x60, 0x02, 0x40, 0x02, 0xC0, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xE0, 0xE0, 0x07, 0x00, 0x60,
  0x18, 0x00, 0x60, 0x60, 0x00, 0x40, 0x80, 0x00, 0x83, 0x07, 0xC1, 0x8C,
  0x18, 0xC3, 0x10, 0x60, 0x86, 0x61, 0x81, 0x0C, 0x82, 0x06, 0x1B, 0x0C,
  0x08, 0x36, 0x10, 0x10, 0x48, 0x60, 0x60, 0x90, 0xC0, 0xC1, 0x61, 0x01,
  0x02, 0xC2, 0x02, 0x0D, 0x04, 0x0C, 0x12, 0x18, 0x18, 0x24, 0x10, 0x60,
  0xC8, 0x21, 0x63, 0x18, 0x66, 0xCC, 0x30, 0x78, 0xF0, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x08, 0x00, 0xF0, 0xF0, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x58, 0x00, 0x0D, 0x80, 0x00, 0x98, 0x00, 0x19, 0x80, 0x01, 0x18, 0x00,
  0x30, 0x80, 0x02, 0x08, 0x00, 0x60, 0xC0, 0x04, 0x0C, 0x00, 0xC0, 0xC0,
  0x08, 0x0C, 0x01, 0x80, 0xC0, 0x10, 0x04, 0x03, 0x00, 0x40, 0x20, 0x06,
  0x06, 0x00, 0x60, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xC0, 0x06, 0x18, 0x00,
  0x21, 0x80, 0x02, 0x30, 0x00, 0x33, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00,
  0x03, 0xC0, 0x00, 0x30, 0x07, 0xFF, 0x00, 0x40, 0xFC, 0x0C, 0x00, 0xE0,
  0xC0, 0x06, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0x80, 0x03,
  0x18, 0x00, 0x31, 0x80, 0x06, 0x18, 0x00, 0x61, 0x80, 0x0C, 0x10, 0x03,
  0x81, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0x00, 0x38, 0x30, 0x00, 0xC3, 0x00,
  0x0C, 0x20, 0x00, 0x62, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60,
  0x00, 0xC6, 0x00, 0x0C, 0x40, 0x01, 0x84, 0x00, 0x38, 0xC0, 0x07, 0x0F,
  0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x03, 0xFC, 0x00, 0x70,
  0x70, 0x06, 0x00, 0xC0, 0x60, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC3,
  0x00, 0x02, 0x18, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x31, 0x00, 0x03, 0x08, 0x00, 0x18, 0x60, 0x01, 0x83, 0x00,
  0x0C, 0x0C, 0x00, 0xC0, 0x60, 0x0C, 0x01, 0xC3, 0xC0, 0x07, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x60, 0x7C, 0x03, 0x00, 0x70, 0x18, 0x01, 0xC0, 0xC0,
  0x06, 0x04, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x02, 0x18, 0x00, 0x10,
  0xC0, 0x00, 0xC4, 0x00, 0x06, 0x20, 0x00, 0x33, 0x00, 0x01, 0x18, 0x00,
  0x08, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x20, 0x00, 0x31, 0x00, 0x01, 0x98,
  0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x04, 0x30, 0x00, 0x61, 0x00, 0x06,
  0x08, 0x00, 0x30, 0xC0, 0x03, 0x06, 0x00, 0x70, 0x30, 0x07, 0x01, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFC, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x03, 0xFC, 0x00,
  0x70, 0x70, 0x06, 0x00, 0xC0, 0x60, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00,
  0x43, 0x00, 0x03, 0x10, 0x00, 0x19, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x1F, 0xE2, 0x01, 0xFF, 0x30, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00,
  0x06, 0x60, 0x00, 0x31, 0x00, 0x01, 0x08, 0x00, 0x08, 0x60, 0x00, 0xC3,
  0x00, 0x06, 0x0C, 0x00, 0x30, 0x30, 0x07, 0x01, 0xE1, 0xE0, 0x03, 0xFC,
  0x00, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x08, 0x10, 0x00, 0x10, 0x20, 0x00,
  0x60, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x02, 0x06, 0x00, 0x04,
  0x08, 0x00, 0x18, 0x10, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1,
  0x80, 0x01, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x08, 0x00, 0x18, 0x30,
  0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0x81, 0x00, 0x01, 0x02, 0x00,
  0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x20, 0x60, 0x00,
  0x40, 0x80, 0x00, 0x81, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C,
  0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x01,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xC1, 0x00, 0x03, 0x04, 0x00, 0x08, 0x10, 0x00, 0x60,
  0x60, 0x03, 0x01, 0x80, 0x0C, 0x03, 0x00, 0xE0, 0x07, 0x0F, 0x00, 0x0F,
  0xF0, 0x00, 0x06, 0x00, 0x0E, 0x0C, 0x00, 0x30, 0x10, 0x00, 0xC0, 0x60,
  0x03, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00, 0xC0, 0x06, 0x03,
  0x00, 0x08, 0x0C, 0x00, 0x30, 0x30, 0x00, 0x60, 0xC0, 0x00, 0xC3, 0x00,
  0x01, 0x8C, 0x00, 0x02, 0x38, 0x00, 0x05, 0xF0, 0x00, 0x1F, 0x30, 0x00,
  0x3C, 0x30, 0x00, 0x70, 0x60, 0x00, 0xC0, 0x60, 0x01, 0x00, 0xC0, 0x02,
  0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x01, 0x80, 0x60,
  0x03, 0x00, 0x80, 0x03, 0x01, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0C, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00,
  0x70, 0x28, 0x01, 0xA0, 0x58, 0x03, 0xC1, 0xB0, 0x0D, 0x83, 0x60, 0x1B,
  0x06, 0xC0, 0x66, 0x0C, 0x80, 0xC8, 0x11, 0x03, 0x10, 0x23, 0x04, 0x60,
  0xC6, 0x18, 0xC1, 0x8C, 0x61, 0x83, 0x08, 0xC3, 0x06, 0x13, 0x04, 0x08,
  0x36, 0x18, 0x10, 0x78, 0x30, 0x60, 0xE0, 0x60, 0xC0, 0xC0, 0xC1, 0x81,
  0x01, 0x03, 0x00, 0x02, 0x04, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00,
  0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0x81, 0x00, 0x01, 0x02, 0x00, 0x06,
  0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x0E, 0x00, 0x08, 0x1C, 0x00,
  0x30, 0x28, 0x00, 0x60, 0xD8, 0x00, 0xC1, 0xB0, 0x01, 0x83, 0x20, 0x02,
  0x06, 0x60, 0x04, 0x08, 0xC0, 0x18, 0x10, 0x80, 0x30, 0x61, 0x80, 0x60,
  0xC3, 0x00, 0xC1, 0x83, 0x01, 0x03, 0x06, 0x02, 0x04, 0x04, 0x0C, 0x08,
  0x0C, 0x18, 0x30, 0x18, 0x30, 0x60, 0x10, 0x60, 0xC0, 0x30, 0x81, 0x80,
  0x63, 0x02, 0x00, 0x46, 0x04, 0x00, 0xCC, 0x18, 0x00, 0x98, 0x30, 0x01,
  0xA0, 0x60, 0x03, 0x40, 0xC0, 0x03, 0x81, 0x00, 0x07, 0x06, 0x00, 0x0E,
  0x0C, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xF8, 0x01, 0xC1, 0xC0,
  0x30, 0x0E, 0x06, 0x00, 0x60, 0xC0, 0x02, 0x0C, 0x00, 0x31, 0x80, 0x03,
  0x18, 0x00, 0x13, 0x00, 0x01, 0x30, 0x00, 0x13, 0x00, 0x01, 0x20, 0x00,
  0x36, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x34, 0x00,
  0x02, 0x40, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x04, 0x40,
  0x00, 0xC4, 0x00, 0x08, 0x60, 0x01, 0x86, 0x00, 0x30, 0x30, 0x07, 0x03,
  0x80, 0xE0, 0x1C, 0x3C, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x80, 0x18, 0x07,
  0x80, 0x60, 0x07, 0x01, 0x80, 0x06, 0x04, 0x00, 0x18, 0x30, 0x00, 0x20,
  0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x08, 0x20, 0x00, 0x60, 0x80,
  0x01, 0x86, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x01, 0x81, 0x80, 0x1C,
  0x07, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x07, 0xFC, 0x00, 0x70, 0x70, 0x06,
  0x00, 0xC0, 0x60, 0x02, 0x06, 0x00, 0x18, 0x60, 0x00, 0x43, 0x00, 0x02,
  0x30, 0x00, 0x19, 0x80, 0x00, 0xC8, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00,
  0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x48, 0x00, 0x02, 0xC0, 0x00, 0x36,
  0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x4C, 0x00, 0x06, 0x60, 0x00,
  0x33, 0x00, 0x01, 0x18, 0x00, 0x18, 0x40, 0x01, 0x83, 0x00, 0x0C, 0x08,
  0x00, 0xC0, 0x60, 0x1C, 0x01, 0xC3, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x07,
  0xFF, 0x00, 0x30, 0x3E, 0x01, 0x00, 0x38, 0x08, 0x00, 0xC0, 0xC0, 0x03,
  0x06, 0x00, 0x18, 0x30, 0x00, 0x41, 0x80, 0x02, 0x08, 0x00, 0x10, 0xC0,
  0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0xC1, 0x80, 0x0E, 0x08, 0x00, 0xE0,
  0x40, 0x0C, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0x80, 0x60, 0x0C, 0x03,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x60, 0x30, 0x03, 0x01, 0x80, 0x0C, 0x0C,
  0x00, 0x60, 0x60, 0x03, 0x02, 0x00, 0x0C, 0x10, 0x00, 0x61, 0x80, 0x03,
  0x0C, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xFC, 0x00, 0x70, 0x70,
  0x0E, 0x00, 0xC0, 0x60, 0x03, 0x06, 0x00, 0x18, 0x20, 0x00, 0x63, 0x00,
  0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0xC3, 0x00, 0x06,
  0x18, 0x00, 0x60, 0x60, 0x06, 0x01, 0xE1, 0xE0, 0x03, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x18, 0xC0, 0x00, 0x84, 0x00, 0x04, 0x20, 0x00, 0x63, 0x00,
  0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0x86, 0x00, 0x04, 0x20, 0x00, 0x61,
  0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x04, 0x30, 0x00,
  0x21, 0x00, 0x03, 0x08, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30,
  0x00, 0x21, 0x00, 0x01, 0x08, 0x00, 0x18, 0x40, 0x00, 0xC2, 0x00, 0x04,
  0x18, 0x00, 0x60, 0xC0, 0x06, 0x03, 0x00, 0x70, 0x18, 0x07, 0x00, 0x70,
  0xF0, 0x01, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x7C, 0x00, 0x06, 0xC0, 0x00,
  0xCC, 0x00, 0x0C, 0xC0, 0x00, 0x8C, 0x00, 0x18, 0x40, 0x01, 0x06, 0x00,
  0x30, 0x60, 0x03, 0x06, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0xC0, 0x20,
  0x0C, 0x02, 0x01, 0x80, 0x30, 0x18, 0x03, 0x03, 0x00, 0x30, 0x30, 0x03,
  0x06, 0x00, 0x10, 0x60, 0x01, 0x04, 0x00, 0x10, 0xC0, 0x01, 0x88, 0x00,
  0x19, 0x80, 0x01, 0x90, 0x00, 0x1B, 0x00, 0x00, 0xB0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x6C,
  0x07, 0x01, 0xB0, 0x1C, 0x04, 0xC0, 0x70, 0x13, 0x03, 0xC0, 0xCC, 0x0F,
  0x03, 0x30, 0x2C, 0x08, 0xC1, 0x90, 0x63, 0x06, 0x41, 0x8C, 0x11, 0x04,
  0x30, 0xC4, 0x30, 0xC2, 0x10, 0xC3, 0x18, 0x42, 0x0C, 0x61, 0x08, 0x31,
  0x04, 0x60, 0xCC, 0x11, 0x83, 0x30, 0x44, 0x0C, 0x81, 0x30, 0x36, 0x04,
  0xC0, 0xD8, 0x12, 0x03, 0x40, 0x58, 0x0F, 0x01, 0x60, 0x3C, 0x05, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x00, 0x07, 0x00, 0x03, 0x81, 0x80, 0x03, 0x00, 0xC0, 0x01, 0x80,
  0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x06, 0x01, 0x80, 0x03, 0x00, 0xC0,
  0x00, 0xC0, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x0C, 0x60,
  0x00, 0x02, 0x60, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x36, 0x00, 0x00, 0x33, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x18, 0x60, 0x00, 0x18, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x18,
  0x02, 0x00, 0x0C, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x0C,
  0x00, 0x18, 0x06, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x7C,
  0x00, 0x06, 0xC0, 0x00, 0xC6, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x30,
  0x30, 0x06, 0x03, 0x00, 0x40, 0x30, 0x0C, 0x01, 0x81, 0x80, 0x18, 0x10,
  0x00, 0x83, 0x00, 0x0C, 0x60, 0x00, 0xC4, 0x00, 0x04, 0xC0, 0x00, 0x58,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x18, 0x00, 0xC0, 0x04,
  0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00,
  0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0xF8, 0x00, 0xC0, 0x40,
  0x40, 0x60, 0x60, 0x60, 0x20, 0x20, 0x30, 0x30, 0x30, 0x10, 0x10, 0x18,
  0x18, 0x18, 0x08, 0x08, 0x0C, 0x0C, 0x0C, 0x04, 0x04, 0x06, 0x06, 0x06,
  0x02, 0x02, 0x03, 0x03, 0x03, 0x01, 0x03, 0xF0, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x04, 0x00, 0x40, 0xFC, 0x00, 0x00, 0x60, 0x03, 0x80, 0x0A, 0x00, 0x68,
  0x03, 0x30, 0x0C, 0xC0, 0x63, 0x01, 0x84, 0x0C, 0x18, 0x20, 0x61, 0x81,
  0x84, 0x02, 0x30, 0x09, 0x80, 0x36, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xC3, 0x08, 0x61, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1C,
  0x06, 0x06, 0x00, 0x61, 0x80, 0x04, 0x30, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x0F, 0xFF, 0x07, 0x80, 0x63, 0x80,
  0x0C, 0xE0, 0x01, 0x18, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00,
  0x73, 0x00, 0x1E, 0x30, 0x0E, 0x83, 0x87, 0x98, 0x3F, 0xC3, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x0F, 0xC0, 0x27,
  0xFC, 0x0D, 0x80, 0xC1, 0xE0, 0x0C, 0x38, 0x01, 0x86, 0x00, 0x10, 0x80,
  0x03, 0x10, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00, 0x33, 0x00,
  0x04, 0x40, 0x01, 0x88, 0x00, 0x33, 0x00, 0x06, 0x60, 0x01, 0x8C, 0x00,
  0x31, 0x80, 0x0C, 0x38, 0x03, 0x8D, 0x00, 0xE1, 0xB8, 0x78, 0x31, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0xE0, 0x30, 0x70, 0x06, 0x18, 0x00,
  0x8C, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0x40, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x04, 0xC0, 0x03, 0x30, 0x00, 0xC6, 0x00, 0x61, 0xC0, 0x30, 0x38, 0x38,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x1F, 0x84, 0x07, 0xFC, 0xC0, 0xE0, 0x6C, 0x18, 0x01, 0xC3,
  0x80, 0x1C, 0x30, 0x00, 0xC6, 0x00, 0x08, 0x60, 0x01, 0x84, 0x00, 0x18,
  0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x10, 0xC0, 0x03,
  0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x06, 0x06, 0x00,
  0xE0, 0x60, 0x1A, 0x03, 0x87, 0x60, 0x1F, 0xC6, 0x00, 0x00, 0x7E, 0x00,
  0x3F, 0xE0, 0x1C, 0x06, 0x07, 0x00, 0x60, 0xC0, 0x04, 0x30, 0x00, 0xCC,
  0x00, 0x19, 0x80, 0x03, 0x60, 0x00, 0x6F, 0xFF, 0xFD, 0xFF, 0xFF, 0xB0,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x06, 0x0C, 0x01, 0x80, 0xE1, 0xE0, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xE3, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFC, 0x20, 0x7F,
  0xC4, 0x1C, 0x0D, 0x86, 0x00, 0xF1, 0xC0, 0x0E, 0x30, 0x00, 0xCC, 0x00,
  0x11, 0x80, 0x02, 0x20, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00,
  0x66, 0x00, 0x08, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01,
  0x8C, 0x00, 0x70, 0xC0, 0x1C, 0x18, 0x06, 0x81, 0xC3, 0xB0, 0x1F, 0xC6,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x82, 0x00, 0x30,
  0x60, 0x0C, 0x06, 0x07, 0x00, 0x7F, 0xC0, 0x03, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x07, 0xE0, 0x63, 0xFE,
  0x0C, 0xC0, 0xE1, 0xA0, 0x0C, 0x38, 0x00, 0x86, 0x00, 0x18, 0xC0, 0x03,
  0x30, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x01, 0x18, 0x00, 0x62, 0x00, 0x0C,
  0x40, 0x01, 0x98, 0x00, 0x33, 0x00, 0x04, 0x60, 0x00, 0x8C, 0x00, 0x31,
  0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x02, 0x30, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x0F, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x0C, 0x60, 0x07, 0x0C,
  0x01, 0xC1, 0x00, 0x60, 0x20, 0x18, 0x0C, 0x0E, 0x01, 0x83, 0x80, 0x30,
  0xC0, 0x06, 0x30, 0x00, 0x9C, 0x00, 0x37, 0x80, 0x07, 0x98, 0x00, 0xE1,
  0x80, 0x18, 0x30, 0x03, 0x03, 0x00, 0x40, 0x30, 0x18, 0x06, 0x03, 0x00,
  0x60, 0x60, 0x06, 0x0C, 0x00, 0xE1, 0x80, 0x0C, 0x20, 0x00, 0xC0, 0x03,
  0xFE, 0x03, 0xFF, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C,
  0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x19, 0xF0, 0xF8, 0x37, 0xF3, 0xF8, 0x70,
  0x6C, 0x18, 0xC0, 0x70, 0x31, 0x80, 0xC0, 0x66, 0x01, 0x80, 0xCC, 0x02,
  0x01, 0x98, 0x04, 0x03, 0x30, 0x18, 0x04, 0x40, 0x30, 0x08, 0x80, 0x60,
  0x33, 0x00, 0xC0, 0x66, 0x01, 0x00, 0xCC, 0x06, 0x01, 0x98, 0x0C, 0x02,
  0x20, 0x18, 0x04, 0x40, 0x30, 0x19, 0x80, 0x40, 0x33, 0x00, 0x80, 0x66,
  0x03, 0x00, 0xC8, 0x06, 0x01, 0x10, 0x0C, 0x02, 0x00, 0x08, 0x3E, 0x03,
  0x1F, 0xF0, 0x66, 0x07, 0x0D, 0x00, 0x61, 0x40, 0x04, 0x30, 0x00, 0xC6,
  0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x46, 0x00, 0x08, 0xC0, 0x03, 0x10,
  0x00, 0x66, 0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00, 0x23, 0x00, 0x04, 0x60,
  0x01, 0x88, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x11, 0x80,
  0x06, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1C, 0x06, 0x06, 0x00, 0x61,
  0x80, 0x0C, 0x60, 0x00, 0xCC, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x6C,
  0x00, 0x0D, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x36, 0x00, 0x06, 0x40, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x0C, 0x18,
  0x07, 0x01, 0xC3, 0xC0, 0x1F, 0xE0, 0x00, 0x04, 0x3F, 0x00, 0xCF, 0xF8,
  0x0D, 0x80, 0xC0, 0xF0, 0x06, 0x0E, 0x00, 0x60, 0xC0, 0x06, 0x08, 0x00,
  0x21, 0x80, 0x03, 0x18, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x21, 0x80,
  0x02, 0x10, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x0C, 0x30,
  0x00, 0xC3, 0x00, 0x18, 0x30, 0x03, 0x07, 0x80, 0x70, 0x6E, 0x1E, 0x06,
  0x3F, 0x80, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x01, 0xF8,
  0x41, 0xFF, 0x90, 0xE0, 0x6C, 0x60, 0x07, 0x38, 0x01, 0xCC, 0x00, 0x36,
  0x00, 0x09, 0x80, 0x02, 0x40, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00,
  0x06, 0xC0, 0x01, 0x30, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x03,
  0x30, 0x01, 0x86, 0x00, 0xE1, 0x80, 0x68, 0x38, 0x76, 0x07, 0xF1, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x0C, 0x1F, 0xC2, 0x1F, 0xE0, 0x9C,
  0x00, 0x6C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF,
  0xC0, 0xC0, 0x18, 0x60, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00,
  0x4C, 0x00, 0x31, 0x80, 0x18, 0x38, 0x3C, 0x07, 0xFE, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0E, 0x08, 0x03, 0xF8, 0x10, 0x00, 0x66, 0x00, 0x08, 0xC0, 0x01, 0x18,
  0x00, 0x63, 0x00, 0x0C, 0x40, 0x01, 0x88, 0x00, 0x33, 0x00, 0x04, 0x60,
  0x00, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x20, 0x00, 0xC4, 0x00, 0x19, 0x80,
  0x02, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0xE1, 0x00,
  0x3C, 0x30, 0x0D, 0x03, 0x87, 0x20, 0x3F, 0x8C, 0x00, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0x60, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x06, 0x18,
  0x00, 0xC1, 0x00, 0x30, 0x30, 0x04, 0x06, 0x01, 0x80, 0xC0, 0x20, 0x08,
  0x0C, 0x01, 0x83, 0x00, 0x30, 0x60, 0x06, 0x18, 0x00, 0x43, 0x00, 0x0C,
  0xC0, 0x01, 0x90, 0x00, 0x36, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x20, 0x0F, 0x00, 0x80, 0x6C, 0x07, 0x01, 0xB0, 0x1C,
  0x04, 0xC0, 0xF0, 0x33, 0x02, 0xC0, 0x8C, 0x1B, 0x06, 0x30, 0x6C, 0x18,
  0xC1, 0x30, 0x43, 0x0C, 0x43, 0x0C, 0x21, 0x0C, 0x11, 0x84, 0x20, 0x46,
  0x11, 0x81, 0x10, 0x44, 0x04, 0xC1, 0x30, 0x12, 0x04, 0xC0, 0x58, 0x1A,
  0x01, 0x40, 0x78, 0x05, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x60, 0x1C, 0x01,
  0x80, 0x20, 0x00, 0x0C, 0x00, 0x1C, 0x30, 0x00, 0x60, 0x60, 0x03, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0xC0, 0x06, 0x06, 0x00, 0x18, 0x30, 0x00, 0x31,
  0x80, 0x00, 0x6C, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x30, 0x00, 0x18, 0xC0, 0x00, 0xC1, 0x80, 0x06,
  0x06, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x18, 0x0C, 0x00, 0x60, 0x60, 0x00,
  0xC3, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x01, 0x82, 0x00, 0x01, 0x81, 0x80,
  0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x00, 0x30, 0x00, 0xC0, 0x30, 0x00,
  0x60, 0x18, 0x00, 0x30, 0x18, 0x00, 0x08, 0x0C, 0x00, 0x06, 0x0C, 0x00,
  0x03, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF0, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x02,
  0x04, 0x18, 0x30, 0x60, 0xC1, 0x02, 0x04, 0x18, 0x30, 0x60, 0x81, 0x02,
  0x0C, 0x18, 0x30, 0x40, 0x81, 0x06, 0x0C, 0x18, 0x30, 0x40, 0x81, 0x06,
  0x0C, 0x18, 0x20, 0x40, 0x83, 0x00, 0x01, 0x00, 0x03, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x7F, 0x00, 0x33, 0x0E, 0x00, 0xD8, 0x1C,
  0x02, 0xC0, 0x38, 0x1B, 0x00, 0x79, 0xC8, 0x00, 0x7E, 0x00,
};

const GFXglyph RobotoMono_ExtraLightItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 7, 29, 24, 8, -29 },
  { 27, 8, 9, 24, 10, -31 },
  { 36, 23, 29, 24, 1, -29 },
  { 120, 19, 37, 24, 3, -33 },
  { 208, 20, 30, 24, 2, -30 },
  { 283, 20, 30, 24, 2, -30 },
  { 358, 3, 9, 24, 12, -31 },
  { 362, 13, 42, 24, 7, -33 },
  { 431, 12, 42, 24, 4, -33 },
  { 494, 18, 17, 24, 5, -29 },
  { 533, 20, 21, 24, 2, -24 },
  { 586, 5, 9, 24, 5, -3 },
  { 592, 14, 2, 24, 5, -14 },
  { 596, 3, 3, 24, 9, -3 },
  { 598, 19, 31, 24, 3, -29 },
  { 672, 19, 30, 24, 3, -30 },
  { 744, 11, 29, 24, 6, -29 },
  { 784, 19, 30, 24, 1, -30 },
  { 856, 20, 30, 24, 1, -30 },
  { 931, 20, 29, 24, 1, -29 },
  { 1004, 21, 29, 24, 3, -29 },
  { 1081, 18, 29, 24, 2, -29 },
  { 1147, 19, 29, 24, 5, -29 },
  { 1216, 21, 30, 24, 2, -30 },
  { 1295, 18, 30, 24, 4, -30 },
  { 1363, 7, 21, 24, 10, -21 },
  { 1382, 8, 27, 24, 8, -21 },
  { 1409, 19, 17, 24, 3, -22 },
  { 1450, 19, 10, 24, 3, -18 },
  { 1474, 19, 17, 24, 2, -22 },
  { 1515, 16, 30, 24, 6, -30 },
  { 1575, 23, 29, 24, 1, -29 },
  { 1659, 20, 29, 24, 0, -29 },
  { 1732, 20, 29, 24, 2, -29 },
  { 1805, 21, 30, 24, 2, -30 },
  { 1884, 21, 29, 24, 2, -29 },
  { 1961, 21, 29, 24, 2, -29 },
  { 2038, 22, 29, 24, 2, -29 },
  { 2118, 21, 30, 24, 2, -30 },
  { 2197, 23, 29, 24, 1, -29 },
  { 2281, 21, 29, 24, 2, -29 },
  { 2358, 22, 29, 24, 1, -29 },
  { 2438, 23, 29, 24, 2, -29 },
  { 2522, 17, 29, 24, 2, -29 },
  { 2584, 23, 29, 24, 1, -29 },
  { 2668, 23, 29, 24, 1, -29 },
  { 2752, 20, 30, 24, 2, -30 },
  { 2827, 22, 29, 24, 2, -29 },
  { 2907, 21, 35, 24, 2, -30 },
  { 2999, 21, 29, 24, 2, -29 },
  { 3076, 21, 30, 24, 2, -30 },
  { 3155, 20, 29, 24, 5, -29 },
  { 3228, 21, 29, 24, 3, -29 },
  { 3305, 20, 29, 24, 5, -29 },
  { 3378, 22, 29, 24, 4, -29 },
  { 3458, 25, 29, 24, 0, -29 },
  { 3549, 20, 29, 24, 5, -29 },
  { 3622, 22, 29, 24, 1, -29 },
  { 3702, 13, 39, 24, 6, -33 },
  { 3766, 8, 32, 24, 8, -29 },
  { 3798, 12, 39, 24, 6, -33 },
  { 3857, 14, 16, 24, 5, -29 },
  { 3885, 17, 2, 24, 1, 0 },
  { 3890, 5, 5, 24, 12, -30 },
  { 3894, 19, 22, 24, 2, -22 },
  { 3947, 19, 31, 24, 2, -31 },
  { 4021, 18, 22, 24, 3, -22 },
  { 4071, 20, 31, 24, 3, -31 },
  { 4149, 19, 22, 24, 2, -22 },
  { 4202, 20, 31, 24, 5, -31 },
  { 4280, 19, 31, 24, 2, -22 },
  { 4354, 19, 31, 24, 2, -31 },
  { 4428, 17, 29, 24, 2, -29 },
  { 4490, 19, 38, 24, 0, -29 },
  { 4581, 19, 31, 24, 3, -31 },
  { 4655, 17, 31, 24, 2, -31 },
  { 4721, 23, 22, 24, 0, -22 },
  { 4785, 19, 22, 24, 2, -22 },
  { 4838, 19, 22, 24, 2, -22 },
  { 4891, 20, 30, 24, 1, -22 },
  { 4966, 18, 30, 24, 3, -22 },
  { 5034, 18, 22, 24, 5, -22 },
  { 5084, 18, 22, 24, 3, -22 },
  { 5134, 16, 27, 24, 5, -27 },
  { 5188, 19, 22, 24, 3, -22 },
  { 5241, 19, 22, 24, 4, -22 },
  { 5294, 22, 22, 24, 3, -22 },
  { 5355, 22, 22, 24, 1, -22 },
  { 5416, 25, 31, 24, -1, -22 },
  { 5513, 21, 22, 24, 1, -22 },
  { 5571, 16, 40, 24, 6, -32 },
  { 5651, 7, 35, 24, 8, -29 },
  { 5682, 16, 40, 24, 3, -32 },
  { 5762, 22, 7, 24, 1, -16 },
};

const GFXfont RobotoMono_ExtraLightItalic41pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic41pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic41pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC41PT7B_H_
