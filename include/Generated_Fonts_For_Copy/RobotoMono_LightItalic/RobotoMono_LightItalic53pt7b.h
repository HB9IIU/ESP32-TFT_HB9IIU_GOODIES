#ifndef _ROBOTOMONO_LIGHTITALIC53PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x1E, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x1E, 0x0F, 0x07, 0x00, 0x38, 0x33, 0x07, 0x30,
  0x77, 0x07, 0x70, 0x77, 0x06, 0x70, 0x66, 0x0E, 0x60, 0xEE, 0x0C, 0xE0,
  0xCC, 0x0C, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x60, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x38, 0x06, 0x00, 0x00, 0x60,
  0x1C, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x06, 0x01,
  0xC0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x80, 0x06, 0x01, 0xC0,
  0x00, 0x1C, 0x03, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x60, 0x1C, 0x00,
  0x01, 0xC0, 0x30, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0x80, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x01,
  0xC0, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x18, 0x07,
  0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x01, 0x80, 0x70,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0xF0, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0x3C, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x1E, 0x00, 0x0F, 0x03, 0x80, 0x07,
  0x80, 0xF0, 0x03, 0xE0, 0x1F, 0x87, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x18, 0x00, 0x1C, 0x06,
  0x01, 0xC6, 0x01, 0xC0, 0x61, 0x80, 0x60, 0x38, 0x60, 0x18, 0x1C, 0x38,
  0x06, 0x0E, 0x0E, 0x03, 0x83, 0x83, 0x80, 0xE1, 0xC0, 0x60, 0x30, 0xE0,
  0x1C, 0x1C, 0x30, 0x07, 0xBE, 0x1C, 0x00, 0xFF, 0x0E, 0x00, 0x0F, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x07, 0x07, 0xE0, 0x01, 0x87, 0xFC,
  0x00, 0xE3, 0xC3, 0x80, 0x70, 0xE0, 0x60, 0x18, 0x70, 0x18, 0x0E, 0x1C,
  0x07, 0x07, 0x06, 0x01, 0xC3, 0x81, 0x80, 0x60, 0xC0, 0x60, 0x18, 0x70,
  0x38, 0x06, 0x38, 0x0E, 0x03, 0x84, 0x03, 0x80, 0xE0, 0x00, 0x60, 0x70,
  0x00, 0x1C, 0x38, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFB, 0xE0, 0x00,
  0x3C, 0x1E, 0x00, 0x0F, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x07,
  0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x07,
  0x00, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x39, 0xE0, 0x00, 0x07, 0x78, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x1E, 0x1C, 0x01, 0xC7, 0x83, 0xC0, 0x31, 0xE0, 0x38, 0x0E, 0x38, 0x03,
  0x81, 0xCF, 0x00, 0x78, 0x39, 0xC0, 0x07, 0x0E, 0x38, 0x00, 0xF1, 0xCF,
  0x00, 0x0E, 0x71, 0xC0, 0x00, 0xFE, 0x38, 0x00, 0x1F, 0x87, 0x80, 0x01,
  0xE0, 0x70, 0x00, 0x3C, 0x0F, 0x00, 0x1F, 0xC0, 0xF0, 0x07, 0xB8, 0x1F,
  0x87, 0xE7, 0x80, 0xFF, 0xF8, 0x70, 0x0F, 0xFC, 0x07, 0x00, 0x08, 0x00,
  0x00, 0x39, 0x8C, 0xE7, 0x39, 0x8C, 0xE7, 0x39, 0x80, 0x00, 0x01, 0x00,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x08, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x20, 0x1C, 0x02, 0xF0, 0x38, 0x3D, 0xF8, 0x61, 0xF9, 0xFE, 0xDF, 0xF8,
  0x7F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xEE, 0x00, 0x07, 0x8C, 0x00, 0x1E, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0xE0,
  0x38, 0x03, 0x80, 0x38, 0x0F, 0x00, 0x78, 0x0C, 0x00, 0x40, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x1C, 0x38, 0xF1, 0xE3, 0x87, 0x1E, 0x38, 0xE1,
  0xC7, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x31, 0xEF, 0xBE, 0x78,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x7C, 0x03, 0x80, 0x38, 0x00,
  0xE0, 0x38, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x1C, 0x00,
  0x07, 0x0E, 0x00, 0x01, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xF3, 0x80,
  0x01, 0xF1, 0xC0, 0x03, 0xF9, 0xC0, 0x03, 0xDC, 0xE0, 0x03, 0xCE, 0x70,
  0x03, 0x87, 0x38, 0x07, 0x83, 0x9C, 0x07, 0x81, 0xDE, 0x07, 0x80, 0xEE,
  0x07, 0x00, 0xE7, 0x0F, 0x00, 0x73, 0x8F, 0x00, 0x39, 0xCF, 0x00, 0x1C,
  0xEE, 0x00, 0x0E, 0x7E, 0x00, 0x0E, 0x3E, 0x00, 0x07, 0x1E, 0x00, 0x03,
  0x8E, 0x00, 0x03, 0xC7, 0x00, 0x01, 0xC3, 0x80, 0x01, 0xE1, 0xC0, 0x00,
  0xE0, 0x70, 0x00, 0xF0, 0x38, 0x00, 0xF0, 0x0E, 0x00, 0xF0, 0x07, 0xC1,
  0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x70, 0x0F, 0xC0, 0xFF, 0x1F, 0xFD, 0xFC, 0x7F, 0xC3, 0xB8,
  0x0E, 0x80, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0xEF, 0xE0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x07, 0x01, 0xE0,
  0x01, 0xE0, 0x70, 0x00, 0x38, 0x3C, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83,
  0x80, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xF7, 0xF0, 0x03, 0xC0, 0x3C, 0x01,
  0xE0, 0x03, 0x80, 0xF0, 0x00, 0xE0, 0x78, 0x00, 0x1C, 0x1C, 0x00, 0x07,
  0x07, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x41, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x40, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x3C, 0x00, 0x03, 0x87,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x3C, 0x0E, 0x00, 0x1E,
  0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0xF1, 0xC0, 0x00, 0x78, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x0E, 0x00,
  0x07, 0x03, 0x80, 0x03, 0xC0, 0xE0, 0x01, 0xE0, 0x38, 0x00, 0x70, 0x1C,
  0x00, 0x38, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80,
  0x1C, 0x01, 0xC0, 0x0F, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x38,
  0x00, 0x38, 0x1E, 0x00, 0x0E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE3, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xE0, 0x3E, 0x01, 0xE0, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x03,
  0xC0, 0x1E, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x81, 0xE0, 0x07, 0x1F, 0xF8, 0x1C,
  0xFF, 0xF8, 0x3B, 0xC0, 0xF8, 0x7E, 0x00, 0x79, 0xF8, 0x00, 0x73, 0xE0,
  0x00, 0xE7, 0x80, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x0F, 0x38, 0x00, 0x1C,
  0x78, 0x00, 0x78, 0x70, 0x01, 0xE0, 0x70, 0x07, 0x80, 0xF8, 0x3E, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xF7, 0xF0, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x07,
  0x80, 0xF0, 0x00, 0xF0, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x3C, 0x00, 0x0F, 0x07,
  0x00, 0x03, 0x81, 0xC0, 0x01, 0xE0, 0x70, 0x00, 0x70, 0x0E, 0x00, 0x78,
  0x03, 0xE0, 0x3C, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x07, 0xC0, 0xF8, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0xF0,
  0x00, 0x38, 0x38, 0x00, 0x0F, 0x1C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x03, 0x8F, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x78, 0x70, 0x00, 0x1C, 0x1E, 0x00, 0x1E, 0x03, 0xC0,
  0x0F, 0x80, 0x7C, 0x0F, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x3C, 0x03, 0xC0, 0xF0, 0x03, 0x83, 0xC0, 0x03, 0x87, 0x00, 0x07, 0x1C,
  0x00, 0x0E, 0x38, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0xF3, 0x80, 0x03,
  0xE7, 0x80, 0x0F, 0xC7, 0x80, 0x3B, 0x87, 0x81, 0xEE, 0x07, 0xFF, 0x9C,
  0x07, 0xFC, 0x38, 0x03, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0x07, 0xC3, 0xE1, 0xF0, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0xF8, 0x7C, 0x3E, 0x1E,
  0x00, 0x00, 0x70, 0x07, 0x80, 0x7E, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x10, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xF0, 0x08, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFC,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x7F,
  0xF8, 0x0F, 0xFF, 0xC1, 0xE0, 0x1E, 0x3C, 0x00, 0xE7, 0x80, 0x0F, 0x70,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFE, 0xFC, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x70, 0x03, 0x80, 0x00, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x06, 0x03, 0x01, 0xF8, 0x18, 0x1C, 0x0F, 0xF0, 0x60, 0xE0, 0x78, 0xE1,
  0x83, 0x03, 0x83, 0x07, 0x1C, 0x1C, 0x0C, 0x1C, 0x60, 0xE0, 0x30, 0x71,
  0x83, 0x00, 0xC1, 0x8E, 0x1C, 0x06, 0x06, 0x30, 0x60, 0x18, 0x18, 0xC1,
  0x80, 0x60, 0x67, 0x0E, 0x01, 0x81, 0x98, 0x38, 0x0C, 0x06, 0x60, 0xC0,
  0x30, 0x39, 0x83, 0x00, 0xC0, 0xC6, 0x0C, 0x07, 0x03, 0x18, 0x30, 0x18,
  0x0C, 0xE0, 0xC0, 0xE0, 0x63, 0x83, 0x07, 0x81, 0x8E, 0x0C, 0x1E, 0x0C,
  0x18, 0x39, 0xDC, 0x70, 0x60, 0xFE, 0x3F, 0x81, 0x81, 0xF0, 0xFC, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x02, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x0E,
  0x00, 0x03, 0x83, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x38,
  0x0E, 0x00, 0x0E, 0x01, 0x80, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x07, 0x00, 0x1C,
  0x03, 0x80, 0x07, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFE, 0x0F, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE1, 0xE0, 0x00, 0x38, 0x70,
  0x00, 0x0E, 0x3C, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x77, 0x80, 0x00, 0x1D,
  0xC0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x70, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xC0, 0x0F, 0xC0,
  0x38, 0x00, 0x78, 0x07, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x70, 0x3C, 0x00,
  0x07, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x83,
  0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x83, 0x80, 0x01,
  0xE0, 0x70, 0x00, 0x78, 0x0E, 0x00, 0x3E, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x01, 0xC0, 0x03, 0xE0, 0x38, 0x00, 0x1E,
  0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38,
  0x70, 0x00, 0x0E, 0x1E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x78, 0x70, 0x00,
  0x1E, 0x0E, 0x00, 0x07, 0x81, 0xC0, 0x03, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xF9, 0xF8, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x00, 0x78,
  0x07, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x0E, 0x0E, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x1E, 0x00, 0x00, 0xF3,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x8E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C,
  0x1C, 0x00, 0x07, 0x03, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x38, 0x07, 0x00,
  0x0E, 0x00, 0xF0, 0x07, 0xC0, 0x0F, 0x83, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xC0, 0x1F, 0x00, 0x38, 0x00, 0xF0,
  0x0E, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x07, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00,
  0x07, 0x1E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x8F, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x1C,
  0x1C, 0x00, 0x07, 0x83, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x78, 0x0E, 0x00,
  0x3E, 0x03, 0x80, 0x1F, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF0, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x07,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x0E, 0x0E, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0E, 0x00, 0x7F, 0xF9, 0xC0, 0x0F, 0xFF, 0x38, 0x01, 0xFF, 0xE7,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x1C, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x1C, 0x1C,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x78, 0x00, 0x0E, 0x07, 0x80, 0x03,
  0xC0, 0x78, 0x01, 0xF0, 0x0F, 0xC1, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x06, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x0C,
  0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x18, 0x00, 0x01, 0x80, 0xE0,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x03, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x06,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1E, 0x0E,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x78, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xF0, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x3E, 0x03, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x1C,
  0x00, 0x0F, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0,
  0x03, 0xC0, 0x01, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x0E, 0x00,
  0xF0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x70, 0x3C,
  0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x07, 0x0F, 0x00,
  0x00, 0x0E, 0x3C, 0x00, 0x00, 0x1C, 0xF8, 0x00, 0x00, 0x3B, 0xF0, 0x00,
  0x00, 0x7F, 0x70, 0x00, 0x01, 0xFC, 0xF0, 0x00, 0x03, 0xF0, 0xE0, 0x00,
  0x07, 0xC1, 0xE0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0xC0, 0x00,
  0x38, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x80, 0x01, 0xC0, 0x07, 0x00, 0x03,
  0x80, 0x0F, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x3C, 0x01, 0xC0,
  0x00, 0x38, 0x03, 0x80, 0x00, 0x78, 0x07, 0x00, 0x00, 0x70, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xF0, 0x1E, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x3F,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0xEE, 0x03, 0x30, 0x03, 0xB8, 0x1C, 0xC0,
  0x1C, 0xC0, 0x73, 0x80, 0xF7, 0x01, 0xCE, 0x03, 0x9C, 0x07, 0x38, 0x1C,
  0x70, 0x1C, 0xE0, 0x71, 0xC0, 0x61, 0x83, 0x87, 0x03, 0x86, 0x0E, 0x18,
  0x0E, 0x1C, 0x70, 0xE0, 0x38, 0x71, 0xC3, 0x80, 0xE1, 0xCE, 0x0E, 0x03,
  0x87, 0x38, 0x38, 0x0C, 0x0D, 0xC0, 0xE0, 0x70, 0x3F, 0x07, 0x01, 0xC0,
  0xF8, 0x1C, 0x07, 0x03, 0xE0, 0x70, 0x1C, 0x0F, 0x01, 0xC0, 0x70, 0x18,
  0x07, 0x03, 0x80, 0x60, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x3E, 0x00, 0x03, 0x80, 0xF8,
  0x00, 0x0E, 0x03, 0xE0, 0x00, 0x38, 0x0F, 0xC0, 0x00, 0xE0, 0x3F, 0x00,
  0x03, 0x80, 0xFC, 0x00, 0x1C, 0x07, 0xB8, 0x00, 0x70, 0x1C, 0xE0, 0x01,
  0xC0, 0x73, 0x80, 0x07, 0x01, 0xC7, 0x00, 0x1C, 0x07, 0x1C, 0x00, 0x70,
  0x1C, 0x38, 0x03, 0x80, 0xE0, 0xE0, 0x0E, 0x03, 0x83, 0x80, 0x38, 0x0E,
  0x07, 0x00, 0xE0, 0x38, 0x1C, 0x03, 0x80, 0xE0, 0x70, 0x1E, 0x03, 0x80,
  0xE0, 0x70, 0x1C, 0x03, 0x81, 0xC0, 0x70, 0x0E, 0x07, 0x01, 0xC0, 0x1C,
  0x1C, 0x07, 0x00, 0x70, 0x70, 0x1C, 0x01, 0xC3, 0xC0, 0x70, 0x03, 0x8E,
  0x03, 0x80, 0x0E, 0x38, 0x0E, 0x00, 0x38, 0xE0, 0x38, 0x00, 0x73, 0x80,
  0xE0, 0x01, 0xCE, 0x03, 0x80, 0x03, 0xF0, 0x1E, 0x00, 0x0F, 0xC0, 0x70,
  0x00, 0x3F, 0x01, 0xC0, 0x00, 0x7C, 0x07, 0x00, 0x01, 0xF0, 0x1C, 0x00,
  0x07, 0xC0, 0x70, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xC0, 0x78, 0x03,
  0xC0, 0x0F, 0x00, 0xE0, 0x01, 0xE0, 0x70, 0x00, 0x38, 0x3C, 0x00, 0x0E,
  0x0E, 0x00, 0x01, 0x87, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0xF0, 0x00,
  0x07, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1D, 0xC0,
  0x00, 0x07, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x07,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0x78, 0x00, 0x78, 0x0E, 0x00, 0x3C,
  0x03, 0xC0, 0x1E, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0xF8, 0x03, 0x80, 0x03, 0xC0, 0x70,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xE0, 0xE0, 0x00,
  0x1C, 0x1E, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x78, 0x1C, 0x00, 0x1F, 0x01,
  0xC0, 0x07, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x38, 0x02,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x3C, 0x00, 0x70, 0x0F,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x1E, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x38, 0xF0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x0C, 0xF0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E,
  0x70, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x70, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xF3, 0x80, 0x00,
  0x1C, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38,
  0x00, 0x07, 0x03, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x78, 0x07, 0x00, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x0F, 0x87, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x01, 0xC0, 0x07, 0xC0, 0x38, 0x00, 0x3C, 0x07, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x78, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x1C,
  0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x81,
  0xC0, 0x01, 0xE0, 0x38, 0x00, 0x78, 0x07, 0x00, 0xFE, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x38,
  0x03, 0x80, 0x07, 0x80, 0x70, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x01, 0xC0,
  0x01, 0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x78,
  0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0xF8, 0x07,
  0x80, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x70, 0x70,
  0x00, 0x0E, 0x0E, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x70, 0x70,
  0x00, 0x1E, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x03, 0xE0, 0x0F, 0xC1, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x38,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x38, 0x00, 0x03, 0x83, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0x78, 0x03, 0x80,
  0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07,
  0x3C, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x78, 0x70, 0x00,
  0x1C, 0x1C, 0x00, 0x0F, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x38,
  0x00, 0x70, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x03, 0x80,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x0E,
  0x00, 0x1C, 0x07, 0x80, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0xF0, 0x00, 0x70,
  0x38, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x60, 0x07, 0x00, 0x76, 0x00, 0x70, 0x07, 0x60, 0x0F, 0x00, 0x66, 0x00,
  0xF0, 0x0E, 0x60, 0x0F, 0x00, 0xEE, 0x01, 0xF0, 0x0E, 0xE0, 0x1F, 0x01,
  0xCE, 0x01, 0xF0, 0x1C, 0xE0, 0x3F, 0x01, 0xCE, 0x03, 0xF0, 0x18, 0xE0,
  0x77, 0x03, 0x8E, 0x07, 0x70, 0x38, 0xE0, 0x77, 0x03, 0x8E, 0x0E, 0x70,
  0x70, 0xE0, 0xE3, 0x07, 0x0E, 0x0E, 0x30, 0x70, 0xE1, 0xC3, 0x06, 0x0E,
  0x1C, 0x30, 0xE0, 0xE1, 0x83, 0x0E, 0x0E, 0x38, 0x30, 0xC0, 0xE3, 0x83,
  0x1C, 0x0E, 0x30, 0x31, 0xC0, 0xE7, 0x03, 0x1C, 0x0E, 0x70, 0x31, 0x80,
  0xE6, 0x03, 0x38, 0x0E, 0xE0, 0x33, 0x80, 0xEE, 0x03, 0x30, 0x0E, 0xC0,
  0x37, 0x00, 0xFC, 0x03, 0x70, 0x0F, 0xC0, 0x37, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x38, 0x03,
  0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x07, 0x3C,
  0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1E, 0x70,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x00, 0xF0, 0x1C, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x03,
  0x80, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x3C, 0x70, 0x00,
  0x0E, 0x1E, 0x00, 0x07, 0x83, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x3C,
  0x00, 0x78, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x07, 0x80,
  0x0E, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x78, 0x00, 0x1C, 0x1C,
  0x00, 0x07, 0x0E, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x0E,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xE0, 0x0C, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0C,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0C, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x07,
  0x38, 0x01, 0xC7, 0x00, 0x38, 0x60, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x70,
  0x38, 0x0E, 0x03, 0x03, 0x80, 0x70, 0xE0, 0x0E, 0x1C, 0x01, 0xC7, 0x00,
  0x38, 0xE0, 0x03, 0x38, 0x00, 0x7F, 0x00, 0x0E, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xE0, 0xE1, 0xC1, 0xC3, 0x83, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xE0, 0x7C,
  0x07, 0x80, 0x1E, 0x0F, 0x00, 0x0E, 0x1E, 0x00, 0x0E, 0x1C, 0x00, 0x0F,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x1F, 0xC0, 0x0E,
  0x3E, 0x00, 0x1C, 0x78, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0xF0, 0x00, 0x1C,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x78,
  0xF0, 0x01, 0xF8, 0x70, 0x03, 0xF8, 0x7E, 0x1F, 0x38, 0x3F, 0xFE, 0x38,
  0x0F, 0xF8, 0x38, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x20, 0x00, 0x70, 0xFF, 0x00, 0x39,
  0xFF, 0xE0, 0x1D, 0xF1, 0xF8, 0x0D, 0xC0, 0x3C, 0x0F, 0x80, 0x0F, 0x07,
  0x80, 0x03, 0x83, 0xC0, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38,
  0x70, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03,
  0x8E, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xE3, 0x80, 0x00,
  0x71, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x3C, 0x70, 0x00, 0x1C, 0x38, 0x00,
  0x1E, 0x3C, 0x00, 0x0E, 0x1E, 0x00, 0x0F, 0x0F, 0x80, 0x0F, 0x07, 0xE0,
  0x0F, 0x03, 0xBC, 0x3F, 0x01, 0xCF, 0xFF, 0x01, 0xC3, 0xFE, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x1F, 0x07, 0xC0, 0x78, 0x03, 0xC1, 0xC0, 0x03, 0x87, 0x00, 0x07, 0x9E,
  0x00, 0x07, 0x38, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x38, 0x00, 0x1E, 0x38, 0x00, 0x38,
  0x70, 0x00, 0xF0, 0x70, 0x03, 0xC0, 0xF8, 0x3F, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x02, 0x01, 0xC0, 0x07,
  0xFC, 0x38, 0x03, 0xFF, 0xC7, 0x00, 0xFC, 0x3D, 0xE0, 0x3E, 0x01, 0xF8,
  0x0F, 0x00, 0x1F, 0x01, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0E, 0x00,
  0x03, 0x83, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x1C, 0x1E, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x78, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x1C,
  0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x07,
  0x01, 0xE0, 0x01, 0xE0, 0x1C, 0x00, 0x7C, 0x03, 0xC0, 0x1F, 0x80, 0x3E,
  0x1F, 0x70, 0x03, 0xFF, 0xCC, 0x00, 0x3F, 0xE3, 0x80, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xF0,
  0x7C, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x0E, 0x0F, 0x00, 0x0F, 0x1E, 0x00,
  0x07, 0x1C, 0x00, 0x07, 0x38, 0x00, 0x07, 0x38, 0x00, 0x07, 0x70, 0x00,
  0x07, 0x70, 0x00, 0x07, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x10, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x0F, 0x83, 0xF0, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x03, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x0F, 0xF8, 0x70, 0x0F, 0xFF, 0x1C, 0x07, 0xE1, 0xE7, 0x03, 0xE0,
  0x1F, 0x81, 0xE0, 0x03, 0xE0, 0x70, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0E,
  0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C,
  0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00,
  0x3C, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x87, 0x80, 0x00, 0xE0, 0xE0,
  0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x83, 0x80, 0x01, 0xC0,
  0xF0, 0x00, 0xF0, 0x1C, 0x00, 0x7C, 0x07, 0x80, 0x3F, 0x00, 0xF8, 0x7D,
  0xC0, 0x1F, 0xFE, 0x70, 0x03, 0xFE, 0x38, 0x00, 0x08, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x10, 0x00, 0x3C, 0x04,
  0x00, 0x1E, 0x03, 0x80, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x0F, 0xDF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x10, 0x00, 0x70, 0x7F, 0x80,
  0x38, 0xFF, 0xF0, 0x18, 0xF0, 0xF8, 0x1C, 0xE0, 0x1E, 0x0E, 0xC0, 0x07,
  0x07, 0xC0, 0x03, 0xC3, 0xC0, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00,
  0x38, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00,
  0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x71, 0xC0, 0x00, 0x78, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x78,
  0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x03, 0x87,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0xE3, 0xC0, 0x00, 0x71, 0xC0, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x01, 0x87, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x07, 0xC3, 0x80, 0x03, 0xC0, 0xE0, 0x01, 0xE0, 0x38, 0x01, 0xF0, 0x0E,
  0x00, 0xF0, 0x03, 0x80, 0x78, 0x01, 0xE0, 0x3C, 0x00, 0x70, 0x1E, 0x00,
  0x1C, 0x1F, 0x00, 0x07, 0x0F, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x73, 0xC0,
  0x00, 0x3D, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xF3, 0x80, 0x00, 0xF8,
  0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x00, 0xF0, 0x01,
  0xC0, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x00, 0x1C,
  0x01, 0xC0, 0x07, 0x80, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x1C, 0x0E, 0x00,
  0x07, 0x83, 0x80, 0x00, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x80, 0x39,
  0xFC, 0x1F, 0xC0, 0xEF, 0xF9, 0xFF, 0x83, 0xF1, 0xFF, 0x1E, 0x0F, 0x03,
  0xF0, 0x38, 0x38, 0x07, 0x80, 0x71, 0xE0, 0x1C, 0x01, 0xC7, 0x00, 0x70,
  0x07, 0x1C, 0x01, 0xC0, 0x18, 0x70, 0x07, 0x00, 0xE1, 0xC0, 0x38, 0x03,
  0x86, 0x00, 0xE0, 0x0E, 0x38, 0x03, 0x80, 0x38, 0xE0, 0x0E, 0x00, 0xE3,
  0x80, 0x38, 0x03, 0x0E, 0x00, 0xE0, 0x1C, 0x38, 0x07, 0x00, 0x70, 0xC0,
  0x1C, 0x01, 0xC7, 0x00, 0x70, 0x07, 0x1C, 0x01, 0xC0, 0x1C, 0x70, 0x07,
  0x00, 0x61, 0xC0, 0x18, 0x03, 0x87, 0x00, 0xE0, 0x0E, 0x18, 0x03, 0x80,
  0x38, 0xE0, 0x0E, 0x00, 0xE3, 0x80, 0x38, 0x03, 0x8E, 0x00, 0xE0, 0x0C,
  0x38, 0x03, 0x00, 0x70, 0xE0, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x80, 0x03,
  0x87, 0xFC, 0x01, 0xC7, 0xFF, 0x80, 0xCF, 0x87, 0xC0, 0xEF, 0x00, 0xF0,
  0x76, 0x00, 0x38, 0x3E, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x0E, 0x00, 0x03,
  0x87, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00,
  0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x78, 0x00, 0x0E, 0x38, 0x00,
  0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0xE3, 0xC0, 0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70,
  0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x7E, 0x1F, 0x80, 0x78, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x78, 0x00,
  0x38, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x9C, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8,
  0x00, 0x03, 0xDC, 0x00, 0x01, 0xCE, 0x00, 0x01, 0xE7, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0xF0, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0xF0,
  0x07, 0xC1, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x38, 0xFF, 0x80, 0x07, 0x3F, 0xFC, 0x00,
  0xDF, 0x0F, 0xC0, 0x3B, 0x80, 0x78, 0x07, 0xC0, 0x07, 0x80, 0xF0, 0x00,
  0x70, 0x1E, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x1C, 0x1C,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x38, 0x38, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38,
  0x1C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xC0, 0xF0, 0x00, 0x78, 0x1F, 0x00,
  0x1E, 0x03, 0xF0, 0x07, 0x80, 0x77, 0x87, 0xE0, 0x0E, 0x7F, 0xF8, 0x03,
  0x87, 0xFC, 0x00, 0x70, 0x0C, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xE1, 0xC0, 0x7F,
  0xF8, 0xE0, 0x7E, 0x1E, 0x70, 0x7C, 0x03, 0xF0, 0x78, 0x00, 0xF8, 0x38,
  0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E,
  0x00, 0x03, 0x8F, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x71,
  0xC0, 0x00, 0x38, 0xE0, 0x00, 0x3C, 0x70, 0x00, 0x1C, 0x78, 0x00, 0x0E,
  0x3C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x01,
  0xC1, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0xF0, 0x38, 0x00, 0xF8, 0x1E, 0x00,
  0xFC, 0x07, 0xC3, 0xEE, 0x01, 0xFF, 0xE6, 0x00, 0x7F, 0xC7, 0x00, 0x02,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30,
  0x0E, 0x0F, 0xFC, 0x1C, 0x7F, 0xF8, 0x39, 0xFF, 0xE0, 0x77, 0x80, 0x01,
  0xDC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xF0, 0x7E, 0x07, 0x80, 0x1E,
  0x0F, 0x00, 0x0F, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0xF0, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x78, 0x00, 0x3C,
  0x3C, 0x00, 0x78, 0x1F, 0x03, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x00, 0x10, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xE0, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C,
  0x00, 0x07, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38,
  0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0x70,
  0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0xF0,
  0x00, 0x3C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0,
  0x00, 0x38, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0xF0, 0x70,
  0x01, 0xF0, 0x78, 0x07, 0xF0, 0x3C, 0x1F, 0x70, 0x3F, 0xFC, 0x70, 0x0F,
  0xF8, 0x60, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xB8,
  0x00, 0x03, 0xCE, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xE3, 0x80, 0x00, 0xE1,
  0xC0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x38,
  0x0E, 0x00, 0x38, 0x03, 0x00, 0x3C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x1C,
  0x00, 0x70, 0x0E, 0x00, 0x18, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x07,
  0x00, 0x03, 0x83, 0x80, 0x00, 0xC3, 0x80, 0x00, 0x73, 0xC0, 0x00, 0x39,
  0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x7E, 0x00, 0xE0, 0x0E, 0xE0, 0x0E, 0x00, 0xEE, 0x01, 0xE0, 0x0C, 0xE0,
  0x1E, 0x01, 0xCE, 0x03, 0xE0, 0x1C, 0xE0, 0x36, 0x01, 0x8E, 0x03, 0x60,
  0x38, 0xE0, 0x76, 0x03, 0x8E, 0x06, 0x60, 0x70, 0xE0, 0xE7, 0x07, 0x0E,
  0x0C, 0x70, 0x60, 0xE1, 0xC7, 0x0E, 0x0E, 0x1C, 0x70, 0xE0, 0xE1, 0x87,
  0x0C, 0x0E, 0x38, 0x31, 0xC0, 0xE3, 0x03, 0x18, 0x0E, 0x70, 0x33, 0x80,
  0x66, 0x03, 0x38, 0x06, 0x60, 0x33, 0x00, 0x6E, 0x03, 0x70, 0x06, 0xC0,
  0x36, 0x00, 0x7C, 0x03, 0x60, 0x07, 0x80, 0x3E, 0x00, 0x78, 0x03, 0xC0,
  0x07, 0x00, 0x3C, 0x00, 0x70, 0x03, 0xC0, 0x07, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xF8, 0x1C, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x78, 0x03, 0x80,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0x70, 0x07, 0x80, 0x01, 0xC0, 0x78,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x38, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x07, 0x78, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xCE, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x1C, 0x07, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x1E, 0x00, 0xE0, 0x01, 0xE0,
  0x03, 0x80, 0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x70, 0x1E, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x03, 0x80, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0xE0, 0x03,
  0xC0, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x70, 0x07, 0x80, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x3C, 0x70,
  0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1D, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x5F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0C, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0x80, 0x60, 0x18, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x20, 0xFF, 0xC0, 0x01, 0xCF, 0x9F, 0x80, 0x0C,
  0x70, 0x3E, 0x00, 0xE7, 0x00, 0x78, 0x07, 0x30, 0x01, 0xE0, 0xF3, 0x80,
  0x07, 0xFF, 0x1C, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0x00,
};

const GFXglyph RobotoMono_LightItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 9, 38, 31, 11, -38 },
  { 44, 12, 12, 31, 12, -40 },
  { 62, 31, 38, 31, 1, -38 },
  { 210, 26, 48, 31, 3, -43 },
  { 366, 26, 39, 31, 3, -38 },
  { 493, 27, 39, 31, 2, -38 },
  { 625, 5, 12, 31, 15, -40 },
  { 633, 17, 54, 31, 9, -42 },
  { 748, 16, 54, 31, 5, -42 },
  { 856, 23, 23, 31, 7, -38 },
  { 923, 26, 27, 31, 3, -31 },
  { 1011, 7, 13, 31, 6, -5 },
  { 1023, 19, 2, 31, 6, -18 },
  { 1028, 6, 5, 31, 11, -5 },
  { 1032, 25, 41, 31, 4, -38 },
  { 1161, 25, 39, 31, 4, -38 },
  { 1283, 14, 38, 31, 8, -38 },
  { 1350, 26, 38, 31, 1, -38 },
  { 1474, 26, 39, 31, 1, -38 },
  { 1601, 26, 38, 31, 1, -38 },
  { 1725, 26, 39, 31, 4, -38 },
  { 1852, 23, 39, 31, 3, -38 },
  { 1965, 25, 38, 31, 6, -38 },
  { 2084, 26, 39, 31, 3, -38 },
  { 2211, 23, 38, 31, 5, -38 },
  { 2321, 9, 28, 31, 13, -28 },
  { 2353, 13, 36, 31, 9, -28 },
  { 2412, 24, 22, 31, 4, -28 },
  { 2478, 25, 14, 31, 3, -24 },
  { 2522, 24, 22, 31, 3, -28 },
  { 2588, 20, 38, 31, 8, -38 },
  { 2683, 30, 38, 31, 1, -38 },
  { 2826, 26, 38, 31, 0, -38 },
  { 2950, 27, 38, 31, 2, -38 },
  { 3079, 27, 39, 31, 3, -38 },
  { 3211, 27, 38, 31, 2, -38 },
  { 3340, 28, 38, 31, 2, -38 },
  { 3473, 28, 38, 31, 3, -38 },
  { 3606, 27, 39, 31, 3, -38 },
  { 3738, 30, 38, 31, 1, -38 },
  { 3881, 28, 38, 31, 2, -38 },
  { 4014, 28, 39, 31, 2, -38 },
  { 4151, 31, 38, 31, 2, -38 },
  { 4299, 22, 38, 31, 3, -38 },
  { 4404, 30, 38, 31, 1, -38 },
  { 4547, 30, 38, 31, 1, -38 },
  { 4690, 26, 39, 31, 3, -38 },
  { 4817, 28, 38, 31, 3, -38 },
  { 4950, 27, 45, 31, 3, -38 },
  { 5102, 27, 38, 31, 2, -38 },
  { 5231, 27, 39, 31, 3, -38 },
  { 5363, 26, 38, 31, 6, -38 },
  { 5487, 28, 39, 31, 3, -38 },
  { 5624, 26, 38, 31, 6, -38 },
  { 5748, 28, 38, 31, 5, -38 },
  { 5881, 32, 38, 31, 0, -38 },
  { 6033, 26, 38, 31, 6, -38 },
  { 6157, 28, 38, 31, 1, -38 },
  { 6290, 16, 51, 31, 8, -43 },
  { 6392, 11, 41, 31, 10, -38 },
  { 6449, 17, 51, 31, 7, -43 },
  { 6558, 19, 21, 31, 6, -38 },
  { 6608, 23, 3, 31, 1, 0 },
  { 6617, 7, 7, 31, 15, -39 },
  { 6624, 24, 30, 31, 3, -29 },
  { 6714, 25, 41, 31, 2, -40 },
  { 6843, 23, 30, 31, 4, -29 },
  { 6930, 27, 41, 31, 3, -40 },
  { 7069, 24, 30, 31, 3, -29 },
  { 7159, 26, 41, 31, 6, -41 },
  { 7293, 26, 40, 31, 2, -29 },
  { 7423, 25, 40, 31, 2, -40 },
  { 7548, 22, 38, 31, 3, -38 },
  { 7653, 25, 49, 31, 0, -38 },
  { 7807, 26, 40, 31, 3, -40 },
  { 7937, 22, 40, 31, 3, -40 },
  { 8047, 30, 29, 31, 0, -29 },
  { 8156, 25, 29, 31, 2, -29 },
  { 8247, 25, 30, 31, 3, -29 },
  { 8341, 27, 40, 31, 0, -29 },
  { 8476, 25, 40, 31, 3, -29 },
  { 8601, 23, 29, 31, 6, -29 },
  { 8685, 24, 30, 31, 3, -29 },
  { 8775, 21, 36, 31, 6, -35 },
  { 8870, 24, 29, 31, 4, -28 },
  { 8957, 25, 28, 31, 5, -28 },
  { 9045, 28, 28, 31, 4, -28 },
  { 9143, 29, 28, 31, 1, -28 },
  { 9245, 32, 39, 31, -1, -28 },
  { 9401, 27, 28, 31, 1, -28 },
  { 9496, 21, 51, 31, 8, -41 },
  { 9630, 10, 47, 31, 10, -38 },
  { 9689, 20, 51, 31, 5, -41 },
  { 9817, 29, 9, 31, 1, -20 },
};

const GFXfont RobotoMono_LightItalic53pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic53pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic53pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _ROBOTOMONO_LIGHTITALIC53PT7B_H_
