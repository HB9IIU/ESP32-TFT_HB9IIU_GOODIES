#ifndef _ROBOTOMONO_LIGHTITALIC9PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xF0, 0x2B, 0xCD, 0xF5, 0x50, 0x69, 0x84, 0x29, 0xA4, 0x8D,
  0xE4, 0x7D, 0x70, 0x22, 0x94, 0x46, 0xC9, 0xE0, 0xC0, 0x29, 0x29, 0x22,
  0x40, 0x44, 0x92, 0x52, 0x80, 0x2F, 0x6A, 0x44, 0xF4, 0xC0, 0xE0, 0x80,
  0x12, 0x24, 0x88, 0x80, 0x69, 0x9B, 0xD9, 0xE0, 0xE4, 0xA4, 0x80, 0x78,
  0x44, 0x44, 0x78, 0x78, 0x4C, 0x29, 0x78, 0x11, 0x95, 0x27, 0x88, 0x78,
  0xE1, 0x9E, 0x73, 0xDB, 0xC0, 0xF2, 0x24, 0x48, 0xF9, 0x69, 0x9E, 0xF9,
  0x9E, 0x2C, 0x40, 0x80, 0x40, 0xA0, 0x16, 0xC2, 0xFE, 0x41, 0x8F, 0x80,
  0xF1, 0x24, 0x04, 0x7B, 0xF7, 0xBB, 0x38, 0x13, 0x57, 0x99, 0x7A, 0x5C,
  0x98, 0xF8, 0xF9, 0x88, 0x9E, 0x7A, 0x53, 0x18, 0xF8, 0x7A, 0x1C, 0x88,
  0x78, 0x7A, 0x1C, 0x88, 0x40, 0x7A, 0x21, 0x38, 0xB8, 0x4A, 0x5F, 0x18,
  0xC8, 0x79, 0x08, 0x42, 0x78, 0x08, 0x42, 0x19, 0x38, 0x4D, 0x46, 0x18,
  0x92, 0x20, 0x44, 0x44, 0x8F, 0x4A, 0x5F, 0x58, 0xC8, 0x4B, 0x5B, 0x59,
  0x48, 0xF9, 0x99, 0x9E, 0x7A, 0x52, 0xE8, 0x40, 0x7A, 0x63, 0x18, 0xB8,
  0x40, 0x7A, 0x52, 0xE9, 0x48, 0x7A, 0x08, 0x38, 0xB8, 0xFA, 0x10, 0x84,
  0x20, 0x99, 0x99, 0x9E, 0x99, 0xAA, 0xC4, 0xAF, 0xBD, 0x4A, 0x50, 0x49,
  0x88, 0x45, 0x4C, 0x9A, 0x64, 0x44, 0x78, 0x88, 0x44, 0x78, 0x69, 0x25,
  0x26, 0xAA, 0x94, 0x64, 0x92, 0x96, 0x2E, 0x80, 0xF0, 0xC0, 0x32, 0x5D,
  0x27, 0x00, 0x42, 0x1C, 0x94, 0xC7, 0xC0, 0x69, 0x88, 0xE0, 0x11, 0x79,
  0x9A, 0xE0, 0x69, 0xF8, 0xE0, 0x3A, 0x3C, 0x84, 0x22, 0x00, 0x3A, 0x63,
  0x27, 0x0B, 0x80, 0x42, 0x1C, 0x94, 0xC6, 0x40, 0x16, 0x22, 0x2F, 0x13,
  0x11, 0x12, 0x2C, 0x42, 0x12, 0xA6, 0x52, 0x40, 0x31, 0x12, 0x22, 0xF0,
  0x7D, 0x6B, 0x5A, 0x80, 0x72, 0x53, 0x19, 0x00, 0x32, 0x63, 0x17, 0x00,
  0x72, 0x53, 0x1F, 0x42, 0x00, 0x79, 0x9A, 0xE2, 0x20, 0x74, 0x88, 0x80,
  0x69, 0x61, 0xE0, 0x4F, 0x44, 0x46, 0x99, 0x9A, 0xE0, 0x99, 0xAA, 0x40,
  0xDD, 0xBA, 0xA0, 0x4A, 0x88, 0xA9, 0x00, 0x4A, 0x54, 0xA2, 0x22, 0x00,
  0x78, 0x88, 0x8F, 0x00, 0x12, 0x24, 0x84, 0x44, 0x20, 0xFE, 0x44, 0x92,
  0x92, 0x80, 0xF8,
};

const GFXglyph RobotoMono_LightItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 2, 2, 5, 2, -7 },
  { 3, 5, 6, 5, 0, -6 },
  { 7, 4, 8, 5, 1, -7 },
  { 11, 4, 7, 5, 1, -7 },
  { 15, 5, 7, 5, 0, -7 },
  { 20, 1, 2, 5, 2, -7 },
  { 21, 3, 9, 5, 1, -7 },
  { 25, 3, 9, 5, 1, -7 },
  { 29, 4, 4, 5, 1, -6 },
  { 31, 4, 4, 5, 1, -5 },
  { 33, 1, 2, 5, 1, -1 },
  { 34, 3, 1, 5, 1, -3 },
  { 35, 1, 1, 5, 2, -1 },
  { 36, 4, 7, 5, 1, -6 },
  { 40, 4, 7, 5, 1, -7 },
  { 44, 3, 6, 5, 1, -6 },
  { 47, 5, 6, 5, 0, -6 },
  { 51, 5, 6, 5, 0, -6 },
  { 55, 5, 6, 5, 0, -6 },
  { 59, 4, 6, 5, 1, -6 },
  { 62, 3, 6, 5, 1, -6 },
  { 65, 4, 6, 5, 1, -6 },
  { 68, 4, 6, 5, 1, -6 },
  { 71, 4, 6, 5, 1, -6 },
  { 74, 2, 5, 5, 2, -5 },
  { 76, 2, 6, 5, 2, -5 },
  { 78, 4, 4, 5, 1, -5 },
  { 80, 4, 2, 5, 1, -4 },
  { 81, 5, 4, 5, 0, -5 },
  { 84, 4, 6, 5, 1, -6 },
  { 87, 5, 6, 5, 0, -6 },
  { 91, 4, 6, 5, 0, -6 },
  { 94, 5, 6, 5, 0, -6 },
  { 98, 4, 6, 5, 1, -6 },
  { 101, 5, 6, 5, 0, -6 },
  { 105, 5, 6, 5, 0, -6 },
  { 109, 5, 6, 5, 0, -6 },
  { 113, 5, 6, 5, 0, -6 },
  { 117, 5, 6, 5, 0, -6 },
  { 121, 5, 6, 5, 0, -6 },
  { 125, 5, 6, 5, 0, -6 },
  { 129, 6, 6, 5, 0, -6 },
  { 134, 4, 6, 5, 0, -6 },
  { 137, 5, 6, 5, 0, -6 },
  { 141, 5, 6, 5, 0, -6 },
  { 145, 4, 6, 5, 1, -6 },
  { 148, 5, 6, 5, 0, -6 },
  { 152, 5, 7, 5, 0, -6 },
  { 157, 5, 6, 5, 0, -6 },
  { 161, 5, 6, 5, 0, -6 },
  { 165, 5, 6, 5, 1, -6 },
  { 169, 4, 6, 5, 1, -6 },
  { 172, 4, 6, 5, 1, -6 },
  { 175, 5, 6, 5, 1, -6 },
  { 179, 5, 6, 5, 0, -6 },
  { 183, 4, 6, 5, 1, -6 },
  { 186, 5, 6, 5, 0, -6 },
  { 190, 3, 8, 5, 1, -7 },
  { 193, 2, 7, 5, 2, -6 },
  { 195, 3, 8, 5, 1, -7 },
  { 198, 3, 3, 5, 1, -6 },
  { 200, 4, 1, 5, 0, 0 },
  { 201, 1, 2, 5, 3, -7 },
  { 202, 5, 5, 5, 0, -5 },
  { 206, 5, 7, 5, 0, -7 },
  { 211, 4, 5, 5, 1, -5 },
  { 214, 4, 7, 5, 1, -7 },
  { 218, 4, 5, 5, 1, -5 },
  { 221, 5, 7, 5, 1, -7 },
  { 226, 5, 7, 5, 0, -5 },
  { 231, 5, 7, 5, 0, -7 },
  { 236, 4, 6, 5, 0, -6 },
  { 239, 4, 8, 5, 0, -6 },
  { 243, 5, 7, 5, 0, -7 },
  { 248, 4, 7, 5, 0, -7 },
  { 252, 5, 5, 5, 0, -5 },
  { 256, 5, 5, 5, 0, -5 },
  { 260, 5, 5, 5, 0, -5 },
  { 264, 5, 7, 5, 0, -5 },
  { 269, 4, 7, 5, 1, -5 },
  { 273, 4, 5, 5, 1, -5 },
  { 276, 4, 5, 5, 1, -5 },
  { 279, 4, 6, 5, 1, -6 },
  { 282, 4, 5, 5, 1, -5 },
  { 285, 4, 5, 5, 1, -5 },
  { 288, 4, 5, 5, 1, -5 },
  { 291, 5, 5, 5, 0, -5 },
  { 295, 5, 7, 5, 0, -5 },
  { 300, 5, 5, 5, 0, -5 },
  { 304, 4, 9, 5, 1, -7 },
  { 309, 1, 7, 5, 2, -6 },
  { 310, 3, 9, 5, 1, -7 },
  { 314, 5, 1, 5, 0, -3 },
};

const GFXfont RobotoMono_LightItalic9pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic9pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _ROBOTOMONO_LIGHTITALIC9PT7B_H_
