#ifndef _ROBOTOMONO_LIGHTITALIC40PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x0C, 0x18, 0x70, 0xC1, 0x83, 0x06, 0x1C, 0x38, 0x60, 0xC1,
  0x83, 0x0E, 0x1C, 0x30, 0x60, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC3,
  0x87, 0x00, 0x71, 0xB0, 0xD8, 0x6C, 0x36, 0x13, 0x1B, 0x0D, 0x86, 0xC3,
  0x00, 0x00, 0x1C, 0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x81,
  0x80, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30,
  0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00,
  0x18, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x03,
  0x06, 0x00, 0x0C, 0x0C, 0x03, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x00, 0xC0,
  0xC0, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18,
  0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x03, 0x83, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x07, 0xC0, 0x03, 0xFE,
  0x01, 0xF1, 0xE0, 0x78, 0x0E, 0x0E, 0x00, 0xC3, 0x80, 0x18, 0x60, 0x03,
  0x8C, 0x00, 0x71, 0x80, 0x0E, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x98, 0x00, 0x73,
  0x00, 0x0E, 0x60, 0x01, 0x8E, 0x00, 0x70, 0xC0, 0x0E, 0x1C, 0x07, 0x81,
  0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x30, 0xC0, 0x07, 0x0C, 0x00,
  0x60, 0x40, 0xC6, 0x04, 0x0C, 0x60, 0xC1, 0x84, 0x0C, 0x30, 0x40, 0xC7,
  0x06, 0x0C, 0x60, 0x61, 0x8C, 0x03, 0xF1, 0x80, 0x1E, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0xFC, 0x03,
  0x9C, 0xE0, 0x31, 0x86, 0x06, 0x30, 0x30, 0xC3, 0x03, 0x0C, 0x30, 0x31,
  0x83, 0x06, 0x30, 0x20, 0x61, 0x03, 0x06, 0x00, 0x30, 0xC0, 0x03, 0x9C,
  0x00, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0x07, 0xF8, 0x00, 0x78, 0xE0, 0x03,
  0x03, 0x00, 0x38, 0x18, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x70,
  0x03, 0x03, 0x00, 0x18, 0x30, 0x00, 0xC7, 0x00, 0x03, 0x70, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xEC, 0x00, 0x0E, 0x70, 0x18,
  0xE1, 0xC1, 0x8E, 0x06, 0x0C, 0x60, 0x38, 0x67, 0x00, 0xC7, 0x30, 0x07,
  0x31, 0x80, 0x1F, 0x8C, 0x00, 0x78, 0x60, 0x03, 0x83, 0x80, 0x3C, 0x0E,
  0x07, 0xF0, 0x3F, 0xF9, 0xC0, 0xFF, 0x07, 0x00, 0x37, 0x66, 0x66, 0x6C,
  0xC0, 0x00, 0x10, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x07, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x04, 0x00, 0x01, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x30, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00,
  0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x1C, 0x00, 0x40, 0x00, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x03, 0x06, 0x0F, 0xE3,
  0x3E, 0x7F, 0xFE, 0x07, 0xF0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xCC, 0x00,
  0xC7, 0x00, 0xC1, 0x80, 0xE0, 0xE0, 0xE0, 0x38, 0x20, 0x10, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x07, 0xFF, 0xFF,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x71, 0xC6, 0x18, 0xE3, 0x1C, 0xE1, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x27, 0x77, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x1E,
  0x1E, 0x07, 0x00, 0xC0, 0xC0, 0x1C, 0x30, 0x01, 0x86, 0x00, 0x31, 0x80,
  0x06, 0x30, 0x00, 0xEE, 0x00, 0x7D, 0x80, 0x1F, 0x30, 0x07, 0x66, 0x01,
  0xCC, 0xC0, 0xE1, 0xB8, 0x38, 0x37, 0x0E, 0x0E, 0xC3, 0x81, 0xD9, 0xC0,
  0x33, 0x70, 0x06, 0x7C, 0x00, 0xCF, 0x00, 0x39, 0x80, 0x06, 0x30, 0x00,
  0xC6, 0x00, 0x38, 0xE0, 0x0E, 0x0C, 0x01, 0x81, 0xC0, 0xE0, 0x1F, 0xF8,
  0x01, 0xFE, 0x00, 0x00, 0xE0, 0x7C, 0x7F, 0x3E, 0x6F, 0x0D, 0x01, 0x80,
  0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x0F,
  0x1E, 0x03, 0x80, 0xE0, 0xE0, 0x0E, 0x38, 0x01, 0xC6, 0x00, 0x19, 0xC0,
  0x03, 0x38, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xFF,
  0xCF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x3F, 0xF0, 0x0F, 0x0F, 0x03, 0x80,
  0x70, 0xE0, 0x06, 0x18, 0x00, 0xC7, 0x00, 0x18, 0xC0, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x78, 0x03, 0x7C,
  0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x1D, 0x80, 0x03, 0x30, 0x00, 0x67, 0x00, 0x1C,
  0xE0, 0x03, 0x0E, 0x00, 0xE0, 0xE0, 0x38, 0x1F, 0xFE, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x6C, 0x00, 0x0E,
  0xC0, 0x01, 0xDC, 0x00, 0x19, 0xC0, 0x03, 0x18, 0x00, 0x61, 0x80, 0x0E,
  0x18, 0x01, 0xC1, 0x80, 0x38, 0x38, 0x03, 0x03, 0x80, 0x60, 0x30, 0x0C,
  0x03, 0x01, 0xC0, 0x30, 0x38, 0x03, 0x03, 0x00, 0x70, 0x60, 0x06, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x03, 0xFF,
  0xF0, 0x3F, 0xFF, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x19,
  0xFC, 0x01, 0xFF, 0xE0, 0x1E, 0x0F, 0x03, 0x80, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0xC0, 0x01, 0x8C, 0x00, 0x38, 0xE0, 0x03, 0x06, 0x00, 0x70, 0x70, 0x0E,
  0x03, 0x81, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x07,
  0xE0, 0x07, 0xF8, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x87, 0x00, 0xCF, 0xF8, 0x37,
  0x8F, 0x0F, 0x00, 0xC7, 0x80, 0x39, 0xC0, 0x06, 0x60, 0x01, 0xD8, 0x00,
  0x76, 0x00, 0x1D, 0x80, 0x07, 0xE0, 0x01, 0x98, 0x00, 0x66, 0x00, 0x19,
  0x80, 0x0C, 0x70, 0x07, 0x0C, 0x01, 0x83, 0x81, 0xE0, 0x7F, 0xE0, 0x0F,
  0xF0, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x0F, 0xF8, 0x03, 0xE3, 0xC0, 0x38, 0x0E, 0x07, 0x00, 0x70, 0xE0, 0x07,
  0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x70, 0xC0, 0x06, 0x0C, 0x00,
  0xE0, 0xE0, 0x0C, 0x07, 0x03, 0x80, 0x3F, 0xF0, 0x01, 0xFC, 0x00, 0x79,
  0xF0, 0x1C, 0x03, 0x83, 0x80, 0x18, 0x30, 0x00, 0xC7, 0x00, 0x0C, 0x60,
  0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x1C, 0x60, 0x01, 0x87,
  0x00, 0x38, 0x38, 0x0F, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0xF0,
  0x03, 0xFE, 0x03, 0xC7, 0x83, 0x80, 0xE3, 0x80, 0x31, 0x80, 0x1D, 0xC0,
  0x06, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1F, 0x80, 0x1E, 0xC0, 0x1E, 0x70, 0x1B, 0x1E, 0x39,
  0x87, 0xF9, 0x80, 0xE0, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x01, 0xF0, 0x0F, 0xE0, 0x07, 0xC0, 0x00,
  0x08, 0x73, 0xC7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x0E, 0x38, 0xE0, 0x01, 0x01, 0xC1, 0xE0, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x07, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x70, 0x10, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0xF0, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x18, 0x7F,
  0xFF, 0xDF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x10, 0x00,
  0x07, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0x80, 0x03, 0x80, 0x00, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x1F, 0xF0, 0xF8, 0xF1, 0xC0, 0x77, 0x00, 0xFC, 0x00,
  0xF0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0,
  0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0xFF, 0x80, 0x0F, 0x0F, 0x00, 0x70, 0x0E, 0x03, 0x00, 0x18, 0x18, 0x00,
  0x30, 0xC0, 0xE0, 0xC7, 0x0F, 0xC3, 0x18, 0x71, 0x8C, 0xC3, 0x06, 0x33,
  0x0C, 0x10, 0xC8, 0x60, 0x43, 0x61, 0x83, 0x0D, 0x8C, 0x0C, 0x34, 0x30,
  0x20, 0xF0, 0xC1, 0x82, 0xC2, 0x06, 0x0B, 0x08, 0x18, 0x6C, 0x60, 0xC1,
  0x31, 0x87, 0x0C, 0xC3, 0x14, 0x23, 0x0F, 0x9B, 0x8C, 0x1C, 0x3C, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x40, 0x07, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0x98, 0x00, 0x39, 0x80, 0x03, 0x18,
  0x00, 0x71, 0x80, 0x06, 0x18, 0x00, 0xE1, 0x80, 0x0C, 0x1C, 0x01, 0xC0,
  0xC0, 0x18, 0x0C, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x07, 0x00, 0xC0, 0x60,
  0x0C, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0C, 0x00, 0x61, 0x80, 0x06, 0x18,
  0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x7C,
  0x00, 0x07, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0C, 0x01, 0xE0, 0xC0, 0x06,
  0x0C, 0x00, 0x70, 0xC0, 0x07, 0x1C, 0x00, 0x71, 0x80, 0x07, 0x18, 0x00,
  0x61, 0x80, 0x0E, 0x18, 0x01, 0xC1, 0x80, 0x38, 0x3F, 0xFF, 0x03, 0xFF,
  0xE0, 0x30, 0x0F, 0x03, 0x00, 0x38, 0x30, 0x01, 0xC7, 0x00, 0x0C, 0x70,
  0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x01, 0xCE,
  0x00, 0x38, 0xE0, 0x07, 0x0C, 0x01, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00,
  0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x03, 0xC3, 0xC0, 0x70, 0x0E, 0x0E, 0x00,
  0x60, 0xC0, 0x07, 0x1C, 0x00, 0x31, 0x80, 0x03, 0x38, 0x00, 0x33, 0x00,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0xCE, 0x00, 0x0C, 0x60, 0x01, 0x86, 0x00, 0x18,
  0x60, 0x03, 0x03, 0x00, 0x70, 0x38, 0x0E, 0x01, 0xFF, 0xC0, 0x0F, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0x80, 0x70, 0x0C, 0x01, 0xC0,
  0xE0, 0x07, 0x07, 0x00, 0x18, 0x30, 0x00, 0xE1, 0x80, 0x03, 0x0C, 0x00,
  0x18, 0x60, 0x00, 0xC7, 0x00, 0x06, 0x38, 0x00, 0x31, 0x80, 0x01, 0x8C,
  0x00, 0x1C, 0x60, 0x00, 0xE7, 0x00, 0x06, 0x38, 0x00, 0x31, 0x80, 0x01,
  0x8C, 0x00, 0x1C, 0x60, 0x00, 0xC3, 0x00, 0x0E, 0x38, 0x00, 0x61, 0xC0,
  0x06, 0x0C, 0x00, 0x70, 0x60, 0x0F, 0x03, 0x01, 0xF0, 0x1F, 0xFE, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xF8,
  0x03, 0xE3, 0xC0, 0x70, 0x0E, 0x0E, 0x00, 0x60, 0xC0, 0x07, 0x1C, 0x00,
  0x31, 0x80, 0x03, 0x38, 0x00, 0x33, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x03, 0xFE, 0xE0,
  0x3F, 0xEE, 0x03, 0xFE, 0xC0, 0x00, 0xEC, 0x00, 0x0C, 0xE0, 0x00, 0xCE,
  0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x70, 0x01, 0xC3, 0x00, 0x18,
  0x3C, 0x07, 0x81, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x06, 0x00, 0x0C, 0x18,
  0x00, 0x30, 0xE0, 0x00, 0xC3, 0x00, 0x07, 0x0C, 0x00, 0x18, 0x30, 0x00,
  0x60, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x1C, 0x00, 0x38, 0x60, 0x00, 0xC1,
  0x80, 0x03, 0x06, 0x00, 0x0C, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0x00,
  0x07, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x06,
  0x1C, 0x00, 0x18, 0x60, 0x00, 0xE1, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x18,
  0x00, 0x30, 0x60, 0x00, 0xC3, 0x80, 0x03, 0x0C, 0x00, 0x1C, 0x30, 0x00,
  0x60, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0x80, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x8E, 0x00, 0x1C, 0x70, 0x00,
  0xC1, 0x80, 0x0E, 0x0C, 0x00, 0x60, 0x70, 0x07, 0x01, 0xC0, 0xF0, 0x07,
  0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x06, 0x00, 0x1E, 0x1C, 0x00, 0x70, 0x30,
  0x01, 0xC0, 0x60, 0x07, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x70, 0x07, 0x01,
  0xC0, 0x0E, 0x07, 0x00, 0x18, 0x1C, 0x00, 0x30, 0x70, 0x00, 0x61, 0xC0,
  0x00, 0xC7, 0x00, 0x03, 0xBC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1E, 0x38, 0x00, 0x38, 0x30, 0x00, 0x60, 0x70, 0x01, 0xC0, 0x60, 0x03,
  0x80, 0xE0, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x30,
  0x03, 0x80, 0xE0, 0x03, 0x01, 0xC0, 0x07, 0x03, 0x00, 0x07, 0x06, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0xF0, 0x70, 0x03, 0xC3, 0x60,
  0x1F, 0x0D, 0x80, 0x6C, 0x36, 0x03, 0x60, 0xD8, 0x0D, 0x83, 0x60, 0x66,
  0x0D, 0x81, 0x98, 0x73, 0x0C, 0x61, 0x8C, 0x73, 0x86, 0x31, 0x8C, 0x18,
  0xCE, 0x30, 0x63, 0x30, 0xC3, 0x87, 0xC3, 0x0E, 0x1E, 0x1C, 0x30, 0x70,
  0x70, 0xC1, 0xC1, 0x83, 0x06, 0x06, 0x0C, 0x00, 0x18, 0x70, 0x00, 0x61,
  0xC0, 0x03, 0x86, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80,
  0x03, 0x0E, 0x00, 0x0C, 0x30, 0x00, 0x70, 0x07, 0x00, 0x0C, 0x1C, 0x00,
  0x30, 0xF0, 0x01, 0xC3, 0xE0, 0x06, 0x0D, 0x80, 0x18, 0x36, 0x00, 0x60,
  0xDC, 0x01, 0x83, 0x30, 0x0E, 0x1C, 0xC0, 0x38, 0x73, 0x80, 0xC1, 0x86,
  0x03, 0x06, 0x18, 0x0C, 0x18, 0x70, 0x30, 0x60, 0xC1, 0xC3, 0x83, 0x87,
  0x0C, 0x06, 0x18, 0x30, 0x18, 0x60, 0xC0, 0x71, 0x83, 0x00, 0xC6, 0x0C,
  0x03, 0x38, 0x70, 0x0E, 0xE1, 0x80, 0x1B, 0x06, 0x00, 0x6C, 0x18, 0x01,
  0xF0, 0x60, 0x03, 0xC3, 0x80, 0x0F, 0x0E, 0x00, 0x3C, 0x30, 0x00, 0x60,
  0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x03, 0xE3, 0xC0, 0x70, 0x0C, 0x0E, 0x00,
  0xE0, 0xC0, 0x06, 0x1C, 0x00, 0x61, 0x80, 0x07, 0x38, 0x00, 0x33, 0x00,
  0x03, 0x30, 0x00, 0x37, 0x00, 0x03, 0x60, 0x00, 0x76, 0x00, 0x07, 0x60,
  0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0xEE,
  0x00, 0x0C, 0xE0, 0x00, 0xCE, 0x00, 0x1C, 0x60, 0x01, 0x86, 0x00, 0x38,
  0x70, 0x07, 0x03, 0x00, 0x60, 0x38, 0x1C, 0x01, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x03, 0x80, 0x1C, 0x1C, 0x00, 0x60,
  0xC0, 0x03, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x03, 0x1C, 0x00,
  0x18, 0xE0, 0x01, 0xC6, 0x00, 0x0C, 0x30, 0x00, 0xE1, 0x80, 0x0E, 0x0C,
  0x01, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x03, 0xE3, 0xC0, 0x70,
  0x0E, 0x0E, 0x00, 0x60, 0xC0, 0x06, 0x18, 0x00, 0x33, 0x80, 0x03, 0x30,
  0x00, 0x33, 0x00, 0x03, 0x70, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x36,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x06,
  0xC0, 0x00, 0x6C, 0x00, 0x0E, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xE0, 0x01,
  0xC6, 0x00, 0x18, 0x60, 0x03, 0x07, 0x00, 0x60, 0x38, 0x1E, 0x01, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x10, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x0E, 0x01, 0xE0,
  0xC0, 0x06, 0x0C, 0x00, 0x70, 0xC0, 0x03, 0x0C, 0x00, 0x31, 0xC0, 0x03,
  0x18, 0x00, 0x31, 0x80, 0x07, 0x18, 0x00, 0x61, 0x80, 0x0E, 0x18, 0x01,
  0xC3, 0x80, 0x78, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x30, 0x1C, 0x03, 0x01,
  0xC0, 0x70, 0x0C, 0x07, 0x00, 0xE0, 0x60, 0x0E, 0x06, 0x00, 0x60, 0x60,
  0x07, 0x06, 0x00, 0x70, 0xE0, 0x03, 0x0E, 0x00, 0x38, 0xC0, 0x03, 0x8C,
  0x00, 0x18, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x03, 0xC3, 0xC0, 0x70, 0x0E,
  0x0E, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xCE,
  0x00, 0x0C, 0x60, 0x01, 0xC7, 0x00, 0x38, 0x38, 0x0F, 0x01, 0xFF, 0xE0,
  0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC7, 0x00,
  0x0E, 0x30, 0x00, 0x71, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC3,
  0x00, 0x06, 0x38, 0x00, 0x71, 0x80, 0x03, 0x8C, 0x00, 0x18, 0x60, 0x00,
  0xC3, 0x00, 0x06, 0x38, 0x00, 0x31, 0xC0, 0x03, 0x8C, 0x00, 0x18, 0x60,
  0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x31, 0xC0, 0x03, 0x8E, 0x00, 0x1C,
  0x30, 0x00, 0xC1, 0x80, 0x0E, 0x0C, 0x00, 0xE0, 0x70, 0x06, 0x01, 0xC0,
  0xF0, 0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xE0, 0x00, 0x76, 0x00, 0x06,
  0x60, 0x00, 0xE6, 0x00, 0x0C, 0x60, 0x01, 0xC7, 0x00, 0x18, 0x70, 0x03,
  0x83, 0x00, 0x30, 0x30, 0x03, 0x03, 0x00, 0x60, 0x30, 0x06, 0x03, 0x00,
  0xE0, 0x38, 0x0C, 0x03, 0x81, 0xC0, 0x18, 0x18, 0x01, 0x83, 0x80, 0x18,
  0x30, 0x01, 0x87, 0x00, 0x18, 0x60, 0x01, 0xCE, 0x00, 0x0C, 0xC0, 0x00,
  0xCC, 0x00, 0x0D, 0x80, 0x00, 0xD8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x70, 0x1E, 0x03, 0x81, 0xB0, 0x1C,
  0x0D, 0x81, 0xE0, 0x6C, 0x0F, 0x07, 0x60, 0x78, 0x33, 0x06, 0xC1, 0x98,
  0x36, 0x0C, 0xC1, 0xB0, 0xC6, 0x19, 0x86, 0x30, 0xCC, 0x31, 0x86, 0x63,
  0x0C, 0x63, 0x18, 0x63, 0x18, 0xC3, 0x38, 0xCE, 0x19, 0x86, 0x60, 0xCC,
  0x33, 0x06, 0xE1, 0x98, 0x36, 0x0D, 0x81, 0xB0, 0x6C, 0x0F, 0x83, 0x60,
  0x78, 0x1F, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x01,
  0xC0, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x00, 0x07, 0x00, 0x07, 0x03, 0x00,
  0x0E, 0x03, 0x80, 0x1C, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x38, 0x00, 0xC0,
  0x70, 0x00, 0xC0, 0xE0, 0x00, 0xE0, 0xC0, 0x00, 0x61, 0xC0, 0x00, 0x73,
  0x80, 0x00, 0x37, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x66, 0x00, 0x00, 0xE6,
  0x00, 0x01, 0xC7, 0x00, 0x01, 0x83, 0x00, 0x03, 0x03, 0x80, 0x07, 0x01,
  0x80, 0x0E, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x38, 0x00,
  0xE0, 0x70, 0x00, 0x60, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x77, 0x00, 0x0E,
  0x70, 0x00, 0xC3, 0x00, 0x1C, 0x30, 0x03, 0x83, 0x80, 0x30, 0x18, 0x07,
  0x01, 0x80, 0xE0, 0x1C, 0x0C, 0x00, 0xC1, 0xC0, 0x0C, 0x38, 0x00, 0xC3,
  0x00, 0x06, 0x70, 0x00, 0x66, 0x00, 0x06, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x3F, 0x07, 0xF0,
  0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E,
  0x00, 0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x60,
  0x60, 0x60, 0x30, 0x30, 0x30, 0x30, 0x30, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x06, 0x06, 0x06, 0x06, 0x06, 0x03, 0x03,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0,
  0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x3F, 0x03, 0xF8, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0xF8, 0x03,
  0x60, 0x1C, 0xC0, 0x63, 0x03, 0x0C, 0x0C, 0x30, 0x60, 0x63, 0x81, 0x8C,
  0x06, 0x70, 0x19, 0x80, 0x7C, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xE0, 0xC3, 0x06, 0x1C, 0x00, 0x10, 0x00, 0x7F, 0x80, 0x7D, 0xF8, 0x38,
  0x0E, 0x1C, 0x01, 0xC6, 0x00, 0x33, 0x80, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x70, 0x7F, 0xF8, 0x7F, 0x9E, 0x3C, 0x01, 0x9C, 0x00, 0x66,
  0x00, 0x1B, 0x80, 0x0E, 0xC0, 0x03, 0x30, 0x01, 0xCE, 0x00, 0xF1, 0xC0,
  0xEC, 0x7F, 0xF3, 0x07, 0xF0, 0xC0, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x1C, 0x10, 0x06, 0x3F, 0x81, 0xBF, 0xF0, 0x7C, 0x0E, 0x1C, 0x01, 0xC6,
  0x00, 0x73, 0x80, 0x0C, 0xE0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x33, 0x00,
  0x0C, 0xC0, 0x03, 0x70, 0x00, 0xDC, 0x00, 0x76, 0x00, 0x19, 0x80, 0x06,
  0x60, 0x03, 0x98, 0x01, 0xCF, 0x00, 0x63, 0x60, 0x78, 0xCF, 0xFC, 0x31,
  0xFC, 0x00, 0x00, 0x60, 0x00, 0xFF, 0x00, 0x7D, 0xF0, 0x78, 0x1C, 0x18,
  0x03, 0x8E, 0x00, 0x67, 0x00, 0x19, 0x80, 0x06, 0x60, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x0C, 0xC0, 0x03, 0x38, 0x01, 0x86, 0x00, 0xE1, 0xC0, 0x70, 0x3F,
  0xF8, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x40, 0xC0, 0x3F, 0x8C, 0x0F, 0xFD, 0xC1, 0xE0, 0x7C, 0x38, 0x03,
  0xC3, 0x00, 0x38, 0x70, 0x01, 0x86, 0x00, 0x18, 0xE0, 0x01, 0x8E, 0x00,
  0x38, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0,
  0x07, 0x0C, 0x00, 0x70, 0xC0, 0x06, 0x0E, 0x00, 0xE0, 0xE0, 0x1E, 0x07,
  0x03, 0xE0, 0x3F, 0xF6, 0x01, 0xFC, 0xE0, 0x00, 0x10, 0x00, 0x3F, 0xC0,
  0x0F, 0xBC, 0x07, 0x81, 0xC0, 0xC0, 0x1C, 0x38, 0x01, 0x8E, 0x00, 0x31,
  0x80, 0x07, 0x70, 0x00, 0xEC, 0x00, 0x1D, 0xFF, 0xFF, 0x3F, 0xFF, 0xE6,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x0E, 0x1E, 0x07, 0x81, 0xFF, 0xE0, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x07, 0xFC, 0x01, 0xF9, 0x80, 0x70, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x03,
  0xFF, 0xFC, 0x7F, 0xFF, 0x80, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x0F, 0xE3, 0x03, 0xFF, 0x30, 0x78, 0x1F,
  0x0E, 0x00, 0xF0, 0xC0, 0x0E, 0x1C, 0x00, 0x61, 0x80, 0x06, 0x38, 0x00,
  0x63, 0x80, 0x0E, 0x30, 0x00, 0xE3, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00,
  0x0C, 0x30, 0x01, 0xC3, 0x00, 0x1C, 0x30, 0x01, 0xC3, 0x80, 0x38, 0x18,
  0x07, 0x81, 0xC0, 0xF8, 0x0F, 0xFD, 0x80, 0x7F, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x07, 0x04, 0x00, 0x60, 0xE0, 0x0E, 0x07, 0x01, 0xC0,
  0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C,
  0x08, 0x06, 0x3F, 0xC1, 0x9F, 0xF8, 0x6C, 0x07, 0x1E, 0x01, 0xCF, 0x00,
  0x33, 0x80, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0D,
  0xC0, 0x07, 0x70, 0x01, 0xD8, 0x00, 0x66, 0x00, 0x19, 0x80, 0x06, 0x60,
  0x01, 0xB8, 0x00, 0xEE, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x07, 0x80, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x33, 0xE0, 0x0F, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x0F, 0x1C,
  0x01, 0xC1, 0xC0, 0x78, 0x18, 0x0E, 0x01, 0x81, 0xC0, 0x18, 0x38, 0x01,
  0x87, 0x00, 0x39, 0xE0, 0x03, 0xB8, 0x00, 0x37, 0x80, 0x03, 0xFC, 0x00,
  0x3C, 0xE0, 0x03, 0x86, 0x00, 0x70, 0x70, 0x07, 0x03, 0x80, 0x60, 0x18,
  0x06, 0x01, 0xC0, 0x60, 0x0E, 0x06, 0x00, 0x60, 0xE0, 0x07, 0x0C, 0x00,
  0x38, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x40, 0x20, 0x67, 0xE7, 0xE1, 0xFF,
  0xBF, 0xC7, 0x07, 0x83, 0x18, 0x1C, 0x0C, 0x60, 0x70, 0x33, 0x81, 0x80,
  0xCC, 0x06, 0x03, 0x30, 0x18, 0x0C, 0xC0, 0x60, 0x33, 0x03, 0x81, 0xDC,
  0x0E, 0x06, 0x60, 0x30, 0x19, 0x80, 0xC0, 0x66, 0x03, 0x01, 0x98, 0x0C,
  0x06, 0x60, 0x70, 0x3B, 0x81, 0x80, 0xCC, 0x06, 0x03, 0x30, 0x18, 0x0C,
  0xC0, 0x60, 0x33, 0x01, 0x81, 0xC0, 0x00, 0x08, 0x06, 0x3F, 0xC1, 0x9F,
  0xF8, 0x6C, 0x07, 0x1E, 0x01, 0xCF, 0x00, 0x33, 0x80, 0x0C, 0xC0, 0x03,
  0x30, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0D, 0xC0, 0x07, 0x70, 0x01, 0x98,
  0x00, 0x66, 0x00, 0x19, 0x80, 0x06, 0x60, 0x03, 0xB8, 0x00, 0xEE, 0x00,
  0x33, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x3F,
  0xC0, 0x1F, 0xFC, 0x07, 0x01, 0xC1, 0xC0, 0x1C, 0x70, 0x01, 0x8C, 0x00,
  0x33, 0x80, 0x07, 0x60, 0x00, 0xEC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x77, 0x00, 0x0C, 0xE0, 0x03,
  0x8C, 0x00, 0x61, 0xC0, 0x1C, 0x1C, 0x0F, 0x01, 0xFF, 0xC0, 0x1F, 0xE0,
  0x00, 0x00, 0x04, 0x00, 0x63, 0xF8, 0x06, 0xFF, 0xC0, 0x7C, 0x0E, 0x07,
  0x00, 0x60, 0x60, 0x07, 0x0E, 0x00, 0x30, 0xE0, 0x03, 0x0C, 0x00, 0x30,
  0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x1C, 0x00, 0x31, 0x80, 0x07,
  0x18, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0xE3, 0x80, 0x1C, 0x3C, 0x03,
  0x83, 0x60, 0x78, 0x37, 0xFF, 0x03, 0x1F, 0xC0, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x40, 0x00, 0xFE, 0x30, 0xFF, 0xCC, 0x70,
  0x1F, 0x38, 0x03, 0xCC, 0x00, 0x67, 0x00, 0x19, 0x80, 0x06, 0xE0, 0x01,
  0xB8, 0x00, 0xEC, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0xCC,
  0x00, 0x73, 0x00, 0x1C, 0xC0, 0x06, 0x38, 0x01, 0x8E, 0x00, 0xE1, 0xC0,
  0xF8, 0x3F, 0xF6, 0x07, 0xF3, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0x04, 0x0E, 0x3F, 0xC6, 0x7F, 0xE3, 0x70, 0x01, 0xF0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x20, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x70, 0x0E, 0x38, 0x01, 0x8C, 0x00,
  0x73, 0x00, 0x1C, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0xC0,
  0x03, 0x30, 0x00, 0xCE, 0x00, 0x71, 0xC0, 0x38, 0x3F, 0xFC, 0x07, 0xFC,
  0x00, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x3F, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x1F, 0xF0, 0x1F, 0xE0, 0x38, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0xC0,
  0x07, 0x30, 0x01, 0xDC, 0x00, 0x67, 0x00, 0x19, 0x80, 0x06, 0x60, 0x03,
  0x98, 0x00, 0xE6, 0x00, 0x33, 0x80, 0x0C, 0xE0, 0x03, 0x30, 0x00, 0xCC,
  0x00, 0x73, 0x00, 0x1C, 0xE0, 0x0E, 0x38, 0x07, 0x87, 0x03, 0x60, 0xFF,
  0x98, 0x1F, 0xC6, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x3B, 0x00, 0x06, 0x70,
  0x01, 0xC6, 0x00, 0x30, 0xC0, 0x0E, 0x18, 0x01, 0x83, 0x80, 0x60, 0x30,
  0x1C, 0x06, 0x03, 0x00, 0xC0, 0xE0, 0x1C, 0x18, 0x01, 0x87, 0x00, 0x30,
  0xC0, 0x06, 0x30, 0x00, 0xE6, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0xC0, 0x60, 0x1E, 0x03, 0x01, 0xB0,
  0x38, 0x0D, 0x81, 0xC0, 0x6C, 0x0B, 0x06, 0x60, 0xD8, 0x33, 0x06, 0xC3,
  0x18, 0x66, 0x18, 0xC3, 0x30, 0xC6, 0x11, 0x8C, 0x31, 0x8C, 0x61, 0x8C,
  0x63, 0x0C, 0xC3, 0x30, 0x66, 0x19, 0x83, 0x60, 0xD8, 0x1B, 0x02, 0xC0,
  0x50, 0x16, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xC0, 0x30, 0x06, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x3C, 0x38, 0x01, 0xC0, 0x60, 0x0E, 0x01, 0xC0,
  0x70, 0x03, 0x83, 0x80, 0x06, 0x0C, 0x00, 0x1C, 0x60, 0x00, 0x33, 0x80,
  0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x01,
  0xD8, 0x00, 0x0E, 0x70, 0x00, 0x70, 0xC0, 0x01, 0x81, 0x80, 0x0E, 0x07,
  0x00, 0x70, 0x0C, 0x03, 0x80, 0x38, 0x1C, 0x00, 0x70, 0xE0, 0x00, 0xC0,
  0x0E, 0x00, 0x07, 0x06, 0x00, 0x07, 0x06, 0x00, 0x0E, 0x07, 0x00, 0x0C,
  0x07, 0x00, 0x1C, 0x03, 0x00, 0x38, 0x03, 0x00, 0x30, 0x03, 0x80, 0x70,
  0x03, 0x80, 0x60, 0x01, 0x80, 0xE0, 0x01, 0x80, 0xC0, 0x01, 0xC1, 0x80,
  0x00, 0xC3, 0x80, 0x00, 0xC3, 0x00, 0x00, 0xC7, 0x00, 0x00, 0xE6, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0xF8,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0xC0, 0x06, 0x0C, 0x18, 0x30, 0x41, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x10, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x30, 0x60, 0xC1, 0x83, 0x00,
  0x03, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x40, 0x00, 0x1F, 0x80, 0x0C, 0xFF, 0x00, 0x67,
  0x0F, 0x01, 0xB8, 0x1E, 0x0E, 0xC0, 0x1E, 0xF3, 0x00, 0x3F, 0x80, 0x00,
  0x38, 0x00,
};

const GFXglyph RobotoMono_LightItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 7, 28, 23, 8, -28 },
  { 26, 9, 9, 23, 9, -30 },
  { 37, 23, 28, 23, 1, -28 },
  { 118, 19, 37, 23, 3, -33 },
  { 206, 20, 29, 23, 2, -29 },
  { 279, 21, 29, 23, 1, -29 },
  { 356, 4, 9, 23, 11, -30 },
  { 361, 12, 41, 23, 7, -32 },
  { 423, 13, 41, 23, 3, -32 },
  { 490, 17, 17, 23, 5, -28 },
  { 527, 20, 21, 23, 2, -24 },
  { 580, 6, 10, 23, 4, -4 },
  { 588, 15, 2, 23, 4, -14 },
  { 592, 4, 4, 23, 8, -4 },
  { 594, 19, 30, 23, 3, -28 },
  { 666, 19, 29, 23, 3, -29 },
  { 735, 11, 28, 23, 6, -28 },
  { 774, 19, 29, 23, 1, -29 },
  { 843, 19, 29, 23, 1, -29 },
  { 912, 20, 28, 23, 1, -28 },
  { 982, 20, 28, 23, 3, -28 },
  { 1052, 18, 29, 23, 2, -29 },
  { 1118, 19, 28, 23, 4, -28 },
  { 1185, 20, 29, 23, 2, -29 },
  { 1258, 17, 29, 23, 4, -29 },
  { 1320, 6, 21, 23, 10, -21 },
  { 1336, 9, 27, 23, 7, -21 },
  { 1367, 18, 16, 23, 3, -21 },
  { 1403, 18, 10, 23, 3, -18 },
  { 1426, 18, 17, 23, 2, -21 },
  { 1465, 15, 29, 23, 6, -29 },
  { 1520, 22, 29, 23, 1, -29 },
  { 1600, 20, 28, 23, 0, -28 },
  { 1670, 20, 28, 23, 2, -28 },
  { 1740, 20, 29, 23, 2, -29 },
  { 1813, 21, 28, 23, 1, -28 },
  { 1887, 21, 28, 23, 2, -28 },
  { 1961, 21, 28, 23, 2, -28 },
  { 2035, 20, 29, 23, 2, -29 },
  { 2108, 22, 28, 23, 1, -28 },
  { 2185, 21, 28, 23, 2, -28 },
  { 2259, 21, 28, 23, 1, -28 },
  { 2333, 23, 28, 23, 2, -28 },
  { 2414, 17, 28, 23, 2, -28 },
  { 2474, 22, 28, 23, 1, -28 },
  { 2551, 22, 28, 23, 1, -28 },
  { 2628, 20, 29, 23, 2, -29 },
  { 2701, 21, 28, 23, 2, -28 },
  { 2775, 20, 34, 23, 2, -29 },
  { 2860, 20, 28, 23, 2, -28 },
  { 2930, 20, 29, 23, 2, -29 },
  { 3003, 21, 28, 23, 4, -28 },
  { 3077, 21, 28, 23, 2, -28 },
  { 3151, 20, 28, 23, 4, -28 },
  { 3221, 21, 28, 23, 4, -28 },
  { 3295, 24, 28, 23, 0, -28 },
  { 3379, 20, 28, 23, 4, -28 },
  { 3449, 21, 28, 23, 1, -28 },
  { 3523, 12, 39, 23, 6, -33 },
  { 3582, 8, 30, 23, 8, -28 },
  { 3612, 13, 39, 23, 5, -33 },
  { 3676, 14, 15, 23, 5, -28 },
  { 3703, 17, 2, 23, 1, 0 },
  { 3708, 6, 5, 23, 11, -29 },
  { 3712, 18, 22, 23, 2, -22 },
  { 3762, 18, 30, 23, 2, -30 },
  { 3830, 18, 22, 23, 3, -22 },
  { 3880, 20, 30, 23, 3, -30 },
  { 3955, 19, 22, 23, 2, -22 },
  { 4008, 19, 31, 23, 5, -31 },
  { 4082, 20, 30, 23, 1, -22 },
  { 4157, 18, 30, 23, 2, -30 },
  { 4225, 17, 29, 23, 2, -29 },
  { 4287, 19, 38, 23, 0, -29 },
  { 4378, 20, 30, 23, 2, -30 },
  { 4453, 17, 30, 23, 2, -30 },
  { 4517, 22, 22, 23, 0, -22 },
  { 4578, 18, 22, 23, 2, -22 },
  { 4628, 19, 22, 23, 2, -22 },
  { 4681, 20, 30, 23, 0, -22 },
  { 4756, 18, 30, 23, 3, -22 },
  { 4824, 17, 22, 23, 5, -22 },
  { 4871, 18, 22, 23, 3, -22 },
  { 4921, 15, 27, 23, 5, -27 },
  { 4972, 18, 21, 23, 3, -21 },
  { 5020, 19, 21, 23, 4, -21 },
  { 5070, 21, 21, 23, 3, -21 },
  { 5126, 22, 21, 23, 1, -21 },
  { 5184, 24, 30, 23, -1, -21 },
  { 5274, 20, 21, 23, 1, -21 },
  { 5327, 16, 39, 23, 6, -31 },
  { 5405, 7, 35, 23, 8, -28 },
  { 5436, 16, 39, 23, 3, -31 },
  { 5514, 22, 7, 23, 1, -15 },
};

const GFXfont RobotoMono_LightItalic40pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic40pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic40pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _ROBOTOMONO_LIGHTITALIC40PT7B_H_
