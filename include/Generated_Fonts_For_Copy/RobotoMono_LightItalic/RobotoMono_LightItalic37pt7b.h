#ifndef _ROBOTOMONO_LIGHTITALIC37PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x0C, 0x18, 0x70, 0xC1, 0x83, 0x06, 0x0C, 0x30, 0x60, 0xC1,
  0x83, 0x0E, 0x18, 0x30, 0x60, 0x00, 0x00, 0x00, 0x00, 0x30, 0xE0, 0xC0,
  0x31, 0x90, 0xD8, 0x6C, 0x26, 0x33, 0x19, 0x0D, 0x86, 0x00, 0x18, 0x18,
  0x00, 0x60, 0xC0, 0x01, 0x03, 0x00, 0x0C, 0x08, 0x00, 0x30, 0x60, 0x00,
  0x81, 0x80, 0x06, 0x0C, 0x03, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x03, 0x06,
  0x00, 0x0C, 0x18, 0x00, 0x60, 0x60, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00,
  0x30, 0x20, 0x00, 0xC1, 0x80, 0x02, 0x06, 0x01, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFE, 0x01, 0x03, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x00, 0x81, 0x80,
  0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x01, 0xFF, 0x00, 0xF1, 0xE0, 0x70,
  0x18, 0x38, 0x07, 0x0C, 0x00, 0xC3, 0x00, 0x31, 0xC0, 0x0C, 0x70, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC6, 0x00,
  0x31, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x01, 0xC7, 0x00, 0x60, 0xE0, 0x78,
  0x3F, 0xF8, 0x03, 0xFC, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x07, 0xC0, 0x03, 0x18, 0x01, 0x82, 0x00, 0x60,
  0xC1, 0x90, 0x20, 0xCC, 0x08, 0x63, 0x06, 0x18, 0xC1, 0x8C, 0x10, 0xC6,
  0x07, 0x71, 0x80, 0xF8, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x06, 0x18, 0x03, 0x1F, 0x80, 0xCE, 0x60, 0x63, 0x0C, 0x31, 0x83, 0x08,
  0x60, 0xC6, 0x18, 0x33, 0x04, 0x0C, 0x81, 0x82, 0x00, 0x61, 0x80, 0x1C,
  0xC0, 0x03, 0xE0, 0x00, 0x30, 0x00, 0x1F, 0xC0, 0x07, 0x18, 0x01, 0xC1,
  0x80, 0x30, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x30, 0x06, 0x0E,
  0x00, 0xE3, 0x80, 0x0C, 0xE0, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x03, 0xB0, 0x00, 0xE3, 0x03, 0x38, 0x70, 0x66, 0x06, 0x1D, 0xC0, 0xE3,
  0x30, 0x0C, 0x66, 0x00, 0xD8, 0xC0, 0x1F, 0x18, 0x01, 0xC3, 0x00, 0x78,
  0x30, 0x1F, 0x87, 0xFF, 0x30, 0x3F, 0x87, 0x00, 0x32, 0x66, 0x66, 0x4C,
  0x00, 0x10, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x60,
  0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x20,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x20, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x81, 0xE1, 0x8E, 0xF9, 0x3F, 0x1F, 0xF8, 0x03, 0x80,
  0x07, 0x80, 0x0C, 0xC0, 0x1C, 0xC0, 0x38, 0x60, 0x70, 0x70, 0xE0, 0x30,
  0x20, 0x20, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x18, 0xCE, 0x73,
  0x39, 0x98, 0xFF, 0xFF, 0xFF, 0xC0, 0xEF, 0xE0, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xFE,
  0x01, 0xC3, 0x81, 0x80, 0xE1, 0x80, 0x31, 0xC0, 0x0C, 0xC0, 0x06, 0x60,
  0x03, 0x60, 0x03, 0xB0, 0x07, 0xD8, 0x07, 0x6C, 0x07, 0x3E, 0x06, 0x3E,
  0x0E, 0x1B, 0x0E, 0x0D, 0x8E, 0x06, 0xCC, 0x03, 0x7C, 0x03, 0xBC, 0x01,
  0x9C, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x63, 0x00, 0x31, 0xC0, 0x30, 0x60,
  0x30, 0x1E, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0xC0, 0x78, 0x7F, 0x3E, 0x66,
  0x0D, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x00, 0x70, 0x00, 0xFF, 0x80, 0x78,
  0xF0, 0x38, 0x0E, 0x1C, 0x01, 0x86, 0x00, 0x63, 0x80, 0x18, 0xC0, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x7F, 0x80,
  0x78, 0x70, 0x38, 0x06, 0x0C, 0x01, 0xC7, 0x00, 0x31, 0x80, 0x0C, 0x60,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x01, 0xCE, 0x00, 0x61, 0x80,
  0x38, 0x70, 0x1C, 0x0F, 0xBE, 0x01, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x0C, 0xC0, 0x07, 0x30,
  0x01, 0x8C, 0x00, 0xC3, 0x00, 0x61, 0xC0, 0x30, 0x60, 0x1C, 0x18, 0x0E,
  0x06, 0x03, 0x01, 0x81, 0x80, 0x60, 0xC0, 0x38, 0x70, 0x0C, 0x38, 0x03,
  0x0F, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0,
  0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x7C, 0x01, 0x7F, 0x80, 0xF8, 0x70, 0x30, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x73, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x03, 0x06, 0x01, 0xC1, 0xC0,
  0xE0, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x01, 0x00, 0x3E, 0x00, 0xFE,
  0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x33, 0xF8, 0x37, 0xFC, 0x6C, 0x0E, 0x78, 0x07, 0x70, 0x03,
  0x60, 0x03, 0x60, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07,
  0x60, 0x06, 0x60, 0x0E, 0x70, 0x0C, 0x30, 0x18, 0x1E, 0xF0, 0x0F, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x7F,
  0xC0, 0x3C, 0x78, 0x1C, 0x07, 0x0E, 0x00, 0xC3, 0x00, 0x31, 0xC0, 0x0C,
  0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x70, 0xC0, 0x18, 0x38, 0x1C, 0x07,
  0xBE, 0x00, 0xFE, 0x00, 0xFB, 0xC0, 0x70, 0x18, 0x30, 0x03, 0x1C, 0x00,
  0xC6, 0x00, 0x19, 0x80, 0x06, 0xE0, 0x03, 0xB8, 0x00, 0xC6, 0x00, 0x31,
  0x80, 0x18, 0x70, 0x1E, 0x0F, 0xBE, 0x00, 0xFF, 0x00, 0x00, 0xC0, 0x07,
  0xF8, 0x1E, 0x3C, 0x38, 0x0C, 0x30, 0x06, 0x60, 0x06, 0x60, 0x06, 0xC0,
  0x06, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0,
  0x0E, 0xE0, 0x1E, 0x70, 0x36, 0x3F, 0xEC, 0x1F, 0xCC, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x80, 0x7F,
  0x00, 0x7C, 0x00, 0x1C, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE3, 0x8E, 0x00, 0x07, 0x0F, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x30,
  0x30, 0x30, 0x70, 0x60, 0xE0, 0xC0, 0x00, 0x01, 0x00, 0x03, 0x00, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1C,
  0x00, 0x04, 0x3F, 0xFF, 0xCF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x3F, 0xFF,
  0xC0, 0x20, 0x00, 0x0C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x3E,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x03, 0x80, 0x01, 0x00, 0x00, 0x03,
  0x80, 0x7F, 0x83, 0xC7, 0x1C, 0x06, 0xE0, 0x1B, 0x00, 0x7C, 0x01, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x0F, 0x0E, 0x00, 0xE0, 0x18, 0x0C, 0x00, 0x60, 0xC0, 0x03,
  0x04, 0x1E, 0x08, 0x61, 0xFC, 0x46, 0x18, 0x42, 0x31, 0x82, 0x11, 0x08,
  0x30, 0x98, 0xC1, 0x84, 0x86, 0x08, 0x24, 0x20, 0x43, 0x63, 0x06, 0x1B,
  0x18, 0x30, 0x98, 0xC1, 0x04, 0xC6, 0x18, 0x66, 0x31, 0xC2, 0x31, 0x9A,
  0x31, 0x87, 0x9F, 0x0C, 0x10, 0x20, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x01, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x36, 0x00, 0x0C, 0x80, 0x07, 0x30,
  0x01, 0x8C, 0x00, 0xE3, 0x00, 0x30, 0xC0, 0x1C, 0x30, 0x06, 0x0C, 0x03,
  0x83, 0x00, 0xC0, 0x60, 0x70, 0x18, 0x18, 0x06, 0x06, 0x01, 0x83, 0xFF,
  0xE0, 0xFF, 0xF8, 0x60, 0x06, 0x18, 0x01, 0xCC, 0x00, 0x33, 0x00, 0x0D,
  0x80, 0x03, 0x60, 0x00, 0xF0, 0x00, 0x30, 0x0F, 0xFE, 0x03, 0xFF, 0xC0,
  0xC0, 0x38, 0x70, 0x07, 0x18, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0x60,
  0x03, 0x18, 0x01, 0x8E, 0x00, 0xE3, 0x00, 0x70, 0xFF, 0xF8, 0x3F, 0xF8,
  0x0C, 0x07, 0x83, 0x00, 0x71, 0x80, 0x0C, 0x60, 0x01, 0x98, 0x00, 0x66,
  0x00, 0x19, 0x80, 0x0E, 0xE0, 0x03, 0x30, 0x01, 0xCC, 0x00, 0xE3, 0x00,
  0x70, 0xFF, 0xF8, 0x3F, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xC0, 0x0E,
  0x1E, 0x03, 0x00, 0xC0, 0xC0, 0x1C, 0x38, 0x01, 0x86, 0x00, 0x31, 0x80,
  0x07, 0x30, 0x00, 0xEE, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x01, 0xCC, 0x00, 0x31, 0xC0, 0x06, 0x18, 0x01,
  0x83, 0x00, 0x70, 0x30, 0x1C, 0x03, 0xDF, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0xFF, 0xF0, 0x0C, 0x03, 0x80, 0xC0, 0x1C, 0x0C, 0x00, 0xC0,
  0xC0, 0x06, 0x0C, 0x00, 0x61, 0xC0, 0x06, 0x18, 0x00, 0x61, 0x80, 0x06,
  0x18, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0x63, 0x80, 0x06, 0x30, 0x00,
  0x63, 0x00, 0x0E, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x01, 0xC6, 0x00,
  0x18, 0x60, 0x03, 0x06, 0x00, 0x70, 0x60, 0x0E, 0x06, 0x03, 0xC0, 0xFF,
  0xF0, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x30, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0xFF,
  0xF0, 0x7F, 0xFC, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x3F,
  0xC0, 0x0F, 0x1E, 0x03, 0x80, 0xC0, 0xC0, 0x0C, 0x38, 0x01, 0x86, 0x00,
  0x31, 0x80, 0x07, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x1F, 0xF6, 0x03, 0xFC, 0xC0, 0x01,
  0x98, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x39, 0xC0, 0x06,
  0x18, 0x00, 0xC3, 0x80, 0x18, 0x38, 0x0E, 0x03, 0xFF, 0x80, 0x3F, 0xC0,
  0x00, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C,
  0x00, 0x31, 0x80, 0x06, 0x18, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0x61,
  0x80, 0x06, 0x18, 0x00, 0x63, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0x00, 0x0C,
  0x30, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0xC6, 0x00, 0x18, 0x60, 0x01,
  0x86, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x18, 0x60, 0x01, 0x8C, 0x00,
  0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x0C, 0x00,
  0x30, 0xE0, 0x07, 0x06, 0x00, 0x60, 0x60, 0x0E, 0x03, 0x01, 0xC0, 0x3F,
  0xF8, 0x00, 0xFE, 0x00, 0x0C, 0x00, 0x78, 0x60, 0x07, 0x03, 0x00, 0x70,
  0x18, 0x07, 0x01, 0x80, 0x70, 0x0C, 0x07, 0x00, 0x60, 0x70, 0x03, 0x07,
  0x00, 0x18, 0x70, 0x01, 0xC7, 0x00, 0x0C, 0x70, 0x00, 0x67, 0x00, 0x03,
  0x7C, 0x00, 0x1F, 0x60, 0x00, 0xF3, 0x80, 0x0F, 0x0C, 0x00, 0x70, 0x70,
  0x03, 0x01, 0x80, 0x18, 0x0E, 0x00, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x70,
  0x06, 0x03, 0x00, 0x38, 0x18, 0x00, 0xC0, 0xC0, 0x03, 0x06, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0E, 0x00, 0x78, 0x78, 0x03, 0x83, 0xC0, 0x3C, 0x1E, 0x01,
  0xE0, 0xF0, 0x1B, 0x07, 0x80, 0xD8, 0x64, 0x0C, 0xC3, 0x30, 0x6C, 0x19,
  0x86, 0x60, 0xCC, 0x33, 0x06, 0x63, 0x18, 0x33, 0x38, 0xC3, 0x09, 0x8C,
  0x18, 0x7C, 0x60, 0xC3, 0xC3, 0x06, 0x1C, 0x18, 0x30, 0xE0, 0xC1, 0x86,
  0x06, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC1,
  0x80, 0x06, 0x1C, 0x00, 0x70, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x30, 0xE0, 0x03, 0x0F, 0x00, 0x30, 0xF0, 0x03, 0x0F, 0x00, 0x71,
  0xD8, 0x06, 0x19, 0x80, 0x61, 0x98, 0x06, 0x18, 0xC0, 0x61, 0x8C, 0x06,
  0x18, 0xC0, 0xE3, 0x86, 0x0C, 0x30, 0x60, 0xC3, 0x06, 0x0C, 0x30, 0x30,
  0xC3, 0x03, 0x0C, 0x30, 0x39, 0xC7, 0x01, 0x98, 0x60, 0x19, 0x86, 0x00,
  0xD8, 0x60, 0x0D, 0x86, 0x00, 0xD8, 0x60, 0x07, 0x0E, 0x00, 0x70, 0xC0,
  0x07, 0x0C, 0x00, 0x30, 0x00, 0x38, 0x00, 0x7F, 0x80, 0x3C, 0xF0, 0x1C,
  0x0E, 0x0C, 0x01, 0x87, 0x00, 0x31, 0x80, 0x0C, 0xC0, 0x03, 0x30, 0x00,
  0xDC, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00,
  0x0C, 0xC0, 0x03, 0x18, 0x01, 0xC6, 0x00, 0x61, 0x80, 0x30, 0x30, 0x38,
  0x07, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x30, 0x07,
  0x06, 0x00, 0x70, 0xC0, 0x06, 0x38, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03,
  0x18, 0x00, 0x63, 0x00, 0x1C, 0x60, 0x03, 0x1C, 0x00, 0xE3, 0x00, 0x78,
  0x7F, 0xFE, 0x0F, 0xFF, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xC0,
  0x0F, 0x1C, 0x07, 0x01, 0xC0, 0xC0, 0x1C, 0x30, 0x01, 0x8E, 0x00, 0x31,
  0x80, 0x06, 0x30, 0x00, 0xEC, 0x00, 0x0D, 0x80, 0x03, 0xB0, 0x00, 0x7E,
  0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xD8,
  0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x31, 0x80, 0x06, 0x18,
  0x01, 0x83, 0x00, 0x60, 0x30, 0x18, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x0F,
  0xFE, 0x01, 0xFF, 0xE0, 0x30, 0x0E, 0x06, 0x00, 0xE1, 0xC0, 0x0C, 0x30,
  0x01, 0x86, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x38, 0xC0,
  0x06, 0x18, 0x01, 0x83, 0x00, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x01, 0x81,
  0x80, 0x60, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x06, 0x06, 0x00,
  0xC1, 0xC0, 0x18, 0x30, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x07, 0x18, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x3F, 0xE0, 0x1F, 0x1E, 0x07, 0x00, 0xE1, 0xC0,
  0x0C, 0x30, 0x01, 0x86, 0x00, 0x38, 0xC0, 0x07, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xCC, 0x00, 0x19, 0x80, 0x07, 0x38, 0x00, 0xC3, 0x00, 0x38, 0x70, 0x0E,
  0x07, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x63, 0x00,
  0x0C, 0x60, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x60, 0x01, 0x8C, 0x00,
  0x31, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x30, 0x00,
  0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x03,
  0x98, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x8E, 0x00, 0x70, 0xC0, 0x0C,
  0x18, 0x03, 0x01, 0x81, 0xC0, 0x3F, 0xF0, 0x01, 0xFC, 0x00, 0xC0, 0x00,
  0xF0, 0x00, 0x6E, 0x00, 0x19, 0x80, 0x0E, 0x60, 0x03, 0x18, 0x01, 0xC6,
  0x00, 0x61, 0x80, 0x38, 0x60, 0x0C, 0x1C, 0x07, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x30, 0x0C, 0x0C, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x18, 0xC0,
  0x06, 0x30, 0x01, 0x9C, 0x00, 0x66, 0x00, 0x1B, 0x80, 0x06, 0xC0, 0x00,
  0xB0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0x60, 0x60, 0x36,
  0x06, 0x03, 0x60, 0x60, 0x66, 0x0F, 0x06, 0x60, 0xF0, 0x66, 0x0B, 0x0C,
  0x61, 0xB0, 0xC6, 0x1B, 0x0C, 0x61, 0x30, 0xC6, 0x33, 0x18, 0x63, 0x31,
  0x86, 0x23, 0x18, 0x66, 0x33, 0x06, 0x63, 0x30, 0x64, 0x33, 0x06, 0xC3,
  0x20, 0x4C, 0x36, 0x05, 0x83, 0x60, 0x58, 0x36, 0x05, 0x83, 0xC0, 0xD0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0x06, 0x00, 0x1C, 0x1C, 0x00, 0x60, 0x30, 0x03, 0x00, 0xE0,
  0x1C, 0x01, 0x80, 0xE0, 0x06, 0x03, 0x00, 0x0C, 0x18, 0x00, 0x30, 0xE0,
  0x00, 0xE7, 0x00, 0x01, 0x98, 0x00, 0x06, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x33, 0x00, 0x01, 0xCC,
  0x00, 0x06, 0x18, 0x00, 0x30, 0x60, 0x01, 0xC1, 0xC0, 0x0E, 0x03, 0x00,
  0x30, 0x0E, 0x01, 0x80, 0x18, 0x0E, 0x00, 0x60, 0x70, 0x01, 0xC3, 0x80,
  0x03, 0x80, 0xE0, 0x01, 0xD8, 0x00, 0x66, 0x00, 0x39, 0xC0, 0x1C, 0x30,
  0x06, 0x0C, 0x03, 0x83, 0x00, 0xC0, 0x60, 0x60, 0x18, 0x38, 0x06, 0x0C,
  0x00, 0xC6, 0x00, 0x33, 0x80, 0x0C, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x03, 0xF0, 0x3F, 0x03, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x7E, 0x0F, 0xC0,
  0xC0, 0x40, 0x60, 0x60, 0x60, 0x60, 0x20, 0x30, 0x30, 0x30, 0x30, 0x10,
  0x18, 0x18, 0x18, 0x18, 0x08, 0x0C, 0x0C, 0x0C, 0x0C, 0x04, 0x06, 0x06,
  0x06, 0x06, 0x02, 0x03, 0x07, 0xF0, 0x7E, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0xFC, 0x0F, 0xC0, 0x00, 0xC0,
  0x07, 0x00, 0x78, 0x06, 0xC0, 0x36, 0x03, 0x18, 0x18, 0xC1, 0x86, 0x0C,
  0x30, 0xC1, 0x8E, 0x06, 0x60, 0x36, 0x01, 0xF0, 0x0C, 0xFF, 0xFF, 0xFF,
  0xFE, 0xC6, 0x63, 0x30, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0x81, 0xC3, 0x80,
  0x63, 0x80, 0x31, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x07,
  0xFF, 0x87, 0xC0, 0xCE, 0x00, 0x66, 0x00, 0x67, 0x00, 0x33, 0x00, 0x19,
  0x80, 0x1C, 0xC0, 0x1E, 0x70, 0x1B, 0x1F, 0xF9, 0x87, 0xF8, 0xC0, 0x0E,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0xF8, 0x0D, 0xFF, 0x07, 0xC3, 0x87, 0x80,
  0xE3, 0x80, 0x31, 0x80, 0x1C, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x01, 0xB8,
  0x00, 0xD8, 0x00, 0xEC, 0x00, 0x66, 0x00, 0x33, 0x00, 0x19, 0x80, 0x19,
  0xC0, 0x1C, 0xE0, 0x0C, 0x78, 0x0E, 0x37, 0xFE, 0x19, 0xFC, 0x00, 0x00,
  0xF8, 0x01, 0xFF, 0x03, 0xC1, 0xC3, 0x80, 0x61, 0x80, 0x39, 0x80, 0x0C,
  0xC0, 0x06, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x1C, 0xC0, 0x0C, 0x70, 0x0E, 0x18,
  0x0E, 0x07, 0xBE, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x01, 0xF1, 0xC0, 0xFF, 0xB0, 0x3C, 0x3E, 0x0E, 0x03, 0xC1, 0x80,
  0x38, 0x60, 0x07, 0x0C, 0x00, 0xE3, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00,
  0x61, 0x80, 0x0C, 0x70, 0x01, 0x8E, 0x00, 0x61, 0xC0, 0x0C, 0x18, 0x01,
  0x83, 0x00, 0x30, 0x60, 0x0E, 0x06, 0x07, 0xC0, 0xFF, 0xF0, 0x0F, 0xE6,
  0x00, 0x00, 0xF8, 0x01, 0xFF, 0x03, 0xC1, 0xC3, 0x80, 0x61, 0x80, 0x39,
  0x80, 0x0D, 0xC0, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xBF, 0xFF, 0xF8, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70,
  0x06, 0x1C, 0x07, 0x07, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x0F,
  0xF8, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x7F, 0xFF, 0x1F, 0xFF, 0xC0, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xF8, 0x60, 0x7F, 0xD8, 0x1E, 0x1F, 0x07, 0x01,
  0xE0, 0xC0, 0x1C, 0x30, 0x03, 0x86, 0x00, 0x71, 0x80, 0x0C, 0x30, 0x01,
  0x86, 0x00, 0x30, 0xC0, 0x06, 0x38, 0x00, 0xC7, 0x00, 0x38, 0xE0, 0x06,
  0x0C, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x07, 0x03, 0x03, 0xE0, 0x7F, 0xF8,
  0x07, 0xF3, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x02, 0x00, 0xE0,
  0xE0, 0x38, 0x0E, 0x0E, 0x00, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x78, 0x0C, 0xFF, 0x06, 0xC1, 0xC6, 0xC0, 0x63,
  0x80, 0x39, 0xC0, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x03, 0xB0, 0x01,
  0x98, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x33, 0x00, 0x1B, 0x80, 0x19, 0x80,
  0x0C, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x01, 0x98, 0x01, 0xC0, 0x00, 0x08,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x01,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x03, 0xC0, 0x7F, 0xC0, 0x3F, 0x80, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x01, 0xC6, 0x00, 0xE1, 0x80, 0x70, 0x60, 0x38, 0x18, 0x38,
  0x0E, 0x1C, 0x03, 0x0E, 0x00, 0xC7, 0x00, 0x37, 0x80, 0x0F, 0xE0, 0x03,
  0xD8, 0x01, 0xE7, 0x00, 0x70, 0xE0, 0x18, 0x18, 0x06, 0x07, 0x01, 0x80,
  0xE0, 0x60, 0x18, 0x30, 0x07, 0x0C, 0x00, 0xE3, 0x00, 0x1C, 0x07, 0xFC,
  0x07, 0xF8, 0x08, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x19, 0xE1, 0xE0, 0xDF, 0xBF, 0x87,
  0x0D, 0x8C, 0x30, 0x70, 0x33, 0x83, 0x81, 0x98, 0x18, 0x0C, 0xC0, 0xC0,
  0xC6, 0x06, 0x06, 0x30, 0x30, 0x31, 0x81, 0x81, 0x98, 0x0C, 0x0C, 0xC0,
  0xC0, 0x66, 0x06, 0x06, 0x30, 0x30, 0x31, 0x81, 0x81, 0x98, 0x0C, 0x0C,
  0xC0, 0xE0, 0x66, 0x06, 0x03, 0x30, 0x30, 0x31, 0x81, 0x81, 0x80, 0x0C,
  0x3E, 0x03, 0x3F, 0xC0, 0x98, 0x38, 0x6C, 0x06, 0x1C, 0x01, 0xC7, 0x00,
  0x31, 0x80, 0x0C, 0x60, 0x03, 0x38, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x18,
  0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0xE7, 0x00, 0x31, 0x80, 0x0C, 0x60,
  0x03, 0x18, 0x00, 0xC6, 0x00, 0x33, 0x80, 0x1C, 0x01, 0xF8, 0x03, 0xFE,
  0x03, 0x83, 0x83, 0x80, 0xE3, 0x80, 0x39, 0x80, 0x0D, 0x80, 0x06, 0xC0,
  0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1B, 0x00, 0x1D, 0xC0, 0x0C, 0x60, 0x0E, 0x38, 0x0E, 0x0F, 0xBE,
  0x01, 0xFC, 0x00, 0x06, 0x3E, 0x00, 0xDF, 0xE0, 0x1F, 0x0E, 0x07, 0x80,
  0xE0, 0xE0, 0x0C, 0x18, 0x01, 0xC3, 0x00, 0x38, 0x60, 0x03, 0x0C, 0x00,
  0x63, 0x80, 0x1C, 0x60, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x03,
  0x86, 0x00, 0x61, 0xC0, 0x1C, 0x38, 0x03, 0x07, 0x81, 0xE0, 0xDF, 0xF8,
  0x19, 0xFC, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x00, 0x01, 0xF0,
  0xC1, 0xFF, 0x60, 0xF0, 0xF8, 0x70, 0x1E, 0x18, 0x03, 0x8C, 0x00, 0x63,
  0x00, 0x39, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x33, 0x80,
  0x0C, 0xE0, 0x06, 0x38, 0x01, 0x86, 0x00, 0x61, 0x80, 0x18, 0x60, 0x0E,
  0x0C, 0x0F, 0x83, 0xFF, 0xC0, 0x7F, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x0C, 0x3F, 0x0C, 0xFF, 0x1D, 0xE1, 0x1B, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0x81, 0xC3,
  0x80, 0x71, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x1B, 0x80,
  0x0D, 0xC0, 0x06, 0x60, 0x06, 0x38, 0x07, 0x0F, 0xFF, 0x01, 0xFE, 0x00,
  0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x1F, 0xFF, 0xFF,
  0xFF, 0x83, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x30,
  0x01, 0x98, 0x01, 0xCC, 0x00, 0xCE, 0x00, 0x66, 0x00, 0x33, 0x00, 0x19,
  0x80, 0x0C, 0xC0, 0x0C, 0x60, 0x06, 0x70, 0x03, 0x30, 0x01, 0x98, 0x00,
  0xCC, 0x00, 0xE6, 0x00, 0x63, 0x00, 0x31, 0x80, 0x38, 0xC0, 0x1C, 0x70,
  0x36, 0x1F, 0xF3, 0x07, 0xF3, 0x00, 0xC0, 0x00, 0xD8, 0x00, 0x66, 0x00,
  0x19, 0x80, 0x0C, 0x60, 0x07, 0x0C, 0x01, 0x83, 0x00, 0xE0, 0xC0, 0x30,
  0x30, 0x18, 0x06, 0x06, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x18, 0x60, 0x03,
  0x18, 0x00, 0xCC, 0x00, 0x37, 0x00, 0x0D, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0xC0, 0x40, 0x78, 0x18, 0x0F, 0x03, 0x03, 0x60, 0xE0,
  0x6C, 0x1C, 0x0D, 0x82, 0x83, 0x30, 0xD8, 0x66, 0x13, 0x08, 0xC6, 0x63,
  0x18, 0xCC, 0x63, 0x31, 0x88, 0x66, 0x33, 0x0C, 0x86, 0x61, 0xB0, 0xD8,
  0x34, 0x1B, 0x07, 0x81, 0x40, 0xF0, 0x38, 0x1C, 0x07, 0x03, 0x80, 0xC0,
  0x60, 0x18, 0x00, 0x18, 0x00, 0x70, 0xC0, 0x0E, 0x0E, 0x01, 0xC0, 0x60,
  0x38, 0x07, 0x07, 0x00, 0x30, 0x60, 0x01, 0x8C, 0x00, 0x19, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0x03, 0xB0, 0x00,
  0x71, 0x80, 0x06, 0x1C, 0x00, 0xC0, 0xC0, 0x18, 0x0E, 0x03, 0x00, 0x60,
  0x70, 0x03, 0x0E, 0x00, 0x38, 0x0C, 0x00, 0x0E, 0x18, 0x00, 0x18, 0x38,
  0x00, 0x60, 0x30, 0x01, 0xC0, 0x60, 0x03, 0x00, 0xE0, 0x0E, 0x00, 0xC0,
  0x18, 0x01, 0x80, 0x60, 0x03, 0x01, 0xC0, 0x07, 0x03, 0x00, 0x06, 0x0E,
  0x00, 0x0C, 0x18, 0x00, 0x18, 0x60, 0x00, 0x38, 0xC0, 0x00, 0x33, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xFE, 0x7F,
  0xFF, 0xC0, 0x00, 0x0C, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x03, 0xC0, 0x0E, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x06, 0x0C, 0x18, 0x30, 0x41, 0x83, 0x06,
  0x0C, 0x18, 0x20, 0xC1, 0x83, 0x06, 0x0C, 0x10, 0x20, 0xC1, 0x83, 0x06,
  0x0C, 0x10, 0x60, 0xC1, 0x83, 0x06, 0x08, 0x30, 0x60, 0x02, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x70, 0x03, 0xC0, 0x0E,
  0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x37, 0xFC, 0x03, 0x60, 0xE0,
  0x6C, 0x07, 0x06, 0xC0, 0x3F, 0xC8, 0x01, 0xF8,
};

const GFXglyph RobotoMono_LightItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 7, 26, 22, 7, -26 },
  { 24, 9, 8, 22, 8, -28 },
  { 33, 22, 26, 22, 0, -26 },
  { 105, 18, 34, 22, 2, -30 },
  { 182, 18, 27, 22, 2, -27 },
  { 243, 19, 27, 22, 1, -27 },
  { 308, 4, 8, 22, 10, -28 },
  { 312, 12, 38, 22, 6, -30 },
  { 369, 12, 38, 22, 3, -30 },
  { 426, 16, 16, 22, 5, -26 },
  { 458, 18, 19, 22, 2, -22 },
  { 501, 5, 8, 22, 4, -3 },
  { 506, 13, 2, 22, 4, -13 },
  { 510, 4, 3, 22, 8, -3 },
  { 512, 17, 28, 22, 3, -26 },
  { 572, 17, 27, 22, 3, -27 },
  { 630, 11, 26, 22, 5, -26 },
  { 666, 18, 27, 22, 1, -27 },
  { 727, 18, 27, 22, 1, -27 },
  { 788, 18, 26, 22, 1, -26 },
  { 847, 18, 26, 22, 3, -26 },
  { 906, 16, 27, 22, 2, -27 },
  { 960, 17, 26, 22, 4, -26 },
  { 1016, 18, 27, 22, 2, -27 },
  { 1077, 16, 27, 22, 4, -27 },
  { 1131, 6, 19, 22, 9, -19 },
  { 1146, 8, 24, 22, 7, -19 },
  { 1170, 16, 16, 22, 3, -20 },
  { 1202, 18, 10, 22, 2, -17 },
  { 1225, 17, 16, 22, 2, -20 },
  { 1259, 14, 27, 22, 6, -27 },
  { 1307, 21, 26, 22, 1, -26 },
  { 1376, 18, 26, 22, 0, -26 },
  { 1435, 18, 26, 22, 2, -26 },
  { 1494, 19, 27, 22, 2, -27 },
  { 1559, 20, 26, 22, 1, -26 },
  { 1624, 19, 26, 22, 2, -26 },
  { 1686, 19, 26, 22, 2, -26 },
  { 1748, 19, 27, 22, 2, -27 },
  { 1813, 20, 26, 22, 1, -26 },
  { 1878, 20, 26, 22, 1, -26 },
  { 1943, 20, 26, 22, 1, -26 },
  { 2008, 21, 26, 22, 2, -26 },
  { 2077, 15, 26, 22, 2, -26 },
  { 2126, 21, 26, 22, 1, -26 },
  { 2195, 20, 26, 22, 1, -26 },
  { 2260, 18, 27, 22, 2, -27 },
  { 2321, 19, 26, 22, 2, -26 },
  { 2383, 19, 32, 22, 2, -27 },
  { 2459, 19, 26, 22, 2, -26 },
  { 2521, 19, 27, 22, 2, -27 },
  { 2586, 19, 26, 22, 4, -26 },
  { 2648, 19, 26, 22, 2, -26 },
  { 2710, 18, 26, 22, 4, -26 },
  { 2769, 20, 26, 22, 3, -26 },
  { 2834, 22, 26, 22, 0, -26 },
  { 2906, 18, 26, 22, 4, -26 },
  { 2965, 20, 26, 22, 1, -26 },
  { 3030, 12, 36, 22, 5, -30 },
  { 3084, 8, 28, 22, 7, -26 },
  { 3112, 12, 36, 22, 5, -30 },
  { 3166, 13, 14, 22, 4, -26 },
  { 3189, 16, 2, 22, 1, 0 },
  { 3193, 4, 5, 22, 11, -27 },
  { 3196, 17, 20, 22, 2, -20 },
  { 3239, 17, 28, 22, 2, -28 },
  { 3299, 17, 20, 22, 2, -20 },
  { 3342, 19, 28, 22, 2, -28 },
  { 3409, 17, 20, 22, 2, -20 },
  { 3452, 19, 28, 22, 4, -28 },
  { 3519, 19, 28, 22, 1, -20 },
  { 3586, 17, 28, 22, 2, -28 },
  { 3646, 16, 27, 22, 2, -27 },
  { 3700, 17, 35, 22, 0, -27 },
  { 3775, 18, 28, 22, 2, -28 },
  { 3838, 16, 28, 22, 2, -28 },
  { 3894, 21, 20, 22, 0, -20 },
  { 3947, 18, 20, 22, 1, -20 },
  { 3992, 17, 20, 22, 2, -20 },
  { 4035, 19, 28, 22, 0, -20 },
  { 4102, 18, 28, 22, 2, -20 },
  { 4165, 16, 20, 22, 4, -20 },
  { 4205, 17, 20, 22, 2, -20 },
  { 4248, 15, 25, 22, 4, -25 },
  { 4295, 17, 20, 22, 3, -20 },
  { 4338, 18, 20, 22, 3, -20 },
  { 4383, 19, 20, 22, 3, -20 },
  { 4431, 20, 20, 22, 1, -20 },
  { 4481, 23, 28, 22, -1, -20 },
  { 4562, 19, 20, 22, 1, -20 },
  { 4610, 14, 36, 22, 6, -29 },
  { 4673, 7, 32, 22, 7, -26 },
  { 4701, 15, 36, 22, 3, -29 },
  { 4769, 20, 6, 22, 1, -14 },
};

const GFXfont RobotoMono_LightItalic37pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic37pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic37pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _ROBOTOMONO_LIGHTITALIC37PT7B_H_
