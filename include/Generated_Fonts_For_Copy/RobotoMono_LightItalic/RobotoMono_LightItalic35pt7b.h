#ifndef _ROBOTOMONO_LIGHTITALIC35PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x30, 0xC3, 0x0C, 0x61, 0x86, 0x18, 0x61, 0x8C, 0x30, 0xC3,
  0x0C, 0x31, 0x80, 0x00, 0x00, 0x04, 0x38, 0xE0, 0x63, 0x63, 0x63, 0x42,
  0xC6, 0xC6, 0xC6, 0x00, 0x18, 0x30, 0x00, 0x83, 0x00, 0x0C, 0x18, 0x00,
  0x60, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x02, 0x01, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF8, 0x04, 0x08, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x10,
  0x60, 0x01, 0x83, 0x00, 0x0C, 0x10, 0x00, 0x41, 0x80, 0x7F, 0xFF, 0xC7,
  0xFF, 0xFE, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0x81, 0x00, 0x0C, 0x18,
  0x00, 0x60, 0xC0, 0x02, 0x04, 0x00, 0x30, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x1C, 0x1C,
  0x18, 0x06, 0x0C, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x33, 0x00, 0x19, 0x80, 0x0C,
  0x60, 0x06, 0x30, 0x06, 0x1C, 0x07, 0x07, 0xDF, 0x01, 0xFE, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x00, 0x1E, 0x00, 0x19, 0x80,
  0x18, 0x60, 0x08, 0x30, 0x6C, 0x18, 0x66, 0x0C, 0x23, 0x06, 0x31, 0x82,
  0x30, 0xC3, 0x10, 0x3F, 0x18, 0x0F, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x78, 0x04, 0x7E, 0x06, 0x61, 0x86, 0x20, 0xC2, 0x30,
  0x63, 0x18, 0x33, 0x0C, 0x1B, 0x06, 0x08, 0x03, 0x0C, 0x00, 0xCC, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x30, 0x60, 0x1C, 0x18, 0x06,
  0x06, 0x01, 0x81, 0x80, 0x60, 0xC0, 0x18, 0x70, 0x06, 0x38, 0x01, 0xDC,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0x30, 0x01, 0x8E, 0x0C,
  0xC1, 0x83, 0x70, 0x31, 0x98, 0x0C, 0x66, 0x01, 0xB9, 0x80, 0x7C, 0x60,
  0x0E, 0x18, 0x03, 0x87, 0x03, 0xF0, 0xF3, 0xCC, 0x1F, 0xC3, 0x80, 0x6D,
  0xAD, 0xB0, 0x00, 0x20, 0x1C, 0x07, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x03,
  0x00, 0x70, 0x04, 0x00, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01,
  0x80, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xC0,
  0x38, 0x0E, 0x03, 0x80, 0x40, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x80, 0x01, 0x80, 0x61, 0x86, 0xFD, 0xBF, 0x1F, 0xF8, 0x03, 0x80,
  0x06, 0x80, 0x0E, 0xC0, 0x0C, 0x60, 0x18, 0x60, 0x70, 0x30, 0x20, 0x30,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x39, 0x8C, 0x63, 0x33, 0x98, 0xFF, 0xFF,
  0xFF, 0x7F, 0x70, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xFC, 0x01, 0xFF, 0x01, 0x81, 0xC1, 0x80, 0x61, 0x80, 0x10,
  0xC0, 0x0C, 0xC0, 0x06, 0x60, 0x07, 0x30, 0x07, 0x98, 0x0E, 0xD8, 0x0E,
  0x6C, 0x0C, 0x66, 0x0C, 0x33, 0x1C, 0x19, 0x9C, 0x0C, 0xD8, 0x06, 0xD8,
  0x03, 0x78, 0x03, 0x38, 0x01, 0x8C, 0x01, 0xC6, 0x00, 0xC3, 0x00, 0xC0,
  0xC0, 0xE0, 0x79, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0xC0, 0xF1, 0xF9, 0xF6,
  0xE1, 0xA0, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0x81, 0xC3, 0x80, 0x61,
  0x80, 0x31, 0x80, 0x18, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x03,
  0xFF, 0x03, 0x81, 0xC1, 0x80, 0x61, 0x80, 0x18, 0xC0, 0x0C, 0xC0, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x7F, 0x00, 0x3F,
  0x00, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x30,
  0x01, 0x98, 0x00, 0xCC, 0x00, 0xE7, 0x00, 0x61, 0xC0, 0xE0, 0x79, 0xE0,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x03, 0x60,
  0x03, 0xB0, 0x01, 0xB0, 0x01, 0x98, 0x01, 0x8C, 0x01, 0x86, 0x01, 0xC3,
  0x00, 0xC1, 0x00, 0xC1, 0x80, 0xC0, 0xC0, 0xC0, 0x60, 0xE0, 0x30, 0x60,
  0x18, 0x60, 0x18, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x07, 0xFF, 0x83,
  0xFF, 0xC3, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x19, 0xF0, 0x0F, 0xFE, 0x07, 0x07, 0x81, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x30,
  0x03, 0x18, 0x01, 0x8C, 0x01, 0xC6, 0x00, 0xC1, 0x80, 0xC0, 0x7B, 0xC0,
  0x1F, 0xC0, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x07, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x67, 0xE1, 0xBD, 0xE3,
  0xC0, 0x67, 0x00, 0xEC, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x66, 0x00, 0xCC, 0x03, 0x0C, 0x0E, 0x1E, 0x78,
  0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x81, 0xC0, 0xC1, 0x80,
  0x30, 0xC0, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x18, 0x03, 0x0E,
  0x01, 0x83, 0x03, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0xF0, 0xE0, 0xE0, 0x38,
  0xE0, 0x0C, 0x60, 0x03, 0x70, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0xCC, 0x00,
  0x63, 0x00, 0x71, 0xC0, 0x70, 0x7D, 0xF0, 0x1F, 0xE0, 0x00, 0x03, 0xF0,
  0x1F, 0xF0, 0x70, 0x31, 0xC0, 0x33, 0x00, 0x6C, 0x00, 0xD8, 0x01, 0xB0,
  0x03, 0x60, 0x07, 0x80, 0x0F, 0x80, 0x1B, 0x00, 0x36, 0x00, 0xEE, 0x03,
  0xCE, 0x1D, 0x0F, 0xF6, 0x0F, 0x8C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0xF0, 0x3F, 0x80, 0x7C, 0x00, 0x1C, 0x71, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0xF1, 0x80, 0x07,
  0x07, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x18, 0x18, 0x30, 0x30, 0x70, 0x60, 0xC0, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x02, 0x00, 0x3F, 0xFF, 0x9F, 0xFF, 0x90, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0x20,
  0x00, 0x38, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x7C,
  0x00, 0xF0, 0x00, 0x80, 0x00, 0x0F, 0xE0, 0x7F, 0xC3, 0x83, 0x98, 0x06,
  0x60, 0x1B, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x0E, 0x03, 0x03, 0x00, 0x20, 0xC0,
  0x06, 0x30, 0x70, 0xC4, 0x3F, 0x89, 0x8C, 0x21, 0x21, 0x04, 0x2C, 0x60,
  0x85, 0x88, 0x30, 0xA3, 0x04, 0x1C, 0x60, 0x87, 0x88, 0x10, 0xB1, 0x06,
  0x14, 0x20, 0x82, 0x84, 0x30, 0x90, 0x8E, 0x33, 0x1F, 0x7C, 0x61, 0xC7,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x04, 0x00, 0xF7, 0x80, 0x0F, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x06, 0x80, 0x03, 0x40,
  0x03, 0x30, 0x01, 0x98, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0xC3, 0x00, 0x61,
  0x80, 0x60, 0x40, 0x30, 0x30, 0x38, 0x18, 0x18, 0x0C, 0x1C, 0x06, 0x0F,
  0xFF, 0x07, 0xFF, 0x86, 0x00, 0xC3, 0x00, 0x33, 0x00, 0x19, 0x80, 0x0D,
  0x80, 0x06, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x07, 0xF8, 0x01, 0xFF, 0xC0,
  0xC0, 0x38, 0x30, 0x06, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x60,
  0x03, 0x18, 0x01, 0x86, 0x00, 0xE1, 0x80, 0x70, 0x7F, 0xF0, 0x1F, 0xFC,
  0x0C, 0x03, 0x83, 0x00, 0x30, 0xC0, 0x0E, 0x30, 0x01, 0x8C, 0x00, 0x63,
  0x00, 0x19, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x01, 0x86, 0x01, 0xE1, 0xFF,
  0xE0, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x01, 0x81, 0xC1, 0x80,
  0x71, 0x80, 0x19, 0xC0, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x01, 0xB0, 0x01, 0x98, 0x00, 0xC6, 0x00,
  0xC3, 0x00, 0xE1, 0xC0, 0xE0, 0x79, 0xE0, 0x1F, 0xC0, 0x00, 0x0F, 0xF8,
  0x03, 0xFF, 0x80, 0xC0, 0x70, 0x30, 0x0E, 0x0C, 0x01, 0x83, 0x00, 0x31,
  0x80, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0x60,
  0x03, 0x30, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x06, 0x30, 0x01,
  0x98, 0x00, 0x66, 0x00, 0x31, 0x80, 0x1C, 0x60, 0x0E, 0x18, 0x07, 0x06,
  0x03, 0x83, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF1,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xF8, 0x3F, 0xFC,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0xFF,
  0xF0, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xFE, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x60, 0x70, 0x30, 0x0E, 0x18, 0x01,
  0x8E, 0x00, 0x63, 0x00, 0x19, 0xC0, 0x01, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x1F, 0xCC, 0x07, 0xF3, 0x00,
  0x0C, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x18, 0x60, 0x06,
  0x18, 0x01, 0x83, 0x00, 0xE0, 0xFB, 0xE0, 0x0F, 0xF0, 0x00, 0x0C, 0x00,
  0x61, 0x80, 0x0C, 0x30, 0x01, 0x84, 0x00, 0x31, 0x80, 0x06, 0x30, 0x01,
  0x86, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0xC2, 0x00, 0x18, 0xC0, 0x02,
  0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x60, 0x03, 0x0C, 0x00, 0x61, 0x00, 0x0C,
  0x60, 0x01, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x31,
  0x80, 0x06, 0x30, 0x00, 0x86, 0x00, 0x30, 0xC0, 0x06, 0x00, 0x07, 0xFF,
  0xE1, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x03, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xE3, 0x00, 0x18, 0x60, 0x03, 0x0E, 0x00, 0xE0,
  0xC0, 0x38, 0x1C, 0x0E, 0x01, 0xF7, 0x80, 0x1F, 0xC0, 0x00, 0x0C, 0x00,
  0xF0, 0xC0, 0x1C, 0x18, 0x03, 0x81, 0x80, 0x70, 0x18, 0x0E, 0x01, 0x81,
  0xC0, 0x18, 0x38, 0x01, 0x87, 0x00, 0x30, 0xE0, 0x03, 0x1C, 0x00, 0x33,
  0x80, 0x03, 0x78, 0x00, 0x3F, 0x80, 0x03, 0xDC, 0x00, 0x78, 0xC0, 0x07,
  0x0E, 0x00, 0x60, 0x60, 0x06, 0x07, 0x00, 0x60, 0x30, 0x06, 0x01, 0x80,
  0xC0, 0x18, 0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x0C, 0x00, 0x60, 0xC0, 0x07,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x80, 0x0C, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x70,
  0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x1E, 0x0B, 0x03, 0xE1, 0xB0, 0x36,
  0x1B, 0x06, 0x41, 0xB0, 0x6C, 0x19, 0x0C, 0xC1, 0x90, 0xCC, 0x11, 0x98,
  0xC3, 0x19, 0x8C, 0x31, 0xB1, 0x83, 0x1B, 0x18, 0x30, 0xE1, 0x83, 0x0E,
  0x18, 0x60, 0xC1, 0x86, 0x08, 0x18, 0x60, 0x03, 0x06, 0x00, 0x30, 0x60,
  0x03, 0x06, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x20, 0xC0, 0x06, 0x00,
  0x0C, 0x00, 0x61, 0xC0, 0x0C, 0x38, 0x01, 0x87, 0x00, 0x31, 0xB0, 0x0E,
  0x36, 0x01, 0x86, 0xC0, 0x30, 0xCC, 0x06, 0x19, 0x80, 0xC3, 0x30, 0x18,
  0xC3, 0x06, 0x18, 0x60, 0xC3, 0x06, 0x18, 0x60, 0xC3, 0x0C, 0x18, 0x61,
  0x81, 0x8C, 0x60, 0x33, 0x0C, 0x06, 0x61, 0x80, 0x6C, 0x30, 0x0D, 0x86,
  0x01, 0xB0, 0xC0, 0x1E, 0x30, 0x03, 0x86, 0x00, 0x70, 0xC0, 0x06, 0x00,
  0x01, 0xF8, 0x01, 0xFF, 0x01, 0x81, 0xC1, 0x80, 0x61, 0x80, 0x19, 0xC0,
  0x0C, 0xC0, 0x06, 0x60, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x6C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03,
  0x60, 0x01, 0xB0, 0x01, 0x98, 0x00, 0xC6, 0x00, 0xC3, 0x00, 0xE1, 0xC0,
  0xE0, 0x7F, 0xE0, 0x1F, 0xC0, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xC0,
  0x38, 0x30, 0x06, 0x18, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03,
  0x18, 0x00, 0xC4, 0x00, 0x73, 0x00, 0x18, 0xC0, 0x0C, 0x30, 0x0E, 0x0F,
  0xFF, 0x03, 0xFE, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0xE0, 0x70, 0x30, 0x0C,
  0x18, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x19, 0x80, 0x06, 0x60, 0x00, 0xD8,
  0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00,
  0x1B, 0x00, 0x0E, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x63, 0x00, 0x18,
  0xC0, 0x0C, 0x18, 0x07, 0x07, 0x03, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x0F, 0xF8, 0x07,
  0xFF, 0x06, 0x01, 0xC3, 0x00, 0x71, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06,
  0x30, 0x03, 0x30, 0x01, 0x98, 0x01, 0xCC, 0x00, 0xC6, 0x00, 0xC3, 0x01,
  0xC1, 0xFF, 0xC1, 0xFF, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x18,
  0x06, 0x0C, 0x03, 0x0C, 0x01, 0xC6, 0x00, 0x63, 0x00, 0x31, 0x80, 0x1C,
  0xC0, 0x06, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0xE0, 0x30, 0x70, 0x06,
  0x18, 0x01, 0x8E, 0x00, 0x73, 0x00, 0x1C, 0xC0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C,
  0xC0, 0x06, 0x38, 0x03, 0x87, 0x01, 0xC0, 0xFB, 0xE0, 0x1F, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0xC6, 0x00, 0x31, 0x80,
  0x0C, 0x60, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x06,
  0x30, 0x01, 0x88, 0x00, 0x66, 0x00, 0x19, 0x80, 0x0C, 0x60, 0x03, 0x18,
  0x00, 0xC6, 0x00, 0x31, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x01, 0x8C, 0x00,
  0x63, 0x00, 0x18, 0xE0, 0x0C, 0x18, 0x07, 0x07, 0x03, 0x80, 0xF7, 0xC0,
  0x1F, 0xC0, 0x00, 0xC0, 0x01, 0xE0, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0xEC,
  0x00, 0x63, 0x00, 0x71, 0x80, 0x30, 0xC0, 0x18, 0x60, 0x18, 0x30, 0x0C,
  0x18, 0x0C, 0x06, 0x06, 0x03, 0x06, 0x01, 0x83, 0x00, 0xC3, 0x00, 0x61,
  0x80, 0x31, 0x80, 0x18, 0xC0, 0x06, 0xE0, 0x03, 0x60, 0x01, 0xB0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x6C,
  0x1C, 0x09, 0x83, 0x83, 0x30, 0x70, 0x64, 0x1E, 0x0C, 0x83, 0xC3, 0x10,
  0x58, 0x62, 0x1B, 0x0C, 0x43, 0x61, 0x08, 0x4C, 0x63, 0x19, 0x8C, 0x63,
  0x31, 0x8C, 0x46, 0x61, 0x98, 0xCC, 0x33, 0x19, 0x86, 0x43, 0x20, 0xD8,
  0x6C, 0x1B, 0x0D, 0x83, 0x41, 0xA0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xC0,
  0xF0, 0x38, 0x0C, 0x07, 0x01, 0x80, 0xC0, 0x30, 0x00, 0x0E, 0x00, 0x38,
  0x30, 0x01, 0x81, 0xC0, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x00, 0xC0,
  0xC0, 0x06, 0x0C, 0x00, 0x18, 0xE0, 0x00, 0xC6, 0x00, 0x07, 0x60, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x60,
  0x00, 0x3B, 0x00, 0x01, 0x8C, 0x00, 0x18, 0x60, 0x01, 0x81, 0x80, 0x1C,
  0x0C, 0x00, 0xC0, 0x70, 0x0C, 0x01, 0x80, 0xC0, 0x0C, 0x0E, 0x00, 0x30,
  0xE0, 0x01, 0xC0, 0xC0, 0x01, 0xE0, 0x01, 0x98, 0x01, 0xCC, 0x00, 0xC6,
  0x00, 0xC1, 0x80, 0xE0, 0xC0, 0x60, 0x60, 0x60, 0x18, 0x70, 0x0C, 0x30,
  0x06, 0x30, 0x01, 0x38, 0x00, 0xD8, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0xC0, 0x18, 0x03, 0x00,
  0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30,
  0x06, 0x00, 0xFC, 0x00, 0xC1, 0x83, 0x06, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0x60, 0xC1, 0x83, 0x06, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x60, 0xC1, 0x83,
  0x06, 0x06, 0x0C, 0x18, 0x07, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0xFC, 0x00, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x06, 0x40, 0x66, 0x0C,
  0x60, 0xC6, 0x18, 0x61, 0x83, 0x30, 0x36, 0x03, 0x60, 0x3C, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0xC3, 0x18, 0x61, 0x80, 0x01, 0xF0, 0x07, 0xFC, 0x1E,
  0x0E, 0x18, 0x06, 0x30, 0x06, 0x30, 0x03, 0x00, 0x06, 0x00, 0x06, 0x03,
  0xFE, 0x1F, 0xFE, 0x38, 0x06, 0x60, 0x06, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0,
  0x0C, 0xC0, 0x1C, 0xE0, 0x7C, 0x7B, 0xEC, 0x3F, 0x8C, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0xF0, 0x13, 0xFC, 0x36, 0x0C, 0x3C, 0x06, 0x38, 0x06, 0x30, 0x03, 0x30,
  0x03, 0x30, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x06, 0x60, 0x06, 0x60,
  0x06, 0xC0, 0x0E, 0xC0, 0x0C, 0xE0, 0x1C, 0xF0, 0x38, 0xDF, 0xF0, 0xCF,
  0xE0, 0x01, 0xF0, 0x07, 0xFC, 0x0E, 0x0E, 0x1C, 0x06, 0x38, 0x03, 0x30,
  0x03, 0x60, 0x03, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x06, 0x60, 0x0C, 0x60, 0x0C, 0x30, 0x38, 0x3C,
  0xF0, 0x0F, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x07, 0x8E, 0x07, 0xFB, 0x03,
  0x87, 0xC1, 0x80, 0x70, 0xE0, 0x1C, 0x30, 0x03, 0x18, 0x01, 0x86, 0x00,
  0x61, 0x80, 0x18, 0xE0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x30,
  0xC0, 0x0C, 0x18, 0x03, 0x06, 0x01, 0xC1, 0xC0, 0xF0, 0x3D, 0xEC, 0x07,
  0xE6, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0E, 0x0E, 0x1C, 0x06, 0x38, 0x03,
  0x30, 0x03, 0x60, 0x03, 0x60, 0x03, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x04, 0x30, 0x1C,
  0x3E, 0x78, 0x0F, 0xE0, 0x00, 0x0F, 0x00, 0x3F, 0xC0, 0x38, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x7F,
  0xFE, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xF0, 0x40, 0xFF, 0x60, 0x70, 0xF8, 0x30, 0x0E, 0x1C,
  0x03, 0x86, 0x00, 0x63, 0x00, 0x38, 0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x00,
  0xC6, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x06, 0x18, 0x01, 0x83, 0x00, 0x60,
  0xC0, 0x38, 0x38, 0x1E, 0x07, 0xBD, 0x80, 0xFE, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x07, 0x04, 0x01, 0x83, 0x80, 0xC0, 0x79, 0xE0, 0x07, 0xF0,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0xF8, 0x19, 0xFE, 0x0D, 0xC3, 0x87, 0x80,
  0xC3, 0x80, 0x31, 0x80, 0x18, 0xC0, 0x0C, 0xC0, 0x06, 0x60, 0x06, 0x30,
  0x03, 0x18, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x66, 0x00, 0x33, 0x00, 0x31,
  0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x70, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0, 0x87, 0x80, 0xFF, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x01, 0x18, 0x07, 0x0C, 0x07, 0x06, 0x07, 0x06,
  0x0E, 0x03, 0x0E, 0x01, 0x8E, 0x00, 0xCE, 0x00, 0x6E, 0x00, 0x7F, 0x00,
  0x3C, 0xC0, 0x1C, 0x70, 0x0C, 0x18, 0x06, 0x06, 0x03, 0x03, 0x83, 0x00,
  0xC1, 0x80, 0x70, 0xC0, 0x1C, 0x60, 0x07, 0x00, 0x0F, 0xF8, 0x1F, 0xF0,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x19, 0xC3, 0x81,
  0xFE, 0x7E, 0x1C, 0x7C, 0x63, 0x83, 0x83, 0x30, 0x30, 0x33, 0x03, 0x02,
  0x30, 0x30, 0x63, 0x06, 0x06, 0x20, 0x60, 0x66, 0x06, 0x06, 0x60, 0x60,
  0x66, 0x06, 0x04, 0x60, 0x40, 0xC6, 0x0C, 0x0C, 0xC0, 0xC0, 0xCC, 0x0C,
  0x0C, 0xC0, 0xC0, 0xCC, 0x0C, 0x08, 0xC1, 0x81, 0x80, 0x08, 0x78, 0x0C,
  0xFF, 0x06, 0xE1, 0xC3, 0xC0, 0x61, 0xC0, 0x18, 0xC0, 0x0C, 0x60, 0x06,
  0x60, 0x03, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x63, 0x00,
  0x33, 0x00, 0x19, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x38,
  0x01, 0x80, 0x01, 0xE0, 0x07, 0xF8, 0x0E, 0x0C, 0x18, 0x06, 0x30, 0x07,
  0x70, 0x03, 0x60, 0x03, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0C, 0x60, 0x1C, 0x70, 0x38,
  0x3C, 0xF0, 0x1F, 0xC0, 0x06, 0x3C, 0x01, 0x3F, 0xC0, 0xD8, 0x70, 0x38,
  0x06, 0x0E, 0x01, 0x83, 0x00, 0x70, 0xC0, 0x0C, 0x60, 0x03, 0x18, 0x00,
  0xC6, 0x00, 0x31, 0x80, 0x18, 0x60, 0x06, 0x18, 0x01, 0x8C, 0x00, 0xE3,
  0x00, 0x30, 0xE0, 0x1C, 0x3C, 0x0E, 0x0D, 0xDF, 0x03, 0x3F, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x00, 0x01, 0xE0, 0x83, 0xFD, 0x83, 0x83, 0xC3, 0x00, 0xE3,
  0x80, 0x71, 0x80, 0x19, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x03,
  0x30, 0x01, 0x98, 0x00, 0xCC, 0x00, 0xC6, 0x00, 0x61, 0x80, 0x30, 0xC0,
  0x38, 0x70, 0x3C, 0x1E, 0x76, 0x07, 0xF6, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x00,
  0x3E, 0x33, 0xFC, 0x6F, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x00, 0x01,
  0xF0, 0x07, 0xFC, 0x0E, 0x0E, 0x18, 0x07, 0x38, 0x03, 0x30, 0x03, 0x30,
  0x00, 0x18, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x06, 0xC0, 0x06, 0x60, 0x0E, 0x70, 0x1C, 0x3E, 0xF8, 0x1F,
  0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x03, 0xFF, 0xF0,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x1C, 0x00, 0x3D, 0x80, 0x7F, 0x00, 0x30, 0x07, 0x60, 0x06, 0x60, 0x06,
  0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C,
  0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x38,
  0xE0, 0x78, 0x7B, 0xD8, 0x3F, 0x18, 0xC0, 0x00, 0xE0, 0x01, 0x98, 0x00,
  0xCC, 0x00, 0xC6, 0x00, 0xE3, 0x00, 0x60, 0xC0, 0x60, 0x60, 0x30, 0x30,
  0x30, 0x18, 0x18, 0x06, 0x18, 0x03, 0x0C, 0x01, 0x8C, 0x00, 0xC6, 0x00,
  0x26, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x40, 0x68, 0x1C, 0x19, 0x03, 0x83, 0x20, 0xF0, 0x44, 0x1E, 0x18, 0x86,
  0xC3, 0x10, 0xD8, 0x43, 0x13, 0x18, 0x66, 0x63, 0x0C, 0x84, 0xC1, 0xB0,
  0x98, 0x36, 0x12, 0x06, 0x82, 0xC0, 0xF0, 0x58, 0x1C, 0x0A, 0x03, 0x81,
  0xC0, 0x70, 0x30, 0x0C, 0x06, 0x00, 0x0C, 0x00, 0x10, 0xE0, 0x0E, 0x06,
  0x01, 0xC0, 0x30, 0x38, 0x03, 0x03, 0x00, 0x18, 0x60, 0x01, 0xCC, 0x00,
  0x0D, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0x98, 0x00, 0x71, 0xC0, 0x06, 0x0C, 0x00, 0xC0, 0x60, 0x18, 0x06,
  0x03, 0x00, 0x30, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x04, 0x30, 0x00, 0x60,
  0xC0, 0x03, 0x01, 0x80, 0x1C, 0x06, 0x00, 0x60, 0x18, 0x03, 0x80, 0x60,
  0x0C, 0x00, 0xC0, 0x60, 0x03, 0x03, 0x80, 0x0C, 0x0C, 0x00, 0x38, 0x70,
  0x00, 0x61, 0x80, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x0D, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0xC0, 0x00,
  0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00,
  0xE0, 0x07, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x06, 0x00, 0x04,
  0x30, 0xC3, 0x0C, 0x20, 0x86, 0x18, 0x61, 0x86, 0x10, 0x43, 0x0C, 0x30,
  0xC2, 0x08, 0x61, 0x86, 0x18, 0x61, 0x04, 0x30, 0xC3, 0x0C, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x3C, 0x01, 0xE0, 0x0C, 0x00, 0x60, 0x03, 0x80,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x03, 0x00, 0x00, 0x3F,
  0x00, 0x6E, 0x70, 0x0B, 0x83, 0x03, 0x60, 0x38, 0xC8, 0x03, 0xF8, 0x00,
  0x1C, 0x00,
};

const GFXglyph RobotoMono_LightItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 6, 25, 21, 7, -25 },
  { 20, 8, 7, 21, 8, -26 },
  { 27, 21, 25, 21, 0, -25 },
  { 93, 17, 33, 21, 2, -29 },
  { 164, 17, 25, 21, 2, -25 },
  { 218, 18, 25, 21, 1, -25 },
  { 275, 3, 7, 21, 10, -26 },
  { 278, 11, 36, 21, 6, -28 },
  { 328, 11, 36, 21, 3, -28 },
  { 378, 16, 15, 21, 4, -25 },
  { 408, 17, 19, 21, 2, -21 },
  { 449, 5, 8, 21, 4, -3 },
  { 454, 12, 2, 21, 4, -12 },
  { 457, 4, 3, 21, 7, -3 },
  { 459, 17, 27, 21, 2, -25 },
  { 517, 17, 25, 21, 2, -25 },
  { 571, 10, 25, 21, 5, -25 },
  { 603, 17, 25, 21, 1, -25 },
  { 657, 17, 25, 21, 1, -25 },
  { 711, 17, 25, 21, 1, -25 },
  { 765, 17, 25, 21, 3, -25 },
  { 819, 15, 25, 21, 2, -25 },
  { 866, 16, 25, 21, 4, -25 },
  { 916, 17, 25, 21, 2, -25 },
  { 970, 15, 25, 21, 3, -25 },
  { 1017, 6, 18, 21, 8, -18 },
  { 1031, 8, 23, 21, 6, -18 },
  { 1054, 15, 15, 21, 3, -19 },
  { 1083, 17, 9, 21, 2, -16 },
  { 1103, 16, 15, 21, 2, -19 },
  { 1133, 14, 25, 21, 5, -25 },
  { 1177, 19, 25, 21, 1, -25 },
  { 1237, 17, 25, 21, 0, -25 },
  { 1291, 18, 25, 21, 1, -25 },
  { 1348, 17, 25, 21, 2, -25 },
  { 1402, 18, 25, 21, 1, -25 },
  { 1459, 18, 25, 21, 2, -25 },
  { 1516, 18, 25, 21, 2, -25 },
  { 1573, 18, 25, 21, 2, -25 },
  { 1630, 19, 25, 21, 1, -25 },
  { 1690, 19, 25, 21, 1, -25 },
  { 1750, 19, 25, 21, 1, -25 },
  { 1810, 20, 25, 21, 2, -25 },
  { 1873, 14, 25, 21, 2, -25 },
  { 1917, 20, 25, 21, 1, -25 },
  { 1980, 19, 25, 21, 1, -25 },
  { 2040, 17, 25, 21, 2, -25 },
  { 2094, 18, 25, 21, 2, -25 },
  { 2151, 18, 29, 21, 2, -25 },
  { 2217, 17, 25, 21, 2, -25 },
  { 2271, 18, 25, 21, 2, -25 },
  { 2328, 17, 25, 21, 4, -25 },
  { 2382, 18, 25, 21, 2, -25 },
  { 2439, 17, 25, 21, 4, -25 },
  { 2493, 19, 25, 21, 3, -25 },
  { 2553, 21, 25, 21, 0, -25 },
  { 2619, 17, 25, 21, 4, -25 },
  { 2673, 18, 25, 21, 1, -25 },
  { 2730, 11, 33, 21, 5, -28 },
  { 2776, 7, 27, 21, 7, -25 },
  { 2800, 11, 33, 21, 5, -28 },
  { 2846, 12, 14, 21, 4, -25 },
  { 2867, 15, 2, 21, 1, 0 },
  { 2871, 5, 5, 21, 10, -26 },
  { 2875, 16, 19, 21, 2, -19 },
  { 2913, 16, 26, 21, 2, -26 },
  { 2965, 16, 19, 21, 2, -19 },
  { 3003, 18, 26, 21, 2, -26 },
  { 3062, 16, 19, 21, 2, -19 },
  { 3100, 17, 27, 21, 4, -27 },
  { 3158, 18, 26, 21, 1, -19 },
  { 3217, 17, 26, 21, 1, -26 },
  { 3273, 15, 25, 21, 2, -25 },
  { 3320, 16, 32, 21, 0, -25 },
  { 3384, 17, 26, 21, 2, -26 },
  { 3440, 15, 26, 21, 2, -26 },
  { 3489, 20, 19, 21, 0, -19 },
  { 3537, 17, 19, 21, 1, -19 },
  { 3578, 16, 19, 21, 2, -19 },
  { 3616, 18, 26, 21, 0, -19 },
  { 3675, 17, 26, 21, 2, -19 },
  { 3731, 15, 19, 21, 4, -19 },
  { 3767, 16, 19, 21, 2, -19 },
  { 3805, 14, 23, 21, 4, -23 },
  { 3846, 16, 18, 21, 3, -18 },
  { 3882, 17, 19, 21, 3, -19 },
  { 3923, 19, 18, 21, 2, -18 },
  { 3966, 20, 19, 21, 0, -19 },
  { 4014, 22, 26, 21, -1, -19 },
  { 4086, 18, 18, 21, 1, -18 },
  { 4127, 14, 34, 21, 5, -27 },
  { 4187, 6, 31, 21, 7, -25 },
  { 4211, 14, 34, 21, 3, -27 },
  { 4271, 19, 6, 21, 1, -13 },
};

const GFXfont RobotoMono_LightItalic35pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic35pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic35pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _ROBOTOMONO_LIGHTITALIC35PT7B_H_
