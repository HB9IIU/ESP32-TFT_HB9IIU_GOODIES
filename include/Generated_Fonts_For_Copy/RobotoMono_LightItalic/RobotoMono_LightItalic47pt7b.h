#ifndef _ROBOTOMONO_LIGHTITALIC47PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0x03,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0x80, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x01, 0xC1,
  0xE0, 0x70, 0x00, 0x70, 0xEC, 0x19, 0x83, 0x30, 0x66, 0x1D, 0xC3, 0x30,
  0x66, 0x0C, 0xC1, 0x98, 0x70, 0x00, 0x07, 0x01, 0x80, 0x00, 0xC0, 0x70,
  0x00, 0x18, 0x0C, 0x00, 0x07, 0x01, 0x80, 0x00, 0xC0, 0x70, 0x00, 0x18,
  0x0C, 0x00, 0x07, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x0C, 0x01,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x88, 0x18, 0x0C, 0x00, 0x06, 0x03,
  0x80, 0x00, 0xC0, 0x60, 0x00, 0x38, 0x0C, 0x00, 0x06, 0x03, 0x80, 0x00,
  0xC0, 0x60, 0x00, 0x38, 0x0C, 0x00, 0x06, 0x03, 0x80, 0x00, 0xC0, 0x60,
  0x00, 0x38, 0x0C, 0x01, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xF0, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x38, 0x1C, 0x00,
  0x06, 0x03, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x30, 0x1C, 0x00, 0x06, 0x03,
  0x00, 0x01, 0xC0, 0x60, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF8, 0x03, 0xC0, 0x78, 0x0F,
  0x00, 0x78, 0x1C, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x00, 0xC1, 0xC0,
  0x01, 0x83, 0x80, 0x03, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x06, 0x38,
  0x00, 0x0C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x70, 0xE0, 0x01, 0xE1, 0xC0,
  0x03, 0x83, 0xC0, 0x1E, 0x03, 0xC0, 0xF8, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0x00, 0x03, 0x8E, 0x00,
  0x1C, 0x18, 0x00, 0x60, 0x70, 0x11, 0x81, 0xC0, 0xEE, 0x07, 0x03, 0x30,
  0x1C, 0x18, 0xC0, 0x60, 0xE3, 0x01, 0x87, 0x0C, 0x06, 0x18, 0x38, 0x30,
  0xE0, 0x61, 0xC7, 0x01, 0xFE, 0x18, 0x03, 0xF0, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00,
  0xC3, 0xF8, 0x07, 0x1E, 0xE0, 0x38, 0xE0, 0xC0, 0xC3, 0x03, 0x06, 0x1C,
  0x0C, 0x38, 0x60, 0x30, 0xC1, 0x80, 0xC6, 0x06, 0x03, 0x38, 0x18, 0x0C,
  0xC0, 0x60, 0x70, 0x01, 0x81, 0x80, 0x07, 0x0E, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x10, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x0F, 0x07, 0x00, 0x1C, 0x06, 0x00, 0x70, 0x0E, 0x00, 0xE0,
  0x1C, 0x01, 0xC0, 0x30, 0x03, 0x00, 0xE0, 0x06, 0x01, 0xC0, 0x0E, 0x07,
  0x00, 0x1C, 0x1C, 0x00, 0x38, 0xF0, 0x00, 0x3B, 0xC0, 0x00, 0x7E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0xE0, 0x00,
  0xF1, 0xC0, 0x33, 0xC1, 0xC0, 0x67, 0x03, 0x81, 0xDC, 0x03, 0x83, 0xB8,
  0x03, 0x86, 0xE0, 0x07, 0x1D, 0xC0, 0x07, 0x33, 0x80, 0x07, 0xE7, 0x00,
  0x0F, 0x8E, 0x00, 0x0E, 0x0C, 0x00, 0x3C, 0x1C, 0x00, 0xFC, 0x1E, 0x07,
  0x9C, 0x1F, 0xFE, 0x38, 0x1F, 0xF0, 0x38, 0x33, 0x37, 0x76, 0x66, 0xEC,
  0x00, 0x02, 0x00, 0x08, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x02, 0x00, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x07,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0x40, 0x00, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x60, 0x60, 0x7F, 0x86, 0x1F, 0x7F, 0x6F,
  0xF0, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xB0, 0x00, 0x73,
  0x80, 0x0E, 0x18, 0x00, 0xE1, 0xC0, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x70,
  0x07, 0x02, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x18, 0x70, 0xE1, 0xC3, 0x8E, 0x1C, 0x71, 0xC1, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x77, 0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0xBF, 0x00,
  0xF0, 0x1C, 0x07, 0x80, 0x38, 0x1C, 0x00, 0x60, 0xE0, 0x01, 0xC3, 0x00,
  0x07, 0x1C, 0x00, 0x0C, 0x60, 0x00, 0x73, 0x80, 0x03, 0xCE, 0x00, 0x1F,
  0x38, 0x00, 0xFC, 0xC0, 0x0F, 0x77, 0x00, 0x79, 0xDC, 0x03, 0x87, 0x70,
  0x1C, 0x1D, 0xC1, 0xE0, 0x67, 0x0F, 0x01, 0x98, 0x70, 0x0E, 0x63, 0x80,
  0x3B, 0xBC, 0x00, 0xEF, 0xE0, 0x03, 0xBE, 0x00, 0x0C, 0xF0, 0x00, 0x73,
  0x80, 0x01, 0xCE, 0x00, 0x0E, 0x18, 0x00, 0x38, 0x60, 0x01, 0xC1, 0xC0,
  0x07, 0x03, 0x80, 0x78, 0x0F, 0x03, 0xC0, 0x1F, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x38, 0x07, 0xC1, 0xFC, 0x3F, 0x6F, 0xC7, 0x78, 0x3A, 0x01,
  0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x1E, 0x03, 0xC0, 0x78, 0x03, 0xC1, 0xE0, 0x03,
  0x83, 0x80, 0x07, 0x0E, 0x00, 0x06, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0xFF, 0xE0, 0x03, 0xF7, 0xE0, 0x1E, 0x01, 0xE0, 0x38, 0x01, 0xC0,
  0xE0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0C, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x73,
  0x80, 0x00, 0xC7, 0x00, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x1C, 0x0E,
  0x00, 0x70, 0x1E, 0x03, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1D, 0x80, 0x00, 0x73, 0x00, 0x00, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x0E,
  0x38, 0x00, 0x38, 0x60, 0x00, 0xE0, 0xC0, 0x03, 0x81, 0x80, 0x07, 0x07,
  0x00, 0x1C, 0x0E, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0x30, 0x07, 0x00, 0x60,
  0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0xE0, 0x07, 0x03, 0x80, 0x0E, 0x0E,
  0x00, 0x18, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x01, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xDF, 0xF0, 0x03,
  0xFF, 0xF0, 0x07, 0xC1, 0xF0, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0xE1, 0x80, 0x01,
  0xC3, 0x80, 0x03, 0x87, 0x00, 0x0E, 0x06, 0x00, 0x3C, 0x0E, 0x00, 0xF0,
  0x0F, 0x03, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x7E, 0x03, 0x9F, 0xF8, 0x37, 0xEF, 0xC7, 0xF0,
  0x1E, 0x7C, 0x00, 0xE7, 0x80, 0x06, 0x70, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x06, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0x70, 0x01, 0xC7, 0x00, 0x3C,
  0x38, 0x07, 0x83, 0xC0, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xC0, 0x07,
  0xF7, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0xE0, 0x03, 0x83, 0x80,
  0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x18, 0x00, 0x1C, 0x30, 0x00,
  0x30, 0x60, 0x00, 0xE0, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x01, 0xC0, 0x3C,
  0x01, 0xF3, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x3E, 0x0F, 0x00,
  0xF0, 0x07, 0x03, 0x80, 0x07, 0x0E, 0x00, 0x06, 0x1C, 0x00, 0x0E, 0x70,
  0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xC7, 0x00,
  0x03, 0x8E, 0x00, 0x07, 0x0E, 0x00, 0x1C, 0x1E, 0x00, 0x70, 0x1E, 0x03,
  0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0x80, 0xF0, 0x3C, 0x1C, 0x01, 0xC3, 0x80, 0x0E, 0x70, 0x00,
  0xE7, 0x00, 0x06, 0x60, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x6E, 0x00, 0x0E, 0xE0,
  0x00, 0xEE, 0x00, 0x1E, 0x70, 0x03, 0xE7, 0x80, 0xEE, 0x3E, 0x3C, 0xC1,
  0xFF, 0x9C, 0x07, 0xE1, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0x0F, 0x0F, 0x0F, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0xF8, 0xF8, 0x70, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x01,
  0xC0, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x80, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x10, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0x38, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x01, 0xFF, 0x81, 0xFF, 0xF0, 0xF0, 0x1E, 0x38, 0x03, 0x9C, 0x00, 0x76,
  0x00, 0x1F, 0x80, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x01, 0xE0, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x60, 0x00, 0x60, 0x30,
  0x00, 0x18, 0x1C, 0x06, 0x03, 0x0E, 0x0F, 0xE0, 0xC3, 0x07, 0x9C, 0x31,
  0xC3, 0x83, 0x0C, 0x60, 0xC0, 0xC3, 0x38, 0x60, 0x60, 0xCC, 0x18, 0x18,
  0x33, 0x0C, 0x06, 0x0D, 0x83, 0x01, 0x83, 0x61, 0xC0, 0xC0, 0xD8, 0x60,
  0x30, 0x26, 0x18, 0x0C, 0x19, 0x86, 0x03, 0x06, 0xC1, 0x81, 0x81, 0xB0,
  0x60, 0x60, 0xCC, 0x18, 0x38, 0x33, 0x06, 0x1E, 0x18, 0xC1, 0x8D, 0x8E,
  0x38, 0x7E, 0x3F, 0x06, 0x0F, 0x0F, 0x81, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x08, 0x00, 0x78, 0x0E, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x36, 0x00, 0x00, 0xEC, 0x00,
  0x01, 0x9C, 0x00, 0x07, 0x38, 0x00, 0x0C, 0x70, 0x00, 0x38, 0x60, 0x00,
  0x70, 0xC0, 0x01, 0xC1, 0x80, 0x03, 0x83, 0x00, 0x0E, 0x07, 0x00, 0x1C,
  0x0E, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00,
  0x60, 0x1C, 0x00, 0xC0, 0x38, 0x01, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x18, 0x70, 0x00, 0x31,
  0xC0, 0x00, 0x73, 0x80, 0x00, 0xE6, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB0,
  0x00, 0x07, 0xE0, 0x00, 0x06, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x07,
  0x00, 0x7C, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x06, 0x00, 0x06, 0x06,
  0x00, 0x06, 0x0E, 0x00, 0x06, 0x0E, 0x00, 0x06, 0x0E, 0x00, 0x0E, 0x0E,
  0x00, 0x0E, 0x0C, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x1C, 0x00, 0x78, 0x1C,
  0x07, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x18, 0x00, 0xF0, 0x38,
  0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x30,
  0x00, 0x1C, 0x30, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x18, 0x70,
  0x00, 0x38, 0x70, 0x00, 0x78, 0x60, 0x00, 0xF0, 0x60, 0x01, 0xE0, 0xE0,
  0x1F, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1E, 0x03, 0xC0, 0x78, 0x01, 0xC1, 0xE0,
  0x03, 0x83, 0x80, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x70, 0x00,
  0x1C, 0xE0, 0x00, 0x39, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0x63, 0x80,
  0x01, 0xC7, 0x00, 0x07, 0x06, 0x00, 0x0E, 0x0E, 0x00, 0x38, 0x0E, 0x00,
  0xE0, 0x1E, 0x07, 0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x07, 0x00, 0xF0, 0x06, 0x00,
  0x38, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00,
  0x06, 0x0E, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00,
  0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x18, 0x00, 0x07, 0x18, 0x00,
  0x07, 0x38, 0x00, 0x06, 0x38, 0x00, 0x06, 0x38, 0x00, 0x0E, 0x38, 0x00,
  0x0E, 0x30, 0x00, 0x0E, 0x30, 0x00, 0x0C, 0x70, 0x00, 0x1C, 0x70, 0x00,
  0x1C, 0x70, 0x00, 0x38, 0x70, 0x00, 0x70, 0x60, 0x00, 0x70, 0x60, 0x00,
  0xE0, 0xE0, 0x03, 0xC0, 0xE0, 0x07, 0x80, 0xE0, 0x7F, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1E, 0x03, 0xC0, 0x78, 0x01, 0xC1, 0xE0,
  0x03, 0x83, 0x80, 0x03, 0x8E, 0x00, 0x07, 0x18, 0x00, 0x0E, 0x70, 0x00,
  0x1C, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x7F, 0xF6, 0x00, 0xFF, 0xEC, 0x01, 0xFF, 0x98, 0x00, 0x03, 0x30,
  0x00, 0x0E, 0x60, 0x00, 0x1C, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80,
  0x00, 0xC7, 0x00, 0x01, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x0E, 0x00,
  0x38, 0x1F, 0x03, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x1C,
  0x00, 0x07, 0x07, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x38,
  0x18, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00,
  0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x07, 0x03, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x70, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x06, 0x00, 0x01, 0x81,
  0x80, 0x00, 0xE0, 0x60, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03,
  0x03, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x1C, 0x1C, 0x00,
  0x07, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x18, 0x18,
  0x00, 0x06, 0x06, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38,
  0x00, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x60, 0xE0, 0x00,
  0xE0, 0xE0, 0x01, 0xE0, 0x70, 0x01, 0xC0, 0x70, 0x07, 0x80, 0x3C, 0x1F,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0x80, 0x03, 0xE0, 0x60,
  0x00, 0xF0, 0x1C, 0x00, 0x3C, 0x03, 0x80, 0x0F, 0x00, 0x70, 0x03, 0xC0,
  0x0E, 0x00, 0xF0, 0x01, 0x80, 0x3C, 0x00, 0x70, 0x0F, 0x00, 0x0E, 0x03,
  0xC0, 0x01, 0xC0, 0xF0, 0x00, 0x38, 0x3C, 0x00, 0x06, 0x0F, 0x00, 0x00,
  0xC3, 0xC0, 0x00, 0x38, 0xF0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0xEF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xF7, 0x80, 0x00, 0x7C, 0x70, 0x00, 0x1F,
  0x07, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x01, 0xC0,
  0x01, 0x80, 0x1C, 0x00, 0x30, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0,
  0x07, 0x00, 0x38, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0xE0,
  0x18, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0,
  0x03, 0xE0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0,
  0x7C, 0x00, 0xFC, 0x0F, 0xC0, 0x1B, 0x81, 0xB8, 0x07, 0x60, 0x33, 0x00,
  0xCC, 0x06, 0x60, 0x3B, 0x81, 0xCC, 0x06, 0x70, 0x39, 0x81, 0xCE, 0x07,
  0x38, 0x71, 0xC0, 0xC7, 0x0E, 0x30, 0x18, 0x63, 0x86, 0x03, 0x0C, 0x71,
  0xC0, 0xE1, 0x9C, 0x38, 0x1C, 0x33, 0x07, 0x03, 0x87, 0xE0, 0xC0, 0x60,
  0xF8, 0x18, 0x0C, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x06, 0x03, 0x81, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x06, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x30, 0x18, 0x00, 0x06, 0x03, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x7C, 0x00, 0x1C,
  0x1F, 0x00, 0x07, 0x07, 0xC0, 0x01, 0x81, 0xF8, 0x00, 0xE0, 0x7E, 0x00,
  0x38, 0x19, 0x80, 0x0E, 0x0E, 0x70, 0x03, 0x83, 0x9C, 0x00, 0xE0, 0xE3,
  0x00, 0x30, 0x38, 0xE0, 0x1C, 0x0C, 0x18, 0x07, 0x03, 0x07, 0x01, 0xC1,
  0xC1, 0xC0, 0x70, 0x70, 0x30, 0x18, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x83,
  0x81, 0x80, 0x60, 0xE0, 0x60, 0x1C, 0x38, 0x38, 0x07, 0x0E, 0x0E, 0x00,
  0xC3, 0x03, 0x80, 0x38, 0xC0, 0xE0, 0x0E, 0x70, 0x30, 0x01, 0x9C, 0x0C,
  0x00, 0x77, 0x07, 0x00, 0x0D, 0xC1, 0xC0, 0x03, 0xE0, 0x70, 0x00, 0xF8,
  0x1C, 0x00, 0x1E, 0x06, 0x00, 0x07, 0x83, 0x80, 0x01, 0xE0, 0xE0, 0x00,
  0x38, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1E,
  0x03, 0x80, 0x78, 0x03, 0x81, 0xE0, 0x03, 0x83, 0x80, 0x07, 0x0E, 0x00,
  0x06, 0x18, 0x00, 0x0C, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0x80, 0x00,
  0x77, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xD8, 0x00, 0x03, 0xB0, 0x00, 0x06,
  0xE0, 0x00, 0x0D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0xEC,
  0x00, 0x01, 0xD8, 0x00, 0x03, 0x30, 0x00, 0x0E, 0x60, 0x00, 0x1C, 0xC0,
  0x00, 0x31, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x07, 0x06, 0x00,
  0x1C, 0x0E, 0x00, 0x78, 0x0E, 0x01, 0xE0, 0x1E, 0x0F, 0x80, 0x1F, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0xC0,
  0x07, 0x80, 0x60, 0x01, 0xE0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x1C,
  0x00, 0x0E, 0x0E, 0x00, 0x07, 0x06, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0xE1, 0xC0, 0x00, 0x60, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x78,
  0x30, 0x00, 0x78, 0x38, 0x00, 0x78, 0x1C, 0x00, 0xF8, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xE0, 0x3C,
  0x03, 0x80, 0x1C, 0x07, 0x00, 0x0E, 0x0F, 0x00, 0x06, 0x0E, 0x00, 0x07,
  0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x38, 0x00, 0x07, 0x38, 0x00, 0x03,
  0x38, 0x00, 0x03, 0x30, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07,
  0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x1C, 0x60, 0x00, 0x18, 0x60, 0x00, 0x38, 0x70, 0x00, 0x70,
  0x70, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x3C, 0x01, 0xC0, 0x1E, 0x07, 0x80,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x40,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x07, 0x00, 0x7C, 0x07, 0x00, 0x1E,
  0x07, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x06, 0x00, 0x07, 0x06, 0x00, 0x07,
  0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x0E,
  0x0C, 0x00, 0x0E, 0x0C, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x1C, 0x00, 0x78,
  0x1C, 0x03, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x38, 0x07, 0x00,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x01, 0xC0,
  0x30, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0,
  0x70, 0x00, 0xE0, 0x60, 0x00, 0x70, 0x60, 0x00, 0x70, 0xE0, 0x00, 0x70,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8,
  0x03, 0xE0, 0x1C, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x0F, 0x0E, 0x00, 0x07,
  0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C,
  0x70, 0x00, 0x1C, 0x70, 0x00, 0x38, 0x78, 0x00, 0x78, 0x3C, 0x00, 0xF0,
  0x1E, 0x03, 0xE0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x03, 0x0C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07,
  0x1C, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x0E,
  0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x30, 0x00, 0x0C,
  0x30, 0x00, 0x1C, 0x30, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C,
  0x70, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x38, 0xE0, 0x00, 0x38,
  0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x70,
  0xE0, 0x00, 0x70, 0xE0, 0x00, 0x60, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xC0,
  0x70, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x3C, 0x1F, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1B, 0x80, 0x00, 0x73,
  0x00, 0x00, 0xE7, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x38,
  0x00, 0x38, 0x70, 0x00, 0xE0, 0x60, 0x01, 0xC0, 0xC0, 0x07, 0x01, 0xC0,
  0x0E, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x0C, 0x03,
  0x80, 0x18, 0x06, 0x00, 0x30, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0, 0xE0,
  0x01, 0xC1, 0xC0, 0x03, 0x87, 0x00, 0x03, 0x0E, 0x00, 0x06, 0x38, 0x00,
  0x0C, 0x70, 0x00, 0x1C, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x76, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x0C, 0x01, 0xB0, 0x0E, 0x01, 0xD8, 0x07, 0x00, 0xCC,
  0x03, 0x80, 0x66, 0x03, 0xC0, 0x73, 0x01, 0xE0, 0x39, 0x80, 0xF0, 0x18,
  0xC0, 0xFC, 0x1C, 0x60, 0x6E, 0x0E, 0x30, 0x37, 0x06, 0x18, 0x3B, 0x83,
  0x0C, 0x19, 0xC3, 0x86, 0x0C, 0xE1, 0xC3, 0x0E, 0x70, 0xC1, 0x86, 0x38,
  0xE0, 0xC3, 0x1C, 0x70, 0x63, 0x86, 0x30, 0x31, 0x83, 0x18, 0x19, 0xC1,
  0x9C, 0x0C, 0xE0, 0xCE, 0x06, 0x60, 0x66, 0x03, 0x70, 0x37, 0x01, 0xB8,
  0x1B, 0x81, 0xD8, 0x0D, 0x80, 0xFC, 0x06, 0xC0, 0x7E, 0x03, 0xE0, 0x3E,
  0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x0E, 0x00, 0x07, 0x00, 0x70, 0x00, 0x70, 0x01, 0x80, 0x07,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00,
  0x0E, 0x03, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x06,
  0x1C, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x38, 0x60, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x1C,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x0E, 0x00,
  0x1E, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x70, 0x0F, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0x0F, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x3C, 0x70, 0x00, 0x38, 0x38, 0x00,
  0x70, 0x38, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x03, 0x80, 0x0C, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x0E,
  0x00, 0x06, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x38, 0x00, 0x03, 0x70,
  0x00, 0x03, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFE, 0x03,
  0xF8, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xE0, 0x18,
  0x06, 0x01, 0x80, 0x70, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x03, 0x80,
  0x60, 0x18, 0x06, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x38, 0x0E,
  0x01, 0x80, 0x60, 0x18, 0x07, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xE0,
  0x38, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x07, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0C, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xF8, 0x00, 0xD8, 0x01, 0xD8, 0x01, 0x98, 0x03, 0x9C, 0x07, 0x1C,
  0x07, 0x0C, 0x0E, 0x0C, 0x0C, 0x0E, 0x1C, 0x0E, 0x18, 0x0E, 0x38, 0x06,
  0x70, 0x06, 0x70, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xC3, 0x86, 0x0C, 0x30, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x80,
  0x3C, 0x0F, 0x01, 0xC0, 0x0E, 0x0E, 0x00, 0x38, 0x30, 0x00, 0x61, 0xC0,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x7F, 0xFE, 0x0F, 0xFF, 0xF8, 0x7C, 0x00, 0xE3, 0xC0, 0x03, 0x1E,
  0x00, 0x0C, 0x70, 0x00, 0x71, 0x80, 0x01, 0xC6, 0x00, 0x07, 0x38, 0x00,
  0x3C, 0x70, 0x01, 0xE1, 0xC0, 0x1F, 0x87, 0xC1, 0xF6, 0x0F, 0xFF, 0x38,
  0x0F, 0xF0, 0x60, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE3, 0xFC, 0x03, 0x9F, 0xF8,
  0x0F, 0xE1, 0xF0, 0x3E, 0x01, 0xE0, 0xF0, 0x03, 0x87, 0x80, 0x0E, 0x1C,
  0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x01, 0xC6, 0x00, 0x07, 0x18, 0x00,
  0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x06, 0x38, 0x00, 0x38,
  0xC0, 0x00, 0xE3, 0x00, 0x03, 0x9C, 0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0,
  0x03, 0x87, 0x80, 0x1E, 0x1F, 0x00, 0xF0, 0xEE, 0x07, 0x83, 0x9F, 0xFC,
  0x0E, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x01, 0xF0, 0x78,
  0x1E, 0x00, 0xE0, 0xE0, 0x07, 0x0E, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00,
  0x07, 0x70, 0x00, 0x3B, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x03, 0x18, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x1C, 0x1C,
  0x01, 0xC0, 0xF0, 0x3E, 0x03, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0xFE, 0x1C, 0x03, 0xFF, 0x9C, 0x07, 0xC3,
  0xD8, 0x0F, 0x00, 0xF8, 0x1E, 0x00, 0x78, 0x1C, 0x00, 0x78, 0x38, 0x00,
  0x38, 0x38, 0x00, 0x38, 0x70, 0x00, 0x30, 0x70, 0x00, 0x30, 0x60, 0x00,
  0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00,
  0x60, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00,
  0xE0, 0x60, 0x01, 0xE0, 0x70, 0x03, 0xC0, 0x78, 0x07, 0xC0, 0x3C, 0x1F,
  0xC0, 0x1F, 0xFD, 0xC0, 0x0F, 0xF1, 0xC0, 0x00, 0x7F, 0x80, 0x0F, 0xFE,
  0x01, 0xF0, 0x78, 0x1E, 0x01, 0xE0, 0xE0, 0x07, 0x0E, 0x00, 0x1C, 0xE0,
  0x00, 0xE7, 0x00, 0x03, 0x70, 0x00, 0x1B, 0x80, 0x00, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x0C, 0x1C, 0x00, 0xF0, 0x78, 0x1E, 0x01, 0xFF, 0xE0, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFE, 0x70, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x07, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFE, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x0E,
  0x03, 0xFF, 0x9C, 0x0F, 0x87, 0xB0, 0x3C, 0x03, 0x60, 0xF0, 0x03, 0xC1,
  0xC0, 0x07, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x38, 0x00, 0x18, 0x70,
  0x00, 0x30, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00,
  0x07, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x18, 0x70, 0x00, 0x70, 0xE0, 0x00,
  0xE1, 0xC0, 0x01, 0xC1, 0x80, 0x07, 0x83, 0x80, 0x1E, 0x07, 0x80, 0x7C,
  0x07, 0x83, 0xF8, 0x07, 0xFF, 0x70, 0x07, 0xF8, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x08, 0x00, 0x70, 0x30,
  0x01, 0xC0, 0x78, 0x0F, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE1, 0xFC, 0x03, 0x9F, 0xFC, 0x0C,
  0xF0, 0xF8, 0x37, 0x00, 0xE1, 0xF0, 0x01, 0x87, 0x80, 0x07, 0x1C, 0x00,
  0x1C, 0x70, 0x00, 0x71, 0x80, 0x01, 0xC6, 0x00, 0x07, 0x38, 0x00, 0x18,
  0xE0, 0x00, 0x63, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x30, 0x00, 0x38, 0xC0,
  0x00, 0xE7, 0x00, 0x03, 0x1C, 0x00, 0x0C, 0x70, 0x00, 0x71, 0xC0, 0x01,
  0xC6, 0x00, 0x07, 0x18, 0x00, 0x1C, 0xE0, 0x00, 0x63, 0x80, 0x01, 0x8E,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x01, 0x07, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x0F, 0x0E, 0x00,
  0x3C, 0x0E, 0x00, 0x78, 0x0E, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x0E, 0x07,
  0x80, 0x0C, 0x0F, 0x00, 0x1C, 0x1E, 0x00, 0x1C, 0x3C, 0x00, 0x1C, 0x70,
  0x00, 0x1D, 0xE0, 0x00, 0x1B, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x78,
  0x00, 0x3C, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1E, 0x00, 0x30, 0x0E,
  0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x80, 0x70, 0x03, 0x80, 0x70, 0x01,
  0xC0, 0x70, 0x01, 0xE0, 0x60, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0C, 0xFC,
  0x3F, 0x03, 0x7F, 0x9F, 0xE1, 0xF8, 0xFE, 0x1C, 0x78, 0x1E, 0x07, 0x1C,
  0x07, 0x80, 0xC7, 0x01, 0xC0, 0x31, 0x80, 0x70, 0x0C, 0x60, 0x1C, 0x07,
  0x38, 0x06, 0x01, 0xCE, 0x01, 0x80, 0x73, 0x80, 0xE0, 0x1C, 0xC0, 0x38,
  0x06, 0x30, 0x0E, 0x01, 0x8C, 0x03, 0x80, 0xE7, 0x00, 0xC0, 0x39, 0xC0,
  0x30, 0x0E, 0x70, 0x1C, 0x03, 0x18, 0x07, 0x00, 0xC6, 0x01, 0xC0, 0x31,
  0x80, 0x70, 0x1C, 0xE0, 0x18, 0x07, 0x38, 0x06, 0x01, 0xCE, 0x03, 0x80,
  0x63, 0x00, 0xE0, 0x18, 0xC0, 0x38, 0x0E, 0x00, 0x0E, 0x1F, 0xC0, 0x31,
  0xFF, 0xC0, 0xCF, 0x0F, 0x83, 0x70, 0x0E, 0x1F, 0x00, 0x38, 0x78, 0x00,
  0x71, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x18, 0x00, 0x1C, 0x60, 0x00, 0x73,
  0x80, 0x01, 0x8E, 0x00, 0x06, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x00,
  0x03, 0x8C, 0x00, 0x0E, 0x70, 0x00, 0x31, 0xC0, 0x00, 0xC7, 0x00, 0x07,
  0x1C, 0x00, 0x1C, 0x60, 0x00, 0x71, 0x80, 0x01, 0xCE, 0x00, 0x06, 0x38,
  0x00, 0x18, 0xE0, 0x00, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x3E,
  0x0F, 0x01, 0xE0, 0x1E, 0x0E, 0x00, 0x38, 0x70, 0x00, 0x71, 0xC0, 0x01,
  0xCE, 0x00, 0x07, 0x38, 0x00, 0x0D, 0xC0, 0x00, 0x37, 0x00, 0x00, 0xDC,
  0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x76, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0x60, 0x00, 0x39, 0x80, 0x00, 0xE7, 0x00, 0x07, 0x1C, 0x00, 0x1C,
  0x38, 0x00, 0xE0, 0xE0, 0x07, 0x01, 0xE0, 0x78, 0x03, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0x03, 0x8F, 0xE0, 0x03, 0xBF, 0xF8, 0x03, 0x78, 0x7C, 0x03,
  0xE0, 0x1C, 0x03, 0xC0, 0x0E, 0x07, 0x80, 0x0E, 0x07, 0x00, 0x06, 0x07,
  0x00, 0x07, 0x07, 0x00, 0x07, 0x06, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E,
  0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x06, 0x0C, 0x00, 0x0E, 0x0C,
  0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C,
  0x00, 0x38, 0x1C, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x3B, 0x81, 0xE0, 0x39,
  0xFF, 0xC0, 0x38, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x1C, 0x0F, 0xFE, 0x70, 0x7C, 0x3D, 0x83, 0xC0, 0x3E, 0x1E, 0x00,
  0x78, 0x70, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x70, 0x00, 0x31,
  0xC0, 0x00, 0xC6, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80,
  0x01, 0xCE, 0x00, 0x06, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x03,
  0x8E, 0x00, 0x0E, 0x18, 0x00, 0x78, 0x70, 0x01, 0xC1, 0xE0, 0x1F, 0x03,
  0xC0, 0xFC, 0x07, 0xFF, 0x70, 0x0F, 0xF1, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x0C, 0x1F, 0xF0, 0xC7, 0xFE, 0x0C, 0xFE, 0x61, 0xDC, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0x01, 0xF0, 0x7C, 0x1C,
  0x00, 0xE1, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x60, 0x00, 0x63, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xCE, 0x00, 0x0E, 0x38, 0x00,
  0xF0, 0xF0, 0x1F, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x1C,
  0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x01, 0xC6, 0x00, 0x06, 0x18, 0x00,
  0x18, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x38,
  0xC0, 0x00, 0xC3, 0x00, 0x03, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0,
  0x01, 0xC7, 0x00, 0x07, 0x18, 0x00, 0x18, 0x60, 0x00, 0xE1, 0x80, 0x03,
  0x86, 0x00, 0x0E, 0x18, 0x00, 0x78, 0x70, 0x03, 0xE1, 0xC0, 0x1F, 0x03,
  0xC1, 0xEC, 0x07, 0xFF, 0x70, 0x0F, 0xF1, 0xC0, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x39, 0x80, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x07, 0x06, 0x00,
  0x0E, 0x0C, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x38, 0x01, 0xC0, 0x30, 0x03,
  0x00, 0x60, 0x0E, 0x00, 0xE0, 0x18, 0x01, 0xC0, 0x70, 0x01, 0x81, 0xC0,
  0x03, 0x03, 0x80, 0x07, 0x0E, 0x00, 0x0E, 0x18, 0x00, 0x0C, 0x70, 0x00,
  0x18, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x76, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x0C, 0x01, 0xF0,
  0x0E, 0x01, 0xF8, 0x07, 0x00, 0xDC, 0x07, 0x80, 0xEE, 0x03, 0xC0, 0x73,
  0x01, 0xE0, 0x31, 0x81, 0xB0, 0x38, 0xC0, 0xD8, 0x18, 0x60, 0xEC, 0x0C,
  0x30, 0x66, 0x0E, 0x18, 0x73, 0x06, 0x0C, 0x31, 0x87, 0x06, 0x18, 0xE3,
  0x03, 0x18, 0x31, 0x81, 0x8C, 0x19, 0xC0, 0xCE, 0x0C, 0xC0, 0x66, 0x06,
  0x60, 0x33, 0x03, 0x70, 0x1B, 0x01, 0xB0, 0x0D, 0x80, 0xD8, 0x07, 0x80,
  0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x03, 0x81, 0xC0, 0x03,
  0x80, 0x70, 0x03, 0x80, 0x1C, 0x03, 0xC0, 0x0E, 0x03, 0xC0, 0x03, 0x83,
  0xC0, 0x01, 0xC3, 0xC0, 0x00, 0x71, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xEE, 0x00, 0x01, 0xE3, 0x80, 0x01, 0xE1, 0xC0, 0x00,
  0xE0, 0x70, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x03, 0x80,
  0xE0, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x06, 0x00, 0x03,
  0xC0, 0x38, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x70,
  0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x1C,
  0x00, 0x01, 0x81, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x5F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x40, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x0F, 0xC0, 0x03,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x0E, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x07, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81,
  0xC0, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x0F, 0xC0,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0xCF, 0x3E, 0x00, 0x6E, 0x07, 0x80, 0x76,
  0x01, 0xE0, 0x77, 0x00, 0x7C, 0x7B, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xF0,
};

const GFXglyph RobotoMono_LightItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 9, 33, 28, 9, -33 },
  { 39, 11, 10, 28, 11, -35 },
  { 53, 27, 33, 28, 1, -33 },
  { 165, 23, 44, 28, 3, -39 },
  { 292, 22, 35, 28, 3, -34 },
  { 389, 23, 34, 28, 2, -34 },
  { 487, 4, 10, 28, 13, -35 },
  { 492, 15, 49, 28, 8, -38 },
  { 584, 15, 48, 28, 4, -37 },
  { 674, 20, 20, 28, 6, -33 },
  { 724, 22, 25, 28, 3, -28 },
  { 793, 7, 11, 28, 5, -4 },
  { 803, 17, 2, 28, 5, -16 },
  { 808, 5, 4, 28, 10, -4 },
  { 811, 23, 36, 28, 3, -33 },
  { 915, 22, 34, 28, 3, -34 },
  { 1009, 13, 33, 28, 7, -33 },
  { 1063, 23, 34, 28, 1, -34 },
  { 1161, 23, 34, 28, 1, -34 },
  { 1259, 23, 33, 28, 1, -33 },
  { 1354, 23, 33, 28, 4, -33 },
  { 1449, 20, 34, 28, 3, -34 },
  { 1534, 22, 33, 28, 5, -33 },
  { 1625, 23, 34, 28, 3, -34 },
  { 1723, 20, 34, 28, 5, -34 },
  { 1808, 8, 24, 28, 11, -24 },
  { 1832, 11, 31, 28, 8, -24 },
  { 1875, 21, 20, 28, 4, -25 },
  { 1928, 22, 12, 28, 3, -21 },
  { 1961, 21, 20, 28, 3, -25 },
  { 2014, 18, 34, 28, 7, -34 },
  { 2091, 26, 34, 28, 1, -34 },
  { 2202, 23, 33, 28, 0, -33 },
  { 2297, 24, 33, 28, 2, -33 },
  { 2396, 23, 35, 28, 3, -34 },
  { 2497, 24, 33, 28, 2, -33 },
  { 2596, 25, 33, 28, 2, -33 },
  { 2700, 25, 33, 28, 2, -33 },
  { 2804, 23, 35, 28, 3, -34 },
  { 2905, 26, 33, 28, 1, -33 },
  { 3013, 24, 33, 28, 2, -33 },
  { 3112, 24, 33, 28, 2, -33 },
  { 3211, 27, 33, 28, 2, -33 },
  { 3323, 20, 33, 28, 2, -33 },
  { 3406, 27, 33, 28, 1, -33 },
  { 3518, 26, 33, 28, 1, -33 },
  { 3626, 23, 34, 28, 3, -34 },
  { 3724, 25, 33, 28, 2, -33 },
  { 3828, 24, 40, 28, 2, -34 },
  { 3948, 24, 33, 28, 2, -33 },
  { 4047, 24, 34, 28, 2, -34 },
  { 4149, 24, 33, 28, 5, -33 },
  { 4248, 24, 33, 28, 3, -33 },
  { 4347, 23, 33, 28, 5, -33 },
  { 4442, 25, 33, 28, 4, -33 },
  { 4546, 29, 33, 28, 0, -33 },
  { 4666, 24, 33, 28, 5, -33 },
  { 4765, 25, 33, 28, 1, -33 },
  { 4869, 15, 45, 28, 7, -38 },
  { 4954, 10, 36, 28, 9, -33 },
  { 4999, 15, 45, 28, 6, -38 },
  { 5084, 16, 18, 28, 6, -33 },
  { 5120, 20, 2, 28, 1, 0 },
  { 5125, 6, 6, 28, 13, -34 },
  { 5130, 22, 25, 28, 2, -25 },
  { 5199, 22, 35, 28, 2, -35 },
  { 5296, 21, 25, 28, 3, -25 },
  { 5362, 24, 35, 28, 3, -35 },
  { 5467, 21, 25, 28, 3, -25 },
  { 5533, 23, 36, 28, 6, -36 },
  { 5637, 23, 35, 28, 2, -25 },
  { 5738, 22, 35, 28, 2, -35 },
  { 5835, 19, 34, 28, 3, -34 },
  { 5916, 22, 44, 28, 0, -34 },
  { 6037, 24, 35, 28, 2, -35 },
  { 6142, 19, 35, 28, 3, -35 },
  { 6226, 26, 25, 28, 0, -25 },
  { 6308, 22, 25, 28, 2, -25 },
  { 6377, 22, 25, 28, 2, -25 },
  { 6446, 24, 35, 28, 0, -25 },
  { 6551, 22, 35, 28, 3, -25 },
  { 6648, 20, 25, 28, 6, -25 },
  { 6711, 21, 25, 28, 3, -25 },
  { 6777, 19, 31, 28, 5, -31 },
  { 6851, 22, 25, 28, 3, -25 },
  { 6920, 23, 25, 28, 4, -25 },
  { 6992, 25, 25, 28, 3, -25 },
  { 7071, 25, 25, 28, 1, -25 },
  { 7150, 29, 35, 28, -1, -25 },
  { 7277, 24, 25, 28, 1, -25 },
  { 7352, 18, 46, 28, 7, -37 },
  { 7456, 9, 41, 28, 9, -33 },
  { 7503, 18, 46, 28, 4, -37 },
  { 7607, 25, 8, 28, 1, -18 },
};

const GFXfont RobotoMono_LightItalic47pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic47pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic47pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _ROBOTOMONO_LIGHTITALIC47PT7B_H_
