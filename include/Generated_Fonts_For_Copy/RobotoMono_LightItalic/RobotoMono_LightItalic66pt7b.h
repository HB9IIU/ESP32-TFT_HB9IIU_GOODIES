#ifndef _ROBOTOMONO_LIGHTITALIC66PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC66PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x0F, 0x80, 0xFC, 0x0F, 0x80, 0x78, 0x00,
  0x3C, 0x0E, 0x78, 0x1C, 0xE0, 0x39, 0xC0, 0xF3, 0x81, 0xE7, 0x03, 0x9E,
  0x07, 0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x79, 0xC0, 0xE3, 0x81, 0xCE, 0x03,
  0x9C, 0x07, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0E,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0F, 0x03, 0x80, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00,
  0x78, 0x70, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x1C, 0x0F, 0x00,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x78, 0x07, 0x00, 0x10, 0x70, 0x07, 0x80,
  0x38, 0x70, 0x07, 0x80, 0x38, 0x70, 0x07, 0x80, 0x70, 0xF0, 0x07, 0x00,
  0xF0, 0xE0, 0x07, 0x01, 0xE0, 0xE0, 0x07, 0x01, 0xC0, 0xE0, 0x07, 0x03,
  0x80, 0xE0, 0x0F, 0x07, 0x80, 0xE0, 0x0E, 0x07, 0x00, 0x70, 0x1E, 0x0E,
  0x00, 0x70, 0x3C, 0x1E, 0x00, 0x7C, 0x78, 0x1C, 0x00, 0x3F, 0xF8, 0x38,
  0x00, 0x1F, 0xE0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x1E, 0x07,
  0xF0, 0x00, 0x1C, 0x1F, 0xFC, 0x00, 0x3C, 0x3E, 0x3C, 0x00, 0x78, 0x38,
  0x1E, 0x00, 0x70, 0x70, 0x0E, 0x00, 0xE0, 0xF0, 0x0E, 0x01, 0xE0, 0xE0,
  0x0F, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0xE0, 0x0F, 0x07, 0x81, 0xE0,
  0x0E, 0x0F, 0x01, 0xC0, 0x0E, 0x0E, 0x01, 0xC0, 0x0E, 0x1C, 0x01, 0xC0,
  0x0E, 0x1C, 0x01, 0xC0, 0x1E, 0x08, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0,
  0x3C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x03,
  0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x01, 0xE0, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x0F, 0x0F,
  0x80, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00,
  0x1F, 0x1E, 0x00, 0x00, 0x0F, 0x87, 0x80, 0x0F, 0x07, 0xC0, 0xF0, 0x03,
  0xC3, 0xE0, 0x3E, 0x00, 0xE1, 0xF0, 0x07, 0x80, 0x78, 0x78, 0x00, 0xF0,
  0x1E, 0x3C, 0x00, 0x3C, 0x07, 0x0F, 0x00, 0x07, 0x83, 0xC7, 0x80, 0x01,
  0xF0, 0xF1, 0xE0, 0x00, 0x3C, 0x78, 0x78, 0x00, 0x07, 0x9E, 0x1E, 0x00,
  0x01, 0xEF, 0x07, 0x80, 0x00, 0x3F, 0x81, 0xE0, 0x00, 0x0F, 0xE0, 0x78,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xFC, 0x03, 0xC0, 0x00, 0x7F, 0x80,
  0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0x80, 0x7F, 0x3C, 0x03, 0xFF, 0xFF, 0x0F,
  0x00, 0x7F, 0xFF, 0x01, 0xE0, 0x07, 0xFF, 0x00, 0x7C, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x39, 0xCE, 0x77, 0xBD, 0xCE, 0x73, 0xBD, 0xCE, 0x73, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x03, 0x80, 0x1C,
  0x01, 0x9F, 0x01, 0xC0, 0x7D, 0xFF, 0x0E, 0x1F, 0xF7, 0xFE, 0x73, 0xFF,
  0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xE3,
  0x80, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x1F, 0x03, 0xC0,
  0x01, 0xF0, 0x0F, 0x00, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xE0, 0x0F,
  0x00, 0x0F, 0x80, 0x38, 0x00, 0x30, 0x00, 0x80, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xF0,
  0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x78, 0x3E, 0x07, 0x00, 0x80, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x38,
  0xFB, 0xFF, 0xFF, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xE1, 0xE0, 0x00,
  0x01, 0xC3, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00,
  0x7F, 0x3C, 0x00, 0x01, 0xFC, 0x78, 0x00, 0x07, 0xB8, 0xE0, 0x00, 0x3E,
  0xF3, 0xC0, 0x00, 0xF9, 0xE7, 0x80, 0x03, 0xE3, 0xCF, 0x00, 0x0F, 0x07,
  0x9E, 0x00, 0x7C, 0x0F, 0x3C, 0x01, 0xF0, 0x1E, 0x70, 0x07, 0xC0, 0x38,
  0xE0, 0x1E, 0x00, 0xF3, 0xC0, 0xF8, 0x01, 0xE7, 0x83, 0xE0, 0x03, 0xCF,
  0x0F, 0x80, 0x07, 0x9E, 0x3C, 0x00, 0x0F, 0x3D, 0xF0, 0x00, 0x1C, 0x77,
  0xC0, 0x00, 0x78, 0xFF, 0x00, 0x00, 0xF1, 0xF8, 0x00, 0x01, 0xE3, 0xE0,
  0x00, 0x03, 0x87, 0x80, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x1E, 0x1C, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x01, 0xE0, 0x01,
  0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0xF0, 0x01, 0xF8, 0x01, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE7, 0xFC,
  0x7B, 0xFC, 0x1E, 0xF8, 0x07, 0x38, 0x01, 0xC8, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x3F, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x3E, 0x01,
  0xE0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x7F, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x0F, 0x08,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x1F, 0x80, 0x1F, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x0F, 0xBC,
  0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x07, 0x83, 0x80, 0x00, 0x07, 0xC1, 0xC0, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x01, 0xE0,
  0x0F, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x07, 0x00, 0x78, 0x00, 0x07, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0xC3, 0xFC, 0x00, 0x01, 0xEF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x04, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00,
  0x0F, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x07, 0x80, 0x1E, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x03, 0xF0, 0x00, 0xF0, 0xFF, 0xF0,
  0x07, 0x1F, 0xFF, 0xC0, 0x79, 0xFF, 0xFF, 0x03, 0xDF, 0x00, 0xFC, 0x1D,
  0xE0, 0x01, 0xF0, 0xFC, 0x00, 0x07, 0x8F, 0xC0, 0x00, 0x3C, 0x7C, 0x00,
  0x00, 0xF3, 0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x01, 0xDE,
  0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0x81,
  0xF0, 0x00, 0x78, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x00, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x78,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x38,
  0xF0, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xF0,
  0x78, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0x80, 0xFC, 0x01, 0xF0, 0x01, 0xE0, 0x1F, 0x00, 0x07, 0x81, 0xF0, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x7B, 0x80, 0x00,
  0x03, 0xDC, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3E, 0x78,
  0x00, 0x03, 0xF1, 0xE0, 0x00, 0x3F, 0x8F, 0x80, 0x03, 0xF8, 0x3C, 0x00,
  0x3D, 0xC1, 0xF8, 0x0F, 0xDE, 0x07, 0xFF, 0xFC, 0xF0, 0x1F, 0xFF, 0x87,
  0x00, 0x3F, 0xF0, 0x78, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x01, 0x80, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x1F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xF0, 0x08, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0xFC, 0x07, 0xE0, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x3C, 0xF8, 0x00,
  0x1F, 0x78, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x0F, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0x06, 0x03, 0x80, 0x3F, 0x80, 0x70, 0x78, 0x0F, 0xFE, 0x07,
  0x07, 0x01, 0xF9, 0xF0, 0x70, 0xF0, 0x3C, 0x06, 0x07, 0x0E, 0x07, 0x80,
  0x60, 0x71, 0xC0, 0x70, 0x0E, 0x07, 0x1C, 0x0E, 0x00, 0xE0, 0x73, 0xC0,
  0xE0, 0x0C, 0x07, 0x38, 0x1C, 0x00, 0xC0, 0x73, 0x81, 0xC0, 0x1C, 0x07,
  0x70, 0x38, 0x01, 0xC0, 0x77, 0x03, 0x80, 0x18, 0x07, 0x70, 0x38, 0x03,
  0x80, 0x67, 0x03, 0x80, 0x38, 0x06, 0xE0, 0x70, 0x03, 0x80, 0xEE, 0x07,
  0x00, 0x30, 0x0E, 0xE0, 0x70, 0x07, 0x00, 0xCE, 0x07, 0x00, 0x70, 0x0C,
  0xE0, 0x70, 0x07, 0x01, 0xCE, 0x06, 0x00, 0xE0, 0x18, 0xE0, 0x60, 0x1E,
  0x03, 0x8E, 0x07, 0x03, 0xE0, 0x38, 0xE0, 0x70, 0x76, 0x07, 0x0E, 0x07,
  0x0F, 0x60, 0xE0, 0xE0, 0x7F, 0xE7, 0x9E, 0x0E, 0x03, 0xFC, 0x7F, 0xC0,
  0xE0, 0x1F, 0x03, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x02, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x3D, 0xC0, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x0E, 0x3C, 0x00,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x07, 0x83, 0x80,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x01, 0xC0, 0x07, 0x80, 0x00, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xE0, 0x78,
  0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x00, 0x77, 0x80, 0x00, 0x00, 0x3B,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1E, 0x00, 0x07,
  0xE0, 0x0F, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x7C, 0x03, 0x80, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x78, 0x1C, 0x00,
  0x00, 0x38, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1F, 0x01, 0xC0, 0x00, 0x1F, 0x01, 0xE0,
  0x00, 0x3F, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x1F, 0xE0, 0x0F,
  0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0x70,
  0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x83, 0x80, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x01, 0xF0, 0x38, 0x00, 0x03, 0xF0, 0x3C, 0x00, 0x03,
  0xF0, 0x1E, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07,
  0xF0, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0xF8, 0x03,
  0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x07, 0x07, 0x80, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x03, 0xE0, 0x0F,
  0x00, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x78, 0x07, 0xFC, 0x00, 0x0E,
  0x00, 0x0F, 0xC0, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x00,
  0xF0, 0x07, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x1C,
  0x00, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0x38,
  0x1E, 0x00, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x00, 0xF8, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x01, 0xF0, 0x0E, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xFC,
  0x00, 0x3C, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x10, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F,
  0x03, 0xE0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x3F, 0xFF, 0x9E, 0x00, 0x1F, 0xFF, 0xCF, 0x00, 0x0F, 0xFF, 0xC7, 0x00,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x00, 0x78, 0xE0,
  0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x0E, 0x1E,
  0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x03, 0xC1,
  0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x70,
  0x1E, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x3C, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x3C, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xFC, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x0E, 0x00, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x01, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x7C, 0x00, 0x00, 0x38, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00,
  0x07, 0x80, 0xF8, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x3E,
  0x00, 0x00, 0x01, 0xC1, 0xF0, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x00,
  0x3C, 0x7E, 0x00, 0x00, 0x00, 0xF3, 0xF8, 0x00, 0x00, 0x03, 0xDF, 0xF0,
  0x00, 0x00, 0x0F, 0xFB, 0xC0, 0x00, 0x00, 0x3F, 0xC7, 0x80, 0x00, 0x01,
  0xFE, 0x1F, 0x00, 0x00, 0x07, 0xF0, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0xF8,
  0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0x3E,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x07,
  0x70, 0x00, 0x3F, 0xC0, 0x3B, 0x80, 0x01, 0xDC, 0x01, 0xDC, 0x00, 0x1E,
  0xE0, 0x1E, 0xE0, 0x00, 0xE7, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x07, 0xBC,
  0x00, 0xF3, 0xC0, 0x38, 0xE0, 0x07, 0x9E, 0x01, 0xC7, 0x00, 0x78, 0xE0,
  0x1E, 0x38, 0x03, 0xC7, 0x00, 0xF1, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x01,
  0xE3, 0xC0, 0x3C, 0x78, 0x1E, 0x1E, 0x01, 0xC1, 0xC0, 0xE0, 0xF0, 0x0E,
  0x0E, 0x0F, 0x07, 0x00, 0xF0, 0x70, 0x70, 0x38, 0x07, 0x83, 0x87, 0x83,
  0xC0, 0x3C, 0x1E, 0x78, 0x1E, 0x01, 0xE0, 0xF3, 0xC0, 0xF0, 0x0E, 0x03,
  0xBC, 0x07, 0x00, 0x70, 0x1D, 0xE0, 0x38, 0x07, 0x80, 0xFE, 0x03, 0xC0,
  0x3C, 0x07, 0xF0, 0x1E, 0x01, 0xE0, 0x3F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x07, 0x80, 0x70, 0x07, 0x80, 0x38, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x3C,
  0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x00, 0x0E, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00,
  0x0E, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x1F,
  0x80, 0x00, 0x0F, 0x01, 0xF8, 0x00, 0x00, 0xE0, 0x1F, 0x80, 0x00, 0x1E,
  0x01, 0xFC, 0x00, 0x01, 0xE0, 0x1F, 0xC0, 0x00, 0x1E, 0x03, 0xDC, 0x00,
  0x01, 0xE0, 0x3D, 0xE0, 0x00, 0x1E, 0x03, 0xDE, 0x00, 0x01, 0xC0, 0x3C,
  0xF0, 0x00, 0x3C, 0x03, 0x8F, 0x00, 0x03, 0xC0, 0x78, 0x70, 0x00, 0x3C,
  0x07, 0x87, 0x80, 0x03, 0xC0, 0x78, 0x78, 0x00, 0x3C, 0x07, 0x83, 0x80,
  0x03, 0x80, 0x78, 0x3C, 0x00, 0x78, 0x07, 0x03, 0xC0, 0x07, 0x80, 0xF0,
  0x1C, 0x00, 0x78, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0x78,
  0x0F, 0x00, 0xE0, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xF0,
  0x0F, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0x78, 0x0F, 0x01, 0xE0,
  0x03, 0x80, 0xE0, 0x1E, 0x00, 0x3C, 0x1E, 0x01, 0xE0, 0x03, 0xC1, 0xE0,
  0x1C, 0x00, 0x1C, 0x1E, 0x03, 0xC0, 0x01, 0xE1, 0xE0, 0x3C, 0x00, 0x1E,
  0x1E, 0x03, 0xC0, 0x00, 0xE1, 0xC0, 0x3C, 0x00, 0x0F, 0x3C, 0x03, 0x80,
  0x00, 0xF3, 0xC0, 0x38, 0x00, 0x07, 0x3C, 0x07, 0x80, 0x00, 0x7B, 0xC0,
  0x78, 0x00, 0x07, 0xBC, 0x07, 0x80, 0x00, 0x3B, 0x80, 0x78, 0x00, 0x03,
  0xF8, 0x07, 0x00, 0x00, 0x3F, 0x80, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0x00,
  0x00, 0x1F, 0x80, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xE0, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x0E, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00,
  0x3C, 0xE0, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00,
  0xF0, 0x70, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x78,
  0x00, 0xFF, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x01, 0xC0, 0x00, 0x1F, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x3C, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3E, 0x01, 0xC0, 0x00,
  0x1F, 0x80, 0x78, 0x00, 0x0F, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x00,
  0x39, 0xE0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x01, 0xE7, 0x00, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x07, 0x3C, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x0E, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0x80,
  0x1F, 0xF0, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x1E,
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x3E, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x70, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0E,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x00,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x3C,
  0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x0E, 0x00,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x1F, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xC1, 0xC0, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x38,
  0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3E, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0x78, 0x1C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x07, 0x80, 0x0F, 0x00,
  0x03, 0xC0, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x03,
  0xC0, 0x1C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00,
  0x38, 0x0F, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x00, 0x71, 0xE0, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xEE, 0x00, 0x1E, 0x00, 0x3D, 0xC0,
  0x03, 0xC0, 0x07, 0x38, 0x00, 0xF8, 0x00, 0xE7, 0x00, 0x1F, 0x00, 0x3C,
  0xE0, 0x03, 0xE0, 0x07, 0x9C, 0x00, 0xFC, 0x00, 0xE3, 0x80, 0x1F, 0x80,
  0x3C, 0x70, 0x07, 0xF0, 0x07, 0x8E, 0x00, 0xEE, 0x00, 0xE1, 0xC0, 0x1D,
  0xC0, 0x1C, 0x38, 0x07, 0xB8, 0x07, 0x87, 0x00, 0xE7, 0x00, 0xF0, 0xE0,
  0x1C, 0xE0, 0x1C, 0x1C, 0x07, 0x9C, 0x07, 0x83, 0x80, 0xE3, 0x80, 0xF0,
  0x70, 0x1C, 0x70, 0x1C, 0x0E, 0x07, 0x8E, 0x03, 0x81, 0xC0, 0xE1, 0xC0,
  0xF0, 0x38, 0x1C, 0x38, 0x1C, 0x07, 0x07, 0x87, 0x03, 0x80, 0xE0, 0xE0,
  0xE0, 0xF0, 0x1C, 0x1C, 0x1C, 0x1E, 0x03, 0x87, 0x83, 0x83, 0x80, 0xF0,
  0xE0, 0x70, 0x70, 0x1E, 0x1C, 0x0E, 0x1E, 0x03, 0xC7, 0x81, 0xC3, 0x80,
  0x78, 0xE0, 0x38, 0x70, 0x0F, 0x1C, 0x07, 0x1E, 0x01, 0xE7, 0x80, 0xF3,
  0xC0, 0x3C, 0xE0, 0x1E, 0x70, 0x07, 0x9C, 0x03, 0xCE, 0x00, 0xF7, 0x80,
  0x7B, 0xC0, 0x1E, 0xE0, 0x0F, 0x70, 0x03, 0xDC, 0x01, 0xEE, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x78, 0x00,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x01, 0xE0, 0xF8, 0x00,
  0x00, 0x01, 0xE1, 0xF0, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xE7, 0x00, 0x00,
  0x00, 0x03, 0xE7, 0x80, 0x00, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x01, 0xE0,
  0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0xF8,
  0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x01, 0xE0,
  0x0F, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x01, 0xCF,
  0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xE0, 0x07, 0x80,
  0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E,
  0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x78, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0x78, 0x00, 0x1E, 0x70, 0x00, 0x38, 0xE0, 0x00, 0xF1,
  0xC0, 0x01, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x1E, 0x07, 0x00, 0x3C, 0x0E,
  0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x38, 0x1E, 0x00, 0x70,
  0x3C, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC7, 0x80, 0x03, 0x8E,
  0x00, 0x07, 0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x78, 0x38, 0x3C, 0x1C,
  0x0E, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0,
  0x03, 0xE0, 0x3E, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x81, 0xFC, 0x00, 0x1E, 0x1F, 0x80, 0x00, 0x78, 0x78, 0x00,
  0x01, 0xC3, 0xC0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x78,
  0x70, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x1F, 0x87, 0x80, 0x00, 0xFE, 0x1F,
  0x00, 0x0F, 0xF8, 0x3F, 0x00, 0xFD, 0xE0, 0x7F, 0xFF, 0xC7, 0x80, 0xFF,
  0xFE, 0x1E, 0x01, 0xFF, 0xE0, 0x78, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x04, 0x00, 0x01, 0xE1, 0xFF, 0x80,
  0x03, 0x87, 0xFF, 0xC0, 0x07, 0x3F, 0xFF, 0xC0, 0x1E, 0xF8, 0x0F, 0xC0,
  0x3F, 0xC0, 0x07, 0x80, 0x7F, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x0F, 0x01,
  0xF0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x07, 0x0F, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x70, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x1E,
  0x07, 0xE0, 0x00, 0x7C, 0x0F, 0xE0, 0x03, 0xF0, 0x1D, 0xF0, 0x0F, 0xC0,
  0x79, 0xFF, 0xFF, 0x00, 0xF1, 0xFF, 0xFC, 0x01, 0xE0, 0xFF, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFC, 0x03, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x1E, 0x0F, 0x80,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78,
  0x07, 0x80, 0x07, 0xC0, 0x0F, 0x80, 0x7E, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x02, 0x00,
  0x78, 0x00, 0x3F, 0xF8, 0x3C, 0x00, 0x3F, 0xFE, 0x1E, 0x00, 0x7F, 0xFF,
  0x8E, 0x00, 0x7F, 0x01, 0xEF, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x7C, 0x00,
  0x1F, 0xC0, 0x3C, 0x00, 0x07, 0xE0, 0x3C, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x03, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x70,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x01, 0xC0,
  0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0xF8,
  0x03, 0xC0, 0x00, 0xFC, 0x01, 0xF0, 0x01, 0xFE, 0x00, 0x7E, 0x03, 0xEE,
  0x00, 0x1F, 0xFF, 0xE7, 0x00, 0x07, 0xFF, 0xE3, 0x80, 0x01, 0xFF, 0xC3,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFC, 0x07,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x1E,
  0x0F, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x03, 0xCF,
  0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x03, 0xE0,
  0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x1F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x01, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xFF, 0x83, 0xC0, 0x03, 0xFF,
  0xE1, 0xE0, 0x07, 0xFF, 0xF8, 0xF0, 0x07, 0xF0, 0x1E, 0x70, 0x07, 0xE0,
  0x07, 0xF8, 0x07, 0xC0, 0x01, 0xFC, 0x03, 0xC0, 0x00, 0x7E, 0x03, 0xC0,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x38,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x1F,
  0xE0, 0x07, 0xE0, 0x3E, 0xF0, 0x01, 0xFF, 0xFE, 0x70, 0x00, 0x7F, 0xFE,
  0x78, 0x00, 0x1F, 0xFC, 0x3C, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x08, 0x00, 0x03, 0xC0, 0x1E, 0x00,
  0x03, 0xE0, 0x07, 0x80, 0x03, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0xFF,
  0x1F, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x02, 0x00, 0x01, 0xC0, 0x7F, 0xE0, 0x03, 0x83, 0xFF, 0xE0, 0x0F, 0x1F,
  0xFF, 0xE0, 0x1E, 0x7C, 0x07, 0xE0, 0x3D, 0xE0, 0x03, 0xC0, 0x77, 0x00,
  0x07, 0xC0, 0xFC, 0x00, 0x07, 0x83, 0xF0, 0x00, 0x0F, 0x07, 0xC0, 0x00,
  0x0E, 0x0F, 0x80, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C,
  0x38, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x0E, 0x1E, 0x00,
  0x00, 0x1C, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x03, 0x03, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x3F, 0x03, 0xC0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x38, 0x00, 0x7E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0xFC, 0x00, 0x03, 0x80, 0xFC, 0x00, 0x03, 0xC0, 0xF8,
  0x00, 0x01, 0xE0, 0xF8, 0x00, 0x00, 0xF1, 0xF8, 0x00, 0x00, 0x79, 0xF8,
  0x00, 0x00, 0x3D, 0xF8, 0x00, 0x00, 0x1D, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x0F, 0xF3, 0xC0, 0x00, 0x07, 0xF0, 0xF0, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0xF0,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x00, 0x03, 0xE0, 0x07,
  0x80, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x70, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xC0, 0x01, 0x00, 0x0F, 0x1F, 0xE0, 0x7F, 0x80,
  0x3D, 0xFF, 0xC3, 0xFF, 0x00, 0xEF, 0xFF, 0xBF, 0xFE, 0x03, 0xF8, 0x3E,
  0xE0, 0x78, 0x0F, 0x80, 0x7F, 0x00, 0xF0, 0x3C, 0x01, 0xF8, 0x03, 0xC1,
  0xF0, 0x03, 0xC0, 0x0F, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x38,
  0x00, 0xF0, 0x70, 0x01, 0xE0, 0x03, 0xC1, 0xC0, 0x07, 0x80, 0x0F, 0x07,
  0x00, 0x1E, 0x00, 0x38, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0xF0, 0x01, 0xC0,
  0x07, 0x83, 0xC0, 0x07, 0x00, 0x1E, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x38,
  0x00, 0xF0, 0x01, 0xC1, 0xE0, 0x03, 0xC0, 0x07, 0x07, 0x80, 0x0F, 0x00,
  0x1C, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x78, 0x00, 0xE0, 0x03, 0xC1, 0xC0,
  0x07, 0x80, 0x0F, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x3C, 0x00, 0x78, 0x00,
  0xE0, 0xF0, 0x01, 0xC0, 0x03, 0x83, 0xC0, 0x07, 0x00, 0x1E, 0x0E, 0x00,
  0x1C, 0x00, 0x78, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0xE0, 0x03, 0xC0, 0x07,
  0x07, 0x80, 0x0F, 0x00, 0x1C, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x78, 0x00,
  0xE0, 0x03, 0xC1, 0xC0, 0x07, 0x80, 0x0F, 0x07, 0x00, 0x1E, 0x00, 0x3C,
  0x3C, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x07, 0x01, 0xFF,
  0x00, 0x1E, 0x0F, 0xFF, 0x80, 0x3C, 0x7F, 0xFF, 0x80, 0x79, 0xF0, 0x1F,
  0x80, 0xE7, 0x80, 0x1F, 0x01, 0xDC, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x1E,
  0x0F, 0xC0, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x70,
  0x78, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x3C, 0x38, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x1E, 0x1C, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0xF8, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x01, 0xEE, 0x00,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x1E, 0x70, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xE3, 0xC0, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x7C, 0x07, 0x80, 0x01,
  0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x38, 0x3F, 0xF0, 0x00, 0x1C, 0x7F,
  0xFE, 0x00, 0x1E, 0x7F, 0xFF, 0x80, 0x0F, 0x7C, 0x07, 0xE0, 0x07, 0xF8,
  0x01, 0xF0, 0x03, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x3C, 0x07,
  0x00, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x03, 0xC0, 0x3F, 0x00, 0x03, 0xE0, 0x1F, 0xC0, 0x07,
  0xE0, 0x1E, 0xF0, 0x0F, 0xE0, 0x0F, 0x3F, 0xFF, 0xE0, 0x07, 0x8F, 0xFF,
  0xC0, 0x03, 0xC1, 0xFF, 0x80, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x3C, 0x00, 0xFF, 0xF8, 0x78,
  0x07, 0xFF, 0xFC, 0xE0, 0x1F, 0xC0, 0x79, 0xC0, 0x7E, 0x00, 0x3F, 0x81,
  0xF0, 0x00, 0x3F, 0x03, 0xC0, 0x00, 0x7E, 0x0F, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x38, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE1, 0xC0, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x1C, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01,
  0xE0, 0xE0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x00, 0x03, 0xF0,
  0x1F, 0x00, 0x1F, 0xE0, 0x1F, 0x80, 0xFB, 0x80, 0x1F, 0xFF, 0xE7, 0x00,
  0x1F, 0xFF, 0x9E, 0x00, 0x1F, 0xFC, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x3C, 0x07, 0xFF, 0x03, 0x81, 0xFF, 0xF0, 0x38, 0x7F, 0xFF,
  0x07, 0x8F, 0xE0, 0x60, 0x79, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x0F,
  0x80, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x3E,
  0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xE8, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x38,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x38, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x87, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xE1, 0xE0,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x7C,
  0x3C, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0xFE, 0x07,
  0xC0, 0x07, 0xF8, 0x0F, 0x80, 0x7D, 0xE0, 0x3F, 0xFF, 0xE7, 0x80, 0x7F,
  0xFE, 0x1C, 0x00, 0x7F, 0xE0, 0x70, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xF3, 0x80, 0x00,
  0x03, 0xE7, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x3C, 0x1C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x70,
  0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x38, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00,
  0xE0, 0x78, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xFC, 0x00, 0x3C, 0x00, 0x3B, 0x80,
  0x07, 0x80, 0x0F, 0x70, 0x01, 0xF0, 0x01, 0xCE, 0x00, 0x3E, 0x00, 0x79,
  0xC0, 0x0F, 0xC0, 0x0F, 0x38, 0x01, 0xF8, 0x01, 0xC7, 0x00, 0x3F, 0x00,
  0x78, 0xE0, 0x0E, 0xE0, 0x0E, 0x1C, 0x01, 0xDC, 0x01, 0xC3, 0x80, 0x7B,
  0x80, 0x78, 0x70, 0x0E, 0x70, 0x0E, 0x0E, 0x01, 0xCE, 0x03, 0xC1, 0xC0,
  0x71, 0xC0, 0x70, 0x38, 0x0E, 0x38, 0x0E, 0x07, 0x83, 0x83, 0x03, 0xC0,
  0xF0, 0x70, 0x70, 0x70, 0x1E, 0x1E, 0x0E, 0x0E, 0x03, 0xC3, 0x81, 0xC3,
  0xC0, 0x78, 0x70, 0x38, 0x70, 0x07, 0x1C, 0x07, 0x0E, 0x00, 0xE3, 0x80,
  0xE3, 0x80, 0x1C, 0xF0, 0x1C, 0x70, 0x03, 0x9C, 0x03, 0x9E, 0x00, 0x73,
  0x80, 0x73, 0x80, 0x0E, 0xE0, 0x0E, 0x70, 0x01, 0xDC, 0x01, 0xDC, 0x00,
  0x3F, 0x00, 0x3B, 0x80, 0x07, 0xE0, 0x03, 0x70, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x00,
  0x3D, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xF9, 0xE0, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0xF0, 0x00,
  0x00, 0x7C, 0x07, 0x80, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x3E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x47,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00,
  0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0x0F, 0xFF, 0xC0, 0x00, 0x71, 0xF0, 0x7E, 0x00, 0x0F, 0x3C, 0x03, 0xF0,
  0x00, 0xE3, 0x80, 0x0F, 0x80, 0x1E, 0x78, 0x00, 0x7C, 0x03, 0xC7, 0x00,
  0x03, 0xF0, 0xFC, 0xF0, 0x00, 0x1F, 0xFF, 0x8E, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00,
};

const GFXglyph RobotoMono_LightItalic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 39, 0, -1 },
  { 1, 12, 47, 39, 13, -47 },
  { 72, 15, 15, 39, 15, -50 },
  { 101, 38, 47, 39, 1, -47 },
  { 325, 32, 61, 39, 4, -54 },
  { 569, 32, 49, 39, 4, -48 },
  { 765, 34, 49, 39, 2, -48 },
  { 974, 5, 15, 39, 19, -50 },
  { 984, 21, 68, 39, 11, -53 },
  { 1163, 20, 68, 39, 6, -53 },
  { 1333, 29, 29, 39, 8, -47 },
  { 1439, 32, 34, 39, 4, -39 },
  { 1575, 10, 16, 39, 7, -6 },
  { 1595, 24, 4, 39, 7, -23 },
  { 1607, 7, 6, 39, 14, -6 },
  { 1613, 31, 51, 39, 5, -47 },
  { 1811, 31, 49, 39, 5, -48 },
  { 2001, 18, 47, 39, 10, -47 },
  { 2107, 32, 48, 39, 1, -48 },
  { 2299, 32, 49, 39, 2, -48 },
  { 2495, 33, 47, 39, 1, -47 },
  { 2689, 33, 48, 39, 5, -47 },
  { 2887, 29, 48, 39, 4, -47 },
  { 3061, 31, 47, 39, 7, -47 },
  { 3244, 32, 49, 39, 4, -48 },
  { 3440, 29, 48, 39, 6, -48 },
  { 3614, 11, 34, 39, 16, -34 },
  { 3661, 15, 44, 39, 12, -34 },
  { 3744, 30, 28, 39, 5, -35 },
  { 3849, 31, 17, 39, 4, -30 },
  { 3915, 30, 28, 39, 4, -35 },
  { 4020, 25, 48, 39, 10, -48 },
  { 4170, 36, 47, 39, 2, -47 },
  { 4382, 33, 47, 39, 0, -47 },
  { 4576, 33, 47, 39, 3, -47 },
  { 4770, 33, 49, 39, 4, -48 },
  { 4973, 35, 47, 39, 2, -47 },
  { 5179, 35, 47, 39, 3, -47 },
  { 5385, 35, 47, 39, 3, -47 },
  { 5591, 33, 49, 39, 4, -48 },
  { 5794, 36, 47, 39, 2, -47 },
  { 6006, 34, 47, 39, 3, -47 },
  { 6206, 35, 48, 39, 2, -47 },
  { 6416, 38, 47, 39, 3, -47 },
  { 6640, 27, 47, 39, 4, -47 },
  { 6799, 37, 47, 39, 2, -47 },
  { 7017, 36, 47, 39, 2, -47 },
  { 7229, 32, 49, 39, 4, -48 },
  { 7425, 35, 47, 39, 3, -47 },
  { 7631, 34, 56, 39, 3, -48 },
  { 7869, 34, 47, 39, 3, -47 },
  { 8069, 34, 49, 39, 3, -48 },
  { 8278, 33, 47, 39, 7, -47 },
  { 8472, 34, 48, 39, 4, -47 },
  { 8676, 33, 47, 39, 7, -47 },
  { 8870, 35, 47, 39, 6, -47 },
  { 9076, 40, 47, 39, 0, -47 },
  { 9311, 33, 47, 39, 7, -47 },
  { 9505, 36, 47, 39, 1, -47 },
  { 9717, 21, 64, 39, 9, -54 },
  { 9885, 13, 51, 39, 13, -47 },
  { 9968, 21, 64, 39, 9, -54 },
  { 10136, 23, 25, 39, 8, -47 },
  { 10208, 28, 3, 39, 2, 0 },
  { 10219, 8, 8, 39, 19, -48 },
  { 10227, 30, 37, 39, 3, -36 },
  { 10366, 31, 51, 39, 3, -50 },
  { 10564, 30, 37, 39, 4, -36 },
  { 10703, 33, 51, 39, 4, -50 },
  { 10914, 30, 37, 39, 4, -36 },
  { 11053, 32, 51, 39, 8, -51 },
  { 11257, 33, 50, 39, 2, -36 },
  { 11464, 31, 50, 39, 3, -50 },
  { 11658, 27, 47, 39, 4, -47 },
  { 11817, 30, 61, 39, 1, -47 },
  { 12046, 33, 50, 39, 3, -50 },
  { 12253, 27, 50, 39, 4, -50 },
  { 12422, 38, 36, 39, -1, -36 },
  { 12593, 31, 36, 39, 3, -36 },
  { 12733, 31, 37, 39, 3, -36 },
  { 12877, 33, 49, 39, 0, -36 },
  { 13080, 31, 49, 39, 4, -36 },
  { 13270, 28, 36, 39, 8, -36 },
  { 13396, 30, 37, 39, 4, -36 },
  { 13535, 27, 45, 39, 7, -44 },
  { 13687, 30, 36, 39, 5, -35 },
  { 13822, 31, 35, 39, 6, -35 },
  { 13958, 35, 35, 39, 5, -35 },
  { 14112, 36, 35, 39, 1, -35 },
  { 14270, 40, 49, 39, -1, -35 },
  { 14515, 33, 35, 39, 2, -35 },
  { 14660, 26, 65, 39, 10, -52 },
  { 14872, 12, 58, 39, 13, -47 },
  { 14959, 25, 64, 39, 6, -51 },
  { 15159, 36, 11, 39, 1, -25 },
};

const GFXfont RobotoMono_LightItalic66pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic66pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic66pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _ROBOTOMONO_LIGHTITALIC66PT7B_H_
