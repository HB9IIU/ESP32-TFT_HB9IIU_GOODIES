#ifndef _ROBOTOMONO_LIGHTITALIC70PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x03, 0xC0, 0x00, 0x3C,
  0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x38, 0x0F, 0x38, 0x0E, 0x38, 0x0E, 0x78,
  0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0xF0,
  0x1C, 0xE0, 0x3C, 0xE0, 0x38, 0xE0, 0x38, 0x00, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x0F, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF0,
  0x7C, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x78, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x0F,
  0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0x7C, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x00, 0xE0, 0x0F, 0x00, 0x30, 0x78, 0x01, 0xC0, 0x0E, 0x1C, 0x00,
  0x70, 0x07, 0x87, 0x00, 0x3C, 0x03, 0xC1, 0xC0, 0x0F, 0x00, 0xE0, 0x70,
  0x03, 0x80, 0x78, 0x3C, 0x00, 0xE0, 0x3C, 0x0F, 0x00, 0x38, 0x0E, 0x03,
  0xC0, 0x1E, 0x07, 0x80, 0x70, 0x07, 0x03, 0xC0, 0x1C, 0x03, 0xC1, 0xE0,
  0x07, 0x80, 0xE0, 0x70, 0x00, 0xF0, 0xF8, 0x3C, 0x00, 0x3F, 0xFC, 0x1E,
  0x00, 0x07, 0xFE, 0x07, 0x00, 0x00, 0x7E, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x3E, 0x00, 0x00, 0xF0, 0x3F, 0xE0, 0x00, 0x38, 0x1F, 0xFC,
  0x00, 0x1E, 0x0F, 0x8F, 0x00, 0x0F, 0x07, 0x81, 0xE0, 0x07, 0x83, 0xC0,
  0x38, 0x01, 0xC0, 0xE0, 0x0F, 0x00, 0xF0, 0x78, 0x03, 0xC0, 0x78, 0x1C,
  0x00, 0xF0, 0x1C, 0x07, 0x00, 0x3C, 0x0F, 0x01, 0xC0, 0x0F, 0x07, 0x80,
  0x70, 0x03, 0xC1, 0xC0, 0x3C, 0x00, 0xE0, 0xE0, 0x0F, 0x00, 0x38, 0x78,
  0x03, 0xC0, 0x0E, 0x0C, 0x00, 0xF0, 0x07, 0x81, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x7C,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00,
  0x3E, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x01, 0xE0, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0xF0,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00,
  0x78, 0x07, 0xC0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x00, 0x1E, 0x1F, 0x00, 0x00, 0x03, 0xCF, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFD, 0xF0, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x03,
  0xC3, 0xE0, 0x3C, 0x00, 0x78, 0xF8, 0x03, 0xC0, 0x0E, 0x1E, 0x00, 0x7C,
  0x03, 0xC7, 0xC0, 0x07, 0x80, 0x79, 0xF0, 0x00, 0xF8, 0x0F, 0x3C, 0x00,
  0x0F, 0x03, 0xC7, 0x80, 0x00, 0xF0, 0x79, 0xF0, 0x00, 0x1F, 0x1E, 0x3C,
  0x00, 0x01, 0xE7, 0xC7, 0x80, 0x00, 0x3E, 0xF0, 0xF0, 0x00, 0x03, 0xFE,
  0x1E, 0x00, 0x00, 0x3F, 0x83, 0xC0, 0x00, 0x07, 0xE0, 0x3C, 0x00, 0x00,
  0xF8, 0x07, 0x80, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0x80,
  0x07, 0xEF, 0x00, 0xFC, 0x03, 0xF9, 0xF0, 0x0F, 0xFF, 0xFC, 0x1E, 0x00,
  0xFF, 0xFF, 0x01, 0xE0, 0x07, 0xFF, 0x80, 0x3E, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0xF3, 0xCE, 0x39, 0xE7, 0x9E, 0x71, 0xC7, 0x3C, 0xF3, 0x8E,
  0x38, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x01, 0x00,
  0x0E, 0x00, 0x27, 0x00, 0x38, 0x03, 0xFF, 0x80, 0xE0, 0x7F, 0xFF, 0x83,
  0x87, 0xFD, 0xFF, 0x9C, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x07, 0xC7, 0x80, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x3E,
  0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x80, 0x07, 0x80, 0x3C, 0x00,
  0x1F, 0x00, 0x60, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC1, 0xE0, 0x78, 0x1E,
  0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0x83, 0xE0, 0xF0, 0x78, 0x3E,
  0x0F, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7D, 0xFF, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x3C, 0x03,
  0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x3C,
  0x7C, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x3F, 0x1E, 0x00, 0x00, 0x3F,
  0x8F, 0x00, 0x00, 0x3F, 0xCF, 0x00, 0x00, 0x7F, 0xE7, 0x80, 0x00, 0x7D,
  0xE3, 0xC0, 0x00, 0x7C, 0xF1, 0xE0, 0x00, 0x7C, 0x78, 0xF0, 0x00, 0x7C,
  0x3C, 0xF0, 0x00, 0xF8, 0x1E, 0x78, 0x00, 0xF8, 0x0F, 0x3C, 0x00, 0xF8,
  0x07, 0x9E, 0x01, 0xF0, 0x07, 0x8F, 0x01, 0xF0, 0x03, 0xC7, 0x81, 0xF0,
  0x01, 0xE7, 0x81, 0xF0, 0x00, 0xF3, 0xC3, 0xE0, 0x00, 0x79, 0xE3, 0xE0,
  0x00, 0x3C, 0xF3, 0xE0, 0x00, 0x3C, 0x7B, 0xE0, 0x00, 0x1E, 0x3F, 0xC0,
  0x00, 0x0F, 0x1F, 0xC0, 0x00, 0x07, 0x8F, 0xC0, 0x00, 0x07, 0x87, 0xC0,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x07, 0xE0, 0x01, 0xFE, 0x00,
  0xFF, 0xE0, 0x3F, 0xFE, 0x1F, 0xF9, 0xE7, 0xFC, 0x3C, 0x7F, 0x03, 0xC7,
  0x80, 0x3C, 0x60, 0x03, 0xC8, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x1E, 0x03, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00,
  0x3E, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x03, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3D, 0xC0, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x00, 0xF9, 0xE0,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0xF0, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x0F,
  0x80, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x1E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x3F, 0x80, 0x00, 0x1C, 0x7F, 0xF8, 0x00, 0x07, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x3E,
  0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01,
  0xF0, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3E, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x3C, 0x1F, 0xFC, 0x00, 0xF0, 0xFF,
  0xFC, 0x01, 0xE7, 0xFF, 0xFE, 0x03, 0x9F, 0x80, 0xFC, 0x0F, 0x78, 0x00,
  0x7C, 0x1F, 0xE0, 0x00, 0x7C, 0x3F, 0x80, 0x00, 0x78, 0x7E, 0x00, 0x00,
  0xF9, 0xF8, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x1E,
  0xF8, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0xF0, 0xF8,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x1F, 0x01, 0xE0,
  0x00, 0x7C, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x0F, 0xF0, 0x3F, 0x80, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x0F, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x80,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x07,
  0x87, 0xC0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x0F, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x3E,
  0x1E, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x9F,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3E,
  0x78, 0x00, 0x01, 0xF9, 0xE0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7F, 0x0F,
  0x80, 0x03, 0xDC, 0x3F, 0x00, 0x1E, 0xF0, 0x7E, 0x03, 0xF3, 0xC0, 0xFF,
  0xFF, 0x8E, 0x01, 0xFF, 0xFC, 0x78, 0x01, 0xFF, 0xC1, 0xE0, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFC, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x04, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0x04, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03,
  0xFC, 0x1F, 0xC0, 0xFC, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0xF1, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00, 0x1C,
  0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x00, 0x38, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x1E, 0x00, 0xFF, 0x00,
  0xE0, 0x38, 0x07, 0xFF, 0x81, 0xC0, 0xF0, 0x1F, 0x8F, 0x03, 0x81, 0xC0,
  0x78, 0x0E, 0x07, 0x07, 0x81, 0xE0, 0x1C, 0x06, 0x0E, 0x03, 0x80, 0x38,
  0x0C, 0x3C, 0x0F, 0x00, 0x60, 0x18, 0x70, 0x1C, 0x01, 0xC0, 0x31, 0xE0,
  0x70, 0x03, 0x80, 0xE3, 0x80, 0xE0, 0x07, 0x01, 0xC7, 0x03, 0xC0, 0x0C,
  0x03, 0x9E, 0x07, 0x00, 0x38, 0x07, 0x38, 0x0E, 0x00, 0x70, 0x0E, 0x70,
  0x3C, 0x00, 0xE0, 0x1C, 0xE0, 0x70, 0x01, 0x80, 0x31, 0xC0, 0xE0, 0x07,
  0x00, 0xE7, 0x01, 0xC0, 0x0E, 0x01, 0xCE, 0x03, 0x80, 0x1C, 0x03, 0x9C,
  0x0E, 0x00, 0x70, 0x06, 0x38, 0x1C, 0x00, 0xE0, 0x1C, 0x70, 0x38, 0x03,
  0xC0, 0x38, 0xE0, 0x70, 0x0F, 0x80, 0xE1, 0xC0, 0xE0, 0x1F, 0x01, 0xC3,
  0x81, 0xE0, 0x7E, 0x07, 0x07, 0x01, 0xC1, 0xDC, 0x1E, 0x0E, 0x03, 0xFF,
  0x3C, 0x78, 0x1C, 0x07, 0xFC, 0x3F, 0xE0, 0x3C, 0x07, 0xF0, 0x7F, 0x80,
  0x38, 0x03, 0x80, 0x3C, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x20, 0x00, 0x03, 0xF0,
  0x03, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00,
  0x03, 0xC3, 0x80, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x3C,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x00, 0x00, 0x78,
  0x07, 0x80, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00,
  0x3C, 0x0F, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x70, 0x7C, 0x00,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x1E,
  0xF8, 0x00, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x07, 0xF0, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x78, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x01, 0xF8, 0x01, 0xE0, 0x07,
  0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x3C, 0x00, 0x0F, 0xE0, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07,
  0xC1, 0xE0, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00,
  0x3F, 0x80, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x3C, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x03, 0xC7, 0xC0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x7C, 0x3C, 0x00,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x01, 0xF0,
  0x01, 0xE0, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x0F,
  0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x80,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0x3C, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x07,
  0xC0, 0x3C, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x0F, 0x00,
  0x00, 0x7E, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x07, 0x80, 0x00, 0xFE, 0x00,
  0x3C, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFE,
  0x78, 0x00, 0x3F, 0xFF, 0xCF, 0x00, 0x07, 0xFF, 0xF9, 0xE0, 0x00, 0xFF,
  0xFE, 0x3C, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x3C,
  0x3E, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0x1E, 0x0F, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x1F, 0x00,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x07, 0xF0, 0x03,
  0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x00,
  0x1C, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x07,
  0x00, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00,
  0x00, 0x78, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x38, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x01,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0x00,
  0xFC, 0x00, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0x01, 0xE0, 0x03, 0xF0, 0x00,
  0x03, 0xC0, 0x07, 0xE0, 0x00, 0x03, 0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xC0,
  0x1F, 0x80, 0x00, 0x03, 0xC0, 0x3F, 0x00, 0x00, 0x03, 0xC0, 0x7E, 0x00,
  0x00, 0x03, 0xC0, 0xFC, 0x00, 0x00, 0x07, 0x81, 0xF8, 0x00, 0x00, 0x07,
  0x83, 0xF0, 0x00, 0x00, 0x07, 0x87, 0xE0, 0x00, 0x00, 0x07, 0x8F, 0xC0,
  0x00, 0x00, 0x07, 0x9F, 0xC0, 0x00, 0x00, 0x07, 0xBF, 0xE0, 0x00, 0x00,
  0x0F, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFD, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x7C, 0x00,
  0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xEE,
  0x00, 0x07, 0xBC, 0x03, 0xDC, 0x00, 0x0F, 0x70, 0x07, 0xB8, 0x00, 0x3C,
  0xE0, 0x0E, 0x78, 0x00, 0x7B, 0xC0, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x79,
  0xE0, 0x07, 0xCF, 0x00, 0xF1, 0xC0, 0x0F, 0x1E, 0x01, 0xE3, 0x80, 0x3C,
  0x38, 0x03, 0xC7, 0x00, 0x78, 0xF0, 0x07, 0x0F, 0x01, 0xE1, 0xE0, 0x1E,
  0x1E, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x0F, 0x07, 0x80, 0x78, 0x38, 0x1E,
  0x0F, 0x00, 0xF0, 0x70, 0x78, 0x1C, 0x01, 0xE0, 0xE0, 0xF0, 0x78, 0x03,
  0x81, 0xE3, 0xC0, 0xF0, 0x0F, 0x03, 0xC7, 0x81, 0xE0, 0x1E, 0x03, 0x9E,
  0x03, 0xC0, 0x3C, 0x07, 0x78, 0x07, 0x80, 0x78, 0x0E, 0xF0, 0x1E, 0x00,
  0xF0, 0x1F, 0xC0, 0x3C, 0x01, 0xC0, 0x3F, 0x80, 0x78, 0x07, 0x80, 0x7E,
  0x00, 0xF0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x03, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1E, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xC0,
  0x3F, 0x80, 0x00, 0x07, 0x80, 0x7F, 0x80, 0x00, 0x1E, 0x00, 0xFF, 0x00,
  0x00, 0x3C, 0x01, 0xFE, 0x00, 0x00, 0x78, 0x03, 0xDE, 0x00, 0x00, 0xF0,
  0x07, 0xBC, 0x00, 0x01, 0xE0, 0x1E, 0x78, 0x00, 0x03, 0xC0, 0x3C, 0x78,
  0x00, 0x0F, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x00, 0xF1, 0xE0, 0x00, 0x3C,
  0x01, 0xE1, 0xE0, 0x00, 0x78, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0x0F, 0x07,
  0x80, 0x01, 0xE0, 0x1E, 0x07, 0x80, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x0F,
  0x00, 0x78, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x01, 0xE0,
  0x3C, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x78,
  0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x03, 0xC0,
  0xF0, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x1E,
  0x00, 0x0F, 0x07, 0x80, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0xF8, 0x00, 0x1C,
  0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x78, 0x03, 0xC0, 0x00, 0x78, 0xF0, 0x07,
  0x80, 0x00, 0x79, 0xE0, 0x0F, 0x00, 0x00, 0xF3, 0xC0, 0x1E, 0x00, 0x01,
  0xE7, 0x80, 0x78, 0x00, 0x01, 0xEF, 0x00, 0xF0, 0x00, 0x03, 0xFC, 0x01,
  0xE0, 0x00, 0x07, 0xF8, 0x03, 0xC0, 0x00, 0x07, 0xF0, 0x07, 0x80, 0x00,
  0x0F, 0xE0, 0x0F, 0x00, 0x00, 0x1F, 0xC0, 0x3C, 0x00, 0x00, 0x1F, 0x80,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0xF0, 0x07, 0xC0, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x7C, 0x00,
  0x00, 0x38, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x00, 0xF1, 0xF0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x03, 0x9E, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x07,
  0xC1, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x1E, 0x00,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0x3C, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x07,
  0xC0, 0x78, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x3C, 0x00,
  0x00, 0x3E, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x7E, 0x00,
  0x78, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x0F, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x3E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x7C, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x3C, 0x70,
  0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x00, 0xF8, 0x78, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x3F, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00,
  0xF8, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x07, 0x80,
  0x00, 0xFC, 0x00, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x07,
  0xC0, 0x78, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x00, 0x3E, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x3E, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x00, 0x78, 0xF8, 0x00,
  0x00, 0x0F, 0x87, 0x80, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x0F, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x1F, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x03, 0x80, 0xF0, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x0F, 0x01, 0xC0,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x7C, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00,
  0x3E, 0xF0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x3E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00,
  0x07, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3D, 0xE0, 0x01,
  0xE0, 0x00, 0xE7, 0x80, 0x07, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x00, 0x1E,
  0x78, 0x00, 0xF8, 0x00, 0x71, 0xE0, 0x03, 0xE0, 0x03, 0xC7, 0x80, 0x0F,
  0x80, 0x0F, 0x1E, 0x00, 0x7E, 0x00, 0x3C, 0x78, 0x01, 0xF8, 0x00, 0xE1,
  0xE0, 0x07, 0xE0, 0x07, 0x87, 0x80, 0x3F, 0xC0, 0x1E, 0x1E, 0x00, 0xEF,
  0x00, 0x70, 0x78, 0x03, 0xBC, 0x03, 0xC1, 0xE0, 0x1E, 0xF0, 0x0F, 0x07,
  0x80, 0x73, 0xC0, 0x3C, 0x1E, 0x01, 0xCF, 0x01, 0xE0, 0x78, 0x0F, 0x3C,
  0x07, 0x81, 0xE0, 0x38, 0xF0, 0x1E, 0x07, 0x80, 0xE3, 0xC0, 0x70, 0x1E,
  0x07, 0x8F, 0x03, 0xC0, 0x78, 0x1C, 0x3C, 0x0F, 0x01, 0xE0, 0xF0, 0x70,
  0x38, 0x07, 0x83, 0xC1, 0xC1, 0xE0, 0x1E, 0x0E, 0x07, 0x07, 0x80, 0x78,
  0x78, 0x1C, 0x1E, 0x01, 0xE1, 0xE0, 0x70, 0x70, 0x07, 0x87, 0x01, 0xC3,
  0xC0, 0x1C, 0x3C, 0x07, 0x0F, 0x00, 0x70, 0xF0, 0x1C, 0x38, 0x01, 0xC3,
  0x80, 0x71, 0xE0, 0x07, 0x1E, 0x01, 0xC7, 0x80, 0x1C, 0x78, 0x07, 0x1E,
  0x00, 0x71, 0xC0, 0x1C, 0x70, 0x01, 0xCF, 0x00, 0x73, 0xC0, 0x07, 0x3C,
  0x01, 0xCF, 0x00, 0x1C, 0xE0, 0x07, 0x38, 0x00, 0x77, 0x80, 0x1D, 0xE0,
  0x01, 0xDE, 0x00, 0x77, 0x80, 0x07, 0x70, 0x01, 0xDC, 0x00, 0x1F, 0xC0,
  0x07, 0x70, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x00, 0x01, 0xE7, 0xC0, 0x00,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x87, 0x80, 0x00, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xC0, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x3F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x1F, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x03, 0x81,
  0xE0, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00,
  0xE3, 0xC0, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0x70, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3D, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x3C, 0x00,
  0x0F, 0x0E, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x83, 0xC0, 0x07, 0x81, 0xE0,
  0x03, 0xC0, 0xF0, 0x03, 0xC0, 0x38, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0F,
  0x01, 0xE0, 0x07, 0x80, 0xF0, 0x01, 0xC0, 0xF0, 0x00, 0xE0, 0x78, 0x00,
  0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x3C, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x70, 0x3C,
  0x0E, 0x03, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x1F, 0x80, 0x7E,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0x00, 0x03,
  0xC3, 0xF0, 0x00, 0x07, 0x0F, 0x80, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3E, 0x3C,
  0x00, 0x00, 0xFC, 0x78, 0x00, 0x03, 0xF8, 0xF8, 0x00, 0x1F, 0xF0, 0xF8,
  0x00, 0x7D, 0xE1, 0xFC, 0x07, 0xF3, 0xC1, 0xFF, 0xFF, 0x87, 0x81, 0xFF,
  0xFE, 0x0F, 0x00, 0xFF, 0xF0, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x3C, 0x00, 0x03, 0xC1, 0xFF, 0xC0, 0x01, 0xE3, 0xFF,
  0xF8, 0x00, 0xF3, 0xFF, 0xFE, 0x00, 0x7B, 0xF0, 0x3F, 0x80, 0x3F, 0xC0,
  0x07, 0xC0, 0x1F, 0xC0, 0x01, 0xF0, 0x1F, 0xC0, 0x00, 0x78, 0x0F, 0xC0,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x03, 0xC1, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F,
  0x83, 0xC0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x07, 0x81, 0xF8, 0x00, 0x07,
  0xC0, 0xFE, 0x00, 0x07, 0xC0, 0x7F, 0x80, 0x0F, 0xC0, 0x3D, 0xF0, 0x1F,
  0xC0, 0x1C, 0x7F, 0xFF, 0xC0, 0x1E, 0x1F, 0xFF, 0xC0, 0x0F, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xC0,
  0x3F, 0x00, 0x7E, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x1E, 0x03, 0xE0, 0x00,
  0x1E, 0x0F, 0x80, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00,
  0x79, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x00,
  0x5E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x3E, 0x1E, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x78,
  0x00, 0x1F, 0xFC, 0x0F, 0x00, 0x0F, 0xFF, 0xE1, 0xE0, 0x03, 0xFF, 0xFE,
  0x7C, 0x00, 0xFE, 0x03, 0xEF, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0x80,
  0x01, 0xFC, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x78, 0x00, 0x03, 0xF0, 0x1F,
  0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x1E,
  0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x3F, 0xC0,
  0x03, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0xCF, 0x00, 0x03, 0xFF, 0xF1,
  0xE0, 0x00, 0x3F, 0xF8, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1E, 0x0F,
  0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x7C,
  0x00, 0x00, 0x0F, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xF8, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x20, 0x3E, 0x00, 0x00, 0x70, 0x1F, 0x00, 0x01, 0xF8, 0x0F,
  0x80, 0x03, 0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x0C, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x3C, 0x00, 0x3F, 0xFF, 0x87, 0x80, 0x0F, 0xFF,
  0xF8, 0xF0, 0x03, 0xF8, 0x0F, 0xBC, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x3E,
  0x00, 0x07, 0xF0, 0x0F, 0x80, 0x00, 0x7E, 0x01, 0xE0, 0x00, 0x0F, 0xC0,
  0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1F, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x78, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0xFF,
  0x00, 0x0F, 0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0xFF, 0x3C, 0x00, 0x0F, 0xFF,
  0xC7, 0x80, 0x00, 0xFF, 0xE0, 0xF0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x02, 0x00, 0x00, 0x3C,
  0x00, 0xE0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x03, 0xC0, 0x7F, 0xE0, 0x01, 0xE0,
  0xFF, 0xFC, 0x00, 0xF1, 0xFF, 0xFF, 0x00, 0x79, 0xF8, 0x1F, 0xC0, 0x39,
  0xE0, 0x03, 0xE0, 0x3D, 0xE0, 0x00, 0xF8, 0x1F, 0xC0, 0x00, 0x3C, 0x0F,
  0xC0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x07, 0x83,
  0xE0, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x7C, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x07, 0xC0, 0x3C, 0x00,
  0x03, 0xE0, 0x1E, 0x00, 0x03, 0xF0, 0x07, 0x80, 0x01, 0xF8, 0x01, 0xE0,
  0x00, 0xFC, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0x07,
  0x80, 0x3F, 0x00, 0x03, 0xC0, 0x1F, 0x80, 0x00, 0xF0, 0x0F, 0xC0, 0x00,
  0x3C, 0x07, 0xC0, 0x00, 0x0F, 0x07, 0xE0, 0x00, 0x03, 0xC3, 0xF0, 0x00,
  0x00, 0xF1, 0xF8, 0x00, 0x00, 0x78, 0xFC, 0x00, 0x00, 0x1E, 0x7F, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x9F,
  0x00, 0x00, 0x3F, 0x83, 0xC0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x00, 0xF8,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00,
  0xF8, 0x0F, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC7, 0xFC,
  0x07, 0xF8, 0x01, 0xCF, 0xFE, 0x1F, 0xFC, 0x03, 0xDF, 0xFF, 0x3F, 0xFE,
  0x03, 0xFC, 0x1F, 0x78, 0x1F, 0x03, 0xF0, 0x0F, 0xF0, 0x0F, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x07,
  0x80, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x07, 0x00, 0x0F,
  0x00, 0x0E, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x0F, 0x00, 0x0F, 0x00, 0x1E,
  0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x0F, 0x00,
  0x1E, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x1E,
  0x00, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x1C, 0x00, 0x3C,
  0x00, 0x38, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x00, 0x78,
  0x3C, 0x00, 0x38, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x38, 0x00,
  0x78, 0x00, 0x78, 0x38, 0x00, 0x78, 0x00, 0x70, 0x78, 0x00, 0x78, 0x00,
  0xF0, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x78,
  0x00, 0xF0, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x3F, 0xF0, 0x00, 0xF0,
  0x7F, 0xFE, 0x00, 0x70, 0xFF, 0xFF, 0x80, 0x38, 0xFC, 0x0F, 0xE0, 0x3C,
  0xF0, 0x01, 0xF0, 0x1E, 0xF0, 0x00, 0x7C, 0x0F, 0xE0, 0x00, 0x1E, 0x07,
  0xE0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x03, 0xC1,
  0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x87, 0xC0, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x01, 0xF0, 0xF0, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x01,
  0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3C, 0x0F,
  0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1F, 0x3E,
  0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3E, 0xF0,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x00, 0xF8, 0x78, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x1F, 0xFC, 0x00,
  0x0F, 0x1F, 0xFF, 0xC0, 0x03, 0xCF, 0xFF, 0xF8, 0x00, 0xE7, 0xC0, 0x7F,
  0x00, 0x3B, 0xC0, 0x07, 0xC0, 0x1F, 0xE0, 0x00, 0xF8, 0x07, 0xE0, 0x00,
  0x1E, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x01, 0xF0, 0x1E, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0x7C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x03, 0xC0, 0x7E, 0x00, 0x01, 0xF0, 0x1F, 0xC0, 0x00, 0xF8, 0x07,
  0xF8, 0x00, 0xFC, 0x01, 0xEF, 0x80, 0xFE, 0x00, 0xF9, 0xFF, 0xFF, 0x00,
  0x3C, 0x3F, 0xFF, 0x80, 0x0F, 0x07, 0xFF, 0x80, 0x03, 0xC0, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x0F, 0x00, 0x7F, 0xFF, 0x0F, 0x00, 0xFF, 0xFF, 0x8F,
  0x01, 0xFC, 0x07, 0xDE, 0x03, 0xF0, 0x01, 0xFE, 0x07, 0xC0, 0x00, 0xFE,
  0x0F, 0x80, 0x00, 0x7E, 0x0F, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x3E,
  0x1E, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C,
  0x7C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xE0,
  0x78, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0xE0, 0x3E, 0x00, 0x3F, 0xC0,
  0x1F, 0x80, 0xFF, 0xC0, 0x1F, 0xFF, 0xF3, 0xC0, 0x07, 0xFF, 0xE3, 0xC0,
  0x03, 0xFF, 0x83, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x07, 0x80, 0xFF, 0xF0, 0x1C, 0x0F, 0xFF, 0xC0,
  0xF0, 0xFF, 0xFF, 0x03, 0xC7, 0xFC, 0x3C, 0x0F, 0x3F, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x7C, 0x00, 0x1F, 0x81, 0xF0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x7C,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x0F, 0xC0, 0xFE,
  0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8,
  0x02, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1F,
  0x1F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x03, 0xE0,
  0x78, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x1F, 0xE0,
  0x3E, 0x00, 0x3D, 0xE0, 0x3F, 0x01, 0xF9, 0xE0, 0x1F, 0xFF, 0xF1, 0xC0,
  0x0F, 0xFF, 0xE3, 0xC0, 0x07, 0xFF, 0x83, 0xC0, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x0F, 0x83, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xF0, 0x3C, 0x00,
  0x00, 0x78, 0x07, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x03, 0xE0, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x03, 0xC0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x70,
  0x78, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x7F, 0x80, 0x07, 0x80, 0x03, 0xBC,
  0x00, 0x3C, 0x00, 0x3D, 0xE0, 0x01, 0xE0, 0x01, 0xEF, 0x00, 0x1F, 0x00,
  0x0E, 0x78, 0x00, 0xF8, 0x00, 0xF3, 0xC0, 0x0F, 0xC0, 0x07, 0x9E, 0x00,
  0x7E, 0x00, 0x78, 0xF0, 0x07, 0xF0, 0x03, 0xC7, 0x80, 0x3B, 0xC0, 0x1C,
  0x3C, 0x01, 0xDE, 0x01, 0xE1, 0xE0, 0x1E, 0xF0, 0x0F, 0x0F, 0x00, 0xE3,
  0x80, 0x70, 0x38, 0x0F, 0x1C, 0x07, 0x81, 0xC0, 0x70, 0xE0, 0x38, 0x0E,
  0x03, 0x87, 0x01, 0xC0, 0x70, 0x38, 0x38, 0x1E, 0x03, 0x81, 0xC1, 0xC0,
  0xE0, 0x1C, 0x1E, 0x0E, 0x0F, 0x00, 0xE0, 0xE0, 0x70, 0x78, 0x07, 0x0F,
  0x03, 0x83, 0x80, 0x38, 0x70, 0x1C, 0x3C, 0x01, 0xC3, 0x80, 0xE1, 0xC0,
  0x0E, 0x38, 0x07, 0x0E, 0x00, 0x71, 0xC0, 0x3C, 0xF0, 0x03, 0x9E, 0x00,
  0xE7, 0x00, 0x1C, 0xE0, 0x07, 0x78, 0x00, 0xE7, 0x00, 0x3B, 0x80, 0x07,
  0x70, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x00, 0x07, 0x9F, 0x00,
  0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x00, 0x1F, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x00, 0x03,
  0xE0, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x07, 0xC0,
  0x00, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x0F, 0x80, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x78,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x70, 0x7F, 0xFC, 0x00, 0x01, 0xC3, 0xFF, 0xF8,
  0x00, 0x07, 0x1F, 0x03, 0xF0, 0x00, 0x3C, 0xF8, 0x03, 0xE0, 0x00, 0xE3,
  0xC0, 0x07, 0xC0, 0x07, 0x9E, 0x00, 0x0F, 0xC0, 0x3C, 0x70, 0x00, 0x1F,
  0xC3, 0xF1, 0xC0, 0x00, 0x3F, 0xFF, 0x8F, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00,
};

const GFXglyph RobotoMono_LightItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 13, 50, 41, 14, -50 },
  { 83, 16, 16, 41, 16, -53 },
  { 115, 41, 50, 41, 1, -50 },
  { 372, 34, 64, 41, 4, -57 },
  { 644, 34, 52, 41, 4, -51 },
  { 865, 35, 52, 41, 3, -51 },
  { 1093, 6, 16, 41, 20, -53 },
  { 1105, 22, 72, 41, 12, -56 },
  { 1303, 22, 72, 41, 6, -56 },
  { 1501, 30, 31, 41, 9, -50 },
  { 1618, 34, 36, 41, 4, -41 },
  { 1771, 10, 16, 41, 8, -6 },
  { 1791, 25, 3, 41, 8, -24 },
  { 1801, 7, 6, 41, 15, -6 },
  { 1807, 33, 54, 41, 5, -50 },
  { 2030, 33, 52, 41, 5, -51 },
  { 2245, 20, 50, 41, 10, -50 },
  { 2370, 34, 50, 41, 1, -50 },
  { 2583, 34, 51, 41, 2, -50 },
  { 2800, 35, 50, 41, 1, -50 },
  { 3019, 34, 51, 41, 6, -50 },
  { 3236, 31, 51, 41, 4, -50 },
  { 3434, 32, 50, 41, 8, -50 },
  { 3634, 35, 51, 41, 4, -50 },
  { 3858, 30, 50, 41, 7, -50 },
  { 4046, 12, 36, 41, 17, -36 },
  { 4100, 16, 46, 41, 13, -36 },
  { 4192, 31, 29, 41, 6, -37 },
  { 4305, 32, 17, 41, 5, -31 },
  { 4373, 32, 29, 41, 4, -37 },
  { 4489, 27, 50, 41, 10, -50 },
  { 4658, 39, 50, 41, 2, -50 },
  { 4902, 35, 50, 41, 0, -50 },
  { 5121, 35, 50, 41, 3, -50 },
  { 5340, 35, 51, 41, 4, -50 },
  { 5564, 37, 50, 41, 2, -50 },
  { 5796, 37, 50, 41, 3, -50 },
  { 6028, 38, 50, 41, 3, -50 },
  { 6266, 35, 51, 41, 4, -50 },
  { 6490, 39, 50, 41, 2, -50 },
  { 6734, 36, 50, 41, 3, -50 },
  { 6959, 37, 51, 41, 2, -50 },
  { 7195, 40, 50, 41, 3, -50 },
  { 7445, 29, 50, 41, 4, -50 },
  { 7627, 39, 50, 41, 2, -50 },
  { 7871, 39, 50, 41, 2, -50 },
  { 8115, 34, 51, 41, 4, -50 },
  { 8332, 37, 50, 41, 4, -50 },
  { 8564, 36, 59, 41, 3, -50 },
  { 8830, 36, 50, 41, 3, -50 },
  { 9055, 36, 51, 41, 3, -50 },
  { 9285, 35, 50, 41, 8, -50 },
  { 9504, 37, 51, 41, 4, -50 },
  { 9740, 34, 50, 41, 8, -50 },
  { 9953, 38, 50, 41, 6, -50 },
  { 10191, 42, 50, 41, 0, -50 },
  { 10454, 35, 50, 41, 8, -50 },
  { 10673, 38, 50, 41, 1, -50 },
  { 10911, 22, 68, 41, 10, -57 },
  { 11098, 14, 54, 41, 14, -50 },
  { 11193, 22, 68, 41, 9, -57 },
  { 11380, 25, 27, 41, 8, -50 },
  { 11465, 29, 3, 41, 2, 0 },
  { 11476, 9, 9, 41, 20, -51 },
  { 11487, 31, 39, 41, 4, -38 },
  { 11639, 33, 54, 41, 3, -53 },
  { 11862, 31, 39, 41, 5, -38 },
  { 12014, 35, 54, 41, 5, -53 },
  { 12251, 32, 39, 41, 4, -38 },
  { 12407, 35, 54, 41, 8, -54 },
  { 12644, 35, 53, 41, 2, -38 },
  { 12876, 33, 53, 41, 3, -53 },
  { 13095, 29, 50, 41, 4, -50 },
  { 13277, 31, 65, 41, 1, -50 },
  { 13529, 34, 53, 41, 4, -53 },
  { 13755, 29, 53, 41, 4, -53 },
  { 13948, 40, 38, 41, -1, -38 },
  { 14138, 33, 38, 41, 3, -38 },
  { 14295, 32, 39, 41, 4, -38 },
  { 14451, 34, 52, 41, 1, -38 },
  { 14672, 32, 52, 41, 5, -38 },
  { 14880, 30, 38, 41, 8, -38 },
  { 15023, 31, 39, 41, 5, -38 },
  { 15175, 28, 47, 41, 8, -46 },
  { 15340, 32, 38, 41, 5, -37 },
  { 15492, 34, 37, 41, 6, -37 },
  { 15650, 37, 37, 41, 5, -37 },
  { 15822, 38, 37, 41, 1, -37 },
  { 15998, 42, 52, 41, -1, -37 },
  { 16271, 35, 37, 41, 2, -37 },
  { 16433, 27, 69, 41, 11, -55 },
  { 16666, 13, 61, 41, 14, -50 },
  { 16766, 27, 69, 41, 6, -55 },
  { 16999, 38, 13, 41, 1, -27 },
};

const GFXfont RobotoMono_LightItalic70pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic70pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic70pt7bGlyphs,
  0x20, 0x7E, 92
};

#endif // _ROBOTOMONO_LIGHTITALIC70PT7B_H_
