#ifndef _ROBOTOMONO_LIGHTITALIC36PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x0C, 0x30, 0x60, 0xC1, 0x83, 0x0E, 0x18, 0x30, 0x60, 0xC1,
  0x87, 0x0C, 0x18, 0x30, 0x60, 0x00, 0x00, 0x00, 0x00, 0x30, 0xE1, 0xC0,
  0x61, 0x63, 0x63, 0x63, 0x43, 0x42, 0xC2, 0xC6, 0x00, 0x18, 0x30, 0x00,
  0xC1, 0x80, 0x04, 0x08, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x10, 0x20,
  0x01, 0x83, 0x00, 0x0C, 0x18, 0x0F, 0xFF, 0xF8, 0x86, 0x0C, 0x00, 0x20,
  0x60, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0x81, 0x80, 0x0C, 0x18, 0x00,
  0x60, 0xC0, 0x02, 0x04, 0x03, 0xFF, 0xFF, 0x3F, 0xFF, 0xF0, 0x08, 0x10,
  0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x60, 0x40, 0x03, 0x06, 0x00, 0x18,
  0x30, 0x01, 0x83, 0x00, 0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x78, 0x70, 0x38, 0x0E, 0x0C,
  0x01, 0x83, 0x00, 0x61, 0x80, 0x18, 0x60, 0x06, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x33, 0x80, 0x0C, 0x60,
  0x07, 0x18, 0x01, 0x86, 0x00, 0xE0, 0xC0, 0x70, 0x3F, 0xF8, 0x03, 0xF8,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x1F, 0x80, 0x18, 0x60, 0x0C, 0x30, 0x24, 0x08, 0x36, 0x0C, 0x33, 0x06,
  0x19, 0x83, 0x18, 0xC1, 0x18, 0x31, 0x88, 0x1F, 0x8C, 0x03, 0x0C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x3E, 0x03, 0x3B, 0x83, 0x30,
  0xC3, 0x18, 0x21, 0x08, 0x11, 0x84, 0x09, 0x86, 0x0C, 0x83, 0x06, 0x00,
  0x82, 0x00, 0x63, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x3F, 0x80, 0x0E,
  0x18, 0x01, 0x83, 0x00, 0x60, 0x30, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x30,
  0x70, 0x06, 0x1C, 0x00, 0xE7, 0x00, 0x0D, 0x80, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x0F, 0x80, 0x07, 0x30, 0x08, 0xC3, 0x06, 0x30, 0x70, 0xCE, 0x06,
  0x19, 0x80, 0x66, 0x30, 0x0C, 0xC6, 0x00, 0xF0, 0xC0, 0x1E, 0x18, 0x03,
  0x83, 0x80, 0xF8, 0x3E, 0xF3, 0x81, 0xFC, 0x38, 0x6D, 0xB6, 0xB6, 0x00,
  0x20, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x0C, 0x03,
  0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03,
  0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0E,
  0x00, 0xC0, 0x02, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x30,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x40, 0x83, 0xF8, 0x8F, 0x3F, 0xFE, 0x07, 0xE0, 0x03,
  0x80, 0x06, 0xC0, 0x0E, 0x60, 0x1C, 0x60, 0x38, 0x30, 0x70, 0x38, 0x20,
  0x10, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x01, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x19, 0xCE, 0x63, 0x31, 0x98, 0xFF,
  0xF8, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0xC1, 0xC1, 0xC0, 0x60,
  0xC0, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x60, 0x03, 0x30, 0x03, 0x98, 0x07,
  0xCC, 0x07, 0x6C, 0x06, 0x36, 0x06, 0x1B, 0x0E, 0x0D, 0x8E, 0x0E, 0xCC,
  0x06, 0x6C, 0x03, 0x7C, 0x01, 0xBC, 0x00, 0xC8, 0x00, 0xC6, 0x00, 0x63,
  0x00, 0x61, 0x80, 0x70, 0x60, 0x70, 0x3E, 0xF0, 0x07, 0xF0, 0x00, 0x00,
  0x40, 0x70, 0x7C, 0xFB, 0x70, 0xF0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x00, 0xF8, 0x01, 0xFF,
  0x01, 0xC1, 0xC1, 0x80, 0x61, 0x80, 0x18, 0xC0, 0x0C, 0xC0, 0x06, 0x60,
  0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF,
  0xFE, 0x7F, 0xFF, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0xC1, 0xC1, 0xC0,
  0x71, 0xC0, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xD8, 0x00, 0xEC, 0x00,
  0x66, 0x00, 0x31, 0x80, 0x30, 0xE0, 0x38, 0x3E, 0xF8, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1B, 0x00,
  0x0E, 0xC0, 0x07, 0x30, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x61, 0x80, 0x30,
  0x60, 0x1C, 0x18, 0x06, 0x06, 0x03, 0x03, 0x81, 0x80, 0xC0, 0xC0, 0x30,
  0x70, 0x0C, 0x18, 0x03, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07,
  0xFF, 0xC1, 0xFF, 0xF0, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x7F, 0x00,
  0xFF, 0xF0, 0x38, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x0E, 0x30, 0x03,
  0x0E, 0x01, 0xC1, 0x80, 0xE0, 0x3C, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x7E, 0x01, 0xF0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x31, 0xF0, 0x37, 0xF8, 0x6E, 0x1C, 0x78, 0x0E,
  0x70, 0x06, 0x60, 0x07, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x06,
  0xC0, 0x06, 0xE0, 0x06, 0x60, 0x0C, 0x60, 0x1C, 0x30, 0x38, 0x3E, 0xF0,
  0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0xFF, 0xC0, 0x78, 0x38, 0x38, 0x06, 0x0C, 0x01, 0xC7, 0x00, 0x31,
  0x80, 0x0C, 0x60, 0x07, 0x18, 0x01, 0x86, 0x00, 0xE0, 0xC0, 0x30, 0x38,
  0x38, 0x03, 0xF8, 0x01, 0xFF, 0x01, 0xC0, 0xE0, 0xE0, 0x18, 0x70, 0x03,
  0x18, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x03, 0x38, 0x01, 0xC6,
  0x00, 0xE1, 0xC0, 0x70, 0x3E, 0xF8, 0x03, 0xF8, 0x00, 0x01, 0xF0, 0x07,
  0xFC, 0x0E, 0x0C, 0x18, 0x06, 0x38, 0x06, 0x30, 0x03, 0x60, 0x03, 0x60,
  0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x07, 0x60,
  0x0E, 0x30, 0x1E, 0x38, 0x76, 0x1F, 0xE6, 0x07, 0x0C, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x3F, 0x00, 0x7C,
  0x00, 0x1C, 0xF1, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0xE3, 0x80, 0x03, 0x03, 0xC1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x18, 0x0C, 0x0E,
  0x06, 0x03, 0x03, 0x03, 0x00, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3E, 0x01,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x08, 0x3F,
  0xFF, 0x9F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x00,
  0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x80,
  0x00, 0x07, 0xE0, 0x7F, 0xC3, 0xC3, 0x9C, 0x07, 0x60, 0x0D, 0x80, 0x38,
  0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xE0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x0F, 0xF8, 0x01, 0xC0, 0xC0, 0x70, 0x06, 0x06, 0x00, 0x60,
  0xC0, 0x02, 0x18, 0x7E, 0x31, 0x0C, 0x63, 0x31, 0x86, 0x32, 0x10, 0x63,
  0x63, 0x04, 0x36, 0x20, 0x43, 0x42, 0x0C, 0x2C, 0x60, 0xC2, 0xC6, 0x08,
  0x2C, 0x40, 0x86, 0xC4, 0x18, 0x4C, 0x43, 0x8C, 0xC6, 0x78, 0x8C, 0x7C,
  0xF8, 0xC3, 0x06, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x80, 0x1E,
  0xF8, 0x00, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x06, 0x60, 0x01, 0x98, 0x00, 0xC6,
  0x00, 0x30, 0xC0, 0x1C, 0x30, 0x06, 0x0C, 0x03, 0x83, 0x00, 0xC0, 0xC0,
  0x70, 0x30, 0x18, 0x0C, 0x0E, 0x01, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x60,
  0x06, 0x18, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x19, 0x80, 0x07, 0x60, 0x00,
  0xF0, 0x00, 0x30, 0x07, 0xF8, 0x00, 0xFF, 0xE0, 0x18, 0x1E, 0x06, 0x00,
  0xE0, 0xC0, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x38, 0x60, 0x06, 0x0C, 0x00,
  0xC3, 0x00, 0x38, 0x60, 0x0E, 0x0C, 0x07, 0x81, 0xFF, 0xC0, 0x3F, 0xFC,
  0x0E, 0x01, 0xC1, 0x80, 0x1C, 0x30, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x06,
  0x18, 0x00, 0xC7, 0x00, 0x18, 0xC0, 0x06, 0x18, 0x01, 0xC3, 0x00, 0xF0,
  0x7F, 0xFC, 0x1F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x70, 0x70,
  0x38, 0x06, 0x1C, 0x01, 0x86, 0x00, 0x33, 0x80, 0x0C, 0xC0, 0x03, 0x30,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x33,
  0x00, 0x0C, 0xC0, 0x06, 0x18, 0x01, 0x86, 0x00, 0xC0, 0xC0, 0x60, 0x3C,
  0xF0, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0xC0, 0x30, 0x3C, 0x06,
  0x01, 0xC0, 0xC0, 0x1C, 0x18, 0x01, 0x83, 0x00, 0x30, 0xC0, 0x03, 0x18,
  0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x60,
  0x01, 0xCC, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x39, 0xC0,
  0x06, 0x30, 0x01, 0xC6, 0x00, 0x30, 0xC0, 0x0C, 0x18, 0x03, 0x03, 0x01,
  0xC0, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0xFF, 0x80, 0x70, 0x70, 0x38, 0x06, 0x1C, 0x01, 0xC6, 0x00, 0x33,
  0x00, 0x0C, 0xC0, 0x03, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x07, 0xFB, 0x01, 0xFE, 0xC0, 0x01,
  0xB0, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0xE0, 0x03, 0x18, 0x00, 0xC6,
  0x00, 0x70, 0xC0, 0x38, 0x1F, 0xFC, 0x03, 0xFC, 0x00, 0x0C, 0x00, 0x30,
  0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x06, 0x0C, 0x00, 0x61, 0x80, 0x06,
  0x18, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0x41, 0x80, 0x0C, 0x18, 0x00,
  0xC3, 0x00, 0x0C, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x30, 0x01, 0x83, 0x00,
  0x18, 0x20, 0x01, 0x86, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x18, 0x60,
  0x03, 0x06, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C,
  0x00, 0x70, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x7F,
  0xFE, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x60, 0x01, 0x8C, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x03, 0x03, 0x81,
  0xC0, 0x3F, 0xF0, 0x01, 0xFC, 0x00, 0x0C, 0x00, 0x70, 0xC0, 0x0E, 0x0C,
  0x01, 0xC1, 0xC0, 0x38, 0x18, 0x07, 0x01, 0x80, 0xE0, 0x18, 0x1C, 0x01,
  0x83, 0x80, 0x18, 0x70, 0x03, 0x8E, 0x00, 0x31, 0xC0, 0x03, 0x38, 0x00,
  0x37, 0x80, 0x03, 0xFC, 0x00, 0x3C, 0xC0, 0x07, 0x8E, 0x00, 0x70, 0x60,
  0x06, 0x07, 0x00, 0x60, 0x30, 0x06, 0x03, 0x80, 0x60, 0x18, 0x0C, 0x01,
  0xC0, 0xC0, 0x0C, 0x0C, 0x00, 0x60, 0xC0, 0x07, 0x0C, 0x00, 0x30, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x01,
  0xA0, 0xB0, 0x1E, 0x1B, 0x03, 0x61, 0xB0, 0x36, 0x19, 0x06, 0x61, 0x98,
  0xC6, 0x19, 0x8C, 0xC1, 0x99, 0x8C, 0x31, 0x98, 0xC3, 0x1B, 0x0C, 0x30,
  0xB0, 0xC3, 0x0E, 0x1C, 0x30, 0xE1, 0x86, 0x0C, 0x18, 0x60, 0x01, 0x86,
  0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x30, 0x60, 0x03, 0x0C, 0x00, 0x30,
  0xC0, 0x03, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0xE0, 0x03, 0x0E, 0x00,
  0x60, 0xE0, 0x06, 0x0F, 0x00, 0x61, 0xF0, 0x06, 0x1B, 0x80, 0x61, 0x98,
  0x06, 0x19, 0x80, 0xC1, 0x8C, 0x0C, 0x18, 0xC0, 0xC3, 0x8C, 0x0C, 0x30,
  0x60, 0xC3, 0x06, 0x0C, 0x30, 0x61, 0x83, 0x03, 0x18, 0x30, 0x31, 0x86,
  0x03, 0x18, 0x60, 0x19, 0x86, 0x01, 0xB8, 0x60, 0x1F, 0x06, 0x00, 0xF0,
  0x60, 0x0F, 0x0C, 0x00, 0x70, 0xC0, 0x07, 0x0C, 0x00, 0x70, 0x00, 0xF8,
  0x00, 0xFF, 0x80, 0x70, 0x70, 0x38, 0x0C, 0x1C, 0x01, 0x86, 0x00, 0x63,
  0x80, 0x18, 0xC0, 0x03, 0x30, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x0D, 0x80,
  0x07, 0x60, 0x01, 0xB8, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01,
  0xB0, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x1C, 0xC0, 0x06, 0x18, 0x03, 0x86,
  0x01, 0xC0, 0xC0, 0xE0, 0x3F, 0xF0, 0x03, 0xF0, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0xE0, 0x30, 0x1E, 0x06, 0x00, 0xE0, 0xC0, 0x0C, 0x30, 0x01, 0xC6,
  0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0xE3, 0x00, 0x18, 0x60, 0x03, 0x18,
  0x00, 0xC3, 0x00, 0x38, 0x60, 0x3E, 0x0F, 0xFF, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0xFF, 0x80, 0x70, 0x70, 0x38, 0x0E, 0x1C, 0x01, 0x86, 0x00,
  0x73, 0x00, 0x0C, 0xC0, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1B, 0x00, 0x06, 0xC0,
  0x01, 0xB0, 0x00, 0x6C, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x06, 0x38, 0x01,
  0x86, 0x00, 0xC1, 0xC0, 0xE0, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x0F, 0xF0, 0x03, 0xFF, 0x80,
  0xC0, 0xF0, 0x30, 0x0E, 0x18, 0x01, 0x86, 0x00, 0x31, 0x80, 0x0C, 0x60,
  0x03, 0x18, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x0C, 0x30, 0x0E,
  0x0F, 0xFF, 0x03, 0xFF, 0x01, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0E, 0x06,
  0x01, 0x81, 0x80, 0x60, 0x60, 0x1C, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00,
  0x38, 0xC0, 0x06, 0x30, 0x01, 0x80, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x70,
  0x78, 0x30, 0x06, 0x18, 0x01, 0xC6, 0x00, 0x33, 0x80, 0x0C, 0xE0, 0x03,
  0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x33, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0xC6, 0x00, 0x61, 0xC0, 0x78,
  0x3F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x8C,
  0x00, 0x61, 0x80, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x30,
  0x01, 0xC6, 0x00, 0x30, 0xC0, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0,
  0x03, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x18, 0x00, 0x63, 0x00,
  0x0C, 0x60, 0x03, 0x0C, 0x00, 0x60, 0xC0, 0x1C, 0x18, 0x07, 0x03, 0x81,
  0xC0, 0x3F, 0xF0, 0x01, 0xFC, 0x00, 0xC0, 0x01, 0xF0, 0x00, 0x6C, 0x00,
  0x3B, 0x00, 0x0C, 0xE0, 0x03, 0x18, 0x01, 0x86, 0x00, 0x61, 0x80, 0x30,
  0x60, 0x0C, 0x18, 0x06, 0x06, 0x01, 0x80, 0xC0, 0xE0, 0x30, 0x30, 0x0C,
  0x1C, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x30, 0xC0, 0x06, 0x30, 0x01, 0x98,
  0x00, 0x66, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x60, 0x6C, 0x0C, 0x0D, 0x83, 0x81,
  0xB0, 0x70, 0x36, 0x0E, 0x0C, 0xC3, 0xC1, 0x98, 0x68, 0x33, 0x0D, 0x0C,
  0x63, 0x21, 0x8C, 0x64, 0x31, 0x0C, 0x86, 0x23, 0x11, 0x84, 0x62, 0x30,
  0x8C, 0x46, 0x13, 0x09, 0x82, 0x61, 0x30, 0xCC, 0x26, 0x1B, 0x04, 0x83,
  0x60, 0xF0, 0x6C, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x70, 0x3C, 0x0E, 0x07,
  0x01, 0xC0, 0xE0, 0x30, 0x1C, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x18, 0x00,
  0xE0, 0x70, 0x03, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0xE0, 0x06, 0x03, 0x00,
  0x18, 0x18, 0x00, 0x30, 0xE0, 0x00, 0xC7, 0x00, 0x03, 0x98, 0x00, 0x06,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x36, 0x00, 0x01, 0xCC, 0x00, 0x06, 0x30, 0x00, 0x30, 0x60, 0x01,
  0x81, 0x80, 0x0E, 0x07, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x00,
  0x60, 0x70, 0x01, 0x83, 0x80, 0x07, 0x00, 0xC0, 0x01, 0xF8, 0x00, 0x66,
  0x00, 0x31, 0x80, 0x1C, 0x60, 0x06, 0x0C, 0x03, 0x03, 0x01, 0xC0, 0xC0,
  0x60, 0x18, 0x30, 0x06, 0x1C, 0x01, 0x86, 0x00, 0x33, 0x00, 0x0C, 0xC0,
  0x03, 0x60, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x07, 0xF0, 0x7E, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0F, 0xC0, 0xC1,
  0x83, 0x02, 0x06, 0x0C, 0x18, 0x30, 0x30, 0x60, 0xC1, 0x83, 0x03, 0x06,
  0x0C, 0x18, 0x30, 0x30, 0x60, 0xC1, 0x83, 0x03, 0x06, 0x0C, 0x18, 0x30,
  0x07, 0xE0, 0xFC, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x1F, 0x80, 0x00,
  0xC0, 0x06, 0x00, 0x70, 0x02, 0xC0, 0x36, 0x03, 0x30, 0x19, 0x81, 0x84,
  0x0C, 0x30, 0xC1, 0x8E, 0x0C, 0x60, 0x66, 0x01, 0xF0, 0x0C, 0xFF, 0xFF,
  0xFF, 0xFC, 0xE3, 0x8C, 0x30, 0x03, 0xF8, 0x0F, 0xBE, 0x1C, 0x06, 0x38,
  0x03, 0x30, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x07, 0xFF, 0x1F,
  0xFE, 0x38, 0x06, 0x60, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0E, 0xC0,
  0x1C, 0xE0, 0x3C, 0x7F, 0xEC, 0x3F, 0x8C, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x19,
  0xF8, 0x1F, 0xFE, 0x3E, 0x06, 0x38, 0x07, 0x30, 0x03, 0x30, 0x03, 0x30,
  0x03, 0x30, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60,
  0x06, 0x60, 0x06, 0xE0, 0x0E, 0xE0, 0x1C, 0xF0, 0x38, 0xDF, 0xF0, 0xCF,
  0xE0, 0x03, 0xF8, 0x03, 0xDF, 0x03, 0x01, 0xC3, 0x00, 0x63, 0x80, 0x31,
  0x80, 0x19, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x18, 0x30,
  0x1C, 0x1F, 0x78, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x03, 0xF9, 0x83, 0xEF, 0x61, 0xC0, 0x78, 0x60, 0x1C, 0x30, 0x03, 0x0C,
  0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x07, 0x18, 0x01, 0x8C, 0x00,
  0x63, 0x00, 0x18, 0xC0, 0x06, 0x38, 0x01, 0x86, 0x00, 0xE1, 0x80, 0x70,
  0x70, 0x3C, 0x0F, 0xFB, 0x01, 0xFC, 0xC0, 0x03, 0xF8, 0x03, 0xCF, 0x03,
  0x81, 0x83, 0x00, 0x63, 0x00, 0x31, 0x80, 0x19, 0x80, 0x06, 0xC0, 0x07,
  0x7F, 0xFF, 0x7F, 0xFF, 0xB0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x08, 0x30, 0x1E, 0x0F, 0x3C, 0x03, 0xFC, 0x00,
  0x00, 0x02, 0x00, 0x0F, 0xF0, 0x0F, 0x8C, 0x07, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0x8F, 0xFF,
  0xE0, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x01, 0xFC, 0xC1, 0xF7, 0xB0, 0xE0, 0x2C, 0x30, 0x0E,
  0x18, 0x01, 0x86, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x03, 0x8C,
  0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x0C, 0x00, 0xC3, 0x00,
  0x70, 0xC0, 0x38, 0x38, 0x1E, 0x07, 0xFD, 0x80, 0xFE, 0x60, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x03, 0x04, 0x01, 0x83, 0x80, 0xE0, 0x70, 0xF0, 0x0F,
  0xF0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x7E, 0x04,
  0xF7, 0x86, 0xC0, 0xE3, 0xC0, 0x31, 0xC0, 0x18, 0xC0, 0x0C, 0x60, 0x06,
  0x70, 0x03, 0x30, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x63, 0x00,
  0x33, 0x80, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x07, 0x30, 0x03, 0x38,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0xFF,
  0x00, 0x3E, 0x00, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x03,
  0xC6, 0x01, 0xC1, 0x80, 0xE0, 0x60, 0xE0, 0x30, 0x70, 0x0C, 0x38, 0x03,
  0x1C, 0x00, 0xCE, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x07, 0x98, 0x01, 0xC3,
  0x00, 0x60, 0xE0, 0x18, 0x18, 0x06, 0x03, 0x03, 0x80, 0xE0, 0xC0, 0x18,
  0x30, 0x03, 0x0C, 0x00, 0xE0, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x1B, 0xE3, 0xE1, 0xFF,
  0x7F, 0x18, 0x38, 0x33, 0x83, 0x83, 0x30, 0x30, 0x33, 0x03, 0x03, 0x30,
  0x30, 0x33, 0x03, 0x03, 0x20, 0x60, 0x66, 0x06, 0x06, 0x60, 0x60, 0x66,
  0x06, 0x06, 0x60, 0x60, 0x66, 0x06, 0x06, 0xC0, 0xC0, 0xCC, 0x0C, 0x0C,
  0xC0, 0xC0, 0xCC, 0x0C, 0x0C, 0xC0, 0xC0, 0xC0, 0x0C, 0xFE, 0x0C, 0xFF,
  0x86, 0xC0, 0xE3, 0xC0, 0x31, 0xC0, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x70,
  0x03, 0x30, 0x01, 0x98, 0x00, 0xCC, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x33,
  0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x06, 0x30, 0x03, 0x38, 0x01,
  0x80, 0x03, 0xF8, 0x07, 0xDE, 0x07, 0x01, 0x87, 0x00, 0xE3, 0x00, 0x33,
  0x00, 0x19, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xD8, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x33, 0x80, 0x38, 0xC0, 0x18, 0x70,
  0x38, 0x1E, 0x78, 0x07, 0xF8, 0x00, 0x06, 0x7E, 0x01, 0x7F, 0xE0, 0xF0,
  0x18, 0x38, 0x07, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x03,
  0x18, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x07, 0x18, 0x01, 0x8E,
  0x00, 0x63, 0x00, 0x30, 0xE0, 0x1C, 0x3C, 0x0E, 0x0D, 0xDF, 0x03, 0x3F,
  0x81, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x00, 0x03, 0xF9, 0x87, 0xDE, 0xC7, 0x01, 0xE3,
  0x00, 0xE3, 0x00, 0x31, 0x80, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x07,
  0x30, 0x03, 0x30, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x67, 0x00, 0x31, 0x80,
  0x38, 0xC0, 0x38, 0x70, 0x3C, 0x1F, 0x76, 0x07, 0xF3, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x1C, 0x7F, 0x19, 0xFE, 0x1B, 0x80, 0x1E, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0x03, 0xFC, 0x07, 0xDF, 0x07, 0x01, 0xC3, 0x00, 0x63,
  0x80, 0x19, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x33, 0x80, 0x18, 0xC0,
  0x0C, 0x70, 0x0C, 0x1F, 0x7C, 0x07, 0xFC, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x03, 0xFF, 0xFF, 0xFF, 0xC1, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0xFF,
  0x01, 0xFC, 0x30, 0x03, 0x30, 0x03, 0x60, 0x03, 0x60, 0x07, 0x60, 0x06,
  0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0xC0, 0x06, 0xC0, 0x0E, 0xC0, 0x0C,
  0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x1C, 0xC0, 0x3C, 0xE0, 0x78,
  0x7F, 0xD8, 0x3F, 0x98, 0xC0, 0x01, 0xB0, 0x01, 0xD8, 0x00, 0xCC, 0x00,
  0xC6, 0x00, 0x61, 0x80, 0x60, 0xC0, 0x30, 0x60, 0x30, 0x30, 0x38, 0x0C,
  0x18, 0x06, 0x1C, 0x03, 0x0C, 0x01, 0x8C, 0x00, 0x66, 0x00, 0x36, 0x00,
  0x1B, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0x80, 0xC0, 0xF0,
  0x18, 0x1A, 0x07, 0x03, 0x60, 0xA0, 0xCC, 0x34, 0x19, 0x86, 0x82, 0x30,
  0x90, 0xC6, 0x32, 0x18, 0xC4, 0x42, 0x19, 0x88, 0xC3, 0x31, 0x98, 0x6C,
  0x36, 0x0D, 0x86, 0xC1, 0xA0, 0xD0, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xE0,
  0x70, 0x1C, 0x0E, 0x03, 0x00, 0x80, 0x00, 0x1C, 0x00, 0xE1, 0x80, 0x38,
  0x38, 0x0E, 0x03, 0x03, 0x80, 0x30, 0x60, 0x06, 0x18, 0x00, 0x66, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xD8, 0x00,
  0x73, 0x80, 0x1C, 0x30, 0x03, 0x07, 0x00, 0xC0, 0x60, 0x30, 0x06, 0x0C,
  0x00, 0xE3, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x30, 0x00, 0x60, 0xE0,
  0x03, 0x81, 0x80, 0x0C, 0x06, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x30, 0x0C,
  0x00, 0xC0, 0x70, 0x03, 0x01, 0x80, 0x0E, 0x0C, 0x00, 0x18, 0x70, 0x00,
  0x61, 0x80, 0x01, 0x8E, 0x00, 0x03, 0x30, 0x00, 0x0D, 0x80, 0x00, 0x36,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x01, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC7, 0xFF,
  0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0xFF,
  0xCF, 0xFF, 0xF0, 0x00, 0x18, 0x01, 0xC0, 0x38, 0x01, 0x80, 0x18, 0x01,
  0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x03, 0x80, 0xF8, 0x07, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0x80, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x38, 0x00, 0xC0,
  0x06, 0x0C, 0x10, 0x60, 0xC1, 0x83, 0x06, 0x08, 0x10, 0x60, 0xC1, 0x83,
  0x06, 0x08, 0x30, 0x60, 0xC1, 0x83, 0x04, 0x08, 0x30, 0x60, 0xC1, 0x82,
  0x04, 0x18, 0x30, 0x60, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x3C, 0x00, 0x70,
  0x07, 0xC0, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00,
  0x18, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xF0, 0x0D, 0x87,
  0x01, 0xE0, 0x70, 0x6C, 0x07, 0x9D, 0x00, 0x3F, 0x00, 0x01, 0x00,
};

const GFXglyph RobotoMono_LightItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 7, 26, 21, 7, -26 },
  { 24, 8, 8, 21, 8, -27 },
  { 32, 21, 26, 21, 0, -26 },
  { 101, 18, 34, 21, 2, -30 },
  { 178, 17, 26, 21, 2, -26 },
  { 234, 19, 26, 21, 1, -26 },
  { 296, 3, 8, 21, 10, -27 },
  { 299, 11, 37, 21, 6, -29 },
  { 350, 11, 37, 21, 3, -29 },
  { 401, 16, 16, 21, 4, -26 },
  { 433, 18, 18, 21, 2, -21 },
  { 474, 5, 8, 21, 4, -3 },
  { 479, 13, 1, 21, 4, -12 },
  { 481, 3, 3, 21, 8, -3 },
  { 483, 17, 28, 21, 3, -26 },
  { 543, 17, 26, 21, 2, -26 },
  { 599, 10, 26, 21, 5, -26 },
  { 632, 17, 26, 21, 1, -26 },
  { 688, 17, 26, 21, 1, -26 },
  { 744, 18, 26, 21, 1, -26 },
  { 803, 18, 26, 21, 3, -26 },
  { 862, 16, 26, 21, 2, -26 },
  { 914, 17, 26, 21, 4, -26 },
  { 970, 18, 26, 21, 2, -26 },
  { 1029, 16, 26, 21, 3, -26 },
  { 1081, 6, 18, 21, 9, -18 },
  { 1095, 9, 23, 21, 6, -18 },
  { 1121, 16, 15, 21, 3, -19 },
  { 1151, 17, 9, 21, 2, -16 },
  { 1171, 16, 15, 21, 2, -19 },
  { 1201, 14, 26, 21, 5, -26 },
  { 1247, 20, 26, 21, 1, -26 },
  { 1312, 18, 26, 21, 0, -26 },
  { 1371, 19, 26, 21, 1, -26 },
  { 1433, 18, 26, 21, 2, -26 },
  { 1492, 19, 26, 21, 1, -26 },
  { 1554, 19, 26, 21, 2, -26 },
  { 1616, 19, 26, 21, 2, -26 },
  { 1678, 18, 26, 21, 2, -26 },
  { 1737, 20, 26, 21, 1, -26 },
  { 1802, 19, 26, 21, 1, -26 },
  { 1864, 19, 26, 21, 1, -26 },
  { 1926, 20, 26, 21, 2, -26 },
  { 1991, 15, 26, 21, 2, -26 },
  { 2040, 20, 26, 21, 1, -26 },
  { 2105, 20, 26, 21, 1, -26 },
  { 2170, 18, 26, 21, 2, -26 },
  { 2229, 19, 26, 21, 2, -26 },
  { 2291, 18, 30, 21, 2, -26 },
  { 2359, 18, 26, 21, 2, -26 },
  { 2418, 18, 26, 21, 2, -26 },
  { 2477, 18, 26, 21, 4, -26 },
  { 2536, 19, 26, 21, 2, -26 },
  { 2598, 18, 26, 21, 4, -26 },
  { 2657, 19, 26, 21, 3, -26 },
  { 2719, 22, 26, 21, 0, -26 },
  { 2791, 18, 26, 21, 4, -26 },
  { 2850, 19, 26, 21, 1, -26 },
  { 2912, 12, 34, 21, 5, -29 },
  { 2963, 7, 28, 21, 7, -26 },
  { 2988, 11, 34, 21, 5, -29 },
  { 3035, 13, 14, 21, 4, -26 },
  { 3058, 15, 2, 21, 1, 0 },
  { 3062, 5, 4, 21, 10, -26 },
  { 3065, 16, 19, 21, 2, -19 },
  { 3103, 16, 27, 21, 2, -27 },
  { 3157, 17, 19, 21, 2, -19 },
  { 3198, 18, 27, 21, 2, -27 },
  { 3259, 17, 19, 21, 2, -19 },
  { 3300, 18, 28, 21, 4, -28 },
  { 3363, 18, 27, 21, 1, -19 },
  { 3424, 17, 27, 21, 1, -27 },
  { 3482, 15, 26, 21, 2, -26 },
  { 3531, 17, 34, 21, 0, -26 },
  { 3604, 18, 27, 21, 2, -27 },
  { 3665, 15, 27, 21, 2, -27 },
  { 3716, 20, 19, 21, 0, -19 },
  { 3764, 17, 19, 21, 1, -19 },
  { 3805, 17, 19, 21, 2, -19 },
  { 3846, 18, 26, 21, 0, -19 },
  { 3905, 17, 26, 21, 2, -19 },
  { 3961, 16, 19, 21, 4, -19 },
  { 3999, 17, 19, 21, 2, -19 },
  { 4040, 14, 24, 21, 4, -24 },
  { 4082, 16, 19, 21, 3, -19 },
  { 4120, 17, 19, 21, 3, -19 },
  { 4161, 19, 19, 21, 3, -19 },
  { 4207, 19, 19, 21, 1, -19 },
  { 4253, 22, 27, 21, -1, -19 },
  { 4328, 18, 19, 21, 1, -19 },
  { 4371, 13, 35, 21, 6, -28 },
  { 4428, 7, 32, 21, 7, -26 },
  { 4456, 14, 35, 21, 3, -28 },
  { 4518, 19, 7, 21, 1, -14 },
};

const GFXfont RobotoMono_LightItalic36pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic36pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic36pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _ROBOTOMONO_LIGHTITALIC36PT7B_H_
