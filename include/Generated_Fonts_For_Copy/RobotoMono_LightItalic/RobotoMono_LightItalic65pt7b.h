#ifndef _ROBOTOMONO_LIGHTITALIC65PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC65PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0x00, 0x38, 0x1E,
  0x70, 0x3C, 0xE0, 0x71, 0xC0, 0xE7, 0x81, 0xCE, 0x03, 0x9C, 0x07, 0x38,
  0x1C, 0x70, 0x38, 0xE0, 0x73, 0x80, 0xE7, 0x01, 0xCE, 0x07, 0x1C, 0x0E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x03, 0xC0, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x38, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0x80, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x07, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0x80, 0x38, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x3C,
  0x03, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E,
  0x03, 0x80, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x03, 0xE0,
  0x3C, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x7F, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x08, 0x38, 0x03, 0x80, 0x1C, 0x70,
  0x07, 0x00, 0x71, 0xE0, 0x0E, 0x01, 0xE3, 0x80, 0x1C, 0x07, 0x87, 0x00,
  0x38, 0x0E, 0x0E, 0x00, 0x70, 0x38, 0x1C, 0x01, 0xE0, 0xF0, 0x38, 0x03,
  0x81, 0xC0, 0x78, 0x0F, 0x07, 0x00, 0x70, 0x1C, 0x1E, 0x00, 0xF0, 0x78,
  0x78, 0x00, 0xFF, 0xE0, 0xE0, 0x00, 0xFF, 0x83, 0x80, 0x00, 0xFC, 0x0F,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x3F, 0x80, 0x01, 0xC1, 0xFF, 0x80, 0x07, 0x07, 0xFF,
  0x80, 0x1E, 0x1E, 0x07, 0x00, 0x38, 0x38, 0x0F, 0x00, 0xE0, 0xF0, 0x0E,
  0x03, 0xC1, 0xC0, 0x1C, 0x07, 0x03, 0x80, 0x38, 0x1C, 0x0E, 0x00, 0x70,
  0x78, 0x1C, 0x00, 0xE1, 0xE0, 0x38, 0x01, 0xC3, 0x80, 0x70, 0x03, 0x8E,
  0x00, 0xE0, 0x0E, 0x3C, 0x01, 0xC0, 0x1C, 0x10, 0x03, 0x80, 0x38, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01,
  0xFC, 0xFC, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x01, 0xE0, 0x1F, 0x00,
  0x00, 0xF0, 0x1F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x3E, 0x00,
  0x00, 0x0F, 0x3E, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x00, 0xF8, 0x78,
  0x00, 0xE0, 0xF8, 0x3C, 0x00, 0x70, 0xF8, 0x0F, 0x00, 0x78, 0xF8, 0x03,
  0xC0, 0x3C, 0x78, 0x01, 0xE0, 0x1C, 0x78, 0x00, 0x78, 0x1E, 0x3C, 0x00,
  0x3C, 0x0F, 0x3C, 0x00, 0x0F, 0x0F, 0x1E, 0x00, 0x03, 0xC7, 0x8F, 0x00,
  0x01, 0xE7, 0x87, 0x80, 0x00, 0x7B, 0xC3, 0xC0, 0x00, 0x3F, 0xC1, 0xE0,
  0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xF0, 0x1E,
  0x00, 0x03, 0xF8, 0x0F, 0x80, 0x07, 0xFE, 0x03, 0xE0, 0x0F, 0xCF, 0x00,
  0xFF, 0xFF, 0xC3, 0xC0, 0x3F, 0xFF, 0x81, 0xF0, 0x07, 0xFF, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x00, 0x1C, 0xF3, 0xCF, 0x38, 0xE3, 0x9E, 0x79, 0xC7,
  0x1C, 0x73, 0x80, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x40, 0x07, 0x00, 0x17, 0x80,
  0x70, 0x0F, 0x7E, 0x07, 0x07, 0xFF, 0xFC, 0x71, 0xFF, 0x3F, 0xF7, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E, 0x1C,
  0x00, 0x03, 0xE1, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x03, 0xC0, 0x03, 0xC0, 0x1C, 0x00,
  0x38, 0x00, 0x80, 0x01, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x1E, 0x0F,
  0x0F, 0x07, 0x87, 0x87, 0x81, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFE,
  0x7F, 0x80, 0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x7C, 0x00,
  0x0E, 0x00, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1C, 0x0F, 0x00, 0x00,
  0x38, 0x1E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01,
  0xE1, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1F, 0x8F, 0x00, 0x00, 0x7F,
  0x1E, 0x00, 0x01, 0xFE, 0x38, 0x00, 0x07, 0xBC, 0xF0, 0x00, 0x3E, 0x79,
  0xE0, 0x00, 0xF8, 0xF3, 0xC0, 0x03, 0xE1, 0xC7, 0x80, 0x0F, 0x03, 0x8F,
  0x00, 0x7C, 0x0F, 0x1C, 0x01, 0xF0, 0x1E, 0x78, 0x07, 0x80, 0x3C, 0xF0,
  0x1E, 0x00, 0x79, 0xE0, 0xF8, 0x00, 0xE3, 0xC3, 0xE0, 0x01, 0xC7, 0x8F,
  0x00, 0x07, 0x8E, 0x3C, 0x00, 0x0F, 0x1D, 0xF0, 0x00, 0x1E, 0x7F, 0xC0,
  0x00, 0x38, 0xFE, 0x00, 0x00, 0xF1, 0xF8, 0x00, 0x01, 0xE3, 0xE0, 0x00,
  0x03, 0xC3, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00,
  0x38, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x0F,
  0x80, 0x78, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x0F, 0xE0, 0x3F,
  0xF0, 0x7F, 0xF9, 0xFF, 0x3F, 0xFE, 0x1D, 0xF8, 0x0E, 0xF0, 0x0F, 0x40,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xE7, 0xF0, 0x00, 0x7E,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x0E, 0x07, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x01, 0xFE, 0x3F, 0x80, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F,
  0x1C, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x03,
  0xC0, 0x07, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x70, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x07, 0x1F, 0xFC, 0x00, 0x07, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xF0, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x0F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0xFF, 0x80, 0x1C, 0x3F, 0xFE, 0x03, 0xCF, 0xFF, 0xF0,
  0x3D, 0xF8, 0x1F, 0x83, 0xBC, 0x00, 0x7C, 0x3F, 0x80, 0x03, 0xC7, 0xE0,
  0x00, 0x1E, 0x7C, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x0E, 0x78, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xE7,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x78, 0x3C, 0x00,
  0x0F, 0x83, 0xC0, 0x01, 0xF0, 0x1E, 0x00, 0x3E, 0x01, 0xF8, 0x07, 0xC0,
  0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0xF0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xE0, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0E, 0x07, 0x80, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x78, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x03,
  0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00,
  0x78, 0x70, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00,
  0xF0, 0x70, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xF7, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x00, 0x3C, 0x0F, 0x80,
  0x03, 0xE0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x07, 0x78, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x70,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x3E, 0x7C, 0x00, 0x07, 0xE3, 0xC0, 0x00, 0xFE, 0x3E, 0x00, 0x1F, 0xE1,
  0xF0, 0x07, 0xDC, 0x0F, 0xF7, 0xF9, 0xC0, 0x7F, 0xFE, 0x3C, 0x03, 0xFF,
  0x83, 0x80, 0x07, 0xC0, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x3E, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xC0, 0x00, 0x38, 0x00, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x20,
  0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF1,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xF8, 0x0C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xF8, 0x03, 0xE1, 0xF0, 0x00, 0xF0, 0xF0,
  0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xBC,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xCF,
  0xE0, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x1E, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x1F, 0x00, 0xE0, 0x38, 0x07, 0xFC,
  0x0E, 0x07, 0x01, 0xFF, 0xE0, 0x60, 0xF0, 0x3E, 0x0E, 0x06, 0x0E, 0x03,
  0x80, 0xE0, 0x61, 0xE0, 0x70, 0x0E, 0x06, 0x1C, 0x0E, 0x00, 0xC0, 0x61,
  0xC0, 0xE0, 0x0C, 0x06, 0x38, 0x1C, 0x01, 0xC0, 0x63, 0x81, 0xC0, 0x1C,
  0x06, 0x30, 0x38, 0x01, 0x80, 0x67, 0x03, 0x80, 0x38, 0x0E, 0x70, 0x38,
  0x03, 0x80, 0xE7, 0x07, 0x00, 0x38, 0x0E, 0x60, 0x70, 0x03, 0x00, 0xCE,
  0x07, 0x00, 0x70, 0x0C, 0xE0, 0x70, 0x07, 0x01, 0xCE, 0x06, 0x00, 0x60,
  0x1C, 0xE0, 0x60, 0x0E, 0x01, 0x8E, 0x06, 0x00, 0xE0, 0x38, 0xE0, 0xE0,
  0x1E, 0x03, 0x8E, 0x06, 0x03, 0xE0, 0x30, 0xE0, 0x60, 0x7E, 0x07, 0x0E,
  0x07, 0x0E, 0xE0, 0xE0, 0xE0, 0x7F, 0xE7, 0x1C, 0x0E, 0x07, 0xFC, 0x7F,
  0x80, 0xE0, 0x3F, 0x03, 0xF0, 0x06, 0x00, 0x80, 0x08, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x04, 0x00, 0x00, 0xF8, 0x01, 0xE0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1D, 0xE0, 0x00,
  0x00, 0x3C, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x78, 0xE0, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x07, 0x80, 0x70, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x3C, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x0E, 0x3C,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3C, 0x00, 0x7F, 0x80,
  0x1E, 0x00, 0x07, 0xC0, 0x0E, 0x00, 0x01, 0xF0, 0x07, 0x00, 0x00, 0x7C,
  0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x3E, 0x03, 0xC0, 0x00,
  0x3E, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1E, 0x00,
  0x03, 0xE0, 0x0F, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0x07,
  0x80, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x07, 0xE0, 0x78, 0x00, 0x0F, 0xE0,
  0x3C, 0x00, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7E, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3C, 0x03, 0xE0, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0E, 0x0F, 0x00, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0x70, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x7E,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0x80, 0x0F, 0xE0, 0x01, 0xE0,
  0x00, 0xFC, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x07,
  0x80, 0x00, 0x7C, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0xF0, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x07, 0x83, 0x80, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x7C, 0x07, 0x80,
  0x00, 0x3E, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x1E,
  0x00, 0x1F, 0xC0, 0x07, 0x80, 0x3F, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x03, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0xFF, 0x1E, 0x00,
  0x1F, 0xFF, 0x8E, 0x00, 0x0F, 0xFF, 0xC7, 0x00, 0x00, 0x01, 0xE3, 0x80,
  0x00, 0x00, 0xF1, 0xC0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x01, 0xC0,
  0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x0E, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0x3C, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x07, 0x80, 0x70, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x1C,
  0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x1C,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x03, 0xC0, 0x38, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x03, 0x80, 0x78,
  0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x78,
  0x07, 0x00, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x1C,
  0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xF8, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x07, 0x00, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x1F, 0x00, 0x00, 0x38, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x1F, 0x00,
  0x00, 0x1E, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x07, 0x81,
  0xF0, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x01, 0xC1, 0xF0, 0x00, 0x00,
  0x1E, 0x1F, 0x00, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x00, 0x07, 0x9F, 0xC0,
  0x00, 0x00, 0x3D, 0xFE, 0x00, 0x00, 0x01, 0xDF, 0x78, 0x00, 0x00, 0x0F,
  0xF3, 0xC0, 0x00, 0x00, 0xFF, 0x0F, 0x00, 0x00, 0x07, 0xF0, 0x7C, 0x00,
  0x00, 0x3F, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x3C, 0x00,
  0x00, 0x3C, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x17,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x1E, 0xE0, 0x1D, 0xC0, 0x01, 0xFE, 0x03, 0xDC,
  0x00, 0x3D, 0xE0, 0x3D, 0xC0, 0x03, 0xDC, 0x03, 0x9C, 0x00, 0x79, 0xC0,
  0x39, 0xE0, 0x07, 0x9C, 0x03, 0x9E, 0x00, 0xF3, 0xC0, 0x78, 0xE0, 0x0E,
  0x3C, 0x07, 0x8E, 0x01, 0xE3, 0xC0, 0x78, 0xE0, 0x1C, 0x38, 0x07, 0x0E,
  0x03, 0xC3, 0x80, 0x70, 0xF0, 0x38, 0x78, 0x07, 0x07, 0x07, 0x87, 0x80,
  0xF0, 0x70, 0xF0, 0x78, 0x0F, 0x07, 0x0F, 0x07, 0x80, 0xF0, 0x71, 0xE0,
  0x70, 0x0F, 0x07, 0x1E, 0x07, 0x00, 0xE0, 0x7B, 0xC0, 0xF0, 0x0E, 0x03,
  0xB8, 0x0F, 0x01, 0xE0, 0x3F, 0x80, 0xF0, 0x1E, 0x03, 0xF0, 0x0F, 0x01,
  0xE0, 0x3F, 0x00, 0xE0, 0x1E, 0x03, 0xE0, 0x1E, 0x01, 0xC0, 0x3E, 0x01,
  0xE0, 0x1C, 0x01, 0xC0, 0x1E, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x3C, 0x00,
  0x00, 0x1C, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x3C, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x00, 0x78, 0x07, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x0E, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x1F, 0x80, 0x00, 0x1E, 0x01, 0xF8, 0x00, 0x01, 0xE0,
  0x1F, 0x80, 0x00, 0x1E, 0x03, 0xFC, 0x00, 0x01, 0xC0, 0x3F, 0xC0, 0x00,
  0x1C, 0x03, 0xDC, 0x00, 0x03, 0xC0, 0x3D, 0xE0, 0x00, 0x3C, 0x03, 0xDE,
  0x00, 0x03, 0xC0, 0x38, 0xE0, 0x00, 0x3C, 0x07, 0x8F, 0x00, 0x03, 0x80,
  0x78, 0xF0, 0x00, 0x38, 0x07, 0x87, 0x80, 0x07, 0x80, 0x78, 0x78, 0x00,
  0x78, 0x07, 0x83, 0x80, 0x07, 0x80, 0x70, 0x3C, 0x00, 0x78, 0x0F, 0x03,
  0xC0, 0x07, 0x00, 0xF0, 0x1C, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x0F, 0x00,
  0xF0, 0x1E, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x0F, 0x00,
  0xF0, 0x1E, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x07, 0x01, 0xE0, 0x1E, 0x00,
  0x78, 0x1E, 0x01, 0xE0, 0x07, 0x81, 0xE0, 0x1C, 0x00, 0x3C, 0x1E, 0x01,
  0xC0, 0x03, 0xC1, 0xE0, 0x3C, 0x00, 0x1C, 0x1C, 0x03, 0xC0, 0x01, 0xE3,
  0xC0, 0x3C, 0x00, 0x1E, 0x3C, 0x03, 0xC0, 0x00, 0xE3, 0xC0, 0x38, 0x00,
  0x0F, 0x3C, 0x07, 0x80, 0x00, 0xF3, 0x80, 0x78, 0x00, 0x07, 0x38, 0x07,
  0x80, 0x00, 0x7F, 0x80, 0x78, 0x00, 0x07, 0xF8, 0x07, 0x80, 0x00, 0x3F,
  0x80, 0x70, 0x00, 0x03, 0xF8, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0xF0, 0x00,
  0x01, 0xF0, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7E, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F,
  0x38, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x0E,
  0x78, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x1E,
  0x70, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1C,
  0xF0, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x3C,
  0xE0, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x78,
  0xE0, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x80,
  0x3C, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x0E, 0x00,
  0x01, 0xF0, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x0F,
  0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x78,
  0x07, 0x00, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00,
  0x1C, 0x07, 0x80, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x1C, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xE0,
  0x0E, 0x00, 0x00, 0xFC, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0x78, 0x00, 0x7F,
  0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x3C, 0x03,
  0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xC0,
  0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x03,
  0x9E, 0x00, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x00,
  0xF3, 0x80, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x07, 0x9C, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x0F, 0x0E, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x03, 0xC0, 0x0F, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x18, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x3C, 0x00, 0x3F, 0x80, 0x1E, 0x00, 0x07, 0xE0, 0x0F, 0x00,
  0x00, 0xF0, 0x07, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x07, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x1F, 0x80,
  0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x01,
  0xE0, 0x07, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x01, 0xE0, 0x38, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x01, 0xF0,
  0x07, 0xC0, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0xF0,
  0x1F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xE0,
  0x78, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x07,
  0x81, 0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x1C, 0x0F, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x03, 0xC0, 0xE0, 0x00,
  0x00, 0xF0, 0x38, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x03, 0x81, 0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x78, 0x1C,
  0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0F,
  0x03, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0x38, 0x1E, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x07, 0x81, 0xC0, 0x00,
  0x01, 0xE0, 0x70, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x07, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x7C,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0x70,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x00, 0xF0, 0x38, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x07, 0x80, 0x1C, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07,
  0x03, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07, 0x87, 0x80, 0x00, 0x07,
  0x87, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x03,
  0x9E, 0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xEE, 0x00, 0x3C, 0x00, 0x39,
  0xC0, 0x07, 0x80, 0x0F, 0x38, 0x00, 0xF0, 0x01, 0xC7, 0x00, 0x3E, 0x00,
  0x38, 0xE0, 0x07, 0xC0, 0x0F, 0x1C, 0x00, 0xFC, 0x01, 0xE3, 0x80, 0x3F,
  0x80, 0x38, 0x70, 0x07, 0x70, 0x07, 0x0E, 0x00, 0xEE, 0x01, 0xE1, 0xC0,
  0x3D, 0xC0, 0x38, 0x38, 0x07, 0x38, 0x07, 0x07, 0x00, 0xE7, 0x01, 0xE0,
  0xE0, 0x3C, 0xE0, 0x3C, 0x1C, 0x07, 0x1C, 0x07, 0x03, 0x80, 0xE3, 0x80,
  0xE0, 0x70, 0x3C, 0x70, 0x3C, 0x0E, 0x07, 0x0E, 0x07, 0x03, 0xC0, 0xE1,
  0xC0, 0xE0, 0x78, 0x3C, 0x38, 0x3C, 0x0F, 0x07, 0x07, 0x07, 0x01, 0xE0,
  0xE0, 0xE0, 0xE0, 0x3C, 0x3C, 0x1C, 0x1C, 0x07, 0x87, 0x03, 0x87, 0x80,
  0xF0, 0xE0, 0x70, 0xE0, 0x1E, 0x3C, 0x0E, 0x1C, 0x03, 0xC7, 0x01, 0xC7,
  0x80, 0x78, 0xE0, 0x38, 0xE0, 0x0F, 0x3C, 0x07, 0x1C, 0x01, 0xE7, 0x00,
  0xE7, 0x80, 0x3C, 0xE0, 0x1C, 0xF0, 0x07, 0xBC, 0x03, 0x9C, 0x00, 0xF7,
  0x00, 0x73, 0x80, 0x1E, 0xE0, 0x0E, 0xF0, 0x03, 0xBC, 0x01, 0xDC, 0x00,
  0x77, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x00,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x00, 0x70,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x07,
  0xC0, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3E, 0x78, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF8, 0x3C, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xE0, 0x1E, 0x00,
  0x03, 0xC0, 0x0E, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x03, 0x80, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x20, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0xE0, 0x07,
  0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x78,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xF0,
  0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xB8, 0x00, 0x0F, 0x70, 0x00, 0x1C, 0xF0, 0x00, 0x78, 0xE0,
  0x00, 0xE1, 0xC0, 0x03, 0xC3, 0x80, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00,
  0x78, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x07, 0x00, 0x78, 0x1E,
  0x00, 0x70, 0x78, 0x00, 0xE0, 0xF0, 0x01, 0xC3, 0xC0, 0x03, 0xC7, 0x00,
  0x07, 0x9E, 0x00, 0x07, 0x38, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0x7F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x3C, 0x0F,
  0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0E, 0x03, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xC3, 0xF8, 0x01,
  0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x07, 0x03, 0xE0, 0x00, 0x3C, 0x1F,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x38, 0x78, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x07, 0xE1, 0xE0, 0x00, 0x7F,
  0x87, 0xC0, 0x03, 0xDC, 0x0F, 0x80, 0x3E, 0x70, 0x1F, 0xFF, 0xF1, 0xC0,
  0x3F, 0xFF, 0x07, 0x80, 0x7F, 0xF0, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x38, 0x0F, 0xC0, 0x00, 0xE1, 0xFF, 0xE0, 0x07,
  0x8F, 0xFF, 0xC0, 0x1E, 0xFE, 0x3F, 0x80, 0x7F, 0xC0, 0x1F, 0x01, 0xFC,
  0x00, 0x3C, 0x07, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xE0, 0xF8, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x1C,
  0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC3, 0x80, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x03, 0xE0, 0x7F, 0x00, 0x1F, 0x03,
  0xDF, 0x01, 0xFC, 0x0F, 0x3F, 0xFF, 0xE0, 0x3C, 0x7F, 0xFE, 0x00, 0xE0,
  0x7F, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0E, 0x78,
  0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE3, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x7C, 0x03,
  0xF0, 0x0F, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x70, 0x00, 0x7F, 0xF8, 0x78,
  0x00, 0x7F, 0xFE, 0x3C, 0x00, 0xFF, 0x1F, 0x9E, 0x00, 0xFC, 0x01, 0xEF,
  0x00, 0x7C, 0x00, 0x3F, 0x80, 0x78, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x07,
  0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0xE0, 0x78, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0xE0, 0x1E,
  0x00, 0x03, 0xF0, 0x07, 0x80, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xF8, 0x00,
  0xF8, 0x07, 0xDC, 0x00, 0x3F, 0xFF, 0xDE, 0x00, 0x0F, 0xFF, 0x8F, 0x00,
  0x03, 0xFF, 0x87, 0x80, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0x87, 0xF0,
  0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xE1, 0xE0,
  0x00, 0x03, 0x8F, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x39, 0xE0, 0x00,
  0x00, 0xE7, 0x80, 0x00, 0x03, 0x9F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0x80, 0xF8, 0x00,
  0x0F, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x07, 0x00, 0x1F, 0xFF, 0x8F, 0x00, 0x7F, 0x87, 0xCF,
  0x00, 0xFC, 0x01, 0xEF, 0x00, 0xF8, 0x00, 0x7F, 0x01, 0xF0, 0x00, 0x7E,
  0x03, 0xE0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x38,
  0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xF0,
  0x1E, 0x00, 0x03, 0xF0, 0x0F, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x0F, 0xE0,
  0x07, 0xC0, 0x3F, 0xE0, 0x03, 0xFF, 0xFD, 0xE0, 0x01, 0xFF, 0xF1, 0xE0,
  0x00, 0xFF, 0xE1, 0xE0, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x20, 0x00, 0x0F, 0x80, 0x60, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x07, 0xF0, 0x01, 0xE0, 0xFF, 0xF0,
  0x07, 0x87, 0xFF, 0xE0, 0x1E, 0x7F, 0x1F, 0xC0, 0x7B, 0xE0, 0x1F, 0x81,
  0xDE, 0x00, 0x1E, 0x07, 0x60, 0x00, 0x78, 0x3F, 0x00, 0x00, 0xF0, 0xF8,
  0x00, 0x03, 0xC3, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x38, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x1E,
  0x1C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x03, 0x87, 0x80, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x70,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x07, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0x03,
  0xC0, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0xF8, 0x03, 0x80, 0x01, 0xF0, 0x07,
  0x80, 0x07, 0xE0, 0x07, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x1F, 0x00, 0x07,
  0x80, 0x3E, 0x00, 0x07, 0x80, 0xFC, 0x00, 0x07, 0x01, 0xF8, 0x00, 0x0F,
  0x03, 0xE0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x0F,
  0x3F, 0x00, 0x00, 0x0F, 0x7E, 0x00, 0x00, 0x0E, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x1F, 0xE7, 0x80, 0x00, 0x1F, 0xC7, 0xC0, 0x00, 0x1F,
  0x03, 0xC0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x1C, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x1E, 0x7F, 0xC1, 0xFF,
  0x00, 0xE7, 0xFF, 0x1F, 0xFC, 0x07, 0x7D, 0xFD, 0xF3, 0xF0, 0x3F, 0x03,
  0xFC, 0x07, 0x81, 0xF0, 0x0F, 0xC0, 0x3C, 0x1F, 0x00, 0x7C, 0x00, 0xE0,
  0xF0, 0x03, 0xC0, 0x07, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x38, 0x00, 0xF0,
  0x01, 0xC1, 0xC0, 0x07, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0xF0,
  0x01, 0xC0, 0x07, 0x87, 0x80, 0x0E, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0x01,
  0xC1, 0xC0, 0x07, 0x80, 0x0E, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0xF0, 0x01,
  0xC0, 0x07, 0x87, 0x80, 0x0E, 0x00, 0x3C, 0x3C, 0x00, 0x70, 0x01, 0xE1,
  0xC0, 0x07, 0x80, 0x0E, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x70, 0x01, 0xE0,
  0x07, 0x87, 0x80, 0x0E, 0x00, 0x3C, 0x3C, 0x00, 0x70, 0x01, 0xE1, 0xE0,
  0x07, 0x80, 0x0E, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x70, 0x01, 0xE0, 0x03,
  0x83, 0x80, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0x70, 0x01, 0xE1, 0xE0, 0x03,
  0x80, 0x0F, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x70, 0x01, 0xE0, 0x03, 0x83,
  0x80, 0x0F, 0x00, 0x1C, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x1E, 0x0F, 0xFF, 0x00, 0x78, 0x7F, 0xFE, 0x01, 0xE7, 0xF1, 0xFC,
  0x07, 0x3E, 0x01, 0xF8, 0x1D, 0xE0, 0x01, 0xE0, 0x7E, 0x00, 0x07, 0x83,
  0xF0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x0E, 0x1E, 0x00, 0x00,
  0x78, 0x70, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0F, 0x0E,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x0E, 0x1E, 0x00, 0x00, 0x38, 0x78, 0x00, 0x01, 0xE1, 0xC0, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x7F,
  0x00, 0x1F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x1E, 0x38, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x07, 0xC1, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x3C, 0x07, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xC0, 0x1F,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x38, 0x7F,
  0xF8, 0x00, 0x3C, 0xFF, 0xFE, 0x00, 0x1E, 0xFE, 0x3F, 0x80, 0x0E, 0xF0,
  0x07, 0xE0, 0x07, 0xF0, 0x00, 0xF0, 0x03, 0xF0, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x1E, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x78,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x01, 0xC0,
  0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x0F,
  0x80, 0x3D, 0xE0, 0x1F, 0x80, 0x1E, 0x7F, 0xFF, 0x80, 0x0F, 0x1F, 0xFF,
  0x80, 0x07, 0x83, 0xFF, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x70, 0x07, 0xFF, 0xF3, 0xC0, 0x7F,
  0x87, 0xEF, 0x03, 0xF0, 0x07, 0xBC, 0x0F, 0x80, 0x07, 0xF0, 0x78, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0xF1, 0xC0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x0E, 0x3C, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x07, 0xC0,
  0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x03, 0xF8, 0x07, 0xC0, 0x3F, 0xE0, 0x0F,
  0xFF, 0xF7, 0x80, 0x1F, 0xFF, 0x1E, 0x00, 0x3F, 0xF8, 0x78, 0x00, 0x0C,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x38, 0x1F, 0xFF, 0x07, 0x87, 0xFF, 0xE0, 0x78, 0xFF,
  0xFE, 0x07, 0x9F, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x07, 0x78, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x7F, 0xC7, 0xF8, 0x03, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE3,
  0xC0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xFC, 0x0F, 0xC0,
  0x0F, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xE1,
  0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0x70,
  0x00, 0x01, 0xE1, 0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00,
  0x3C, 0x38, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x07, 0x87,
  0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x07,
  0xE0, 0x78, 0x00, 0x3F, 0x81, 0xE0, 0x01, 0xDC, 0x03, 0xE0, 0x1E, 0x70,
  0x0F, 0xFF, 0xF1, 0xC0, 0x1F, 0xFF, 0x8F, 0x00, 0x1F, 0xF8, 0x3C, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0xE0, 0x3C,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xE0,
  0x00, 0x78, 0x01, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x38, 0x07, 0x80, 0x00, 0x70, 0x1E,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x03, 0x87, 0x80, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x07, 0x3C, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xF8, 0x00, 0x70, 0x00,
  0xEE, 0x00, 0x3C, 0x00, 0x7B, 0x80, 0x0F, 0x00, 0x1E, 0xE0, 0x07, 0xC0,
  0x07, 0x38, 0x01, 0xF0, 0x03, 0xCE, 0x00, 0x6E, 0x00, 0xE3, 0x80, 0x3B,
  0x80, 0x38, 0xE0, 0x0E, 0xE0, 0x1E, 0x38, 0x07, 0x38, 0x07, 0x0E, 0x01,
  0xCE, 0x01, 0xC3, 0x80, 0xF3, 0x80, 0xE0, 0xE0, 0x38, 0xE0, 0x38, 0x38,
  0x0E, 0x38, 0x1E, 0x0E, 0x07, 0x0E, 0x07, 0x03, 0x81, 0xC3, 0x81, 0xC0,
  0xE0, 0xE0, 0xE0, 0xF0, 0x38, 0x38, 0x38, 0x38, 0x0E, 0x0E, 0x0E, 0x0E,
  0x03, 0xC7, 0x01, 0x87, 0x00, 0xF1, 0xC0, 0x71, 0xC0, 0x1C, 0xE0, 0x1C,
  0xF0, 0x07, 0x38, 0x07, 0x38, 0x01, 0xDE, 0x01, 0xCE, 0x00, 0x77, 0x00,
  0x77, 0x00, 0x1D, 0xC0, 0x1D, 0xC0, 0x07, 0xE0, 0x07, 0x70, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x1E, 0x00,
  0x00, 0x7C, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x3E, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00,
  0x03, 0xDF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xBC, 0x00, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x00, 0x3E, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00,
  0x70, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x04,
  0x00, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03,
  0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0x0F, 0xFF, 0x80, 0x00,
  0xE1, 0xF9, 0xFC, 0x00, 0x0E, 0x3E, 0x03, 0xE0, 0x01, 0xE3, 0x80, 0x1F,
  0x00, 0x1C, 0x78, 0x00, 0xF8, 0x03, 0xC7, 0x00, 0x07, 0xE0, 0x78, 0x70,
  0x00, 0x3F, 0xFF, 0x0E, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x06, 0x00,
};

const GFXglyph RobotoMono_LightItalic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 12, 46, 38, 13, -46 },
  { 70, 15, 14, 38, 15, -49 },
  { 97, 38, 46, 38, 1, -46 },
  { 316, 32, 60, 38, 4, -53 },
  { 556, 31, 48, 38, 4, -47 },
  { 742, 33, 48, 38, 2, -47 },
  { 940, 6, 14, 38, 18, -49 },
  { 951, 20, 67, 38, 11, -52 },
  { 1119, 20, 67, 38, 6, -52 },
  { 1287, 28, 28, 38, 8, -46 },
  { 1385, 31, 33, 38, 4, -38 },
  { 1513, 9, 15, 38, 7, -6 },
  { 1530, 23, 3, 38, 7, -22 },
  { 1539, 6, 6, 38, 14, -6 },
  { 1544, 31, 50, 38, 5, -46 },
  { 1738, 31, 48, 38, 4, -47 },
  { 1924, 17, 46, 38, 10, -46 },
  { 2022, 32, 47, 38, 1, -47 },
  { 2210, 31, 48, 38, 2, -47 },
  { 2396, 33, 46, 38, 1, -46 },
  { 2586, 32, 47, 38, 5, -46 },
  { 2774, 28, 48, 38, 4, -47 },
  { 2942, 31, 46, 38, 7, -46 },
  { 3121, 32, 48, 38, 4, -47 },
  { 3313, 28, 47, 38, 6, -47 },
  { 3478, 12, 34, 38, 15, -34 },
  { 3529, 15, 43, 38, 12, -34 },
  { 3610, 29, 27, 38, 5, -34 },
  { 3708, 31, 16, 38, 4, -29 },
  { 3770, 29, 27, 38, 4, -34 },
  { 3868, 25, 47, 38, 10, -47 },
  { 4015, 36, 47, 38, 2, -47 },
  { 4227, 32, 46, 38, 0, -46 },
  { 4411, 33, 46, 38, 3, -46 },
  { 4601, 32, 48, 38, 4, -47 },
  { 4793, 34, 46, 38, 2, -46 },
  { 4989, 34, 46, 38, 3, -46 },
  { 5185, 35, 46, 38, 3, -46 },
  { 5387, 33, 48, 38, 3, -47 },
  { 5585, 36, 46, 38, 2, -46 },
  { 5792, 34, 46, 38, 3, -46 },
  { 5988, 34, 47, 38, 2, -46 },
  { 6188, 37, 46, 38, 3, -46 },
  { 6401, 28, 46, 38, 3, -46 },
  { 6562, 36, 46, 38, 2, -46 },
  { 6769, 36, 46, 38, 2, -46 },
  { 6976, 32, 48, 38, 4, -47 },
  { 7168, 35, 46, 38, 3, -46 },
  { 7370, 33, 55, 38, 3, -47 },
  { 7597, 33, 46, 38, 3, -46 },
  { 7787, 33, 48, 38, 3, -47 },
  { 7985, 33, 46, 38, 7, -46 },
  { 8175, 34, 47, 38, 4, -46 },
  { 8375, 32, 46, 38, 7, -46 },
  { 8559, 35, 46, 38, 6, -46 },
  { 8761, 39, 46, 38, 0, -46 },
  { 8986, 32, 46, 38, 7, -46 },
  { 9170, 35, 46, 38, 1, -46 },
  { 9372, 21, 63, 38, 9, -53 },
  { 9538, 13, 50, 38, 13, -46 },
  { 9620, 20, 63, 38, 9, -53 },
  { 9778, 23, 25, 38, 8, -46 },
  { 9850, 28, 3, 38, 1, 0 },
  { 9861, 9, 9, 38, 18, -48 },
  { 9872, 30, 36, 38, 3, -35 },
  { 10007, 30, 50, 38, 3, -49 },
  { 10195, 29, 36, 38, 4, -35 },
  { 10326, 33, 50, 38, 4, -49 },
  { 10533, 30, 36, 38, 4, -35 },
  { 10668, 32, 50, 38, 8, -50 },
  { 10868, 32, 49, 38, 2, -35 },
  { 11064, 30, 49, 38, 3, -49 },
  { 11248, 28, 47, 38, 3, -47 },
  { 11413, 29, 61, 38, 1, -47 },
  { 11635, 32, 49, 38, 3, -49 },
  { 11831, 28, 49, 38, 3, -49 },
  { 12003, 37, 35, 38, -1, -35 },
  { 12165, 30, 35, 38, 3, -35 },
  { 12297, 31, 36, 38, 3, -35 },
  { 12437, 33, 48, 38, 0, -35 },
  { 12635, 30, 48, 38, 4, -35 },
  { 12815, 28, 35, 38, 8, -35 },
  { 12938, 30, 36, 38, 4, -35 },
  { 13073, 26, 44, 38, 7, -43 },
  { 13216, 30, 35, 38, 5, -34 },
  { 13348, 31, 34, 38, 6, -34 },
  { 13480, 34, 34, 38, 5, -34 },
  { 13625, 36, 34, 38, 1, -34 },
  { 13778, 39, 48, 38, -1, -34 },
  { 14012, 33, 34, 38, 2, -34 },
  { 14153, 25, 64, 38, 10, -51 },
  { 14353, 12, 57, 38, 13, -46 },
  { 14439, 25, 64, 38, 6, -51 },
  { 14639, 36, 12, 38, 1, -25 },
};

const GFXfont RobotoMono_LightItalic65pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic65pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic65pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _ROBOTOMONO_LIGHTITALIC65PT7B_H_
