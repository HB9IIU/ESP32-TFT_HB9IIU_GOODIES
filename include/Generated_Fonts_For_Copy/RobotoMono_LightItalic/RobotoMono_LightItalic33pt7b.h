#ifndef _ROBOTOMONO_LIGHTITALIC33PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x61, 0x86, 0x18, 0x61, 0x0C, 0x30, 0xC3, 0x0C, 0x61, 0x86,
  0x18, 0x00, 0x00, 0x00, 0x43, 0x0C, 0x00, 0x46, 0x8F, 0x1E, 0x3C, 0x50,
  0xA3, 0x00, 0x00, 0x30, 0x40, 0x02, 0x0C, 0x00, 0x60, 0x80, 0x06, 0x18,
  0x00, 0x41, 0x80, 0x0C, 0x10, 0x1F, 0xFF, 0xF1, 0xFF, 0xFE, 0x01, 0x82,
  0x00, 0x10, 0x60, 0x03, 0x06, 0x00, 0x30, 0x40, 0x02, 0x0C, 0x00, 0x60,
  0xC0, 0x06, 0x18, 0x07, 0xFF, 0xF8, 0x8C, 0x10, 0x00, 0xC3, 0x00, 0x08,
  0x30, 0x01, 0x82, 0x00, 0x18, 0x60, 0x01, 0x06, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0xF0, 0x03, 0xFC, 0x07, 0x0E,
  0x0C, 0x06, 0x18, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0x60, 0x1C,
  0x70, 0x38, 0x3C, 0xF0, 0x1F, 0xC0, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x3E, 0x00, 0x63, 0x00, 0x41, 0x04, 0xC1, 0x06, 0xC1, 0x0C,
  0xC3, 0x18, 0xC3, 0x30, 0xC6, 0x30, 0x7E, 0x60, 0x38, 0xC0, 0x00, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x02, 0x3E, 0x06, 0x66, 0x0C, 0xC3, 0x18, 0xC3,
  0x10, 0x83, 0x30, 0x83, 0x60, 0x82, 0x00, 0x86, 0x00, 0xCC, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xFC, 0x00, 0xC3, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x20,
  0x60, 0x30, 0x30, 0x08, 0x30, 0x06, 0x30, 0x03, 0x70, 0x00, 0xF0, 0x00,
  0x60, 0x00, 0xF8, 0x00, 0xEE, 0x0C, 0xE3, 0x06, 0xE0, 0xC2, 0x60, 0x63,
  0x30, 0x19, 0xB0, 0x0F, 0x98, 0x03, 0x86, 0x01, 0xC3, 0x01, 0xE0, 0xE3,
  0x98, 0x3F, 0x86, 0x6D, 0xB4, 0xB0, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x02,
  0x00, 0x04, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x08, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x30,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x00, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x40, 0x61, 0x0F, 0xE5, 0xF1, 0xFF, 0x00, 0xC0, 0x07, 0x80,
  0x36, 0x01, 0x8C, 0x0C, 0x18, 0x60, 0x60, 0x81, 0x00, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x33, 0x33, 0x66, 0xC8, 0xFF,
  0xE0, 0x7F, 0x80, 0x00, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x03, 0xFC, 0x0E, 0x0C, 0x0C,
  0x06, 0x18, 0x02, 0x10, 0x03, 0x30, 0x03, 0x30, 0x07, 0x60, 0x0F, 0x60,
  0x3B, 0x60, 0x72, 0x60, 0xC6, 0x61, 0x86, 0x67, 0x06, 0xCE, 0x06, 0xD8,
  0x06, 0xF0, 0x0C, 0xE0, 0x0C, 0xC0, 0x0C, 0x40, 0x18, 0x60, 0x18, 0x60,
  0x30, 0x38, 0xE0, 0x1F, 0xC0, 0x03, 0x87, 0xDF, 0x5C, 0x68, 0x30, 0x18,
  0x0C, 0x06, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x00, 0xF0, 0x07, 0xF8, 0x0E,
  0x0C, 0x18, 0x06, 0x18, 0x06, 0x30, 0x06, 0x30, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xFC, 0x0E,
  0x0E, 0x1C, 0x06, 0x18, 0x03, 0x30, 0x03, 0x30, 0x03, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x1C, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0,
  0x18, 0x60, 0x38, 0x38, 0xF0, 0x1F, 0xC0, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x36, 0x00, 0x64, 0x00, 0xCC, 0x01, 0xCC, 0x01, 0x8C, 0x03,
  0x0C, 0x06, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x18, 0x30, 0x18, 0x60,
  0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x60, 0x0F, 0xFF, 0x0C, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x37, 0xC0, 0x3F,
  0xF0, 0x70, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x08, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x30, 0x60, 0x70, 0x79,
  0xE0, 0x3F, 0x80, 0x00, 0x1C, 0x03, 0xF0, 0x3E, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x9F, 0xC6, 0xE3, 0x9E, 0x06,
  0x60, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x06, 0x60, 0x19, 0x80, 0xC3, 0xCE, 0x07, 0xF0, 0xFF, 0xFE, 0x00,
  0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xFC, 0x07, 0x0E, 0x0C,
  0x07, 0x18, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x06, 0x18,
  0x06, 0x0C, 0x1C, 0x07, 0xF0, 0x0F, 0xF0, 0x18, 0x18, 0x30, 0x0C, 0x60,
  0x04, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x1C, 0x60,
  0x38, 0x3C, 0xF0, 0x1F, 0xC0, 0x03, 0xC0, 0x3F, 0xC1, 0xC3, 0x8E, 0x07,
  0x30, 0x0D, 0x80, 0x36, 0x00, 0xD0, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0x60, 0x1D, 0xC0, 0xF3, 0x9E, 0x87, 0xE6, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x07, 0xF0, 0x1F, 0x00, 0x18,
  0xF1, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x38, 0xE0,
  0x06, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0xC0, 0x80, 0x00, 0x04,
  0x00, 0x30, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0x30, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xC0, 0x3F,
  0xFF, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0x30, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0x80, 0x1E, 0x01, 0xE0, 0x0F, 0x00,
  0xF8, 0x07, 0x80, 0x0C, 0x00, 0x00, 0x07, 0x80, 0xFF, 0x0E, 0x1C, 0xC0,
  0x6C, 0x03, 0x60, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x7F, 0x80, 0x38, 0x38, 0x18, 0x06, 0x0C, 0x00, 0xC6, 0x0C, 0x31, 0x0F,
  0xC4, 0xC6, 0x31, 0x23, 0x08, 0x58, 0x82, 0x14, 0x60, 0x85, 0x10, 0x63,
  0xC4, 0x10, 0xF1, 0x04, 0x28, 0xC3, 0x0A, 0x30, 0xC6, 0x8C, 0x71, 0x21,
  0xBC, 0xCC, 0x79, 0xE3, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0xCF,
  0x00, 0x3F, 0x80, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x6C, 0x00,
  0x6C, 0x00, 0xCC, 0x00, 0xCC, 0x01, 0x8C, 0x01, 0x84, 0x03, 0x04, 0x03,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x04, 0x06, 0x0C, 0x06, 0x0F, 0xFE, 0x18,
  0x02, 0x18, 0x03, 0x30, 0x03, 0x30, 0x03, 0x60, 0x03, 0x60, 0x03, 0xC0,
  0x03, 0x0F, 0xFC, 0x06, 0x07, 0x83, 0x00, 0xC1, 0x80, 0x30, 0x80, 0x18,
  0xC0, 0x0C, 0x60, 0x06, 0x30, 0x06, 0x18, 0x07, 0x0C, 0x07, 0x07, 0xFE,
  0x07, 0xFF, 0x83, 0x00, 0xE1, 0x80, 0x30, 0xC0, 0x0C, 0x60, 0x06, 0x60,
  0x03, 0x30, 0x01, 0x98, 0x01, 0x8C, 0x01, 0xC6, 0x01, 0xC3, 0xFF, 0xC3,
  0xFF, 0x80, 0x00, 0xF0, 0x03, 0xFC, 0x0E, 0x0E, 0x0C, 0x06, 0x18, 0x03,
  0x30, 0x03, 0x30, 0x03, 0x60, 0x03, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x0C, 0x60, 0x18, 0x60, 0x30, 0x38, 0xE0,
  0x1F, 0xC0, 0x0F, 0xF8, 0x06, 0x0F, 0x03, 0x01, 0xC3, 0x00, 0x61, 0x80,
  0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x18, 0x01, 0x98, 0x00, 0xCC,
  0x00, 0x66, 0x00, 0x33, 0x00, 0x19, 0x80, 0x0C, 0x80, 0x0C, 0xC0, 0x06,
  0x60, 0x06, 0x30, 0x03, 0x18, 0x03, 0x0C, 0x03, 0x04, 0x07, 0x07, 0xFF,
  0x03, 0xFE, 0x00, 0x0F, 0xFF, 0xC3, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x8C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x86, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xFC,
  0x0E, 0x0E, 0x0C, 0x07, 0x18, 0x03, 0x30, 0x03, 0x30, 0x03, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0xFE,
  0xC0, 0xFE, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x04, 0xC0, 0x0C,
  0x60, 0x0C, 0x70, 0x1C, 0x3C, 0xF8, 0x1F, 0xE0, 0x0C, 0x00, 0xC2, 0x00,
  0x31, 0x80, 0x0C, 0x60, 0x02, 0x18, 0x01, 0x86, 0x00, 0x61, 0x00, 0x18,
  0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x43, 0xFF, 0xF0, 0xFF, 0xFC, 0x20,
  0x03, 0x18, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x08, 0x60, 0x06, 0x18, 0x01,
  0x84, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x0C, 0x00, 0xC0,
  0x0F, 0xFF, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x1F,
  0xFF, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0xC0, 0x04, 0x60, 0x06, 0x30, 0x03, 0x0C, 0x03, 0x06, 0x03,
  0x01, 0xE7, 0x00, 0x7F, 0x00, 0x0C, 0x00, 0xE1, 0x80, 0x30, 0x30, 0x0C,
  0x06, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x30, 0x06, 0x0C, 0x00, 0xC3, 0x00,
  0x18, 0xC0, 0x03, 0x30, 0x00, 0x6E, 0x00, 0x1B, 0xE0, 0x03, 0xCC, 0x00,
  0x71, 0xC0, 0x0C, 0x18, 0x01, 0x81, 0x80, 0x20, 0x30, 0x0C, 0x03, 0x01,
  0x80, 0x60, 0x30, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x0C, 0x30, 0x01, 0xC0,
  0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x01, 0xC3, 0x80, 0x71, 0xE0, 0x3C,
  0x78, 0x0F, 0x1A, 0x06, 0xC6, 0x81, 0x21, 0xB0, 0xD8, 0x4C, 0x66, 0x33,
  0x19, 0x8C, 0xCC, 0x63, 0x13, 0x10, 0xC5, 0x8C, 0x31, 0xE3, 0x08, 0x70,
  0xC6, 0x1C, 0x31, 0x86, 0x0C, 0x60, 0x02, 0x18, 0x01, 0x86, 0x00, 0x61,
  0x00, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0xC0, 0x0C, 0x00, 0xC3,
  0x00, 0x31, 0xE0, 0x0C, 0x78, 0x02, 0x1B, 0x01, 0x86, 0xC0, 0x61, 0xB0,
  0x18, 0x46, 0x06, 0x31, 0x81, 0x8C, 0x60, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x18, 0x18, 0xC6, 0x06, 0x31, 0x80, 0x98, 0x60, 0x36, 0x18,
  0x0D, 0x86, 0x01, 0x63, 0x00, 0x78, 0xC0, 0x1C, 0x30, 0x03, 0x0C, 0x00,
  0xC0, 0x00, 0xF0, 0x03, 0xF8, 0x0E, 0x0C, 0x0C, 0x06, 0x18, 0x06, 0x30,
  0x03, 0x30, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0,
  0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0x60, 0x18, 0x60, 0x70, 0x3D, 0xE0, 0x1F,
  0xC0, 0x0F, 0xFC, 0x0C, 0x07, 0x06, 0x00, 0xC3, 0x00, 0x31, 0x80, 0x18,
  0xC0, 0x0C, 0x40, 0x06, 0x60, 0x03, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x03,
  0x86, 0x07, 0x83, 0xFF, 0x83, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xF0, 0x03, 0xFC, 0x0E, 0x0E, 0x1C, 0x06, 0x18, 0x03,
  0x30, 0x03, 0x30, 0x03, 0x60, 0x03, 0x60, 0x01, 0x40, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x06,
  0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x0C, 0x60, 0x18, 0x60, 0x30, 0x3D, 0xE0,
  0x1F, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x1F, 0xF8,
  0x18, 0x1E, 0x18, 0x06, 0x18, 0x03, 0x18, 0x03, 0x10, 0x03, 0x30, 0x03,
  0x30, 0x03, 0x30, 0x06, 0x30, 0x06, 0x30, 0x1C, 0x20, 0xF8, 0x7F, 0xE0,
  0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x30, 0xC0, 0x30, 0xC0, 0x18,
  0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x0C, 0x80, 0x0C, 0x00, 0xF0, 0x03, 0xFE,
  0x03, 0x83, 0x83, 0x80, 0xE1, 0x80, 0x31, 0x80, 0x18, 0xC0, 0x0C, 0x60,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x60, 0x03, 0x30, 0x01,
  0x98, 0x01, 0xCC, 0x00, 0xC3, 0x00, 0xC0, 0xF3, 0xC0, 0x3F, 0xC0, 0xFF,
  0xFF, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x01, 0x88,
  0x00, 0xCC, 0x00, 0x66, 0x00, 0x23, 0x00, 0x31, 0x80, 0x18, 0x80, 0x0C,
  0xC0, 0x06, 0x60, 0x03, 0x30, 0x01, 0x18, 0x01, 0x8C, 0x00, 0xC4, 0x00,
  0x66, 0x00, 0x33, 0x00, 0x19, 0x80, 0x08, 0xC0, 0x0C, 0x60, 0x06, 0x30,
  0x06, 0x0C, 0x03, 0x06, 0x03, 0x01, 0xCF, 0x00, 0x7F, 0x00, 0xC0, 0x07,
  0xC0, 0x06, 0xC0, 0x0E, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0x60, 0x18,
  0x60, 0x30, 0x60, 0x30, 0x60, 0x60, 0x60, 0x60, 0x60, 0xC0, 0x20, 0xC0,
  0x31, 0x80, 0x31, 0x80, 0x31, 0x00, 0x33, 0x00, 0x33, 0x00, 0x36, 0x00,
  0x16, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0xC0, 0xC0, 0xF0, 0x30,
  0x6C, 0x1C, 0x1B, 0x07, 0x04, 0xC3, 0xC3, 0x30, 0xF0, 0xCC, 0x2C, 0x33,
  0x1B, 0x08, 0xC6, 0x46, 0x31, 0x11, 0x8C, 0xC4, 0x43, 0x31, 0x30, 0xC8,
  0x4C, 0x36, 0x13, 0x0D, 0x85, 0x83, 0x41, 0x60, 0xF0, 0x58, 0x3C, 0x14,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x00,
  0x0E, 0x00, 0x70, 0x60, 0x0E, 0x06, 0x00, 0xC0, 0x30, 0x18, 0x03, 0x03,
  0x00, 0x18, 0x70, 0x01, 0x86, 0x00, 0x0C, 0xC0, 0x00, 0xD8, 0x00, 0x0F,
  0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x1B, 0x00, 0x01,
  0x98, 0x00, 0x31, 0x80, 0x06, 0x0C, 0x00, 0xE0, 0xC0, 0x1C, 0x0E, 0x01,
  0x80, 0x60, 0x30, 0x06, 0x07, 0x00, 0x30, 0xE0, 0x03, 0x80, 0xC0, 0x07,
  0xC0, 0x06, 0x60, 0x0C, 0x60, 0x18, 0x60, 0x18, 0x20, 0x30, 0x30, 0x60,
  0x30, 0x60, 0x10, 0xC0, 0x19, 0x80, 0x19, 0x80, 0x0B, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0xE3, 0xFF, 0xF0, 0x07, 0xC1, 0xF0,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0x83,
  0xE0, 0xC0, 0xC1, 0x83, 0x06, 0x04, 0x0C, 0x18, 0x30, 0x60, 0x40, 0xC1,
  0x83, 0x06, 0x04, 0x0C, 0x18, 0x30, 0x60, 0x40, 0xC1, 0x83, 0x06, 0x07,
  0xE0, 0xFC, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x40, 0x18, 0x1F, 0x07, 0xE0, 0x01, 0x80, 0x38, 0x02, 0x80,
  0x6C, 0x0C, 0xC0, 0xCC, 0x18, 0x41, 0x84, 0x30, 0x62, 0x06, 0x60, 0x6C,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0xE3, 0x0C, 0x30, 0x01, 0xE0, 0x1F, 0xF0,
  0x70, 0x71, 0xC0, 0x63, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x0F,
  0xFC, 0x7C, 0x19, 0xC0, 0x36, 0x00, 0x6C, 0x00, 0x98, 0x03, 0x30, 0x0E,
  0x60, 0x3C, 0x73, 0xD8, 0x7E, 0x30, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0xF0, 0x1B, 0xFC,
  0x1F, 0x0E, 0x1C, 0x06, 0x18, 0x06, 0x18, 0x03, 0x30, 0x03, 0x30, 0x03,
  0x30, 0x03, 0x30, 0x03, 0x30, 0x06, 0x20, 0x06, 0x60, 0x06, 0x60, 0x0C,
  0x70, 0x0C, 0x70, 0x18, 0x7E, 0xF0, 0xC7, 0xE0, 0x01, 0xC0, 0x0F, 0xF0,
  0x30, 0x70, 0xC0, 0x63, 0x00, 0x6C, 0x00, 0xD8, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x01, 0x98, 0x06,
  0x30, 0x18, 0x38, 0xE0, 0x3F, 0x80, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x03, 0x84, 0x0F,
  0xF6, 0x0E, 0x0F, 0x0E, 0x03, 0x86, 0x01, 0xC6, 0x00, 0x63, 0x00, 0x21,
  0x80, 0x31, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x18, 0x03,
  0x0C, 0x01, 0x83, 0x00, 0xC1, 0x81, 0xE0, 0x73, 0xB0, 0x1F, 0x98, 0x00,
  0x01, 0xE0, 0x0F, 0xF0, 0x38, 0x70, 0xC0, 0x63, 0x00, 0x6C, 0x00, 0xD8,
  0x01, 0xA0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x18, 0x02, 0x38, 0x0C, 0x3C, 0xF0, 0x3F, 0x80, 0x00, 0x7F,
  0x01, 0xF3, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0xFF, 0xF8, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x07, 0xFB, 0x0E, 0x0F, 0x1C, 0x07, 0x18, 0x07, 0x30, 0x03,
  0x30, 0x02, 0x30, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06,
  0x60, 0x0C, 0x60, 0x0C, 0x30, 0x0C, 0x30, 0x3C, 0x1C, 0xEC, 0x0F, 0xCC,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x40, 0x30, 0xE0, 0x60, 0x3F, 0xC0,
  0x1F, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x18, 0x78, 0x19, 0xFC, 0x1B, 0x0E, 0x1C, 0x06,
  0x18, 0x03, 0x18, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x02, 0x30, 0x06,
  0x30, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x0C, 0x60, 0x0C,
  0x60, 0x0C, 0xC0, 0x0C, 0x00, 0x20, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x06,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x18, 0x1F, 0xE0, 0x3F, 0x00, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x01, 0x10, 0x0E, 0x30, 0x1C, 0x30, 0x30, 0x30, 0x60, 0x31, 0xC0, 0x33,
  0x80, 0x27, 0x00, 0x6E, 0x00, 0x7B, 0x00, 0x73, 0x80, 0x61, 0x80, 0x60,
  0xC0, 0xC0, 0xE0, 0xC0, 0x60, 0xC0, 0x30, 0xC0, 0x38, 0xC0, 0x1C, 0x0F,
  0xF0, 0x3F, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00,
  0x0C, 0x00, 0x30, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0x83, 0x02, 0xFD, 0xF8,
  0xF1, 0xE3, 0x18, 0x38, 0x23, 0x06, 0x04, 0x60, 0xC0, 0x8C, 0x18, 0x31,
  0x03, 0x06, 0x60, 0x40, 0xCC, 0x18, 0x19, 0x83, 0x02, 0x30, 0x60, 0xC4,
  0x0C, 0x18, 0x81, 0x83, 0x30, 0x20, 0x66, 0x0C, 0x0C, 0xC1, 0x81, 0x18,
  0x30, 0x60, 0x00, 0x78, 0x19, 0xFC, 0x1B, 0x0E, 0x1C, 0x06, 0x18, 0x03,
  0x38, 0x03, 0x30, 0x03, 0x30, 0x02, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06,
  0x60, 0x06, 0x60, 0x06, 0x60, 0x04, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C,
  0xC0, 0x0C, 0x01, 0xC0, 0x1F, 0xF0, 0x70, 0x71, 0xC0, 0x63, 0x00, 0x6C,
  0x00, 0xD8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x6C, 0x00, 0xD8, 0x01, 0xB0, 0x06, 0x30, 0x18, 0x38, 0xE0, 0x3F, 0x80,
  0x00, 0x78, 0x06, 0xFF, 0x03, 0xC1, 0xC1, 0xC0, 0x60, 0xC0, 0x30, 0x40,
  0x0C, 0x60, 0x06, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x00, 0x86, 0x00, 0xC2,
  0x00, 0x63, 0x00, 0x31, 0x80, 0x30, 0xC0, 0x38, 0x70, 0x38, 0x3E, 0x78,
  0x33, 0xF8, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x1F, 0xEC, 0x70, 0x79,
  0xC0, 0x73, 0x00, 0x6C, 0x00, 0xD8, 0x01, 0x30, 0x06, 0xC0, 0x0D, 0x80,
  0x1B, 0x00, 0x36, 0x00, 0x6C, 0x01, 0x98, 0x03, 0x18, 0x06, 0x30, 0x1C,
  0x39, 0xD8, 0x3F, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x7C, 0x67, 0xF1, 0x38, 0x0D, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0x01, 0xE0, 0x1F, 0xF0, 0x70, 0x71, 0xC0, 0x33, 0x00, 0x66, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xD8, 0x01, 0xB0, 0x03, 0x30, 0x0C, 0x38, 0xF0, 0x3F, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x7F, 0xFC, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0x30, 0x01, 0xE6, 0x07, 0xF0, 0x30,
  0x07, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06, 0x20, 0x06, 0x60, 0x06, 0x60,
  0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x40, 0x0C, 0x40, 0x0C, 0x40,
  0x18, 0x60, 0x38, 0x60, 0x78, 0x39, 0xD8, 0x1F, 0x98, 0xC0, 0x07, 0xC0,
  0x06, 0x60, 0x0C, 0x60, 0x18, 0x60, 0x18, 0x60, 0x30, 0x20, 0x30, 0x30,
  0x60, 0x30, 0x60, 0x30, 0xC0, 0x10, 0xC0, 0x19, 0x80, 0x19, 0x00, 0x1B,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0xC0, 0xC0, 0xF0, 0x30, 0x6C,
  0x1C, 0x19, 0x05, 0x04, 0x43, 0x43, 0x10, 0x90, 0xC4, 0x64, 0x61, 0x19,
  0x18, 0x44, 0x44, 0x13, 0x13, 0x04, 0x84, 0xC1, 0x61, 0xA0, 0x58, 0x78,
  0x14, 0x1C, 0x07, 0x07, 0x01, 0x81, 0xC0, 0x60, 0x60, 0x00, 0x0C, 0x01,
  0xE0, 0xC0, 0x70, 0x18, 0x0C, 0x01, 0x83, 0x00, 0x18, 0xC0, 0x03, 0x30,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x0E, 0xC0,
  0x03, 0x8C, 0x00, 0x61, 0x80, 0x18, 0x18, 0x06, 0x03, 0x81, 0x80, 0x30,
  0xE0, 0x03, 0x00, 0x18, 0x00, 0x63, 0x00, 0x18, 0x60, 0x07, 0x06, 0x00,
  0xC0, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x01, 0x80, 0x30, 0x70, 0x06, 0x0C,
  0x00, 0xC3, 0x00, 0x0C, 0x60, 0x01, 0x98, 0x00, 0x33, 0x00, 0x06, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x38, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xFF, 0xFC, 0xFF, 0xFE,
  0x00, 0x00, 0x08, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x18, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x70, 0x0F, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x06,
  0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x06, 0x00, 0x38, 0x00, 0x60, 0x06, 0x08, 0x30, 0x60, 0xC1, 0x82, 0x04,
  0x08, 0x30, 0x60, 0xC1, 0x82, 0x04, 0x18, 0x30, 0x60, 0xC1, 0x02, 0x04,
  0x18, 0x30, 0x60, 0xC1, 0x06, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x07, 0x00,
  0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x0F, 0xC0, 0x36, 0x38, 0x0B, 0x03, 0x06, 0x80, 0x7F, 0x20,
  0x0F, 0x80,
};

const GFXglyph RobotoMono_LightItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 6, 23, 19, 7, -23 },
  { 19, 7, 7, 19, 8, -25 },
  { 26, 20, 23, 19, 0, -23 },
  { 84, 16, 30, 19, 2, -27 },
  { 144, 16, 24, 19, 2, -24 },
  { 192, 17, 24, 19, 1, -24 },
  { 243, 3, 7, 19, 9, -25 },
  { 246, 10, 34, 19, 6, -26 },
  { 289, 10, 34, 19, 3, -26 },
  { 332, 14, 14, 19, 4, -23 },
  { 357, 16, 17, 19, 2, -19 },
  { 391, 4, 8, 19, 4, -3 },
  { 395, 11, 1, 19, 4, -11 },
  { 397, 3, 3, 19, 7, -3 },
  { 399, 16, 25, 19, 2, -23 },
  { 449, 16, 24, 19, 2, -24 },
  { 497, 9, 23, 19, 5, -23 },
  { 523, 16, 24, 19, 1, -24 },
  { 571, 16, 24, 19, 1, -24 },
  { 619, 16, 23, 19, 1, -23 },
  { 665, 16, 23, 19, 3, -23 },
  { 711, 14, 24, 19, 2, -24 },
  { 753, 15, 23, 19, 4, -23 },
  { 797, 16, 24, 19, 2, -24 },
  { 845, 14, 24, 19, 3, -24 },
  { 887, 6, 17, 19, 8, -17 },
  { 900, 8, 22, 19, 6, -17 },
  { 922, 14, 14, 19, 3, -18 },
  { 947, 16, 9, 19, 2, -15 },
  { 965, 15, 13, 19, 2, -17 },
  { 990, 13, 24, 19, 5, -24 },
  { 1029, 18, 24, 19, 1, -24 },
  { 1083, 16, 23, 19, 0, -23 },
  { 1129, 17, 23, 19, 1, -23 },
  { 1178, 16, 24, 19, 2, -24 },
  { 1226, 17, 23, 19, 1, -23 },
  { 1275, 18, 23, 19, 1, -23 },
  { 1327, 17, 23, 19, 2, -23 },
  { 1376, 16, 24, 19, 2, -24 },
  { 1424, 18, 23, 19, 1, -23 },
  { 1476, 18, 23, 19, 1, -23 },
  { 1528, 17, 23, 19, 1, -23 },
  { 1577, 19, 23, 19, 1, -23 },
  { 1632, 14, 23, 19, 2, -23 },
  { 1673, 18, 23, 19, 1, -23 },
  { 1725, 18, 23, 19, 1, -23 },
  { 1777, 16, 24, 19, 2, -24 },
  { 1825, 17, 23, 19, 2, -23 },
  { 1874, 16, 28, 19, 2, -24 },
  { 1930, 16, 23, 19, 2, -23 },
  { 1976, 17, 24, 19, 2, -24 },
  { 2027, 16, 23, 19, 4, -23 },
  { 2073, 17, 23, 19, 2, -23 },
  { 2122, 16, 23, 19, 4, -23 },
  { 2168, 18, 23, 19, 3, -23 },
  { 2220, 20, 23, 19, 0, -23 },
  { 2278, 16, 23, 19, 4, -23 },
  { 2324, 17, 23, 19, 1, -23 },
  { 2373, 10, 32, 19, 5, -27 },
  { 2413, 7, 25, 19, 6, -23 },
  { 2435, 11, 32, 19, 4, -27 },
  { 2479, 12, 12, 19, 4, -23 },
  { 2497, 14, 2, 19, 1, 0 },
  { 2501, 5, 4, 19, 9, -24 },
  { 2504, 15, 18, 19, 2, -18 },
  { 2538, 16, 25, 19, 1, -25 },
  { 2588, 15, 18, 19, 2, -18 },
  { 2622, 17, 25, 19, 2, -25 },
  { 2676, 15, 18, 19, 2, -18 },
  { 2710, 16, 25, 19, 4, -25 },
  { 2760, 16, 25, 19, 1, -18 },
  { 2810, 16, 25, 19, 1, -25 },
  { 2860, 14, 24, 19, 2, -24 },
  { 2902, 15, 31, 19, 0, -24 },
  { 2961, 16, 25, 19, 2, -25 },
  { 3011, 14, 25, 19, 2, -25 },
  { 3055, 19, 18, 19, 0, -18 },
  { 3098, 16, 18, 19, 1, -18 },
  { 3134, 15, 18, 19, 2, -18 },
  { 3168, 17, 25, 19, 0, -18 },
  { 3222, 15, 25, 19, 2, -18 },
  { 3269, 14, 18, 19, 4, -18 },
  { 3301, 15, 18, 19, 2, -18 },
  { 3335, 13, 22, 19, 4, -22 },
  { 3371, 16, 17, 19, 2, -17 },
  { 3405, 16, 17, 19, 3, -17 },
  { 3439, 18, 17, 19, 2, -17 },
  { 3478, 19, 17, 19, 0, -17 },
  { 3519, 19, 24, 19, 0, -17 },
  { 3576, 17, 17, 19, 1, -17 },
  { 3613, 13, 32, 19, 5, -26 },
  { 3665, 7, 28, 19, 6, -23 },
  { 3690, 13, 33, 19, 3, -26 },
  { 3744, 18, 6, 19, 1, -13 },
};

const GFXfont RobotoMono_LightItalic33pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic33pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic33pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _ROBOTOMONO_LIGHTITALIC33PT7B_H_
