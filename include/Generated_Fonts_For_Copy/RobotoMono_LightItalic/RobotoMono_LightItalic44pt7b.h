#ifndef _ROBOTOMONO_LIGHTITALIC44PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x07, 0x06, 0x06, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x1C,
  0x1C, 0x1C, 0x18, 0x18, 0x18, 0x38, 0x38, 0x38, 0x30, 0x30, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0xE0, 0x70, 0xDC, 0x36, 0x0D,
  0x87, 0x61, 0x98, 0x66, 0x1B, 0x06, 0xC1, 0xB0, 0xC0, 0x00, 0x06, 0x07,
  0x00, 0x06, 0x03, 0x00, 0x03, 0x03, 0x80, 0x03, 0x81, 0x80, 0x01, 0x80,
  0xC0, 0x00, 0xC0, 0xE0, 0x00, 0xE0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x30,
  0x38, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE0, 0x0C, 0x0C, 0x00, 0x0C,
  0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x01, 0x80, 0x01,
  0x81, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x70, 0x0F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC0, 0x18, 0x1C, 0x00, 0x1C, 0x0C, 0x00,
  0x0C, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x80,
  0x01, 0x81, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x01, 0xE0, 0x00,
  0x7F, 0xE0, 0x07, 0xFF, 0x80, 0x70, 0x1E, 0x07, 0x00, 0x70, 0x70, 0x01,
  0x83, 0x80, 0x0E, 0x18, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x39, 0xC0, 0x01, 0xCE,
  0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x07, 0x0C, 0x00, 0x38, 0x70, 0x03,
  0x81, 0xE0, 0x78, 0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xFC, 0x00,
  0x0E, 0x70, 0x00, 0xC1, 0x80, 0x06, 0x06, 0x04, 0x60, 0x30, 0x33, 0x01,
  0x83, 0x18, 0x1C, 0x38, 0xC0, 0xC1, 0x86, 0x06, 0x18, 0x30, 0x31, 0xC1,
  0x83, 0x0C, 0x07, 0x78, 0xC0, 0x1F, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x70, 0x03, 0x0F, 0xC0,
  0x38, 0xE7, 0x01, 0x8C, 0x18, 0x18, 0x60, 0x61, 0x86, 0x03, 0x1C, 0x30,
  0x18, 0xC1, 0x81, 0xCC, 0x0C, 0x0C, 0xE0, 0x60, 0x62, 0x03, 0x03, 0x00,
  0x18, 0x30, 0x00, 0x77, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x70, 0x70, 0x03, 0x80, 0xC0, 0x0C, 0x03, 0x00,
  0x70, 0x0C, 0x01, 0xC0, 0x70, 0x07, 0x01, 0xC0, 0x1C, 0x0E, 0x00, 0x30,
  0x70, 0x00, 0xC3, 0x80, 0x03, 0xBC, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x39, 0xC0, 0x01, 0xC3, 0x01, 0xCE,
  0x0E, 0x07, 0x70, 0x1C, 0x19, 0xC0, 0x70, 0x6E, 0x00, 0xE3, 0xB8, 0x01,
  0x8C, 0xE0, 0x07, 0x73, 0x00, 0x0F, 0x8E, 0x00, 0x3C, 0x38, 0x00, 0xF0,
  0x70, 0x07, 0xE1, 0xE0, 0x7B, 0x83, 0xFF, 0xC7, 0x03, 0xFC, 0x1E, 0x33,
  0x37, 0x66, 0x66, 0x6C, 0x00, 0x04, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x03,
  0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x02, 0x00, 0x01,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C,
  0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x00, 0x80, 0x00, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x04, 0x06, 0x02, 0x70, 0x60, 0xEF,
  0xE6, 0x7F, 0x1F, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0xE0, 0x00, 0x1F, 0x00,
  0x03, 0xB0, 0x00, 0x71, 0x80, 0x0E, 0x1C, 0x01, 0xC0, 0xC0, 0x38, 0x0E,
  0x03, 0x00, 0x70, 0x10, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x71, 0xC6, 0x38, 0xE3,
  0x1C, 0xE3, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x73, 0xFE, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0,
  0x0F, 0x01, 0xC0, 0x70, 0x07, 0x07, 0x00, 0x18, 0x70, 0x00, 0xC3, 0x80,
  0x06, 0x18, 0x00, 0x39, 0xC0, 0x03, 0xCC, 0x00, 0x3E, 0x60, 0x03, 0xF7,
  0x00, 0x3B, 0xB8, 0x07, 0x99, 0xC0, 0x70, 0xCC, 0x07, 0x06, 0x60, 0x70,
  0x73, 0x0F, 0x03, 0xB8, 0xE0, 0x1D, 0xCE, 0x00, 0xCE, 0xE0, 0x06, 0x7E,
  0x00, 0x73, 0xC0, 0x03, 0x9C, 0x00, 0x18, 0xE0, 0x01, 0xC7, 0x00, 0x0E,
  0x38, 0x00, 0xE0, 0xC0, 0x06, 0x07, 0x00, 0x70, 0x1C, 0x0F, 0x00, 0x7F,
  0xF0, 0x01, 0xFE, 0x00, 0x00, 0x70, 0x1E, 0x0F, 0xE3, 0xF6, 0xF8, 0xEE,
  0x0E, 0x80, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0C, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07,
  0x01, 0xE0, 0x70, 0x07, 0x07, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x07,
  0x18, 0x00, 0x38, 0xC0, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0xF0, 0x1C, 0x07, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0, 0x01, 0x83, 0x00,
  0x06, 0x1C, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x63,
  0x80, 0x03, 0x8E, 0x00, 0x0C, 0x1C, 0x00, 0x70, 0x70, 0x03, 0x80, 0xF0,
  0x3C, 0x01, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x6C, 0x00, 0x03, 0xF0, 0x00, 0x1D, 0xC0,
  0x00, 0xE7, 0x00, 0x03, 0x18, 0x00, 0x18, 0x60, 0x00, 0xE1, 0x80, 0x07,
  0x0E, 0x00, 0x38, 0x38, 0x01, 0xC0, 0xE0, 0x06, 0x03, 0x00, 0x38, 0x0C,
  0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x07, 0x01, 0x80, 0x18, 0x0E,
  0x00, 0x60, 0x70, 0x01, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC1, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x33, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0x87, 0x80, 0xF0, 0x0E,
  0x02, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x18, 0x00, 0x38,
  0xC0, 0x01, 0x86, 0x00, 0x1C, 0x38, 0x01, 0xC0, 0xC0, 0x1E, 0x07, 0x81,
  0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x01, 0xF8,
  0x00, 0xFF, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x18, 0x03,
  0x1F, 0xE0, 0xEF, 0xFE, 0x1B, 0x80, 0xE3, 0xE0, 0x0E, 0x70, 0x01, 0xDE,
  0x00, 0x1B, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x36, 0x00, 0x06, 0xC0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x0E, 0x30,
  0x01, 0x87, 0x00, 0x70, 0x70, 0x3C, 0x07, 0xFF, 0x00, 0x7F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xFE, 0x00, 0x7F,
  0xF8, 0x07, 0x01, 0xE0, 0x70, 0x07, 0x07, 0x00, 0x1C, 0x38, 0x00, 0xE3,
  0x80, 0x03, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00,
  0xE0, 0xC0, 0x06, 0x07, 0x00, 0xF0, 0x1E, 0x1E, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x78, 0x3C, 0x07, 0x00, 0x70, 0x70, 0x01, 0xC7, 0x00, 0x0E,
  0x70, 0x00, 0x33, 0x80, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0xE6, 0x00,
  0x07, 0x38, 0x00, 0x31, 0xC0, 0x03, 0x87, 0x00, 0x38, 0x3C, 0x07, 0x80,
  0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x7F, 0xC0, 0x1F, 0xFE,
  0x07, 0x81, 0xC1, 0xC0, 0x1C, 0x70, 0x01, 0x8E, 0x00, 0x3B, 0x80, 0x07,
  0x70, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x3B, 0x00, 0x0F, 0x70, 0x01, 0xCE, 0x00, 0x78,
  0xE0, 0x3B, 0x0F, 0xBE, 0xE0, 0xFF, 0x18, 0x07, 0x83, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x06, 0x0F, 0x0F,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x78, 0x78, 0x70, 0x03, 0x80, 0xF0, 0x3C,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x1C, 0x07, 0x01,
  0x80, 0xE0, 0x38, 0x0C, 0x07, 0x03, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x0F, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0x80, 0x00, 0x08, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x18, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0xF8, 0x1F,
  0xFE, 0x38, 0x0E, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0x00,
  0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x3C, 0x03, 0x00, 0x38, 0x00, 0xC0,
  0x38, 0x00, 0x70, 0x38, 0x00, 0x18, 0x38, 0x1E, 0x0C, 0x18, 0x3F, 0x86,
  0x18, 0x38, 0x61, 0x0C, 0x38, 0x20, 0x8C, 0x18, 0x30, 0x46, 0x18, 0x18,
  0x23, 0x0C, 0x0C, 0x13, 0x0C, 0x04, 0x19, 0x86, 0x06, 0x0C, 0xC3, 0x03,
  0x06, 0x43, 0x01, 0x83, 0x61, 0x80, 0x81, 0x30, 0xC0, 0xC1, 0x98, 0x60,
  0xE0, 0xCC, 0x30, 0x70, 0xC6, 0x18, 0x78, 0x63, 0x0F, 0xEC, 0xE1, 0x83,
  0xE3, 0xE0, 0x60, 0x40, 0x40, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x06, 0xC0, 0x00, 0x3B, 0x00, 0x00, 0xCC, 0x00, 0x07, 0x38, 0x00, 0x18,
  0xE0, 0x00, 0xE3, 0x80, 0x03, 0x06, 0x00, 0x1C, 0x18, 0x00, 0x60, 0x60,
  0x03, 0x81, 0x80, 0x0C, 0x06, 0x00, 0x70, 0x1C, 0x01, 0x80, 0x70, 0x0E,
  0x00, 0xC0, 0x30, 0x03, 0x01, 0xC0, 0x0C, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0xE0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x60, 0x00, 0x63,
  0x80, 0x01, 0x8C, 0x00, 0x06, 0x70, 0x00, 0x19, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x60, 0x0F, 0x01, 0x80,
  0x0E, 0x0E, 0x00, 0x18, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x00, 0x07,
  0x0C, 0x00, 0x1C, 0x30, 0x00, 0x61, 0xC0, 0x03, 0x87, 0x00, 0x1C, 0x1C,
  0x00, 0xE0, 0x60, 0x1F, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x38, 0x01,
  0xE0, 0xE0, 0x03, 0x83, 0x80, 0x07, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x31,
  0xC0, 0x00, 0xC7, 0x00, 0x03, 0x1C, 0x00, 0x1C, 0x60, 0x00, 0x71, 0x80,
  0x03, 0x86, 0x00, 0x1E, 0x38, 0x00, 0xF0, 0xE0, 0x1F, 0x83, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x1E, 0x03, 0xC0, 0x38, 0x03, 0x80, 0xE0, 0x03, 0x83, 0x80, 0x07,
  0x06, 0x00, 0x06, 0x1C, 0x00, 0x0C, 0x30, 0x00, 0x18, 0xE0, 0x00, 0x09,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x04, 0x30, 0x00,
  0x38, 0x60, 0x00, 0x70, 0xC0, 0x01, 0xC1, 0xC0, 0x03, 0x81, 0x80, 0x0E,
  0x03, 0x80, 0x38, 0x03, 0x81, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x01, 0xC0,
  0x70, 0x01, 0xC0, 0xC0, 0x03, 0x81, 0x80, 0x03, 0x83, 0x00, 0x07, 0x0E,
  0x00, 0x0E, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0,
  0x00, 0x63, 0x80, 0x00, 0xC7, 0x00, 0x01, 0x8E, 0x00, 0x07, 0x1C, 0x00,
  0x0E, 0x30, 0x00, 0x1C, 0x60, 0x00, 0x31, 0xC0, 0x00, 0xE3, 0x80, 0x01,
  0xC7, 0x00, 0x03, 0x0C, 0x00, 0x0E, 0x18, 0x00, 0x38, 0x30, 0x00, 0x70,
  0xE0, 0x01, 0xC1, 0xC0, 0x07, 0x03, 0x80, 0x3C, 0x06, 0x03, 0xF0, 0x0F,
  0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x1E, 0x03, 0xC0, 0x78, 0x03, 0x80,
  0xE0, 0x03, 0x83, 0x80, 0x07, 0x0E, 0x00, 0x06, 0x1C, 0x00, 0x0C, 0x30,
  0x00, 0x1C, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x1F,
  0xF1, 0x80, 0x7F, 0xE7, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x06,
  0x38, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0xE0, 0x00, 0xE1,
  0xC0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x0E, 0x03, 0xC0, 0x78, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x03, 0x83,
  0x80, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x70,
  0x30, 0x00, 0x38, 0x38, 0x00, 0x18, 0x1C, 0x00, 0x0C, 0x0C, 0x00, 0x06,
  0x06, 0x00, 0x07, 0x03, 0x00, 0x03, 0x83, 0x80, 0x01, 0x81, 0xC0, 0x00,
  0xC0, 0xE0, 0x00, 0x60, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x18, 0x00,
  0x1C, 0x1C, 0x00, 0x0C, 0x0E, 0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00,
  0x01, 0x81, 0x80, 0x01, 0xC0, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x60, 0x70,
  0x00, 0x30, 0x30, 0x00, 0x18, 0x18, 0x00, 0x1C, 0x0C, 0x00, 0x0E, 0x06,
  0x00, 0x07, 0x07, 0x00, 0x03, 0x03, 0x80, 0x01, 0x80, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x38, 0x60, 0x00, 0x60,
  0xC0, 0x01, 0xC1, 0xC0, 0x03, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x38, 0x07,
  0x81, 0xE0, 0x07, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x07,
  0x83, 0x80, 0x07, 0x01, 0x80, 0x07, 0x00, 0xC0, 0x07, 0x00, 0x60, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x38, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x0C, 0x07,
  0x00, 0x06, 0x07, 0x00, 0x07, 0x07, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x67, 0x80, 0x00, 0x37, 0xE0, 0x00, 0x3F,
  0x38, 0x00, 0x1F, 0x1C, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x03, 0x80, 0x03,
  0x00, 0xE0, 0x01, 0x80, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x30, 0x01, 0xC0, 0x18, 0x00, 0x70, 0x0C, 0x00, 0x18,
  0x0E, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC0, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0x80, 0x07, 0x83, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF8, 0x03,
  0xE0, 0x7C, 0x01, 0xB0, 0x36, 0x01, 0xF8, 0x3B, 0x00, 0xDC, 0x1D, 0x80,
  0xEC, 0x0E, 0xC0, 0x66, 0x06, 0x70, 0x73, 0x03, 0x38, 0x31, 0x81, 0x8C,
  0x39, 0xC1, 0xC6, 0x38, 0xE0, 0xE3, 0x18, 0x60, 0x71, 0x9C, 0x30, 0x30,
  0xEC, 0x18, 0x18, 0x3E, 0x1C, 0x0C, 0x1E, 0x0E, 0x0E, 0x0F, 0x07, 0x07,
  0x07, 0x03, 0x03, 0x83, 0x81, 0x81, 0x81, 0x80, 0xC0, 0xC0, 0x00, 0xE0,
  0x60, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x18, 0x1C, 0x00, 0x0C,
  0x0C, 0x00, 0x06, 0x06, 0x00, 0x07, 0x03, 0x00, 0x03, 0x83, 0x80, 0x01,
  0x80, 0x07, 0x00, 0x03, 0x07, 0x80, 0x03, 0x07, 0x80, 0x07, 0x07, 0x80,
  0x07, 0x07, 0xC0, 0x07, 0x06, 0xC0, 0x06, 0x0E, 0xC0, 0x06, 0x0E, 0xE0,
  0x06, 0x0E, 0x60, 0x0E, 0x0C, 0x60, 0x0E, 0x0C, 0x70, 0x0E, 0x1C, 0x30,
  0x0C, 0x1C, 0x38, 0x0C, 0x1C, 0x38, 0x0C, 0x1C, 0x18, 0x1C, 0x18, 0x1C,
  0x1C, 0x18, 0x1C, 0x1C, 0x38, 0x0C, 0x18, 0x38, 0x0E, 0x18, 0x38, 0x06,
  0x18, 0x30, 0x06, 0x38, 0x30, 0x07, 0x38, 0x30, 0x03, 0x38, 0x70, 0x03,
  0x30, 0x70, 0x03, 0xB0, 0x70, 0x01, 0xF0, 0x60, 0x01, 0xF0, 0x60, 0x01,
  0xF0, 0x60, 0x00, 0xF0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0x01, 0xC0, 0x70, 0x07, 0x07,
  0x00, 0x38, 0x70, 0x00, 0xC3, 0x00, 0x07, 0x38, 0x00, 0x39, 0x80, 0x01,
  0xDC, 0x00, 0x06, 0xE0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x0D,
  0x80, 0x00, 0xEC, 0x00, 0x07, 0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00,
  0x1C, 0xC0, 0x00, 0xC6, 0x00, 0x0E, 0x38, 0x00, 0xE0, 0xC0, 0x07, 0x07,
  0x00, 0x70, 0x1C, 0x0F, 0x00, 0x7F, 0xF0, 0x01, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x1C, 0x01, 0xE0, 0x38, 0x00, 0xE0, 0x60, 0x00,
  0xE0, 0xC0, 0x01, 0xC1, 0x80, 0x01, 0x87, 0x00, 0x03, 0x0E, 0x00, 0x06,
  0x1C, 0x00, 0x0C, 0x30, 0x00, 0x38, 0x60, 0x00, 0x71, 0xC0, 0x01, 0xC3,
  0x80, 0x07, 0x07, 0x00, 0x1E, 0x0C, 0x00, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x1E, 0x03, 0x80, 0x78, 0x03, 0x80, 0xE0, 0x03, 0x03, 0x80, 0x07,
  0x0E, 0x00, 0x06, 0x1C, 0x00, 0x0C, 0x70, 0x00, 0x18, 0xE0, 0x00, 0x31,
  0x80, 0x00, 0x77, 0x00, 0x00, 0xCE, 0x00, 0x01, 0x9C, 0x00, 0x03, 0x30,
  0x00, 0x06, 0x60, 0x00, 0x1C, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00,
  0x00, 0xCE, 0x00, 0x01, 0x9C, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x70, 0x00,
  0x18, 0xE0, 0x00, 0x70, 0xC0, 0x01, 0xC1, 0xC0, 0x03, 0x03, 0x80, 0x0E,
  0x03, 0x80, 0x38, 0x03, 0x81, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0C, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x60, 0x0F, 0x01,
  0x80, 0x0E, 0x06, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x00, 0xC3, 0x80,
  0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x70, 0xC0, 0x01, 0xC7, 0x00, 0x06,
  0x1C, 0x00, 0x38, 0x70, 0x01, 0xC1, 0x80, 0x0E, 0x06, 0x01, 0xF0, 0x1F,
  0xFF, 0x80, 0xFF, 0xF8, 0x03, 0x80, 0xE0, 0x0E, 0x01, 0x80, 0x30, 0x07,
  0x00, 0xC0, 0x1C, 0x07, 0x00, 0x30, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0x81,
  0x80, 0x07, 0x06, 0x00, 0x1C, 0x18, 0x00, 0x70, 0xE0, 0x00, 0xE3, 0x80,
  0x03, 0x8E, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x1E, 0x03, 0xC0, 0x70, 0x03, 0xC1, 0xC0, 0x03, 0x83, 0x80,
  0x03, 0x06, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x70,
  0x00, 0x18, 0xE0, 0x00, 0x31, 0xC0, 0x00, 0xE1, 0x80, 0x01, 0xC3, 0x80,
  0x07, 0x03, 0x80, 0x1E, 0x07, 0x80, 0xF8, 0x07, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x18, 0x60, 0x00, 0x30,
  0xC0, 0x00, 0xE1, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x06, 0x1C,
  0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x70, 0xC0, 0x00, 0xE3, 0x80,
  0x01, 0xC7, 0x00, 0x03, 0x0E, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00,
  0x38, 0x60, 0x00, 0x71, 0xC0, 0x00, 0xC3, 0x80, 0x01, 0x87, 0x00, 0x03,
  0x0C, 0x00, 0x0E, 0x18, 0x00, 0x1C, 0x30, 0x00, 0x38, 0x60, 0x00, 0x60,
  0xC0, 0x01, 0xC1, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x38, 0x03,
  0x81, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0xEE, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x61, 0x80,
  0x03, 0x86, 0x00, 0x0C, 0x18, 0x00, 0x70, 0x70, 0x01, 0x81, 0xC0, 0x0E,
  0x07, 0x00, 0x38, 0x0C, 0x01, 0xC0, 0x30, 0x07, 0x00, 0xC0, 0x38, 0x03,
  0x80, 0xE0, 0x0E, 0x03, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x60, 0x01, 0x83,
  0x80, 0x06, 0x0C, 0x00, 0x18, 0x70, 0x00, 0x71, 0x80, 0x01, 0xCE, 0x00,
  0x07, 0x30, 0x00, 0x0D, 0xC0, 0x00, 0x37, 0x00, 0x00, 0xD8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x18, 0x06, 0xC0, 0x70, 0x0D, 0x80, 0xE0, 0x3B, 0x01, 0xC0, 0x66, 0x07,
  0x80, 0xCC, 0x0F, 0x03, 0x98, 0x1E, 0x06, 0x70, 0x6C, 0x0C, 0xE0, 0xD8,
  0x19, 0xC1, 0xB0, 0x73, 0x86, 0x60, 0xC7, 0x0C, 0xC1, 0x8E, 0x19, 0x87,
  0x1C, 0x63, 0x8C, 0x38, 0xC7, 0x18, 0x71, 0x8E, 0x30, 0xE6, 0x1C, 0xE1,
  0xCC, 0x19, 0x83, 0x98, 0x33, 0x07, 0x60, 0x6E, 0x0E, 0xC0, 0xD8, 0x19,
  0x81, 0xB0, 0x36, 0x03, 0x60, 0x6C, 0x07, 0x80, 0xD8, 0x0F, 0x01, 0xE0,
  0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01,
  0xC0, 0x38, 0x03, 0x00, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x70,
  0x06, 0x00, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0xE0, 0x01, 0xC0,
  0x38, 0x00, 0x38, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x70, 0x00,
  0x06, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0C, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x0E, 0x18, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x30, 0x00, 0x1C,
  0x07, 0x00, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x18, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x00, 0x30, 0x3C, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xE6, 0x00, 0x07, 0x1C, 0x00,
  0x38, 0x70, 0x00, 0xE0, 0xC0, 0x07, 0x03, 0x80, 0x38, 0x0E, 0x00, 0xE0,
  0x18, 0x07, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xC0, 0x03, 0x07, 0x00, 0x0C,
  0x38, 0x00, 0x38, 0xC0, 0x00, 0x67, 0x00, 0x01, 0xB8, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFC,
  0x07, 0xF0, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x7F, 0x01, 0xFC, 0x0F,
  0xF0, 0x00, 0xC0, 0x60, 0x30, 0x1C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x70,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x1C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x70, 0x01, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x70, 0x00, 0xF8, 0x00, 0xD8, 0x01, 0xD8, 0x01, 0x98, 0x03, 0x98, 0x03,
  0x1C, 0x06, 0x0C, 0x0E, 0x0C, 0x0C, 0x0C, 0x1C, 0x0E, 0x18, 0x0E, 0x38,
  0x06, 0x30, 0x06, 0x70, 0x06, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xE3, 0x1C, 0x61, 0x8C, 0x00, 0x3C, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0,
  0x70, 0x0E, 0x0E, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x1F, 0xF0, 0x3F, 0xFE, 0x0F, 0xE0,
  0x63, 0xE0, 0x06, 0x38, 0x00, 0xE7, 0x00, 0x0E, 0x60, 0x00, 0xEE, 0x00,
  0x0C, 0xE0, 0x01, 0xCE, 0x00, 0x3C, 0x70, 0x07, 0xC7, 0x81, 0xFC, 0x3F,
  0xF9, 0xC1, 0xFE, 0x1C, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xC1, 0xE0, 0x0C, 0x7F, 0x80, 0xDF, 0xFC, 0x1F, 0x80,
  0xE1, 0xF0, 0x0E, 0x1E, 0x00, 0x71, 0xC0, 0x07, 0x18, 0x00, 0x31, 0x80,
  0x03, 0x38, 0x00, 0x33, 0x80, 0x03, 0x38, 0x00, 0x33, 0x00, 0x03, 0x30,
  0x00, 0x73, 0x00, 0x07, 0x70, 0x00, 0x67, 0x00, 0x0E, 0x70, 0x00, 0xE7,
  0x00, 0x1C, 0x70, 0x01, 0xC7, 0x80, 0x38, 0xFC, 0x0F, 0x0E, 0xFF, 0xE0,
  0xC3, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x80, 0xF0,
  0x1C, 0x1E, 0x00, 0xE1, 0xC0, 0x06, 0x38, 0x00, 0x63, 0x00, 0x07, 0x70,
  0x00, 0x76, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x1C,
  0xE0, 0x01, 0xC6, 0x00, 0x38, 0x70, 0x07, 0x03, 0x80, 0xE0, 0x1F, 0xFC,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x01, 0xE0, 0xC0, 0x3F, 0xE3, 0x01, 0xFF, 0xDC,
  0x0F, 0x03, 0xF0, 0x70, 0x07, 0xC3, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x70,
  0x00, 0x61, 0xC0, 0x03, 0x86, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00,
  0xC3, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x70, 0xC0, 0x01, 0xC3,
  0x00, 0x07, 0x0E, 0x00, 0x18, 0x38, 0x00, 0xE0, 0x60, 0x03, 0x81, 0xC0,
  0x1E, 0x03, 0x81, 0xF8, 0x0F, 0xFE, 0xE0, 0x0F, 0xE3, 0x00, 0x00, 0x3C,
  0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x80, 0xF0, 0x1C, 0x1E, 0x00, 0xE1, 0xC0,
  0x06, 0x38, 0x00, 0x67, 0x00, 0x07, 0x70, 0x00, 0x76, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEC, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x10,
  0x70, 0x03, 0x83, 0xC0, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x03,
  0xFE, 0x30, 0x1F, 0xFC, 0xC0, 0xF0, 0x3F, 0x07, 0x00, 0x7C, 0x38, 0x00,
  0xE0, 0xE0, 0x03, 0x87, 0x00, 0x06, 0x1C, 0x00, 0x38, 0x60, 0x00, 0xE3,
  0x80, 0x03, 0x8E, 0x00, 0x0C, 0x38, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00,
  0x07, 0x0C, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x01, 0x83, 0x80, 0x0E,
  0x06, 0x00, 0x38, 0x1C, 0x01, 0xE0, 0x38, 0x1F, 0x80, 0xFF, 0xEE, 0x00,
  0xFE, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x60, 0x03, 0x83, 0xC0, 0x3C, 0x07, 0x81, 0xE0, 0x07, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0xF0, 0x0C, 0x7F, 0xC0, 0xCF, 0xFE, 0x1D, 0xC0, 0xE1,
  0xF0, 0x07, 0x1E, 0x00, 0x71, 0xC0, 0x03, 0x18, 0x00, 0x33, 0x80, 0x03,
  0x38, 0x00, 0x33, 0x80, 0x07, 0x38, 0x00, 0x73, 0x00, 0x07, 0x30, 0x00,
  0x67, 0x00, 0x06, 0x70, 0x00, 0x67, 0x00, 0x0E, 0x60, 0x00, 0xE6, 0x00,
  0x0E, 0x60, 0x00, 0xCE, 0x00, 0x0C, 0xE0, 0x00, 0xCE, 0x00, 0x1C, 0xC0,
  0x01, 0xC0, 0x00, 0x02, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x10, 0xE0, 0x03, 0x83, 0x80, 0x3C, 0x0C, 0x01,
  0xE0, 0x30, 0x0F, 0x01, 0xC0, 0x70, 0x07, 0x07, 0x80, 0x1C, 0x3C, 0x00,
  0x71, 0xE0, 0x01, 0x8E, 0x00, 0x06, 0x70, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xE7, 0x00, 0x0E, 0x0E, 0x00, 0x30, 0x38, 0x00, 0xC0, 0x70,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x07, 0x01, 0x80, 0x1E, 0x06,
  0x00, 0x38, 0x18, 0x00, 0x70, 0xE0, 0x01, 0xE0, 0x03, 0xFF, 0x80, 0x7F,
  0xE0, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x70, 0x1C, 0x06, 0xFE, 0x3F, 0x07, 0xFF, 0xFF,
  0xC3, 0xC1, 0xF0, 0x61, 0xC0, 0xF0, 0x38, 0xC0, 0x70, 0x1C, 0x60, 0x38,
  0x0E, 0x70, 0x1C, 0x06, 0x38, 0x0C, 0x03, 0x1C, 0x06, 0x01, 0x8C, 0x03,
  0x01, 0xC6, 0x01, 0x80, 0xE3, 0x01, 0xC0, 0x73, 0x80, 0xE0, 0x31, 0xC0,
  0x60, 0x18, 0xC0, 0x30, 0x0C, 0x60, 0x18, 0x0E, 0x30, 0x0C, 0x07, 0x18,
  0x0E, 0x03, 0x9C, 0x07, 0x01, 0x8E, 0x03, 0x00, 0xC6, 0x01, 0x80, 0x63,
  0x00, 0xC0, 0x71, 0x80, 0xE0, 0x38, 0x00, 0x0E, 0x00, 0xC7, 0xFC, 0x1C,
  0xFF, 0xE1, 0xDC, 0x0E, 0x1B, 0x00, 0x71, 0xE0, 0x07, 0x1C, 0x00, 0x31,
  0x80, 0x03, 0x38, 0x00, 0x33, 0x80, 0x03, 0x38, 0x00, 0x73, 0x00, 0x07,
  0x30, 0x00, 0x73, 0x00, 0x06, 0x70, 0x00, 0x67, 0x00, 0x06, 0x70, 0x00,
  0xE6, 0x00, 0x0E, 0x60, 0x00, 0xE6, 0x00, 0x0C, 0xE0, 0x00, 0xCE, 0x00,
  0x0C, 0xE0, 0x01, 0xCC, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x0F, 0xFC, 0x00,
  0xFF, 0xF0, 0x0F, 0x03, 0xC0, 0xE0, 0x07, 0x0E, 0x00, 0x38, 0xE0, 0x00,
  0xC7, 0x00, 0x07, 0x30, 0x00, 0x3B, 0x80, 0x01, 0xD8, 0x00, 0x0E, 0xC0,
  0x00, 0x76, 0x00, 0x03, 0xF0, 0x00, 0x1B, 0x80, 0x00, 0xDC, 0x00, 0x0E,
  0xE0, 0x00, 0x73, 0x00, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x03, 0x83, 0x80,
  0x38, 0x1E, 0x07, 0x80, 0x7F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x07, 0x80,
  0x0C, 0xFF, 0x80, 0x37, 0xFF, 0x01, 0xF8, 0x1E, 0x07, 0x80, 0x38, 0x1C,
  0x00, 0x70, 0x70, 0x01, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x38, 0x00,
  0x30, 0xE0, 0x00, 0xC3, 0x80, 0x03, 0x0C, 0x00, 0x1C, 0x30, 0x00, 0x70,
  0xC0, 0x01, 0xC7, 0x00, 0x06, 0x1C, 0x00, 0x38, 0x60, 0x00, 0xE1, 0x80,
  0x07, 0x07, 0x00, 0x1C, 0x3E, 0x00, 0xE0, 0xFC, 0x0F, 0x03, 0xBF, 0xF8,
  0x0E, 0x3F, 0x80, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xE3, 0x07, 0xFF, 0x70,
  0xF0, 0x3F, 0x1C, 0x00, 0xF3, 0x80, 0x0E, 0x38, 0x00, 0x67, 0x00, 0x06,
  0x70, 0x00, 0xE6, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0C, 0xE0, 0x00,
  0xCC, 0x00, 0x0C, 0xC0, 0x01, 0xCC, 0x00, 0x1C, 0xC0, 0x01, 0xCE, 0x00,
  0x18, 0xE0, 0x01, 0x86, 0x00, 0x38, 0x70, 0x07, 0x83, 0x81, 0xF8, 0x3F,
  0xFB, 0x80, 0xFE, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xC1, 0xC7, 0xFC, 0x31, 0xFF, 0x86, 0x70,
  0x00, 0xD8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xE0, 0x1E, 0x1C, 0x00,
  0xE1, 0x80, 0x07, 0x38, 0x00, 0x73, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xCC, 0x00, 0x0C, 0xE0, 0x00, 0xCE,
  0x00, 0x1C, 0x70, 0x03, 0x87, 0x80, 0xF8, 0x3F, 0xFE, 0x00, 0xFF, 0xC0,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x1F, 0xFF, 0xFB, 0xFF, 0xFE, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x18, 0x00, 0x31, 0x80, 0x03, 0x38,
  0x00, 0x73, 0x80, 0x07, 0x38, 0x00, 0x73, 0x00, 0x06, 0x30, 0x00, 0x63,
  0x00, 0x06, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE6, 0x00, 0x0C,
  0x60, 0x00, 0xC6, 0x00, 0x0C, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x01,
  0xCE, 0x00, 0x38, 0x60, 0x07, 0x87, 0x00, 0xF8, 0x78, 0x1D, 0x83, 0xFF,
  0xB8, 0x1F, 0xE3, 0x80, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0x98, 0x00, 0x18,
  0xC0, 0x01, 0xC7, 0x00, 0x0C, 0x38, 0x00, 0xE0, 0xC0, 0x06, 0x06, 0x00,
  0x70, 0x38, 0x07, 0x01, 0xC0, 0x30, 0x06, 0x03, 0x80, 0x30, 0x18, 0x01,
  0x81, 0xC0, 0x0E, 0x0C, 0x00, 0x30, 0xE0, 0x01, 0x86, 0x00, 0x0C, 0x70,
  0x00, 0x77, 0x00, 0x01, 0xB0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x1F, 0x00,
  0xE0, 0x37, 0x03, 0xC0, 0x6E, 0x07, 0x81, 0xDC, 0x1B, 0x03, 0x38, 0x36,
  0x06, 0x70, 0x6C, 0x18, 0xE1, 0x98, 0x30, 0xC3, 0x30, 0xE1, 0x8C, 0x61,
  0x83, 0x18, 0xC3, 0x06, 0x70, 0xCC, 0x0C, 0xC1, 0x98, 0x19, 0x83, 0x30,
  0x36, 0x06, 0xC0, 0x6C, 0x0D, 0x80, 0xF0, 0x1B, 0x01, 0xE0, 0x3C, 0x03,
  0xC0, 0x78, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x0F, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x38, 0x03, 0x80, 0x70,
  0x01, 0x80, 0xE0, 0x01, 0xC1, 0xE0, 0x00, 0xE3, 0xC0, 0x00, 0xE3, 0x80,
  0x00, 0x77, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xCE, 0x00, 0x03, 0xC7, 0x00,
  0x03, 0x83, 0x00, 0x07, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x38, 0x00, 0xE0, 0x70, 0x00, 0x60, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x01,
  0xE0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0x30,
  0x00, 0x70, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0xE0,
  0x01, 0x80, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x60,
  0x38, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x70, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xDC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0x80, 0x07, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x0F, 0x80, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x10, 0x00, 0x07, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x38, 0x30, 0x30, 0x30, 0x30, 0x30, 0x70,
  0x60, 0x60, 0x60, 0x60, 0x60, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xF0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x20, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xE0,
  0x03, 0x3D, 0xF0, 0x06, 0x70, 0x78, 0x06, 0xE0, 0x1C, 0x0E, 0xC0, 0x0F,
  0x3C, 0xC0, 0x07, 0xF8, 0x00, 0x01, 0xE0,
};

const GFXglyph RobotoMono_LightItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 8, 31, 26, 9, -31 },
  { 32, 10, 10, 26, 10, -33 },
  { 45, 25, 31, 26, 1, -31 },
  { 142, 21, 40, 26, 3, -36 },
  { 247, 21, 32, 26, 3, -32 },
  { 331, 22, 32, 26, 2, -32 },
  { 419, 4, 10, 26, 12, -33 },
  { 424, 14, 45, 26, 7, -35 },
  { 503, 14, 45, 26, 4, -35 },
  { 582, 20, 19, 26, 5, -31 },
  { 630, 21, 23, 26, 3, -26 },
  { 691, 6, 10, 26, 5, -4 },
  { 699, 16, 2, 26, 5, -15 },
  { 703, 5, 4, 26, 9, -4 },
  { 706, 21, 34, 26, 3, -31 },
  { 796, 21, 32, 26, 3, -32 },
  { 880, 12, 31, 26, 7, -31 },
  { 927, 21, 32, 26, 1, -32 },
  { 1011, 22, 32, 26, 1, -32 },
  { 1099, 22, 31, 26, 1, -31 },
  { 1185, 21, 31, 26, 4, -31 },
  { 1267, 19, 32, 26, 3, -32 },
  { 1343, 20, 31, 26, 5, -31 },
  { 1421, 21, 32, 26, 3, -32 },
  { 1505, 19, 32, 26, 4, -32 },
  { 1581, 8, 23, 26, 10, -23 },
  { 1604, 10, 29, 26, 8, -23 },
  { 1641, 20, 18, 26, 3, -23 },
  { 1686, 20, 11, 26, 3, -20 },
  { 1714, 20, 18, 26, 2, -23 },
  { 1759, 16, 32, 26, 7, -32 },
  { 1823, 25, 31, 26, 1, -31 },
  { 1920, 22, 31, 26, 0, -31 },
  { 2006, 22, 31, 26, 2, -31 },
  { 2092, 23, 32, 26, 2, -32 },
  { 2184, 23, 31, 26, 1, -31 },
  { 2274, 23, 31, 26, 2, -31 },
  { 2364, 24, 31, 26, 2, -31 },
  { 2457, 23, 33, 26, 2, -32 },
  { 2552, 25, 31, 26, 1, -31 },
  { 2649, 23, 31, 26, 2, -31 },
  { 2739, 23, 31, 26, 2, -31 },
  { 2829, 25, 31, 26, 2, -31 },
  { 2926, 19, 31, 26, 2, -31 },
  { 3000, 25, 31, 26, 1, -31 },
  { 3097, 24, 31, 26, 1, -31 },
  { 3190, 21, 32, 26, 3, -32 },
  { 3274, 23, 31, 26, 2, -31 },
  { 3364, 23, 37, 26, 2, -32 },
  { 3471, 22, 31, 26, 2, -31 },
  { 3557, 23, 32, 26, 2, -32 },
  { 3649, 22, 31, 26, 5, -31 },
  { 3735, 23, 31, 26, 3, -31 },
  { 3825, 22, 31, 26, 5, -31 },
  { 3911, 23, 31, 26, 4, -31 },
  { 4001, 27, 31, 26, 0, -31 },
  { 4106, 22, 31, 26, 5, -31 },
  { 4192, 23, 31, 26, 1, -31 },
  { 4282, 14, 43, 26, 6, -36 },
  { 4358, 9, 34, 26, 9, -31 },
  { 4397, 14, 43, 26, 6, -36 },
  { 4473, 16, 17, 26, 5, -31 },
  { 4507, 19, 2, 26, 1, 0 },
  { 4512, 5, 6, 26, 13, -32 },
  { 4516, 20, 24, 26, 2, -24 },
  { 4576, 20, 33, 26, 2, -33 },
  { 4659, 20, 24, 26, 3, -24 },
  { 4719, 22, 33, 26, 3, -33 },
  { 4810, 20, 24, 26, 3, -24 },
  { 4870, 22, 34, 26, 5, -34 },
  { 4964, 22, 33, 26, 1, -24 },
  { 5055, 20, 33, 26, 2, -33 },
  { 5138, 19, 32, 26, 2, -32 },
  { 5214, 20, 41, 26, 0, -32 },
  { 5317, 22, 33, 26, 2, -33 },
  { 5408, 19, 33, 26, 2, -33 },
  { 5487, 25, 24, 26, 0, -24 },
  { 5562, 20, 24, 26, 2, -24 },
  { 5622, 21, 24, 26, 2, -24 },
  { 5685, 22, 33, 26, 0, -24 },
  { 5776, 20, 33, 26, 3, -24 },
  { 5859, 19, 24, 26, 5, -24 },
  { 5916, 20, 24, 26, 3, -24 },
  { 5976, 18, 29, 26, 5, -29 },
  { 6042, 20, 23, 26, 3, -23 },
  { 6100, 21, 23, 26, 4, -23 },
  { 6161, 23, 23, 26, 3, -23 },
  { 6228, 24, 23, 26, 1, -23 },
  { 6297, 27, 32, 26, -1, -23 },
  { 6405, 22, 23, 26, 1, -23 },
  { 6469, 17, 43, 26, 7, -34 },
  { 6561, 8, 38, 26, 9, -31 },
  { 6599, 17, 43, 26, 4, -34 },
  { 6691, 24, 8, 26, 1, -17 },
};

const GFXfont RobotoMono_LightItalic44pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic44pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic44pt7bGlyphs,
  0x20, 0x7E, 58
};

#endif // _ROBOTOMONO_LIGHTITALIC44PT7B_H_
