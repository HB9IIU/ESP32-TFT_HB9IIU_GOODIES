#pragma once

// Auto-generated by fontMaker.py
#include <TFT_eSPI.h>

struct FontEntry
{
  const GFXfont *font;
  uint16_t sizePt;
  const char *name;
};

// Includes are in all_fonts.h (include that before this file)
static const FontEntry kFonts[] = {
  { &RobotoMono_LightItalic6pt7b, 6, "RobotoMono_LightItalic6pt7b" },
  { &RobotoMono_LightItalic7pt7b, 7, "RobotoMono_LightItalic7pt7b" },
  { &RobotoMono_LightItalic8pt7b, 8, "RobotoMono_LightItalic8pt7b" },
  { &RobotoMono_LightItalic9pt7b, 9, "RobotoMono_LightItalic9pt7b" },
  { &RobotoMono_LightItalic10pt7b, 10, "RobotoMono_LightItalic10pt7b" },
  { &RobotoMono_LightItalic11pt7b, 11, "RobotoMono_LightItalic11pt7b" },
  { &RobotoMono_LightItalic12pt7b, 12, "RobotoMono_LightItalic12pt7b" },
  { &RobotoMono_LightItalic13pt7b, 13, "RobotoMono_LightItalic13pt7b" },
  { &RobotoMono_LightItalic14pt7b, 14, "RobotoMono_LightItalic14pt7b" },
  { &RobotoMono_LightItalic15pt7b, 15, "RobotoMono_LightItalic15pt7b" },
  { &RobotoMono_LightItalic16pt7b, 16, "RobotoMono_LightItalic16pt7b" },
  { &RobotoMono_LightItalic17pt7b, 17, "RobotoMono_LightItalic17pt7b" },
  { &RobotoMono_LightItalic18pt7b, 18, "RobotoMono_LightItalic18pt7b" },
  { &RobotoMono_LightItalic19pt7b, 19, "RobotoMono_LightItalic19pt7b" },
  { &RobotoMono_LightItalic20pt7b, 20, "RobotoMono_LightItalic20pt7b" },
  { &RobotoMono_LightItalic21pt7b, 21, "RobotoMono_LightItalic21pt7b" },
  { &RobotoMono_LightItalic22pt7b, 22, "RobotoMono_LightItalic22pt7b" },
  { &RobotoMono_LightItalic23pt7b, 23, "RobotoMono_LightItalic23pt7b" },
  { &RobotoMono_LightItalic24pt7b, 24, "RobotoMono_LightItalic24pt7b" },
  { &RobotoMono_LightItalic25pt7b, 25, "RobotoMono_LightItalic25pt7b" },
  { &RobotoMono_LightItalic26pt7b, 26, "RobotoMono_LightItalic26pt7b" },
  { &RobotoMono_LightItalic27pt7b, 27, "RobotoMono_LightItalic27pt7b" },
  { &RobotoMono_LightItalic28pt7b, 28, "RobotoMono_LightItalic28pt7b" },
  { &RobotoMono_LightItalic29pt7b, 29, "RobotoMono_LightItalic29pt7b" },
  { &RobotoMono_LightItalic30pt7b, 30, "RobotoMono_LightItalic30pt7b" },
  { &RobotoMono_LightItalic31pt7b, 31, "RobotoMono_LightItalic31pt7b" },
  { &RobotoMono_LightItalic32pt7b, 32, "RobotoMono_LightItalic32pt7b" },
  { &RobotoMono_LightItalic33pt7b, 33, "RobotoMono_LightItalic33pt7b" },
  { &RobotoMono_LightItalic34pt7b, 34, "RobotoMono_LightItalic34pt7b" },
  { &RobotoMono_LightItalic35pt7b, 35, "RobotoMono_LightItalic35pt7b" },
  { &RobotoMono_LightItalic36pt7b, 36, "RobotoMono_LightItalic36pt7b" },
  { &RobotoMono_LightItalic37pt7b, 37, "RobotoMono_LightItalic37pt7b" },
  { &RobotoMono_LightItalic38pt7b, 38, "RobotoMono_LightItalic38pt7b" },
  { &RobotoMono_LightItalic39pt7b, 39, "RobotoMono_LightItalic39pt7b" },
  { &RobotoMono_LightItalic40pt7b, 40, "RobotoMono_LightItalic40pt7b" },
  { &RobotoMono_LightItalic41pt7b, 41, "RobotoMono_LightItalic41pt7b" },
  { &RobotoMono_LightItalic42pt7b, 42, "RobotoMono_LightItalic42pt7b" },
  { &RobotoMono_LightItalic43pt7b, 43, "RobotoMono_LightItalic43pt7b" },
  { &RobotoMono_LightItalic44pt7b, 44, "RobotoMono_LightItalic44pt7b" },
  { &RobotoMono_LightItalic45pt7b, 45, "RobotoMono_LightItalic45pt7b" },
  { &RobotoMono_LightItalic46pt7b, 46, "RobotoMono_LightItalic46pt7b" },
  { &RobotoMono_LightItalic47pt7b, 47, "RobotoMono_LightItalic47pt7b" },
  { &RobotoMono_LightItalic48pt7b, 48, "RobotoMono_LightItalic48pt7b" },
  { &RobotoMono_LightItalic49pt7b, 49, "RobotoMono_LightItalic49pt7b" },
  { &RobotoMono_LightItalic50pt7b, 50, "RobotoMono_LightItalic50pt7b" },
  { &RobotoMono_LightItalic51pt7b, 51, "RobotoMono_LightItalic51pt7b" },
  { &RobotoMono_LightItalic52pt7b, 52, "RobotoMono_LightItalic52pt7b" },
  { &RobotoMono_LightItalic53pt7b, 53, "RobotoMono_LightItalic53pt7b" },
  { &RobotoMono_LightItalic54pt7b, 54, "RobotoMono_LightItalic54pt7b" },
  { &RobotoMono_LightItalic55pt7b, 55, "RobotoMono_LightItalic55pt7b" },
  { &RobotoMono_LightItalic56pt7b, 56, "RobotoMono_LightItalic56pt7b" },
  { &RobotoMono_LightItalic57pt7b, 57, "RobotoMono_LightItalic57pt7b" },
  { &RobotoMono_LightItalic58pt7b, 58, "RobotoMono_LightItalic58pt7b" },
  { &RobotoMono_LightItalic59pt7b, 59, "RobotoMono_LightItalic59pt7b" },
  { &RobotoMono_LightItalic60pt7b, 60, "RobotoMono_LightItalic60pt7b" },
  { &RobotoMono_LightItalic61pt7b, 61, "RobotoMono_LightItalic61pt7b" },
  { &RobotoMono_LightItalic62pt7b, 62, "RobotoMono_LightItalic62pt7b" },
  { &RobotoMono_LightItalic63pt7b, 63, "RobotoMono_LightItalic63pt7b" },
  { &RobotoMono_LightItalic64pt7b, 64, "RobotoMono_LightItalic64pt7b" },
  { &RobotoMono_LightItalic65pt7b, 65, "RobotoMono_LightItalic65pt7b" },
  { &RobotoMono_LightItalic66pt7b, 66, "RobotoMono_LightItalic66pt7b" },
  { &RobotoMono_LightItalic67pt7b, 67, "RobotoMono_LightItalic67pt7b" },
  { &RobotoMono_LightItalic68pt7b, 68, "RobotoMono_LightItalic68pt7b" },
  { &RobotoMono_LightItalic69pt7b, 69, "RobotoMono_LightItalic69pt7b" },
  { &RobotoMono_LightItalic70pt7b, 70, "RobotoMono_LightItalic70pt7b" },
  { &RobotoMono_LightItalic71pt7b, 71, "RobotoMono_LightItalic71pt7b" },
  { &RobotoMono_LightItalic72pt7b, 72, "RobotoMono_LightItalic72pt7b" },
};
static constexpr size_t kFontCount = sizeof(kFonts) / sizeof(kFonts[0]);
