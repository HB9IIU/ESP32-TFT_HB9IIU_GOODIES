#ifndef _ROBOTOMONO_LIGHTITALIC14PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x58, 0x20, 0x76, 0xD0, 0x09, 0x0A, 0x12, 0x7F, 0x14, 0x24,
  0xF6, 0x28, 0x48, 0x48, 0x08, 0x79, 0x12, 0x14, 0x04, 0x06, 0x02, 0x85,
  0x09, 0xE1, 0x00, 0x61, 0x2A, 0x95, 0x45, 0x04, 0x0F, 0xA9, 0x92, 0x38,
  0x38, 0x89, 0x22, 0x82, 0x0C, 0x65, 0x46, 0x89, 0xE8, 0xF0, 0x08, 0x88,
  0x84, 0x22, 0x10, 0x84, 0x20, 0x84, 0x10, 0x20, 0x84, 0x10, 0x84, 0x22,
  0x10, 0x84, 0x44, 0x40, 0x10, 0x8E, 0xCC, 0x52, 0x60, 0x10, 0x20, 0x47,
  0xF2, 0x04, 0x08, 0x00, 0xE8, 0xF8, 0x80, 0x02, 0x08, 0x20, 0x41, 0x02,
  0x08, 0x10, 0x40, 0x82, 0x00, 0x3C, 0x89, 0x0C, 0x39, 0xD4, 0xB1, 0x42,
  0x88, 0xE0, 0x3D, 0x12, 0x22, 0x22, 0x24, 0x1C, 0x45, 0x08, 0x10, 0x41,
  0x04, 0x10, 0x41, 0xF8, 0x1C, 0x45, 0x08, 0x11, 0xC0, 0x80, 0xC1, 0x84,
  0xF0, 0x02, 0x0C, 0x28, 0xA2, 0x44, 0x91, 0x5F, 0x04, 0x10, 0x3E, 0x41,
  0x02, 0x07, 0xC0, 0x81, 0x42, 0x84, 0xF0, 0x1C, 0x84, 0x1C, 0xCA, 0x18,
  0x61, 0x89, 0xC0, 0xFC, 0x10, 0x84, 0x10, 0x82, 0x10, 0x82, 0x00, 0x3C,
  0x85, 0x0A, 0x23, 0x89, 0x21, 0x42, 0x84, 0xF0, 0x39, 0x14, 0x61, 0x85,
  0x33, 0x42, 0x19, 0x80, 0x60, 0x00, 0x30, 0x30, 0x00, 0x00, 0x44, 0xC0,
  0x0C, 0xCC, 0x18, 0x1C, 0xFC, 0x0F, 0xC0, 0x60, 0x60, 0x4E, 0xC0, 0x7C,
  0x42, 0x11, 0x11, 0x00, 0x02, 0x00, 0x1E, 0x21, 0x4D, 0x55, 0x65, 0xA5,
  0xA9, 0xB6, 0x40, 0x38, 0x04, 0x18, 0x30, 0xA1, 0x44, 0x8F, 0x21, 0x43,
  0x04, 0x7C, 0x89, 0x0A, 0x2F, 0x90, 0xA1, 0x42, 0x85, 0xF0, 0x3C, 0x85,
  0x0C, 0x08, 0x10, 0x20, 0x42, 0x88, 0xE0, 0x3C, 0x22, 0x21, 0x41, 0x41,
  0x41, 0x42, 0x42, 0x44, 0xF8, 0x7E, 0x81, 0x02, 0x0F, 0xD0, 0x20, 0x40,
  0x81, 0xF0, 0x7E, 0x81, 0x02, 0x07, 0xD0, 0x20, 0x40, 0x81, 0x00, 0x3C,
  0x85, 0x0C, 0x08, 0x13, 0xA1, 0x42, 0x84, 0xF0, 0x21, 0x21, 0x21, 0x41,
  0x7E, 0x42, 0x42, 0x42, 0x82, 0x82, 0x7E, 0x20, 0x40, 0x81, 0x02, 0x08,
  0x10, 0x21, 0xF0, 0x01, 0x01, 0x02, 0x02, 0x02, 0x02, 0x02, 0x82, 0x44,
  0x78, 0x43, 0x44, 0x48, 0x50, 0xA0, 0xD0, 0x90, 0x88, 0x88, 0x84, 0x41,
  0x04, 0x10, 0x42, 0x08, 0x20, 0x83, 0xF0, 0x21, 0x23, 0x33, 0x55, 0x55,
  0x5A, 0x52, 0x42, 0x42, 0x82, 0x21, 0x21, 0x31, 0x51, 0x4A, 0x4A, 0x4A,
  0x46, 0x46, 0x84, 0x3C, 0x89, 0x0C, 0x18, 0x30, 0xA1, 0x42, 0x88, 0xE0,
  0x7C, 0x85, 0x0A, 0x14, 0x4F, 0x20, 0x40, 0x81, 0x00, 0x3C, 0x8A, 0x0C,
  0x18, 0x30, 0x61, 0x42, 0x88, 0xE0, 0x20, 0x60, 0x7C, 0x85, 0x0A, 0x18,
  0x5F, 0x22, 0x44, 0x89, 0x08, 0x3C, 0x85, 0x0A, 0x03, 0x01, 0x01, 0x42,
  0x84, 0xF0, 0xFE, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x80, 0x42,
  0x85, 0x0C, 0x18, 0x50, 0xA1, 0x42, 0x88, 0xE0, 0x82, 0x85, 0x12, 0x24,
  0x89, 0x12, 0x18, 0x20, 0x40, 0x89, 0x92, 0x9A, 0xAA, 0xAA, 0xAC, 0xCC,
  0xCC, 0xC8, 0x88, 0x21, 0x91, 0x04, 0x82, 0x80, 0x80, 0xC0, 0x50, 0x48,
  0x44, 0x41, 0x00, 0x87, 0x0A, 0x22, 0x85, 0x0C, 0x10, 0x20, 0x40, 0x80,
  0x3F, 0x02, 0x04, 0x04, 0x08, 0x10, 0x20, 0x20, 0x40, 0xFE, 0x32, 0x24,
  0x44, 0x44, 0x48, 0x88, 0xC0, 0x92, 0x48, 0x92, 0x48, 0x80, 0x31, 0x11,
  0x12, 0x22, 0x22, 0x22, 0xC0, 0x21, 0x94, 0xA8, 0x80, 0xFC, 0x90, 0x39,
  0x18, 0x41, 0x7E, 0x18, 0xBE, 0x41, 0x04, 0x14, 0x6E, 0x18, 0x61, 0x86,
  0x2F, 0x00, 0x19, 0x98, 0x60, 0x82, 0x08, 0xDE, 0x02, 0x04, 0x08, 0xA6,
  0xD0, 0xA1, 0x42, 0x85, 0x11, 0xE0, 0x19, 0x98, 0x61, 0xFA, 0x08, 0x5E,
  0x0E, 0x60, 0x85, 0xC4, 0x08, 0x10, 0x20, 0x40, 0x82, 0x00, 0x08, 0x6D,
  0x0A, 0x14, 0x28, 0x51, 0x1E, 0x05, 0x09, 0xE0, 0x41, 0x04, 0x16, 0x65,
  0x18, 0x61, 0x86, 0x18, 0x80, 0x08, 0x06, 0x04, 0x10, 0x41, 0x04, 0x23,
  0xF0, 0x04, 0x01, 0x89, 0x04, 0x10, 0x82, 0x08, 0x20, 0x84, 0xE0, 0x40,
  0x81, 0x02, 0x14, 0xCA, 0x28, 0x70, 0x91, 0x12, 0x30, 0x39, 0x20, 0x84,
  0x10, 0x41, 0x04, 0x10, 0x8F, 0xC0, 0x12, 0x6D, 0x49, 0x49, 0x91, 0x92,
  0x92, 0x92, 0x19, 0x98, 0x61, 0x86, 0x18, 0x62, 0x11, 0xB8, 0x61, 0x86,
  0x18, 0x9C, 0x08, 0x6D, 0x0A, 0x14, 0x28, 0x51, 0x3C, 0x81, 0x02, 0x00,
  0x11, 0xB8, 0x61, 0x86, 0x18, 0x9E, 0x08, 0x20, 0x80, 0x1D, 0x84, 0x20,
  0x82, 0x08, 0x20, 0x19, 0x94, 0x50, 0x38, 0x18, 0x5E, 0x25, 0xD0, 0x84,
  0x21, 0x08, 0x70, 0x46, 0x18, 0x61, 0x86, 0x27, 0x80, 0x82, 0x89, 0x22,
  0x45, 0x06, 0x08, 0x00, 0x93, 0x26, 0xD5, 0xAD, 0x59, 0x22, 0x00, 0x63,
  0x14, 0x18, 0x18, 0x28, 0x24, 0xC2, 0x41, 0x22, 0x22, 0x24, 0x28, 0x18,
  0x10, 0x10, 0x20, 0xC0, 0x3E, 0x08, 0x20, 0x82, 0x08, 0x3F, 0x80, 0x0C,
  0x41, 0x08, 0x20, 0x8C, 0x10, 0x20, 0x84, 0x10, 0x20, 0x40, 0x55, 0x5A,
  0xAA, 0x20, 0x41, 0x04, 0x10, 0x40, 0xC6, 0x10, 0x82, 0x08, 0x42, 0x00,
  0x71, 0x8E,
};

const GFXglyph RobotoMono_LightItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 10, 8, 3, -10 },
  { 4, 3, 4, 8, 3, -11 },
  { 6, 8, 10, 8, 0, -10 },
  { 16, 7, 12, 8, 1, -11 },
  { 27, 7, 10, 8, 1, -10 },
  { 36, 7, 10, 8, 1, -10 },
  { 45, 1, 4, 8, 4, -11 },
  { 46, 5, 14, 8, 2, -11 },
  { 55, 5, 14, 8, 1, -11 },
  { 64, 6, 6, 8, 2, -10 },
  { 69, 7, 7, 8, 1, -8 },
  { 76, 2, 3, 8, 2, -1 },
  { 77, 5, 1, 8, 2, -5 },
  { 78, 1, 1, 8, 3, -1 },
  { 79, 7, 11, 8, 1, -10 },
  { 89, 7, 10, 8, 1, -10 },
  { 98, 4, 10, 8, 2, -10 },
  { 103, 7, 10, 8, 0, -10 },
  { 112, 7, 10, 8, 0, -10 },
  { 121, 7, 10, 8, 0, -10 },
  { 130, 7, 10, 8, 1, -10 },
  { 139, 6, 10, 8, 1, -10 },
  { 147, 6, 10, 8, 2, -10 },
  { 155, 7, 10, 8, 1, -10 },
  { 164, 6, 10, 8, 1, -10 },
  { 172, 3, 7, 8, 3, -7 },
  { 175, 4, 9, 8, 2, -7 },
  { 180, 6, 5, 8, 1, -7 },
  { 184, 6, 3, 8, 1, -6 },
  { 187, 6, 5, 8, 1, -7 },
  { 191, 5, 10, 8, 2, -10 },
  { 198, 8, 10, 8, 0, -10 },
  { 208, 7, 10, 8, 0, -10 },
  { 217, 7, 10, 8, 1, -10 },
  { 226, 7, 10, 8, 1, -10 },
  { 235, 8, 10, 8, 0, -10 },
  { 245, 7, 10, 8, 1, -10 },
  { 254, 7, 10, 8, 1, -10 },
  { 263, 7, 10, 8, 1, -10 },
  { 272, 8, 10, 8, 0, -10 },
  { 282, 7, 10, 8, 1, -10 },
  { 291, 8, 10, 8, 0, -10 },
  { 301, 8, 10, 8, 1, -10 },
  { 311, 6, 10, 8, 1, -10 },
  { 319, 8, 10, 8, 0, -10 },
  { 329, 8, 10, 8, 0, -10 },
  { 339, 7, 10, 8, 1, -10 },
  { 348, 7, 10, 8, 1, -10 },
  { 357, 7, 12, 8, 1, -10 },
  { 368, 7, 10, 8, 1, -10 },
  { 377, 7, 10, 8, 1, -10 },
  { 386, 7, 10, 8, 2, -10 },
  { 395, 7, 10, 8, 1, -10 },
  { 404, 7, 10, 8, 1, -10 },
  { 413, 8, 10, 8, 1, -10 },
  { 423, 9, 10, 8, 0, -10 },
  { 435, 7, 10, 8, 2, -10 },
  { 444, 8, 10, 8, 0, -10 },
  { 454, 4, 13, 8, 2, -11 },
  { 461, 3, 11, 8, 3, -10 },
  { 466, 4, 13, 8, 2, -11 },
  { 473, 5, 5, 8, 2, -10 },
  { 477, 6, 1, 8, 0, 0 },
  { 478, 2, 2, 8, 4, -10 },
  { 479, 6, 8, 8, 1, -8 },
  { 485, 6, 11, 8, 1, -11 },
  { 494, 6, 8, 8, 1, -8 },
  { 500, 7, 11, 8, 1, -11 },
  { 510, 6, 8, 8, 1, -8 },
  { 516, 7, 11, 8, 2, -11 },
  { 526, 7, 11, 8, 0, -8 },
  { 536, 6, 11, 8, 1, -11 },
  { 545, 6, 10, 8, 1, -10 },
  { 553, 6, 13, 8, 0, -10 },
  { 563, 7, 11, 8, 1, -11 },
  { 573, 6, 11, 8, 1, -11 },
  { 582, 8, 8, 8, 0, -8 },
  { 590, 6, 8, 8, 1, -8 },
  { 596, 6, 8, 8, 1, -8 },
  { 602, 7, 11, 8, 0, -8 },
  { 612, 6, 11, 8, 1, -8 },
  { 621, 6, 8, 8, 2, -8 },
  { 627, 6, 8, 8, 1, -8 },
  { 633, 5, 9, 8, 2, -9 },
  { 639, 6, 7, 8, 1, -7 },
  { 645, 7, 7, 8, 1, -7 },
  { 652, 7, 7, 8, 1, -7 },
  { 659, 8, 7, 8, 0, -7 },
  { 666, 8, 10, 8, 0, -7 },
  { 676, 7, 7, 8, 0, -7 },
  { 683, 6, 14, 8, 2, -11 },
  { 694, 2, 12, 8, 3, -10 },
  { 697, 6, 14, 8, 1, -11 },
  { 708, 8, 2, 8, 0, -5 },
};

const GFXfont RobotoMono_LightItalic14pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic14pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic14pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _ROBOTOMONO_LIGHTITALIC14PT7B_H_
