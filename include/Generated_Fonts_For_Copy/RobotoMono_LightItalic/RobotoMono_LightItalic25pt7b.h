#ifndef _ROBOTOMONO_LIGHTITALIC25PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0x84, 0x23, 0x18, 0x84, 0x21, 0x18, 0xC4, 0x00, 0x00, 0xC6,
  0x00, 0x4E, 0x63, 0x19, 0xC8, 0x00, 0x84, 0x03, 0x18, 0x04, 0x20, 0x08,
  0x40, 0x31, 0x03, 0xFF, 0xC8, 0x84, 0x03, 0x10, 0x04, 0x20, 0x08, 0xC0,
  0x21, 0x00, 0x42, 0x0F, 0xFF, 0x82, 0x10, 0x04, 0x20, 0x18, 0xC0, 0x21,
  0x00, 0x46, 0x00, 0x01, 0x00, 0x10, 0x07, 0x81, 0xCE, 0x30, 0x62, 0x02,
  0x20, 0x32, 0x00, 0x20, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0C,
  0x00, 0x48, 0x04, 0x80, 0x4C, 0x0C, 0x61, 0x83, 0xF0, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x78, 0x0C, 0x80, 0x84, 0x68, 0x44, 0x8C, 0x88, 0x98, 0x99,
  0x07, 0x20, 0x06, 0x00, 0x40, 0x08, 0xC1, 0xB2, 0x12, 0x22, 0x62, 0x44,
  0x2C, 0x42, 0x06, 0x60, 0x3C, 0x07, 0x80, 0x66, 0x02, 0x10, 0x30, 0x81,
  0x84, 0x0C, 0x60, 0x66, 0x01, 0xC0, 0x0C, 0x00, 0xF0, 0x0C, 0x86, 0xC6,
  0x2C, 0x13, 0x60, 0xD3, 0x03, 0x98, 0x18, 0x61, 0xE1, 0xF1, 0x80, 0x57,
  0xA0, 0x01, 0x03, 0x04, 0x0C, 0x18, 0x10, 0x30, 0x20, 0x20, 0x60, 0x40,
  0x40, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x40, 0x60,
  0x20, 0x10, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x02, 0x03, 0x03, 0x01, 0x01,
  0x01, 0x01, 0x03, 0x03, 0x03, 0x02, 0x02, 0x06, 0x06, 0x04, 0x0C, 0x08,
  0x18, 0x10, 0x20, 0xC0, 0x80, 0x02, 0x00, 0xC0, 0x18, 0x42, 0x1E, 0x4E,
  0x7F, 0x03, 0x00, 0xD0, 0x33, 0x0C, 0x21, 0x06, 0x00, 0x01, 0x00, 0x08,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x01, 0xFF, 0xF0, 0x40, 0x06, 0x00,
  0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x00, 0x2D, 0xAD, 0x00, 0xFF, 0xFF,
  0xC0, 0xFC, 0x00, 0x30, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x01,
  0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x30,
  0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x07, 0x83, 0x18, 0xC1,
  0x90, 0x16, 0x02, 0x80, 0xD0, 0x3E, 0x0D, 0xC2, 0x39, 0x86, 0x61, 0xD8,
  0x3C, 0x05, 0x00, 0xA0, 0x36, 0x0C, 0x63, 0x07, 0xC0, 0x02, 0x39, 0xD6,
  0x20, 0xC1, 0x83, 0x04, 0x08, 0x10, 0x60, 0xC1, 0x02, 0x04, 0x08, 0x30,
  0x60, 0x03, 0xC0, 0x73, 0x86, 0x04, 0x20, 0x23, 0x01, 0x00, 0x08, 0x00,
  0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x07, 0xFF, 0x00, 0x07, 0xC1, 0xC6, 0x30, 0x22,
  0x03, 0x60, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x0F, 0x80, 0xF8, 0x00, 0xC0,
  0x04, 0x00, 0x68, 0x04, 0x80, 0x4C, 0x0C, 0x61, 0x83, 0xF0, 0x00, 0x60,
  0x06, 0x00, 0xA0, 0x1E, 0x03, 0x60, 0x64, 0x04, 0x40, 0x84, 0x18, 0xC3,
  0x0C, 0x60, 0xC4, 0x08, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x10, 0x0F, 0xF1, 0xFF, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x03,
  0xF8, 0x70, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x68, 0x04, 0xC0, 0xCC,
  0x0C, 0x61, 0x83, 0xE0, 0x00, 0xE0, 0x78, 0x38, 0x04, 0x01, 0x00, 0x60,
  0x08, 0xC3, 0x7E, 0x70, 0x6C, 0x05, 0x00, 0xA0, 0x14, 0x02, 0x80, 0xD0,
  0x1B, 0x06, 0x31, 0x83, 0xE0, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x60, 0x08,
  0x03, 0x00, 0x40, 0x18, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x60,
  0x08, 0x03, 0x00, 0x40, 0x18, 0x00, 0x03, 0xC0, 0x73, 0x86, 0x04, 0x20,
  0x31, 0x01, 0x88, 0x0C, 0x40, 0xC3, 0x0C, 0x0F, 0xC0, 0xFE, 0x0C, 0x18,
  0xC0, 0x44, 0x03, 0x20, 0x19, 0x00, 0x88, 0x0C, 0x70, 0xC0, 0xFC, 0x00,
  0x0F, 0x83, 0x98, 0xC1, 0xB0, 0x34, 0x02, 0x80, 0x50, 0x0E, 0x01, 0x40,
  0x6C, 0x1D, 0xC7, 0x1F, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x0E, 0x0F,
  0x00, 0x33, 0x00, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x0C, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x30, 0x86, 0x30, 0x40, 0x00, 0x60, 0x38,
  0x1C, 0x1C, 0x0E, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x10, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x30, 0x03, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x07, 0x03, 0x81, 0xE0, 0x70, 0x0C, 0x00, 0x1E,
  0x39, 0xB0, 0x70, 0x10, 0x08, 0x0C, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0xE0, 0x18, 0xC1,
  0x81, 0x84, 0x02, 0x23, 0xC9, 0x11, 0x24, 0xC4, 0xB2, 0x12, 0x88, 0x8A,
  0x42, 0x29, 0x08, 0xA4, 0x64, 0x92, 0x92, 0x7B, 0x88, 0x00, 0x30, 0x00,
  0x61, 0x00, 0xFE, 0x00, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x14, 0x03, 0x60,
  0x26, 0x02, 0x60, 0x42, 0x04, 0x20, 0xC2, 0x08, 0x21, 0x82, 0x1F, 0xF3,
  0x03, 0x20, 0x36, 0x01, 0x40, 0x1C, 0x01, 0x1F, 0x80, 0xFF, 0x04, 0x0C,
  0x20, 0x23, 0x01, 0x98, 0x08, 0x80, 0xC4, 0x0C, 0x3F, 0xC3, 0x0E, 0x18,
  0x08, 0xC0, 0x64, 0x03, 0x20, 0x19, 0x00, 0x98, 0x0C, 0xC1, 0xC7, 0xF8,
  0x00, 0x03, 0xC0, 0x73, 0x86, 0x04, 0x20, 0x33, 0x01, 0x90, 0x0D, 0x80,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x01, 0x20, 0x11,
  0x01, 0x8C, 0x08, 0x31, 0x80, 0xF8, 0x00, 0x1F, 0x00, 0x8F, 0x04, 0x0C,
  0x60, 0x23, 0x01, 0x90, 0x0C, 0x80, 0x64, 0x03, 0x60, 0x1B, 0x00, 0xD8,
  0x04, 0x80, 0x24, 0x03, 0x20, 0x13, 0x01, 0x98, 0x18, 0xC3, 0x87, 0xF0,
  0x00, 0x1F, 0xF8, 0xFF, 0xC4, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x04, 0x00, 0x3F, 0xE1, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0xC0, 0x27, 0xFE, 0x00, 0x1F, 0xFC, 0x7F, 0xE1, 0x00,
  0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x3F, 0xE0, 0xFF,
  0x82, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x03, 0xC0, 0x73, 0x86, 0x04, 0x60, 0x32, 0x01, 0xB0,
  0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0xFD, 0x80, 0x6C, 0x03,
  0x20, 0x19, 0x00, 0x8C, 0x04, 0x30, 0xE0, 0xFC, 0x00, 0x10, 0x09, 0x80,
  0x4C, 0x02, 0x40, 0x12, 0x01, 0x90, 0x0C, 0x80, 0x4C, 0x02, 0x7F, 0xF2,
  0x00, 0x90, 0x0C, 0x80, 0x64, 0x02, 0x60, 0x13, 0x00, 0x90, 0x0C, 0x80,
  0x64, 0x03, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x40, 0x02, 0x00, 0x10, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x07, 0xFE, 0x00, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x40, 0x32, 0x01, 0x18, 0x18, 0x61,
  0x81, 0xF0, 0x00, 0x18, 0x0C, 0x40, 0x61, 0x03, 0x04, 0x18, 0x30, 0xC0,
  0xC6, 0x03, 0x30, 0x09, 0x80, 0x2E, 0x00, 0xF8, 0x07, 0x30, 0x18, 0x40,
  0x61, 0x81, 0x02, 0x04, 0x0C, 0x10, 0x10, 0xC0, 0x63, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04,
  0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x1F, 0xFC,
  0x18, 0x0C, 0x60, 0x63, 0x83, 0x8E, 0x0A, 0x28, 0x68, 0xB1, 0x62, 0xCD,
  0x89, 0x24, 0x65, 0x91, 0x94, 0x44, 0x73, 0x11, 0x8C, 0x46, 0x33, 0x00,
  0x8C, 0x02, 0x30, 0x08, 0x80, 0x62, 0x01, 0x80, 0x10, 0x09, 0xC0, 0x4E,
  0x02, 0x70, 0x32, 0xC1, 0x92, 0x0C, 0x90, 0x4C, 0xC2, 0x62, 0x13, 0x11,
  0x90, 0xCC, 0x82, 0x64, 0x12, 0x60, 0xD3, 0x02, 0x98, 0x1C, 0x80, 0xE4,
  0x03, 0x00, 0x03, 0xC0, 0x73, 0x06, 0x0C, 0x20, 0x22, 0x01, 0x90, 0x0D,
  0x80, 0x68, 0x03, 0x40, 0x12, 0x00, 0x90, 0x05, 0x80, 0x6C, 0x03, 0x20,
  0x11, 0x01, 0x8C, 0x18, 0x31, 0x80, 0xF8, 0x00, 0x1F, 0xC0, 0xC3, 0x84,
  0x06, 0x20, 0x11, 0x00, 0x98, 0x04, 0xC0, 0x26, 0x03, 0x20, 0x31, 0xFF,
  0x0F, 0xC0, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06,
  0x00, 0x00, 0x03, 0xC0, 0x73, 0x06, 0x0C, 0x60, 0x32, 0x01, 0xB0, 0x0D,
  0x80, 0x28, 0x03, 0x40, 0x1E, 0x00, 0xF0, 0x05, 0x80, 0x2C, 0x03, 0x60,
  0x11, 0x01, 0x8C, 0x08, 0x31, 0x80, 0xF8, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x1F, 0x80, 0x87, 0x04, 0x0C, 0x20, 0x33, 0x01, 0x98, 0x0C, 0xC0,
  0x44, 0x06, 0x20, 0x61, 0xFE, 0x1F, 0xE0, 0xC3, 0x06, 0x08, 0x20, 0x61,
  0x03, 0x08, 0x08, 0xC0, 0x66, 0x03, 0x00, 0x07, 0xC0, 0x73, 0x86, 0x04,
  0x60, 0x33, 0x01, 0x98, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x18, 0x00, 0x40, 0x03, 0x60, 0x1B, 0x00, 0xC8, 0x0C, 0x70, 0xC0, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01,
  0x00, 0x10, 0x03, 0x00, 0x10, 0x0C, 0xC0, 0x23, 0x00, 0x88, 0x02, 0x20,
  0x18, 0x80, 0x62, 0x01, 0x18, 0x04, 0x60, 0x11, 0x00, 0x44, 0x03, 0x10,
  0x0C, 0x40, 0x21, 0x00, 0x84, 0x06, 0x18, 0x30, 0x31, 0x80, 0x7C, 0x00,
  0x80, 0x38, 0x02, 0xC0, 0x6C, 0x06, 0xC0, 0x4C, 0x0C, 0x40, 0x84, 0x18,
  0x41, 0x06, 0x30, 0x62, 0x06, 0x60, 0x24, 0x02, 0xC0, 0x28, 0x02, 0x80,
  0x30, 0x03, 0x00, 0x43, 0x0D, 0x0C, 0x24, 0x30, 0x91, 0xC6, 0x45, 0x11,
  0x14, 0x44, 0xD3, 0x32, 0x48, 0xC9, 0x23, 0x64, 0x8D, 0x16, 0x34, 0x50,
  0xF1, 0x43, 0x87, 0x0E, 0x18, 0x38, 0x60, 0xC1, 0x83, 0x06, 0x00, 0x18,
  0x06, 0x10, 0x18, 0x30, 0x20, 0x20, 0xC0, 0x63, 0x00, 0xC4, 0x00, 0x90,
  0x01, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0A, 0x00, 0x36, 0x00, 0xC4, 0x03,
  0x0C, 0x04, 0x18, 0x18, 0x10, 0x60, 0x31, 0x80, 0x30, 0x80, 0x3C, 0x02,
  0xC0, 0x64, 0x0C, 0x60, 0x86, 0x18, 0x23, 0x03, 0x20, 0x36, 0x01, 0xC0,
  0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00,
  0x1F, 0xFC, 0x7F, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60,
  0x03, 0x00, 0x08, 0x00, 0x40, 0x03, 0xFF, 0xC0, 0x1E, 0x20, 0x40, 0x81,
  0x06, 0x0C, 0x18, 0x20, 0x40, 0x81, 0x06, 0x0C, 0x10, 0x20, 0x40, 0x83,
  0x06, 0x08, 0x10, 0x20, 0x78, 0x84, 0x30, 0x84, 0x21, 0x0C, 0x21, 0x08,
  0x43, 0x08, 0x42, 0x10, 0xC2, 0x10, 0x0F, 0x01, 0x03, 0x03, 0x02, 0x02,
  0x02, 0x02, 0x06, 0x06, 0x06, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x0C, 0x08,
  0x08, 0x08, 0x08, 0x18, 0x18, 0xF8, 0x06, 0x03, 0x03, 0x81, 0x41, 0x31,
  0x98, 0x84, 0xC2, 0x41, 0x60, 0xC0, 0xFF, 0xC0, 0xCC, 0x80, 0x0F, 0xC1,
  0x86, 0x30, 0x20, 0x03, 0x00, 0x20, 0x7E, 0x3C, 0x26, 0x06, 0x40, 0x6C,
  0x06, 0xC0, 0xC6, 0x3C, 0x3E, 0x40, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00,
  0x10, 0x03, 0x00, 0x37, 0xC2, 0x86, 0x30, 0x22, 0x03, 0x20, 0x36, 0x03,
  0x60, 0x34, 0x02, 0x40, 0x24, 0x06, 0x60, 0xCF, 0x18, 0xDF, 0x00, 0x1F,
  0x86, 0x19, 0x81, 0xA0, 0x3C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x1B, 0x02, 0x31, 0xC3, 0xE0, 0x00, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00,
  0x20, 0x02, 0x1F, 0xA3, 0x0E, 0x60, 0x64, 0x06, 0xC0, 0x48, 0x04, 0x80,
  0x48, 0x0C, 0x80, 0xC8, 0x0C, 0xC1, 0x84, 0x38, 0x7E, 0x80, 0x0F, 0xC1,
  0x86, 0x30, 0x32, 0x03, 0x60, 0x37, 0xFF, 0x7F, 0xF4, 0x00, 0x40, 0x04,
  0x00, 0x60, 0x63, 0x0C, 0x1F, 0x80, 0x01, 0xF0, 0x70, 0x04, 0x00, 0xC0,
  0x08, 0x00, 0x80, 0xFF, 0xC1, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x00, 0x0F,
  0xD1, 0x87, 0x30, 0x32, 0x03, 0x60, 0x24, 0x02, 0x40, 0x24, 0x06, 0x40,
  0x64, 0x06, 0x60, 0xC3, 0x1C, 0x3F, 0x40, 0x0C, 0x00, 0xC8, 0x18, 0xC3,
  0x07, 0xE0, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x37,
  0xE2, 0x86, 0x30, 0x32, 0x03, 0x60, 0x36, 0x02, 0x60, 0x24, 0x02, 0x40,
  0x24, 0x06, 0xC0, 0x6C, 0x04, 0xC0, 0x40, 0x00, 0x80, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00,
  0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x1F, 0xFC, 0x00, 0x20, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01,
  0x00, 0x30, 0x03, 0x00, 0x60, 0xFC, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x04, 0xC0, 0xC6, 0x0C, 0x31, 0x81, 0x18, 0x09,
  0x80, 0x58, 0x07, 0xE0, 0x31, 0x01, 0x8C, 0x08, 0x30, 0x41, 0x82, 0x06,
  0x30, 0x18, 0x0F, 0xC3, 0xF0, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x30,
  0x06, 0x00, 0xC3, 0xFF, 0x80, 0x2F, 0x78, 0xC6, 0x32, 0x18, 0x58, 0x41,
  0x61, 0x0D, 0x04, 0x34, 0x30, 0x90, 0xC2, 0x42, 0x0B, 0x08, 0x6C, 0x21,
  0xA0, 0x84, 0x86, 0x10, 0x37, 0xE2, 0x86, 0x30, 0x32, 0x03, 0x60, 0x36,
  0x02, 0x60, 0x24, 0x02, 0x40, 0x64, 0x06, 0xC0, 0x6C, 0x04, 0xC0, 0x40,
  0x0F, 0xC1, 0x86, 0x30, 0x26, 0x03, 0x40, 0x34, 0x01, 0xC0, 0x3C, 0x03,
  0xC0, 0x24, 0x06, 0x40, 0x46, 0x18, 0x1F, 0x00, 0x1B, 0xE0, 0xE1, 0x86,
  0x04, 0x20, 0x31, 0x01, 0x98, 0x0C, 0xC0, 0x64, 0x02, 0x20, 0x31, 0x01,
  0x98, 0x18, 0xE1, 0x86, 0xF8, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0x1F, 0xA6, 0x1D, 0x81, 0xA0, 0x3C, 0x05, 0x00, 0xA0, 0x14,
  0x06, 0x80, 0xD0, 0x1B, 0x06, 0x21, 0xC7, 0xE8, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x00, 0x20, 0x37, 0xE5, 0x80, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18,
  0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x1F, 0xC6, 0x09,
  0x81, 0xB0, 0x16, 0x00, 0x70, 0x03, 0xC0, 0x0C, 0x00, 0xD0, 0x0A, 0x03,
  0x60, 0xC3, 0xF0, 0x0C, 0x02, 0x00, 0x80, 0x20, 0xFF, 0xC6, 0x01, 0x80,
  0x40, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0xC0, 0x1F,
  0x00, 0x60, 0x2C, 0x05, 0x01, 0xA0, 0x34, 0x07, 0x80, 0xB0, 0x16, 0x02,
  0x80, 0xD0, 0x1B, 0x06, 0x61, 0xC7, 0xC8, 0xC0, 0x34, 0x02, 0x40, 0x66,
  0x04, 0x60, 0xC2, 0x18, 0x21, 0x03, 0x30, 0x32, 0x01, 0x60, 0x14, 0x01,
  0xC0, 0x18, 0x00, 0x82, 0x1C, 0x30, 0xA1, 0x85, 0x14, 0x68, 0xA2, 0x4D,
  0x12, 0x49, 0x12, 0x48, 0xA2, 0xC5, 0x1C, 0x38, 0x61, 0x82, 0x0C, 0x10,
  0x00, 0x18, 0x0C, 0x20, 0x60, 0xC3, 0x01, 0x18, 0x02, 0xC0, 0x0E, 0x00,
  0x30, 0x01, 0xE0, 0x0C, 0x80, 0x23, 0x01, 0x06, 0x0C, 0x08, 0xE0, 0x30,
  0x30, 0x06, 0x60, 0x18, 0x40, 0x60, 0x80, 0x81, 0x83, 0x01, 0x04, 0x02,
  0x18, 0x06, 0x60, 0x0C, 0x80, 0x0B, 0x00, 0x14, 0x00, 0x38, 0x00, 0x60,
  0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x01, 0xC0, 0x00, 0x3F, 0xF0,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x00, 0xFF, 0xE0, 0x00, 0x40, 0x70, 0x20, 0x18, 0x04,
  0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0xC0, 0xE0, 0x38, 0x03,
  0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0x60,
  0x04, 0x00, 0x18, 0x84, 0x21, 0x18, 0xC4, 0x21, 0x08, 0x46, 0x21, 0x08,
  0x42, 0x31, 0x88, 0x40, 0x0C, 0x01, 0x80, 0x20, 0x08, 0x03, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x30, 0x07, 0x03, 0x81, 0x80, 0x40, 0x30,
  0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x04, 0x06, 0x03, 0x00, 0x08, 0x00,
  0xF8, 0x16, 0x30, 0xD0, 0x7E, 0x80, 0x70,
};

const GFXglyph RobotoMono_LightItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 5, 18, 15, 5, -18 },
  { 13, 5, 6, 15, 6, -19 },
  { 17, 15, 18, 15, 0, -18 },
  { 51, 12, 23, 15, 2, -20 },
  { 86, 12, 18, 15, 2, -18 },
  { 113, 13, 18, 15, 1, -18 },
  { 143, 2, 6, 15, 7, -19 },
  { 145, 8, 26, 15, 4, -20 },
  { 171, 8, 26, 15, 2, -20 },
  { 197, 11, 11, 15, 3, -18 },
  { 213, 13, 13, 15, 1, -15 },
  { 235, 3, 6, 15, 3, -2 },
  { 238, 9, 2, 15, 3, -9 },
  { 241, 3, 2, 15, 5, -2 },
  { 242, 12, 20, 15, 2, -18 },
  { 272, 11, 18, 15, 2, -18 },
  { 297, 7, 18, 15, 4, -18 },
  { 313, 13, 18, 15, 0, -18 },
  { 343, 12, 18, 15, 1, -18 },
  { 370, 12, 18, 15, 1, -18 },
  { 397, 12, 18, 15, 2, -18 },
  { 424, 11, 18, 15, 1, -18 },
  { 449, 11, 18, 15, 3, -18 },
  { 474, 13, 18, 15, 1, -18 },
  { 504, 11, 18, 15, 2, -18 },
  { 529, 4, 13, 15, 6, -13 },
  { 536, 6, 17, 15, 4, -13 },
  { 549, 11, 10, 15, 2, -13 },
  { 563, 11, 6, 15, 2, -11 },
  { 572, 12, 10, 15, 1, -13 },
  { 587, 9, 18, 15, 4, -18 },
  { 608, 14, 18, 15, 1, -18 },
  { 640, 12, 18, 15, 0, -18 },
  { 667, 13, 18, 15, 1, -18 },
  { 697, 13, 18, 15, 1, -18 },
  { 727, 13, 18, 15, 1, -18 },
  { 757, 13, 18, 15, 1, -18 },
  { 787, 14, 18, 15, 1, -18 },
  { 819, 13, 18, 15, 1, -18 },
  { 849, 13, 18, 15, 1, -18 },
  { 879, 13, 18, 15, 1, -18 },
  { 909, 13, 18, 15, 1, -18 },
  { 939, 14, 18, 15, 1, -18 },
  { 971, 11, 18, 15, 1, -18 },
  { 996, 14, 18, 15, 1, -18 },
  { 1028, 13, 18, 15, 1, -18 },
  { 1058, 13, 18, 15, 1, -18 },
  { 1088, 13, 18, 15, 1, -18 },
  { 1118, 13, 21, 15, 1, -18 },
  { 1153, 13, 18, 15, 1, -18 },
  { 1183, 13, 18, 15, 1, -18 },
  { 1213, 12, 18, 15, 3, -18 },
  { 1240, 14, 18, 15, 1, -18 },
  { 1272, 12, 18, 15, 3, -18 },
  { 1299, 14, 18, 15, 2, -18 },
  { 1331, 15, 18, 15, 0, -18 },
  { 1365, 12, 18, 15, 3, -18 },
  { 1392, 14, 18, 15, 0, -18 },
  { 1424, 7, 24, 15, 4, -20 },
  { 1445, 5, 20, 15, 5, -18 },
  { 1458, 8, 24, 15, 3, -20 },
  { 1482, 9, 10, 15, 3, -18 },
  { 1494, 10, 1, 15, 1, 0 },
  { 1496, 3, 3, 15, 7, -18 },
  { 1498, 12, 13, 15, 1, -13 },
  { 1518, 12, 19, 15, 1, -19 },
  { 1547, 11, 13, 15, 2, -13 },
  { 1565, 12, 19, 15, 2, -19 },
  { 1594, 12, 13, 15, 1, -13 },
  { 1614, 12, 19, 15, 3, -19 },
  { 1643, 12, 18, 15, 1, -13 },
  { 1670, 12, 19, 15, 1, -19 },
  { 1699, 11, 18, 15, 1, -18 },
  { 1724, 12, 23, 15, 0, -18 },
  { 1759, 13, 19, 15, 1, -19 },
  { 1790, 11, 19, 15, 1, -19 },
  { 1817, 14, 13, 15, 0, -13 },
  { 1840, 12, 13, 15, 1, -13 },
  { 1860, 12, 13, 15, 1, -13 },
  { 1880, 13, 18, 15, 0, -13 },
  { 1910, 11, 18, 15, 2, -13 },
  { 1935, 11, 13, 15, 3, -13 },
  { 1953, 11, 13, 15, 2, -13 },
  { 1971, 10, 17, 15, 3, -17 },
  { 1993, 11, 13, 15, 2, -13 },
  { 2011, 12, 13, 15, 2, -13 },
  { 2031, 13, 13, 15, 2, -13 },
  { 2053, 14, 13, 15, 0, -13 },
  { 2076, 15, 18, 15, 0, -13 },
  { 2110, 12, 13, 15, 1, -13 },
  { 2130, 10, 25, 15, 4, -20 },
  { 2162, 5, 22, 15, 5, -18 },
  { 2176, 10, 24, 15, 2, -19 },
  { 2206, 14, 5, 15, 0, -10 },
};

const GFXfont RobotoMono_LightItalic25pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic25pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic25pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _ROBOTOMONO_LIGHTITALIC25PT7B_H_
