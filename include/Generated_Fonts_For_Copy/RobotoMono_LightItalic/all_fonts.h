#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/RobotoMono_LightItalic
// Headers: 67

#include "RobotoMono_LightItalic6pt7b.h"
#include "RobotoMono_LightItalic7pt7b.h"
#include "RobotoMono_LightItalic8pt7b.h"
#include "RobotoMono_LightItalic9pt7b.h"
#include "RobotoMono_LightItalic10pt7b.h"
#include "RobotoMono_LightItalic11pt7b.h"
#include "RobotoMono_LightItalic12pt7b.h"
#include "RobotoMono_LightItalic13pt7b.h"
#include "RobotoMono_LightItalic14pt7b.h"
#include "RobotoMono_LightItalic15pt7b.h"
#include "RobotoMono_LightItalic16pt7b.h"
#include "RobotoMono_LightItalic17pt7b.h"
#include "RobotoMono_LightItalic18pt7b.h"
#include "RobotoMono_LightItalic19pt7b.h"
#include "RobotoMono_LightItalic20pt7b.h"
#include "RobotoMono_LightItalic21pt7b.h"
#include "RobotoMono_LightItalic22pt7b.h"
#include "RobotoMono_LightItalic23pt7b.h"
#include "RobotoMono_LightItalic24pt7b.h"
#include "RobotoMono_LightItalic25pt7b.h"
#include "RobotoMono_LightItalic26pt7b.h"
#include "RobotoMono_LightItalic27pt7b.h"
#include "RobotoMono_LightItalic28pt7b.h"
#include "RobotoMono_LightItalic29pt7b.h"
#include "RobotoMono_LightItalic30pt7b.h"
#include "RobotoMono_LightItalic31pt7b.h"
#include "RobotoMono_LightItalic32pt7b.h"
#include "RobotoMono_LightItalic33pt7b.h"
#include "RobotoMono_LightItalic34pt7b.h"
#include "RobotoMono_LightItalic35pt7b.h"
#include "RobotoMono_LightItalic36pt7b.h"
#include "RobotoMono_LightItalic37pt7b.h"
#include "RobotoMono_LightItalic38pt7b.h"
#include "RobotoMono_LightItalic39pt7b.h"
#include "RobotoMono_LightItalic40pt7b.h"
#include "RobotoMono_LightItalic41pt7b.h"
#include "RobotoMono_LightItalic42pt7b.h"
#include "RobotoMono_LightItalic43pt7b.h"
#include "RobotoMono_LightItalic44pt7b.h"
#include "RobotoMono_LightItalic45pt7b.h"
#include "RobotoMono_LightItalic46pt7b.h"
#include "RobotoMono_LightItalic47pt7b.h"
#include "RobotoMono_LightItalic48pt7b.h"
#include "RobotoMono_LightItalic49pt7b.h"
#include "RobotoMono_LightItalic50pt7b.h"
#include "RobotoMono_LightItalic51pt7b.h"
#include "RobotoMono_LightItalic52pt7b.h"
#include "RobotoMono_LightItalic53pt7b.h"
#include "RobotoMono_LightItalic54pt7b.h"
#include "RobotoMono_LightItalic55pt7b.h"
#include "RobotoMono_LightItalic56pt7b.h"
#include "RobotoMono_LightItalic57pt7b.h"
#include "RobotoMono_LightItalic58pt7b.h"
#include "RobotoMono_LightItalic59pt7b.h"
#include "RobotoMono_LightItalic60pt7b.h"
#include "RobotoMono_LightItalic61pt7b.h"
#include "RobotoMono_LightItalic62pt7b.h"
#include "RobotoMono_LightItalic63pt7b.h"
#include "RobotoMono_LightItalic64pt7b.h"
#include "RobotoMono_LightItalic65pt7b.h"
#include "RobotoMono_LightItalic66pt7b.h"
#include "RobotoMono_LightItalic67pt7b.h"
#include "RobotoMono_LightItalic68pt7b.h"
#include "RobotoMono_LightItalic69pt7b.h"
#include "RobotoMono_LightItalic70pt7b.h"
#include "RobotoMono_LightItalic71pt7b.h"
#include "RobotoMono_LightItalic72pt7b.h"
