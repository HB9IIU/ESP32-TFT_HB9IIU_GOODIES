#ifndef _ROBOTOMONO_LIGHTITALIC60PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03,
  0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0,
  0x00, 0x38, 0x39, 0xC1, 0xDC, 0x0E, 0xE0, 0x77, 0x03, 0xB8, 0x19, 0xC1,
  0xCC, 0x0E, 0xE0, 0x77, 0x03, 0xB8, 0x19, 0xC0, 0xCC, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x03, 0x80, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x1C, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x00, 0x30, 0x07, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x7C, 0x00, 0x78,
  0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x78, 0x1E,
  0x00, 0x01, 0xC0, 0xF0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x1E, 0x03,
  0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1E,
  0x3C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x00, 0xE0,
  0x08, 0x60, 0x0E, 0x01, 0xCE, 0x00, 0xE0, 0x1C, 0xE0, 0x0E, 0x03, 0x8E,
  0x00, 0xC0, 0x70, 0xE0, 0x0C, 0x0F, 0x0E, 0x01, 0xC0, 0xE0, 0xE0, 0x1C,
  0x1C, 0x0E, 0x01, 0xC3, 0x80, 0xE0, 0x38, 0x38, 0x07, 0x07, 0x07, 0x00,
  0x7F, 0xF0, 0xE0, 0x03, 0xFE, 0x0E, 0x00, 0x1F, 0x81, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0x83, 0xFC, 0x00,
  0x70, 0x7F, 0xE0, 0x07, 0x0F, 0x0E, 0x00, 0xE1, 0xE0, 0x70, 0x1C, 0x1C,
  0x07, 0x03, 0xC3, 0x80, 0x70, 0x38, 0x38, 0x03, 0x07, 0x03, 0x80, 0x30,
  0xE0, 0x38, 0x07, 0x0E, 0x03, 0x00, 0x71, 0xC0, 0x70, 0x07, 0x38, 0x07,
  0x00, 0x71, 0x80, 0x70, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x1C,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x0F, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0xF0, 0x03,
  0x80, 0x01, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1C, 0x0F, 0x00,
  0x00, 0x38, 0x7C, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x00, 0x77, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xF3, 0xC0, 0x01, 0x07,
  0x83, 0x80, 0x1C, 0x1E, 0x07, 0x80, 0x38, 0x78, 0x07, 0x80, 0x71, 0xF0,
  0x0F, 0x01, 0xE3, 0xC0, 0x0F, 0x03, 0x8F, 0x00, 0x0F, 0x07, 0x1E, 0x00,
  0x1E, 0x1E, 0x38, 0x00, 0x1E, 0x38, 0x70, 0x00, 0x1C, 0xF0, 0xE0, 0x00,
  0x3F, 0xC1, 0xC0, 0x00, 0x3F, 0x03, 0x80, 0x00, 0x7E, 0x07, 0x80, 0x00,
  0x78, 0x0F, 0x00, 0x03, 0xF8, 0x0F, 0x00, 0x0F, 0xF0, 0x1F, 0x00, 0x7E,
  0xF0, 0x1F, 0xE7, 0xF1, 0xE0, 0x0F, 0xFF, 0xC1, 0xE0, 0x0F, 0xFE, 0x01,
  0xE0, 0x00, 0xC0, 0x00, 0x00, 0x39, 0xCE, 0x77, 0x39, 0xCE, 0x73, 0x39,
  0xCE, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x20, 0x06, 0x00, 0x5E, 0x03, 0x80, 0xF7, 0xF0, 0xE1, 0xFF, 0xFF, 0x39,
  0xFF, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0x38, 0x00,
  0x0F, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0x78, 0x01, 0xF0, 0x0F,
  0x00, 0xF8, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x02, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x1E, 0x1E, 0x1E,
  0x1C, 0x3C, 0x38, 0x78, 0xF0, 0xE0, 0x40, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x21, 0xEF, 0xFF, 0xFB, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xC0, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x3E, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0xE0, 0x78, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x71, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xF1, 0xC0, 0x00,
  0x3F, 0x3C, 0x00, 0x07, 0xF3, 0xC0, 0x00, 0xF7, 0x38, 0x00, 0x1E, 0x73,
  0x80, 0x07, 0xCF, 0x38, 0x00, 0xF8, 0xF3, 0x80, 0x1E, 0x0F, 0x78, 0x03,
  0xC0, 0xE7, 0x80, 0xF8, 0x0E, 0x70, 0x1F, 0x00, 0xE7, 0x03, 0xC0, 0x0E,
  0x70, 0x78, 0x01, 0xE7, 0x1F, 0x00, 0x1E, 0xF3, 0xC0, 0x01, 0xCF, 0x78,
  0x00, 0x1C, 0xFF, 0x00, 0x01, 0xCF, 0xE0, 0x00, 0x3C, 0xF8, 0x00, 0x03,
  0x8F, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x0F, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x1E, 0x07, 0x80, 0x03,
  0xC0, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x1F, 0xC7, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0x00, 0x07, 0x00, 0x3F, 0x00, 0xFF, 0x07, 0xFF, 0x1F, 0xEE, 0xFF, 0x0E,
  0xFC, 0x0E, 0xE0, 0x0E, 0x80, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xF8, 0x0F, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x0F, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x38, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x07, 0xC0, 0x01, 0xE0, 0x1E,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x1E, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x78,
  0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x03, 0xE0,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x07, 0xB8, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x01, 0xE3, 0x80, 0x00,
  0x0F, 0x0E, 0x00, 0x00, 0x38, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F,
  0x07, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x0E, 0x03,
  0xC0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x1E, 0x00, 0xE0,
  0x00, 0xF0, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0x80, 0x07, 0x00, 0x3C, 0x00, 0x1C, 0x01, 0xE0,
  0x00, 0x70, 0x07, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0x3F, 0xE0, 0x00, 0x77, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0x80, 0xFC, 0x01, 0xF0, 0x01, 0xF0, 0x02, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0xE0,
  0x00, 0x07, 0x87, 0x00, 0x00, 0x38, 0x38, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x1C, 0x07, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xF0,
  0x07, 0xC0, 0x3F, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x3F, 0x80, 0x3C,
  0x7F, 0xF8, 0x0E, 0x3F, 0xFF, 0x03, 0xBF, 0x07, 0xE1, 0xFE, 0x00, 0x7C,
  0x7F, 0x00, 0x0F, 0x1F, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x79, 0xE0, 0x00,
  0x0E, 0xF0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xCF, 0x00, 0x00,
  0xF1, 0xC0, 0x00, 0x38, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x03, 0xC0,
  0x07, 0x80, 0x78, 0x03, 0xE0, 0x0F, 0xEF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0,
  0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x0F,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x38, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07,
  0x83, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x3C, 0x07,
  0x80, 0x01, 0xE0, 0x1E, 0x00, 0x3E, 0x00, 0x78, 0x03, 0xE0, 0x03, 0xF8,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1C, 0x78, 0x00,
  0x00, 0xE3, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x81, 0xF0, 0x00, 0xF8, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x1F, 0x80, 0xF8, 0x07, 0x80, 0x1F, 0x03, 0xC0, 0x03,
  0xC1, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0x9E, 0x00,
  0x00, 0xE7, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x1E, 0xF0, 0x00,
  0x07, 0x9C, 0x00, 0x03, 0xE7, 0x80, 0x01, 0xF1, 0xE0, 0x00, 0xFC, 0x3C,
  0x00, 0xF7, 0x07, 0xC0, 0xF9, 0xC0, 0xFF, 0xFC, 0xE0, 0x1F, 0xFC, 0x38,
  0x01, 0xFC, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0x00, 0x78, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x3E, 0x07, 0xC1, 0xF8, 0x3F, 0x03, 0xC0, 0x00, 0x20, 0x03,
  0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00,
  0x38, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x04, 0x00, 0x3F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x80, 0x08, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0xFC, 0x07, 0xC3, 0xE0, 0x07, 0xC7, 0x80, 0x07,
  0x9E, 0x00, 0x07, 0x38, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x03, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x38, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x07,
  0x03, 0xC0, 0x3E, 0x01, 0x81, 0xC0, 0x7F, 0xC0, 0xC1, 0xC0, 0x7F, 0xF0,
  0x60, 0xE0, 0x78, 0x38, 0x38, 0xE0, 0x70, 0x18, 0x1C, 0x70, 0x70, 0x0C,
  0x0E, 0x70, 0x38, 0x06, 0x07, 0x38, 0x38, 0x07, 0x03, 0x98, 0x1C, 0x03,
  0x01, 0x9C, 0x1C, 0x01, 0x80, 0xCE, 0x0E, 0x00, 0xC0, 0x66, 0x07, 0x00,
  0xE0, 0x37, 0x03, 0x00, 0x60, 0x3B, 0x83, 0x80, 0x30, 0x1D, 0xC1, 0xC0,
  0x38, 0x0C, 0xC0, 0xE0, 0x1C, 0x06, 0x60, 0x60, 0x0C, 0x07, 0x30, 0x30,
  0x0E, 0x03, 0x18, 0x18, 0x07, 0x01, 0x8C, 0x0C, 0x07, 0x81, 0xC6, 0x06,
  0x07, 0xC0, 0xC3, 0x03, 0x87, 0x60, 0xE1, 0x81, 0xFF, 0x39, 0xE0, 0xE0,
  0x7F, 0x1F, 0xE0, 0x70, 0x1F, 0x07, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x70, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x1E, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x03, 0xCE, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x3C, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x80, 0x70,
  0x00, 0x1C, 0x01, 0xE0, 0x00, 0xF0, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x0E,
  0x00, 0x0E, 0x00, 0x78, 0x00, 0x3C, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x70, 0x3C, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x03, 0x9E,
  0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x0F, 0x00, 0xFF, 0x80, 0x1E, 0x00, 0x0F, 0x80, 0x38,
  0x00, 0x0F, 0x00, 0x70, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x0E, 0x03, 0xC0,
  0x00, 0x1C, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x1C, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x03,
  0xC0, 0x1C, 0x00, 0x1F, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x0F, 0xE0, 0x07, 0x00, 0x03, 0xE0,
  0x0E, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x70, 0x78,
  0x00, 0x01, 0xE0, 0xE0, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0F, 0x03, 0x80,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0xE0, 0x3C, 0x00,
  0x3F, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x07, 0xC0, 0x01,
  0xE0, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x3C,
  0x1C, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x1E,
  0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x78, 0x70, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x07, 0x07, 0x80, 0x00,
  0x3C, 0x1E, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C,
  0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0E,
  0x01, 0xFE, 0x00, 0x1C, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x3E, 0x00, 0xF0,
  0x00, 0x3E, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x3C, 0x07, 0x00,
  0x00, 0x78, 0x0E, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00,
  0x38, 0x78, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x78, 0x38, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x0E, 0x00,
  0x07, 0xC0, 0x1C, 0x00, 0x1F, 0x00, 0x38, 0x01, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0x80, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x07, 0xC0, 0x01, 0xE0,
  0x3E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x1C,
  0x00, 0x00, 0x70, 0xF0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x1E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x7F, 0xFE, 0x70, 0x01, 0xFF, 0xF3, 0xC0,
  0x07, 0xFF, 0xCF, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x1C, 0xF0, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E,
  0x0E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x38, 0x07,
  0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x38, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x0E,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x01, 0xC0, 0x3C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x38,
  0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x70, 0x00, 0x03, 0xE0, 0x1C, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00,
  0xF8, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x38, 0x00,
  0x1F, 0x00, 0x0E, 0x00, 0x0F, 0x80, 0x03, 0x80, 0x07, 0xC0, 0x01, 0xE0,
  0x03, 0xE0, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x07,
  0x00, 0x7C, 0x00, 0x01, 0xC0, 0x3E, 0x00, 0x00, 0x70, 0x1F, 0x00, 0x00,
  0x3C, 0x0F, 0x80, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x03, 0xC3, 0xE0, 0x00,
  0x00, 0xE1, 0xF0, 0x00, 0x00, 0x38, 0xF8, 0x00, 0x00, 0x0E, 0x7E, 0x00,
  0x00, 0x07, 0xBF, 0xC0, 0x00, 0x01, 0xFF, 0x70, 0x00, 0x00, 0x7F, 0x9E,
  0x00, 0x00, 0x1F, 0x83, 0xC0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x07, 0x80, 0x00, 0xE0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x38, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x07, 0xE0, 0x3E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xFC, 0x07, 0x70, 0x00, 0xEE, 0x03,
  0xB8, 0x00, 0xF7, 0x03, 0xDC, 0x00, 0x77, 0x81, 0xEE, 0x00, 0x7B, 0x80,
  0xE7, 0x00, 0x39, 0xC0, 0x71, 0xC0, 0x38, 0xE0, 0x38, 0xE0, 0x3C, 0x70,
  0x1C, 0x70, 0x1C, 0x78, 0x1E, 0x38, 0x1E, 0x3C, 0x0F, 0x1C, 0x0E, 0x1C,
  0x07, 0x0E, 0x0F, 0x0E, 0x03, 0x83, 0x87, 0x07, 0x01, 0xC1, 0xC7, 0x83,
  0x80, 0xE0, 0xE3, 0x83, 0xC0, 0xF0, 0x73, 0xC1, 0xE0, 0x78, 0x39, 0xC0,
  0xE0, 0x38, 0x1D, 0xC0, 0x70, 0x1C, 0x07, 0xE0, 0x38, 0x0E, 0x03, 0xE0,
  0x3C, 0x07, 0x01, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x0E, 0x03, 0xC0, 0x78,
  0x07, 0x01, 0xC0, 0x38, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x01, 0xE0, 0x38, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x70, 0x1E, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0x80, 0xF0,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01,
  0xC0, 0x7C, 0x00, 0x00, 0xE0, 0x3F, 0x00, 0x00, 0x70, 0x1F, 0x80, 0x00,
  0x78, 0x0F, 0xC0, 0x00, 0x3C, 0x07, 0xF0, 0x00, 0x1E, 0x07, 0xB8, 0x00,
  0x0E, 0x03, 0xDE, 0x00, 0x07, 0x01, 0xEF, 0x00, 0x03, 0x80, 0xE3, 0x80,
  0x03, 0xC0, 0x71, 0xE0, 0x01, 0xE0, 0x38, 0x70, 0x00, 0xE0, 0x3C, 0x38,
  0x00, 0x70, 0x1E, 0x1E, 0x00, 0x38, 0x0F, 0x07, 0x00, 0x3C, 0x07, 0x03,
  0x80, 0x1E, 0x03, 0x81, 0xE0, 0x0F, 0x01, 0xC0, 0x70, 0x07, 0x01, 0xE0,
  0x38, 0x03, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x78, 0x07, 0x01, 0xE0, 0x38,
  0x03, 0x80, 0xF0, 0x1C, 0x01, 0xE0, 0x78, 0x0E, 0x00, 0x70, 0x38, 0x0F,
  0x00, 0x3C, 0x1C, 0x07, 0x80, 0x0E, 0x0E, 0x03, 0x80, 0x07, 0x0F, 0x01,
  0xC0, 0x03, 0xC7, 0x80, 0xE0, 0x00, 0xE3, 0xC0, 0x70, 0x00, 0x71, 0xC0,
  0x78, 0x00, 0x3C, 0xE0, 0x3C, 0x00, 0x0E, 0x70, 0x1C, 0x00, 0x07, 0x78,
  0x0E, 0x00, 0x03, 0xFC, 0x07, 0x00, 0x00, 0xFC, 0x07, 0x80, 0x00, 0x7E,
  0x03, 0xC0, 0x00, 0x3F, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0x07,
  0xC0, 0x70, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0,
  0xF0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0xF1, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x3C, 0xE0, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x03, 0xCE, 0x00, 0x00,
  0x0E, 0x78, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x07,
  0x9C, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x01, 0xCF,
  0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x03, 0x8F, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x78, 0x70, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01,
  0xE0, 0x38, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0xC0, 0x3E, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xC0, 0x07, 0xF0, 0x01,
  0xC0, 0x00, 0xF8, 0x01, 0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1E, 0x07,
  0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0xF8, 0x0E, 0x00, 0x01, 0xF0, 0x0E, 0x00, 0x07, 0xE0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x38, 0x3C, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x38, 0xF0,
  0x00, 0x01, 0xE1, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x01, 0xE0, 0x38, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0xE0, 0x07, 0xC0, 0x3F, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0C, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x70, 0x03, 0xF8, 0x03, 0xC0,
  0x01, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01,
  0xC1, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0xF0,
  0x70, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x03, 0xC0, 0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x78, 0x0E, 0x00,
  0x07, 0xC0, 0x78, 0x00, 0x7E, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x70, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xF0, 0x03,
  0x80, 0x03, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x78, 0x07, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x0F, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C,
  0x0E, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x70, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C,
  0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xF4, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x01, 0xE0, 0x70, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x07, 0x80, 0x38, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x07, 0x9C, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x78, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x38, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0xF0, 0x07, 0x00, 0x07, 0x80, 0x1C,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xE0, 0x0F,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x00,
  0x00, 0x70, 0x3C, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x1C, 0x1E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07,
  0x8E, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x0F, 0xE0, 0x07, 0x00,
  0x1F, 0xC0, 0x0E, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0xFE, 0x00, 0x78, 0x01,
  0xDC, 0x00, 0xF8, 0x03, 0xB8, 0x03, 0xF0, 0x0F, 0x70, 0x07, 0xE0, 0x1C,
  0xE0, 0x0F, 0xC0, 0x39, 0xC0, 0x3B, 0x80, 0x73, 0x80, 0x77, 0x01, 0xC7,
  0x00, 0xEE, 0x03, 0x8E, 0x03, 0x9C, 0x07, 0x1C, 0x07, 0x38, 0x1E, 0x38,
  0x0E, 0x70, 0x38, 0x70, 0x38, 0xE0, 0x70, 0xE0, 0x71, 0xC0, 0xE1, 0xC1,
  0xE3, 0x83, 0x83, 0x83, 0x87, 0x07, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x1E,
  0x1C, 0x3C, 0x1C, 0x38, 0x38, 0x70, 0x38, 0x70, 0x70, 0xE0, 0x71, 0xE0,
  0xE1, 0xC0, 0xE3, 0x81, 0xC7, 0x01, 0xC7, 0x03, 0x8E, 0x03, 0x9E, 0x07,
  0x1C, 0x07, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x1C, 0xE0, 0x1D, 0xE0, 0x39,
  0xC0, 0x3B, 0x80, 0x73, 0x80, 0x77, 0x00, 0xEE, 0x00, 0xFE, 0x01, 0xDC,
  0x01, 0xF8, 0x03, 0xB8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0,
  0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x07,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x03, 0x83, 0xC0, 0x00,
  0x00, 0x3C, 0x78, 0x00, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x00, 0x1C, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x79, 0xC0,
  0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x03,
  0x80, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E,
  0x3C, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C,
  0x00, 0x0F, 0x00, 0xE0, 0x00, 0xF0, 0x07, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x78, 0x00, 0xE0, 0x07, 0x80, 0x07, 0x00, 0x3C, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0xE0, 0x3C, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x01, 0xE7,
  0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xEE, 0x00, 0x0F, 0x38, 0x00, 0x71, 0xC0, 0x07, 0x8E, 0x00,
  0x38, 0x70, 0x03, 0x83, 0xC0, 0x3C, 0x0E, 0x01, 0xC0, 0x70, 0x1E, 0x03,
  0x80, 0xE0, 0x1C, 0x0F, 0x00, 0x70, 0x70, 0x03, 0x87, 0x80, 0x1C, 0x78,
  0x00, 0xE3, 0x80, 0x07, 0xBC, 0x00, 0x1F, 0xC0, 0x00, 0xE0, 0x7F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x78, 0x38, 0x3C,
  0x1C, 0x0E, 0x0E, 0x07, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFE, 0x00, 0xF8, 0x07, 0xE0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xF8,
  0x01, 0xC3, 0xF0, 0x00, 0x78, 0xF8, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xC7,
  0x80, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x3C, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x3C, 0xF0, 0x00, 0x0F, 0x9E, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0xFC, 0x3C,
  0x00, 0x3F, 0x87, 0xC0, 0x1F, 0x70, 0x7F, 0xFF, 0xCE, 0x07, 0xFF, 0xE1,
  0xC0, 0x3F, 0xF0, 0x38, 0x00, 0x60, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0E, 0x0F, 0xF0, 0x01, 0xC7, 0xFF, 0x80, 0x39,
  0xFF, 0xF8, 0x07, 0x78, 0x0F, 0x81, 0xFC, 0x00, 0xF8, 0x3F, 0x00, 0x0F,
  0x07, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1C, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x38, 0xF0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C,
  0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x0E, 0x78, 0x00,
  0x01, 0xCF, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x0F, 0x38, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x39, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xC7, 0x80, 0x00,
  0x78, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0xF0, 0xFE,
  0x00, 0x3E, 0x1F, 0xE0, 0x1F, 0x83, 0x9F, 0xFF, 0xE0, 0x71, 0xFF, 0xF8,
  0x0E, 0x0F, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x00,
  0x78, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x0E, 0x1C,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x38, 0x70, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x0F, 0x80, 0x3F, 0x8F,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0xFF, 0x83, 0xC0, 0x0F, 0xFF, 0x8F, 0x00, 0x7F, 0xFF, 0x38,
  0x03, 0xF0, 0x1E, 0xE0, 0x1F, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x7E, 0x03,
  0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x03, 0xC0,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x0F, 0x07, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03,
  0x83, 0xC0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x78, 0x38, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x3C,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x7E, 0x00, 0xF8, 0x07,
  0xB8, 0x01, 0xFF, 0xFD, 0xE0, 0x03, 0xFF, 0xE7, 0x00, 0x07, 0xFE, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0x80, 0xF8, 0x03, 0xE0, 0x03, 0xC0, 0x3C,
  0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x07, 0x38,
  0x00, 0x00, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x20,
  0x3C, 0x00, 0x07, 0x01, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x3F, 0x00, 0x7F,
  0x9F, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x80, 0x01, 0xFC, 0x06, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x3C, 0x00, 0xFF,
  0xF8, 0xF0, 0x07, 0xFF, 0xF3, 0x80, 0x3F, 0x01, 0xEE, 0x01, 0xF0, 0x03,
  0xB8, 0x0F, 0x80, 0x07, 0xE0, 0x3C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x3E,
  0x07, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x07,
  0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x0E, 0x0F, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x01, 0xE0, 0xE0, 0x00,
  0x07, 0x83, 0x80, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0,
  0x1C, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xF8, 0x03,
  0xC0, 0x07, 0xE0, 0x0F, 0x80, 0x7B, 0x80, 0x1F, 0xFF, 0xDE, 0x00, 0x3F,
  0xFE, 0x78, 0x00, 0x7F, 0xE1, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x80, 0x00, 0xF0, 0x06, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x3E, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0xFF, 0x80, 0x0E, 0x1F,
  0xFE, 0x00, 0x71, 0xFF, 0xF8, 0x07, 0x9E, 0x03, 0xE0, 0x39, 0xC0, 0x0F,
  0x81, 0xDC, 0x00, 0x3C, 0x0F, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x03,
  0xC0, 0x00, 0x38, 0x3C, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x01, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x20, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x40, 0x7E, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0B,
  0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0xF8, 0x07, 0x80, 0x07, 0xC0, 0x1C, 0x00, 0x3E, 0x00, 0x70,
  0x01, 0xE0, 0x01, 0xC0, 0x1F, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x3C, 0x07,
  0xC0, 0x00, 0xE0, 0x3E, 0x00, 0x03, 0x83, 0xE0, 0x00, 0x0E, 0x1F, 0x00,
  0x00, 0x78, 0xF8, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x07, 0xBF, 0x00, 0x00,
  0x1D, 0xFE, 0x00, 0x00, 0x7F, 0x78, 0x00, 0x01, 0xF8, 0xF0, 0x00, 0x0F,
  0xC3, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0x80,
  0x3E, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x3C,
  0x01, 0xC0, 0x00, 0x78, 0x07, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x04, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x17, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x8F, 0xE0, 0x7F, 0x00,
  0x73, 0xFE, 0x3F, 0xF0, 0x0F, 0xFF, 0xEF, 0xFF, 0x03, 0xB8, 0x3F, 0xC1,
  0xE0, 0x7C, 0x03, 0xE0, 0x1C, 0x0F, 0x00, 0x78, 0x03, 0x81, 0xE0, 0x0F,
  0x00, 0x78, 0x38, 0x01, 0xC0, 0x0F, 0x07, 0x00, 0x38, 0x01, 0xC1, 0xE0,
  0x07, 0x00, 0x38, 0x38, 0x01, 0xE0, 0x07, 0x07, 0x00, 0x3C, 0x00, 0xE0,
  0xE0, 0x07, 0x00, 0x3C, 0x1C, 0x00, 0xE0, 0x07, 0x83, 0x80, 0x1C, 0x00,
  0xE0, 0xF0, 0x03, 0x80, 0x1C, 0x1C, 0x00, 0xF0, 0x03, 0x83, 0x80, 0x1E,
  0x00, 0x70, 0x70, 0x03, 0x80, 0x1E, 0x0E, 0x00, 0x70, 0x03, 0xC3, 0xC0,
  0x0E, 0x00, 0x70, 0x78, 0x01, 0xC0, 0x0E, 0x0E, 0x00, 0x78, 0x01, 0xC1,
  0xC0, 0x0F, 0x00, 0x38, 0x38, 0x01, 0xC0, 0x0F, 0x07, 0x00, 0x38, 0x01,
  0xE1, 0xE0, 0x07, 0x00, 0x38, 0x3C, 0x00, 0xE0, 0x07, 0x07, 0x00, 0x3C,
  0x00, 0xE0, 0xE0, 0x07, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0x07, 0x87, 0x80,
  0x1C, 0x00, 0xF0, 0x03, 0x81, 0xFF, 0x00, 0x1C, 0x3F, 0xFC, 0x00, 0xE3,
  0xFF, 0xF0, 0x0F, 0x3C, 0x07, 0xC0, 0x73, 0x80, 0x1E, 0x03, 0xB8, 0x00,
  0x78, 0x1F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0E, 0x0F, 0x80, 0x00, 0x70,
  0x78, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x38,
  0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE1,
  0xF0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0xF3, 0x80, 0x00, 0x07, 0x78, 0x00, 0x00, 0x77, 0x80, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x1F, 0x03, 0xC0, 0x03,
  0xE0, 0x1F, 0x00, 0x7C, 0x00, 0xFE, 0x7F, 0x80, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0xFF, 0x00, 0x03,
  0x8F, 0xFF, 0x00, 0x0E, 0x7F, 0xFE, 0x00, 0x7F, 0xC0, 0x7C, 0x01, 0xDC,
  0x00, 0xF8, 0x07, 0xE0, 0x01, 0xE0, 0x1F, 0x00, 0x03, 0x80, 0x78, 0x00,
  0x0F, 0x01, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0xF0, 0x70, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x38, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x3C, 0x0E, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C,
  0x07, 0xE0, 0x01, 0xF0, 0x1F, 0xE0, 0x1F, 0x80, 0x7B, 0xF3, 0xFC, 0x01,
  0xC7, 0xFF, 0xC0, 0x07, 0x07, 0xFE, 0x00, 0x3C, 0x01, 0x80, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0xF0, 0x0F, 0xFF, 0x8F, 0x01,
  0xFF, 0xFC, 0xE0, 0x3F, 0x01, 0xEE, 0x07, 0xC0, 0x0F, 0xE0, 0xF8, 0x00,
  0x7E, 0x0F, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x3C, 0x78, 0x00,
  0x03, 0xC7, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x38,
  0xF0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x07, 0x8E, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x07, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x3E, 0x03, 0xC0, 0x07, 0xE0, 0x3E, 0x01, 0xEE, 0x01, 0xFC, 0xFD,
  0xE0, 0x0F, 0xFF, 0x9E, 0x00, 0x7F, 0xE1, 0xC0, 0x00, 0xE0, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x03, 0x80, 0xFF, 0xC1, 0xE0, 0xFF, 0xF0, 0x78, 0xFF, 0xF8,
  0x1C, 0x7E, 0x02, 0x07, 0x3C, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xF0, 0x07, 0xC0,
  0x78, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0x83, 0x80, 0x00, 0x78, 0x70, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0xF1, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x83, 0xE0, 0x07, 0xE0,
  0x3F, 0xCF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0F,
  0x0E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0xE1, 0xE0,
  0x00, 0x0E, 0x1C, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x1E, 0x1C, 0x00, 0x01,
  0xE1, 0xC0, 0x00, 0x1C, 0x3C, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x1C, 0x38,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0x3C, 0x38, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x38, 0x78, 0x00, 0x03, 0x87, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x87,
  0x00, 0x00, 0x78, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x07, 0x07, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x0F, 0x07, 0x00, 0x01, 0xF0,
  0x78, 0x00, 0x3E, 0x07, 0x80, 0x07, 0xE0, 0x3C, 0x01, 0xEE, 0x01, 0xFF,
  0xFC, 0xE0, 0x1F, 0xFF, 0x0E, 0x00, 0x7F, 0xE1, 0xE0, 0x00, 0x60, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x1E, 0x1C, 0x00, 0x01, 0xE0, 0xE0,
  0x00, 0x0F, 0x07, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x78, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0x38, 0x01, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x1E, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x01, 0x80,
  0x07, 0xE0, 0x03, 0x80, 0x0F, 0xE0, 0x03, 0x80, 0x0E, 0xE0, 0x03, 0xC0,
  0x0E, 0xE0, 0x07, 0xC0, 0x1C, 0xF0, 0x07, 0xC0, 0x1C, 0x70, 0x0F, 0xC0,
  0x3C, 0x70, 0x0F, 0xC0, 0x38, 0x70, 0x1D, 0xC0, 0x38, 0x70, 0x1D, 0xC0,
  0x70, 0x70, 0x19, 0xC0, 0x70, 0x70, 0x39, 0xC0, 0x70, 0x70, 0x39, 0xC0,
  0xE0, 0x70, 0x70, 0xC0, 0xE0, 0x70, 0x70, 0xC0, 0xE0, 0x70, 0xE0, 0xC1,
  0xC0, 0x70, 0xE0, 0xC1, 0xC0, 0x70, 0xE0, 0xC3, 0x80, 0x71, 0xC0, 0xE3,
  0x80, 0x71, 0xC0, 0xE3, 0x80, 0x73, 0x80, 0xE7, 0x00, 0x73, 0x80, 0xE7,
  0x00, 0x73, 0x00, 0xE6, 0x00, 0x77, 0x00, 0xEE, 0x00, 0x77, 0x00, 0xEE,
  0x00, 0x7E, 0x00, 0xEC, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xE0, 0x00,
  0x0F, 0x80, 0x78, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x0F, 0x80, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x78,
  0x07, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03,
  0x87, 0x80, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00, 0x77, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x03, 0xE1, 0xE0, 0x00,
  0x03, 0xE0, 0x70, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x0F, 0x00,
  0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x70,
  0x01, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x07,
  0x81, 0xF0, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0x1F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x38, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0x0E, 0x1E, 0x00,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x00, 0x77,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x08, 0x7E, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x10, 0x00, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xC7, 0xFF, 0xC0,
  0x00, 0xC7, 0xC3, 0xF0, 0x00, 0xE3, 0xC0, 0x7C, 0x00, 0x73, 0xC0, 0x1F,
  0x00, 0x71, 0xC0, 0x07, 0xC0, 0x79, 0xC0, 0x00, 0xFF, 0xF8, 0xE0, 0x00,
  0x3F, 0xF8, 0x10, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x60, 0x00,
};

const GFXglyph RobotoMono_LightItalic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 11, 43, 35, 12, -43 },
  { 61, 13, 13, 35, 14, -45 },
  { 83, 35, 43, 35, 1, -43 },
  { 272, 29, 55, 35, 4, -49 },
  { 472, 28, 44, 35, 4, -43 },
  { 626, 31, 44, 35, 2, -43 },
  { 797, 5, 13, 35, 17, -45 },
  { 806, 19, 62, 35, 10, -48 },
  { 954, 19, 62, 35, 5, -48 },
  { 1102, 26, 26, 35, 7, -43 },
  { 1187, 29, 31, 35, 3, -35 },
  { 1300, 8, 15, 35, 7, -6 },
  { 1315, 22, 3, 35, 6, -21 },
  { 1324, 6, 6, 35, 13, -6 },
  { 1329, 29, 47, 35, 4, -43 },
  { 1500, 28, 44, 35, 4, -43 },
  { 1654, 16, 43, 35, 9, -43 },
  { 1740, 29, 43, 35, 1, -43 },
  { 1896, 30, 44, 35, 1, -43 },
  { 2061, 30, 43, 35, 1, -43 },
  { 2223, 29, 44, 35, 5, -43 },
  { 2383, 26, 44, 35, 4, -43 },
  { 2526, 28, 43, 35, 7, -43 },
  { 2677, 29, 44, 35, 4, -43 },
  { 2837, 26, 43, 35, 6, -43 },
  { 2977, 11, 32, 35, 14, -32 },
  { 3021, 14, 41, 35, 11, -32 },
  { 3093, 27, 25, 35, 5, -32 },
  { 3178, 28, 15, 35, 4, -27 },
  { 3231, 28, 25, 35, 3, -32 },
  { 3319, 23, 43, 35, 9, -43 },
  { 3443, 33, 43, 35, 2, -43 },
  { 3621, 30, 43, 35, 0, -43 },
  { 3783, 31, 43, 35, 2, -43 },
  { 3950, 30, 44, 35, 3, -43 },
  { 4115, 31, 43, 35, 2, -43 },
  { 4282, 31, 43, 35, 3, -43 },
  { 4449, 32, 43, 35, 3, -43 },
  { 4621, 30, 44, 35, 3, -43 },
  { 4786, 34, 43, 35, 1, -43 },
  { 4969, 32, 43, 35, 2, -43 },
  { 5141, 31, 44, 35, 2, -43 },
  { 5312, 34, 43, 35, 3, -43 },
  { 5495, 25, 43, 35, 3, -43 },
  { 5630, 33, 43, 35, 2, -43 },
  { 5808, 33, 43, 35, 2, -43 },
  { 5986, 30, 44, 35, 3, -43 },
  { 6151, 32, 43, 35, 3, -43 },
  { 6323, 30, 50, 35, 3, -43 },
  { 6511, 30, 43, 35, 3, -43 },
  { 6673, 31, 44, 35, 3, -43 },
  { 6844, 31, 43, 35, 6, -43 },
  { 7011, 32, 44, 35, 3, -43 },
  { 7187, 30, 43, 35, 6, -43 },
  { 7349, 31, 43, 35, 6, -43 },
  { 7516, 36, 43, 35, 0, -43 },
  { 7710, 29, 43, 35, 7, -43 },
  { 7866, 32, 43, 35, 1, -43 },
  { 8038, 19, 58, 35, 9, -49 },
  { 8176, 12, 47, 35, 12, -43 },
  { 8247, 19, 58, 35, 8, -49 },
  { 8385, 21, 23, 35, 7, -43 },
  { 8446, 26, 3, 35, 1, 0 },
  { 8456, 8, 8, 35, 17, -44 },
  { 8464, 27, 33, 35, 3, -32 },
  { 8576, 27, 46, 35, 3, -45 },
  { 8732, 27, 33, 35, 4, -32 },
  { 8844, 30, 46, 35, 4, -45 },
  { 9017, 28, 33, 35, 3, -32 },
  { 9133, 30, 46, 35, 7, -46 },
  { 9306, 30, 45, 35, 2, -32 },
  { 9475, 29, 45, 35, 2, -45 },
  { 9639, 26, 43, 35, 3, -43 },
  { 9779, 28, 56, 35, 0, -43 },
  { 9975, 30, 45, 35, 3, -45 },
  { 10144, 26, 45, 35, 3, -45 },
  { 10291, 35, 32, 35, -1, -32 },
  { 10431, 29, 32, 35, 2, -32 },
  { 10547, 28, 33, 35, 3, -32 },
  { 10663, 30, 44, 35, 0, -32 },
  { 10828, 28, 44, 35, 4, -32 },
  { 10982, 26, 32, 35, 7, -32 },
  { 11086, 27, 33, 35, 4, -32 },
  { 11198, 24, 41, 35, 7, -40 },
  { 11321, 28, 33, 35, 4, -32 },
  { 11437, 29, 32, 35, 5, -32 },
  { 11553, 32, 32, 35, 4, -32 },
  { 11681, 33, 32, 35, 1, -32 },
  { 11813, 36, 45, 35, -1, -32 },
  { 12016, 31, 32, 35, 1, -32 },
  { 12140, 23, 59, 35, 9, -47 },
  { 12310, 11, 53, 35, 12, -43 },
  { 12383, 23, 59, 35, 5, -47 },
  { 12553, 33, 11, 35, 1, -23 },
};

const GFXfont RobotoMono_LightItalic60pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic60pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic60pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _ROBOTOMONO_LIGHTITALIC60PT7B_H_
