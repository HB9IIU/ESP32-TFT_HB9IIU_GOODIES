#ifndef _ROBOTOMONO_LIGHTITALIC45PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x07, 0x07, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0E, 0x0C,
  0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0x38, 0x38, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0xF0, 0xE0, 0x30, 0xE6, 0x18,
  0xC3, 0x38, 0x66, 0x0C, 0xC1, 0x98, 0x63, 0x0C, 0xE1, 0x98, 0x30, 0x00,
  0x06, 0x03, 0x00, 0x01, 0x81, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18,
  0x00, 0x0C, 0x0E, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xE0,
  0x70, 0x00, 0x30, 0x18, 0x03, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x01,
  0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x38, 0x18, 0x00, 0x0C, 0x06, 0x00,
  0x03, 0x03, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x18, 0x1C,
  0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xC0, 0x18, 0x0C, 0x00, 0x0E, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00,
  0xC0, 0x60, 0x00, 0x70, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x07, 0x00,
  0x03, 0x81, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x01, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0xF0, 0x3C, 0x07, 0x80, 0x70, 0x1C, 0x00, 0xE0, 0xE0,
  0x03, 0x83, 0x80, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18,
  0xE0, 0x00, 0x63, 0x80, 0x01, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x38, 0x70,
  0x01, 0xC1, 0xC0, 0x0F, 0x03, 0xC0, 0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x1C, 0x38, 0x00, 0xC0,
  0xC0, 0x0E, 0x06, 0x03, 0x60, 0x30, 0x33, 0x01, 0x83, 0x98, 0x0C, 0x38,
  0xC0, 0xE1, 0x86, 0x06, 0x18, 0x30, 0x31, 0xC1, 0xC7, 0x0C, 0x07, 0xF0,
  0xC0, 0x1F, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x30, 0xF8, 0x03, 0x0F, 0xE0, 0x38, 0xE3, 0x81, 0x8E,
  0x0C, 0x18, 0x60, 0x61, 0xC7, 0x03, 0x1C, 0x30, 0x18, 0xC1, 0x80, 0xCC,
  0x0C, 0x06, 0xE0, 0x60, 0x70, 0x03, 0x03, 0x00, 0x0C, 0x38, 0x00, 0x7F,
  0x80, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x78, 0x70, 0x01, 0xC0, 0xE0, 0x0E, 0x03, 0x80, 0x30, 0x0E, 0x00, 0xC0,
  0x38, 0x07, 0x00, 0xC0, 0x1C, 0x07, 0x00, 0x30, 0x38, 0x00, 0xC1, 0xC0,
  0x03, 0x9E, 0x00, 0x06, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xE7, 0x00, 0x07, 0x0E, 0x03, 0x38, 0x18,
  0x0D, 0xC0, 0x70, 0x77, 0x00, 0xE1, 0xB8, 0x03, 0x8E, 0xE0, 0x07, 0x3B,
  0x80, 0x0F, 0xCE, 0x00, 0x3E, 0x38, 0x00, 0x78, 0xE0, 0x01, 0xC1, 0xC0,
  0x1F, 0x87, 0x81, 0xF7, 0x0F, 0xFF, 0x1C, 0x0F, 0xF0, 0x38, 0x76, 0x66,
  0x6E, 0xCC, 0xCC, 0x00, 0x08, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80,
  0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x30,
  0x18, 0x1F, 0xC3, 0x1F, 0xFE, 0xDF, 0xE3, 0xFF, 0xC0, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x36, 0x00, 0x0E, 0x60, 0x03, 0x8E, 0x00, 0xE0, 0xC0, 0x38,
  0x1C, 0x0E, 0x01, 0xC0, 0x80, 0x30, 0x00, 0x04, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x1C, 0x71, 0xC7, 0x18, 0xE3, 0x9C, 0x63, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x00, 0xF0, 0x38, 0x0E,
  0x00, 0xE0, 0xE0, 0x03, 0x07, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x00, 0x03,
  0x38, 0x00, 0x19, 0xC0, 0x03, 0xCC, 0x00, 0x3E, 0x60, 0x03, 0xF7, 0x00,
  0x3B, 0xB8, 0x07, 0x9D, 0xC0, 0x70, 0xEE, 0x07, 0x07, 0x60, 0x70, 0x33,
  0x0F, 0x01, 0xB8, 0xE0, 0x1D, 0xCE, 0x00, 0xEE, 0xE0, 0x07, 0x7E, 0x00,
  0x33, 0xC0, 0x01, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xC7, 0x00, 0x0E, 0x18,
  0x00, 0x60, 0xE0, 0x07, 0x07, 0x00, 0x70, 0x1C, 0x0F, 0x00, 0x7F, 0xF0,
  0x01, 0xFE, 0x00, 0x00, 0x30, 0x0F, 0x07, 0xF1, 0xFE, 0xFC, 0x6F, 0x06,
  0x80, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30,
  0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x3C, 0x0F, 0x01,
  0xC0, 0x1E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0x61, 0xC0, 0x01, 0x87, 0x00,
  0x06, 0x18, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x4F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0xC0, 0x3E, 0x07, 0x00, 0xE0, 0x0E, 0x07, 0x00, 0x18, 0x38, 0x00, 0x70,
  0xE0, 0x01, 0xC3, 0x00, 0x07, 0x10, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x01, 0xFC,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x38, 0x00,
  0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0x8E, 0x00, 0x0E, 0x1C, 0x00, 0x70,
  0x78, 0x03, 0xC0, 0xF0, 0x3E, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xB0, 0x00, 0x0E, 0xC0, 0x00, 0x73, 0x00, 0x03, 0x9C, 0x00, 0x1C, 0x70,
  0x00, 0x61, 0xC0, 0x03, 0x86, 0x00, 0x1C, 0x18, 0x00, 0xE0, 0x60, 0x07,
  0x03, 0x80, 0x18, 0x0E, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x03,
  0x01, 0xC0, 0x1C, 0x0E, 0x00, 0x70, 0x30, 0x01, 0xC1, 0xC0, 0x07, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x81,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x04, 0x00,
  0x1B, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xE0, 0x78, 0x0E, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0xC0, 0x01, 0xC3,
  0x00, 0x07, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0x70, 0x07, 0x01, 0xE0,
  0x78, 0x03, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xF8,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x7E, 0x03,
  0x3F, 0xF0, 0xEF, 0x0F, 0x1B, 0x80, 0xF3, 0xC0, 0x0E, 0x70, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xDC, 0x00, 0x3B, 0x80, 0x06, 0x38,
  0x01, 0xC7, 0x00, 0x70, 0x78, 0x3C, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x07, 0xFF, 0x80, 0x3C, 0x0F, 0x01, 0xE0, 0x0E, 0x07, 0x00,
  0x38, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x00, 0x07, 0x1C, 0x00, 0x1C,
  0x70, 0x00, 0x61, 0xC0, 0x03, 0x83, 0x00, 0x1C, 0x0E, 0x00, 0x70, 0x1C,
  0x07, 0x80, 0x3F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x38, 0x0F,
  0x03, 0xC0, 0x0E, 0x0E, 0x00, 0x38, 0x70, 0x00, 0x63, 0x80, 0x01, 0xCE,
  0x00, 0x07, 0x38, 0x00, 0x1C, 0xC0, 0x00, 0x73, 0x80, 0x03, 0x8E, 0x00,
  0x0E, 0x38, 0x00, 0x70, 0x70, 0x03, 0xC0, 0xE0, 0x3E, 0x01, 0xFF, 0xE0,
  0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0x83, 0xC0, 0xE0,
  0x1C, 0x1C, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0x67, 0x00, 0x07, 0x70,
  0x00, 0x76, 0x00, 0x07, 0x60, 0x00, 0x76, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x06, 0x60, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x01, 0xE3, 0x80, 0x3E,
  0x3C, 0x0E, 0xC1, 0xFF, 0xCC, 0x0F, 0xF1, 0xC0, 0x08, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x03, 0xE0, 0x00, 0x0E,
  0x1E, 0x1E, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0xF0, 0xF0, 0xF0, 0x01, 0xC0,
  0xF0, 0x3C, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x07, 0x01, 0x80, 0xE0, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x0E, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x80, 0x3F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xD0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF8, 0x08, 0x00, 0x00, 0x60, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x7C, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xFF, 0x0F, 0x03,
  0xCF, 0x00, 0xE7, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x1E, 0x07, 0x80,
  0x3C, 0x00, 0xC0, 0x38, 0x00, 0x30, 0x18, 0x00, 0x18, 0x18, 0x04, 0x06,
  0x1C, 0x1F, 0x83, 0x0C, 0x1C, 0xE1, 0x8C, 0x18, 0x30, 0xC6, 0x18, 0x18,
  0x66, 0x0C, 0x08, 0x33, 0x0C, 0x0C, 0x1B, 0x86, 0x06, 0x0D, 0x86, 0x03,
  0x06, 0xC3, 0x01, 0x02, 0x61, 0x81, 0x83, 0x20, 0xC0, 0xC1, 0xB0, 0xC0,
  0x60, 0xD8, 0x60, 0x60, 0x4C, 0x30, 0x30, 0x66, 0x18, 0x38, 0x33, 0x0E,
  0x3C, 0x31, 0x83, 0xF3, 0x70, 0x61, 0xF1, 0xF0, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x18, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1B, 0x80, 0x00,
  0xEE, 0x00, 0x03, 0x18, 0x00, 0x1C, 0x60, 0x00, 0x61, 0x80, 0x03, 0x86,
  0x00, 0x0C, 0x18, 0x00, 0x70, 0x70, 0x01, 0x81, 0xC0, 0x0E, 0x07, 0x00,
  0x30, 0x0C, 0x01, 0xC0, 0x30, 0x07, 0x00, 0xC0, 0x38, 0x03, 0x00, 0xE0,
  0x0E, 0x07, 0x00, 0x38, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0x80, 0x06,
  0x1C, 0x00, 0x18, 0x70, 0x00, 0x61, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x30,
  0x00, 0x1D, 0xC0, 0x00, 0x76, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x1C, 0x07, 0xC0, 0x30, 0x01, 0xC0, 0x60, 0x01,
  0xC1, 0xC0, 0x03, 0x83, 0x80, 0x03, 0x07, 0x00, 0x06, 0x0E, 0x00, 0x0C,
  0x18, 0x00, 0x38, 0x30, 0x00, 0x70, 0xE0, 0x01, 0xC1, 0xC0, 0x07, 0x03,
  0x80, 0x3C, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x70,
  0x01, 0xC0, 0xE0, 0x01, 0xC1, 0xC0, 0x01, 0x83, 0x00, 0x03, 0x86, 0x00,
  0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00,
  0xE1, 0x80, 0x01, 0xC3, 0x00, 0x07, 0x0E, 0x00, 0x3C, 0x1C, 0x01, 0xF0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80,
  0x3C, 0x0F, 0x01, 0xC0, 0x1E, 0x0E, 0x00, 0x38, 0x30, 0x00, 0x61, 0xC0,
  0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xC0, 0x00, 0x77, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x07, 0x30, 0x00, 0x18,
  0xC0, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x1C, 0x18, 0x00, 0xE0, 0x70,
  0x07, 0x80, 0xE0, 0x3C, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x03, 0x01, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x00,
  0x1C, 0x07, 0x00, 0x0C, 0x07, 0x00, 0x0E, 0x06, 0x00, 0x06, 0x06, 0x00,
  0x06, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0C, 0x00,
  0x07, 0x0C, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00,
  0x06, 0x1C, 0x00, 0x06, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x0E, 0x38, 0x00,
  0x0C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x30, 0x00,
  0x38, 0x30, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0x70, 0x07,
  0x80, 0x70, 0x3F, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0xE0, 0x07, 0x81, 0xE0, 0x1C, 0x01, 0xE0, 0x70, 0x01,
  0xC1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x1F, 0xF9, 0x80, 0x3F, 0xE7, 0x00, 0x00, 0xCE, 0x00, 0x01, 0x9C, 0x00,
  0x07, 0x18, 0x00, 0x0E, 0x30, 0x00, 0x1C, 0x60, 0x00, 0x30, 0xE0, 0x00,
  0x61, 0xC0, 0x00, 0xC1, 0xC0, 0x03, 0x83, 0xC0, 0x0F, 0x03, 0xC0, 0x78,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x01,
  0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x60, 0x60, 0x00,
  0x30, 0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x1C, 0x00, 0x0E, 0x0E, 0x00,
  0x07, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC1, 0xC0,
  0x00, 0xE0, 0xE0, 0x00, 0x70, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x0C, 0x00, 0x06, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x03, 0x83,
  0x80, 0x01, 0xC1, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30,
  0x70, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x18, 0x00, 0x0E, 0x0C, 0x00, 0x06,
  0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00,
  0xE0, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x70, 0xC0, 0x00, 0xE1, 0x80, 0x03, 0x83,
  0x80, 0x07, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x70, 0x07, 0x03, 0xC0, 0x0F,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x07, 0x00, 0x03, 0xC1, 0xC0, 0x01, 0xC0,
  0x70, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x06, 0x00, 0x38, 0x01, 0x80, 0x1C,
  0x00, 0xE0, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x01,
  0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x30, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x07,
  0x1C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x67, 0xC0, 0x00, 0x1B, 0xB8, 0x00,
  0x0F, 0xCE, 0x00, 0x03, 0xE1, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x38, 0x0E,
  0x00, 0x0C, 0x03, 0x80, 0x03, 0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x01, 0x80, 0x07, 0x00,
  0x60, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x03, 0xC1,
  0xE0, 0x01, 0xE0, 0xF8, 0x01, 0xF0, 0x6C, 0x01, 0xF8, 0x36, 0x00, 0xF8,
  0x1B, 0x00, 0xEC, 0x0D, 0x80, 0x66, 0x0E, 0xE0, 0x73, 0x07, 0x70, 0x33,
  0x83, 0x18, 0x39, 0xC1, 0x8C, 0x18, 0xC0, 0xC6, 0x1C, 0x60, 0xE3, 0x0C,
  0x30, 0x71, 0xCE, 0x38, 0x38, 0xE6, 0x1C, 0x18, 0x37, 0x0E, 0x0C, 0x1F,
  0x06, 0x06, 0x0F, 0x03, 0x07, 0x07, 0x83, 0x83, 0x83, 0x81, 0xC1, 0xC0,
  0xC0, 0xE0, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18, 0x38,
  0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x06, 0x00, 0x03, 0x03,
  0x00, 0x01, 0x81, 0x80, 0x00, 0xC1, 0xC0, 0x00, 0xE0, 0x03, 0x00, 0x03,
  0x83, 0xC0, 0x01, 0xC1, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0x60, 0x7C, 0x00,
  0x30, 0x36, 0x00, 0x18, 0x1B, 0x80, 0x1C, 0x1D, 0xC0, 0x0E, 0x0E, 0x60,
  0x07, 0x07, 0x38, 0x03, 0x03, 0x1C, 0x01, 0x81, 0x86, 0x01, 0xC0, 0xC3,
  0x80, 0xE0, 0xE1, 0xC0, 0x70, 0x70, 0x60, 0x38, 0x38, 0x38, 0x18, 0x18,
  0x0C, 0x0C, 0x0C, 0x06, 0x0E, 0x0E, 0x03, 0x87, 0x07, 0x00, 0xC3, 0x83,
  0x80, 0x61, 0xC1, 0xC0, 0x38, 0xC0, 0xC0, 0x0C, 0x60, 0x60, 0x07, 0x70,
  0x70, 0x03, 0xB8, 0x38, 0x00, 0xDC, 0x1C, 0x00, 0x7C, 0x0E, 0x00, 0x3E,
  0x06, 0x00, 0x0F, 0x03, 0x00, 0x07, 0x83, 0x80, 0x03, 0xC1, 0xC0, 0x00,
  0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x00, 0x3C, 0x1E, 0x01, 0xC0, 0x1C,
  0x0E, 0x00, 0x30, 0x30, 0x00, 0xE1, 0xC0, 0x01, 0x8E, 0x00, 0x06, 0x38,
  0x00, 0x18, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x60, 0x00,
  0x1D, 0x80, 0x00, 0x6E, 0x00, 0x01, 0xB8, 0x00, 0x06, 0xE0, 0x00, 0x3B,
  0x00, 0x00, 0xEC, 0x00, 0x03, 0xB0, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00,
  0x01, 0xCC, 0x00, 0x07, 0x30, 0x00, 0x38, 0xC0, 0x00, 0xE3, 0x80, 0x07,
  0x0E, 0x00, 0x1C, 0x1C, 0x00, 0xE0, 0x70, 0x07, 0x00, 0xF0, 0x78, 0x01,
  0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x07,
  0x00, 0x7C, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x06, 0x06,
  0x00, 0x07, 0x06, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E,
  0x00, 0x07, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x0E, 0x0C, 0x00, 0x1C, 0x1C,
  0x00, 0x3C, 0x1C, 0x00, 0x78, 0x1C, 0x07, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x07,
  0x81, 0xE0, 0x1C, 0x01, 0xC0, 0x70, 0x01, 0xC1, 0xC0, 0x01, 0x83, 0x80,
  0x03, 0x0E, 0x00, 0x07, 0x18, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00,
  0x19, 0x80, 0x00, 0x37, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03,
  0xB0, 0x00, 0x07, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x1B, 0x80, 0x00, 0x37,
  0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0x38, 0x00, 0x0E, 0x70,
  0x00, 0x1C, 0x60, 0x00, 0x70, 0xC0, 0x00, 0xE1, 0xC0, 0x03, 0x81, 0x80,
  0x0E, 0x03, 0x80, 0x38, 0x03, 0xC1, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x1C, 0x03, 0xE0, 0x38, 0x01, 0xC0, 0x60, 0x01, 0xC0, 0xC0, 0x01,
  0x83, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C,
  0x30, 0x00, 0x30, 0x60, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x07, 0x07,
  0x00, 0x1C, 0x0C, 0x00, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF,
  0xF8, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0xE0, 0x18, 0x01, 0xC0, 0x70, 0x01, 0x80, 0xE0, 0x03, 0x81, 0xC0, 0x07,
  0x03, 0x00, 0x06, 0x06, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x18,
  0x70, 0x00, 0x38, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0x81, 0xE0,
  0x3C, 0x00, 0xE0, 0x70, 0x01, 0xC1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x86,
  0x00, 0x07, 0x1C, 0x00, 0x06, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x1C,
  0xE0, 0x00, 0x39, 0xC0, 0x00, 0x71, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x83,
  0x80, 0x1E, 0x07, 0xC0, 0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x06, 0x38, 0x00,
  0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x71, 0x80, 0x00, 0xC3, 0x00, 0x01,
  0x86, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x60, 0x00, 0x30,
  0xC0, 0x00, 0x61, 0x80, 0x00, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x1C,
  0x00, 0x0E, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x63, 0x80,
  0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x18, 0x00, 0x0C, 0x30, 0x00,
  0x18, 0x60, 0x00, 0x70, 0xC0, 0x00, 0xE1, 0xC0, 0x03, 0x83, 0x80, 0x07,
  0x03, 0x00, 0x1C, 0x07, 0x00, 0x70, 0x07, 0x03, 0xC0, 0x07, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x6E, 0x00, 0x03, 0xB8,
  0x00, 0x0E, 0x60, 0x00, 0x71, 0x80, 0x01, 0xC6, 0x00, 0x0E, 0x1C, 0x00,
  0x38, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x18, 0x0C, 0x00, 0xE0,
  0x30, 0x03, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x60, 0x0E, 0x03, 0x80, 0x38,
  0x0C, 0x00, 0x60, 0x70, 0x01, 0x81, 0xC0, 0x06, 0x0E, 0x00, 0x1C, 0x38,
  0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x18, 0x00, 0x0C, 0xE0, 0x00,
  0x33, 0x00, 0x00, 0xDC, 0x00, 0x03, 0x60, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x60, 0x1C, 0x07, 0x60, 0x1C,
  0x07, 0x60, 0x3C, 0x06, 0x60, 0x3C, 0x06, 0x60, 0x3C, 0x0E, 0x60, 0x7C,
  0x0C, 0x60, 0x6C, 0x0C, 0x60, 0x6C, 0x1C, 0x60, 0xEC, 0x1C, 0x60, 0xCC,
  0x18, 0x60, 0xCC, 0x18, 0x61, 0xCC, 0x38, 0xE1, 0x8C, 0x30, 0xE1, 0x8C,
  0x30, 0xE3, 0x8C, 0x70, 0xE3, 0x0C, 0x70, 0xE3, 0x0C, 0x60, 0xE7, 0x0C,
  0x60, 0xE6, 0x0C, 0xE0, 0xE6, 0x0C, 0xC0, 0xEE, 0x0C, 0xC0, 0xEC, 0x0D,
  0xC0, 0xEC, 0x0D, 0xC0, 0xFC, 0x0D, 0x80, 0xF8, 0x0D, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x70,
  0x00, 0x38, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x0C, 0x00, 0x70,
  0x01, 0xC0, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70,
  0x38, 0x00, 0x06, 0x0E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0C, 0x70, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x07, 0x18, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0x30,
  0x00, 0x0E, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x00, 0x30,
  0x1C, 0x00, 0x07, 0x07, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xE7, 0x00, 0x03, 0x9C, 0x00, 0x1C, 0x70, 0x00, 0xE0, 0xC0, 0x03, 0x83,
  0x80, 0x1C, 0x0E, 0x00, 0xE0, 0x18, 0x03, 0x80, 0x70, 0x1C, 0x01, 0xC0,
  0xE0, 0x03, 0x03, 0x80, 0x0E, 0x1C, 0x00, 0x38, 0xE0, 0x00, 0x63, 0x80,
  0x01, 0x9C, 0x00, 0x07, 0x60, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0xC0, 0x60,
  0x38, 0x1C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x70, 0x18, 0x0C, 0x06, 0x03,
  0x81, 0xC0, 0x60, 0x30, 0x18, 0x0E, 0x07, 0x01, 0x80, 0xC0, 0x60, 0x38,
  0x1C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x81,
  0xC0, 0x60, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x07, 0x00, 0x1C, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x30, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xD8, 0x01, 0xDC, 0x01, 0x9C, 0x03, 0x8C, 0x07,
  0x0C, 0x06, 0x0C, 0x0E, 0x0E, 0x0C, 0x06, 0x1C, 0x06, 0x18, 0x06, 0x38,
  0x07, 0x70, 0x07, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE1, 0x87,
  0x0C, 0x18, 0x70, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x01, 0xF0, 0x78, 0x1E,
  0x00, 0xE0, 0xE0, 0x03, 0x0E, 0x00, 0x1C, 0x70, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0xE0, 0xF8,
  0x07, 0x1E, 0x00, 0x38, 0xE0, 0x01, 0x8E, 0x00, 0x0C, 0x60, 0x00, 0xE7,
  0x00, 0x07, 0x38, 0x00, 0x79, 0xC0, 0x07, 0x87, 0x00, 0x7C, 0x3C, 0x0F,
  0x60, 0xFF, 0xF3, 0x03, 0xFE, 0x1C, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x8F, 0xE0, 0x19,
  0xFF, 0x80, 0xDE, 0x1E, 0x07, 0x80, 0x78, 0x78, 0x01, 0xC3, 0x80, 0x06,
  0x1C, 0x00, 0x38, 0xC0, 0x01, 0xC6, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80,
  0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xE6, 0x00, 0x06, 0x30, 0x00, 0x73,
  0x80, 0x03, 0x9C, 0x00, 0x18, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00,
  0xE1, 0xE0, 0x0E, 0x1D, 0xC1, 0xE0, 0xEF, 0xFE, 0x07, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0x83, 0xC0, 0xE0, 0x0E, 0x1C, 0x00,
  0x63, 0x80, 0x07, 0x38, 0x00, 0x77, 0x00, 0x03, 0x70, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x0C, 0x60, 0x01, 0xC7,
  0x00, 0x38, 0x70, 0x07, 0x83, 0xC0, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x07, 0xF0, 0xE0, 0x1F, 0xF9, 0xC0, 0x78,
  0x3B, 0x01, 0xC0, 0x3E, 0x07, 0x00, 0x3C, 0x1C, 0x00, 0x38, 0x38, 0x00,
  0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0x83, 0x00, 0x03, 0x0E, 0x00, 0x0E,
  0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x60, 0xE0, 0x00, 0xC1,
  0xC0, 0x01, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x0C,
  0x00, 0x70, 0x1C, 0x01, 0xE0, 0x1C, 0x0E, 0xC0, 0x1F, 0xF9, 0x80, 0x1F,
  0xC7, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0x83, 0xC0, 0xF0, 0x0E,
  0x1C, 0x00, 0x63, 0x80, 0x07, 0x38, 0x00, 0x77, 0x00, 0x03, 0x70, 0x00,
  0x36, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x08, 0x78, 0x03, 0xC3, 0xC0, 0x78, 0x1F, 0xFE, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x7F, 0x8E, 0x01, 0xFF, 0x9C, 0x07, 0x83, 0xB0, 0x1C, 0x03, 0xE0,
  0x70, 0x03, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x0E, 0x00, 0x0E, 0x1C,
  0x00, 0x18, 0x30, 0x00, 0x30, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80,
  0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0C, 0x1C, 0x00, 0x18, 0x38, 0x00,
  0x70, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC0, 0xE0, 0x07, 0x81, 0xC0, 0x1E,
  0x01, 0xC0, 0xEC, 0x01, 0xFF, 0xB8, 0x01, 0xFE, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x38, 0x1E,
  0x00, 0xE0, 0x1E, 0x07, 0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x07, 0xE0, 0x18, 0xFF, 0xC0, 0xCE, 0x0F,
  0x0E, 0xC0, 0x38, 0x7C, 0x00, 0xE3, 0xC0, 0x07, 0x1C, 0x00, 0x38, 0xC0,
  0x01, 0xC6, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x03, 0x1C, 0x00, 0x18,
  0xC0, 0x00, 0xC6, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00,
  0x18, 0xE0, 0x00, 0xC6, 0x00, 0x0E, 0x30, 0x00, 0x73, 0x80, 0x03, 0x9C,
  0x00, 0x1C, 0xE0, 0x00, 0xC7, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x78, 0x70,
  0x03, 0xC0, 0xE0, 0x0F, 0x01, 0x80, 0x3C, 0x03, 0x00, 0xE0, 0x06, 0x03,
  0x80, 0x1C, 0x1E, 0x00, 0x38, 0x78, 0x00, 0x71, 0xE0, 0x00, 0xC7, 0x00,
  0x01, 0xBC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xDC, 0x00, 0x1F, 0x38, 0x00,
  0x38, 0x38, 0x00, 0x60, 0x38, 0x00, 0xC0, 0x70, 0x03, 0x80, 0x70, 0x07,
  0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x30, 0x00, 0xE0, 0x60,
  0x01, 0xC1, 0xC0, 0x01, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0C, 0xFC, 0x3E, 0x06, 0xFF, 0x7F, 0x87, 0xC3, 0xF0, 0xE3,
  0xC1, 0xF0, 0x71, 0xC0, 0x70, 0x18, 0xC0, 0x30, 0x0C, 0x60, 0x18, 0x06,
  0x70, 0x1C, 0x07, 0x38, 0x0E, 0x03, 0x9C, 0x07, 0x01, 0xCC, 0x03, 0x00,
  0xC6, 0x01, 0x80, 0x63, 0x00, 0xC0, 0x33, 0x80, 0xE0, 0x39, 0xC0, 0x70,
  0x1C, 0xE0, 0x38, 0x0E, 0x60, 0x18, 0x06, 0x30, 0x0C, 0x03, 0x18, 0x06,
  0x01, 0x9C, 0x07, 0x01, 0xCE, 0x03, 0x80, 0xE6, 0x01, 0x80, 0x63, 0x00,
  0xC0, 0x31, 0x80, 0x60, 0x18, 0x0C, 0x1F, 0x80, 0x63, 0xFF, 0x03, 0x38,
  0x3C, 0x3B, 0x00, 0xE1, 0xF0, 0x03, 0x0F, 0x00, 0x1C, 0x70, 0x00, 0xE3,
  0x00, 0x07, 0x18, 0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00, 0x0C, 0x70, 0x00,
  0x63, 0x00, 0x07, 0x18, 0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x70,
  0x00, 0x63, 0x80, 0x03, 0x18, 0x00, 0x38, 0xC0, 0x01, 0xCE, 0x00, 0x0E,
  0x70, 0x00, 0x73, 0x80, 0x03, 0x1C, 0x00, 0x38, 0x00, 0x7F, 0x00, 0x0F,
  0xFE, 0x00, 0xF0, 0x78, 0x1E, 0x01, 0xE0, 0xE0, 0x07, 0x0E, 0x00, 0x1C,
  0xE0, 0x00, 0xE7, 0x00, 0x07, 0x70, 0x00, 0x1B, 0x80, 0x00, 0xDC, 0x00,
  0x06, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x06, 0x60, 0x00, 0x73, 0x00, 0x03, 0x9C, 0x00, 0x38, 0xE0, 0x03,
  0x83, 0x80, 0x38, 0x0E, 0x07, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x03,
  0x0F, 0xE0, 0x06, 0x7F, 0xE0, 0x0D, 0xC1, 0xE0, 0x3E, 0x01, 0xE0, 0x78,
  0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x03, 0x83, 0x00, 0x07, 0x06, 0x00,
  0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x70, 0xC0, 0x00,
  0xC1, 0x80, 0x01, 0x83, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x18,
  0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x03, 0x81, 0xE0, 0x0E, 0x07,
  0xE0, 0x78, 0x0E, 0xFF, 0xE0, 0x1C, 0x7F, 0x80, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x38, 0x1F, 0xF9, 0xC1, 0xE0, 0xEC, 0x1C, 0x03, 0xE1, 0xC0, 0x0F, 0x1C,
  0x00, 0x38, 0xE0, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x63, 0x00, 0x03,
  0x38, 0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80,
  0x03, 0x1C, 0x00, 0x18, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x70,
  0xE0, 0x07, 0x07, 0x00, 0x78, 0x1C, 0x0E, 0xC0, 0x7F, 0xEE, 0x01, 0xFE,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x0E, 0x0F, 0xF0, 0xE3, 0xFE, 0x0E, 0xFC, 0x60, 0xDE, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0x81, 0xE0, 0xE0, 0x0F, 0x1C,
  0x00, 0x71, 0x80, 0x03, 0x18, 0x00, 0x31, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00,
  0xEE, 0x00, 0x1C, 0x70, 0x03, 0xC7, 0x80, 0x78, 0x3F, 0xFF, 0x00, 0xFF,
  0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1C, 0x00, 0x38,
  0xC0, 0x01, 0xC6, 0x00, 0x0E, 0x70, 0x00, 0x63, 0x80, 0x03, 0x1C, 0x00,
  0x38, 0xE0, 0x01, 0xC6, 0x00, 0x0E, 0x30, 0x00, 0x73, 0x80, 0x03, 0x1C,
  0x00, 0x18, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x30, 0x00, 0x71, 0x80, 0x03,
  0x9C, 0x00, 0x18, 0xE0, 0x00, 0xC7, 0x00, 0x0E, 0x18, 0x00, 0x70, 0xC0,
  0x07, 0x87, 0x00, 0x78, 0x1C, 0x0E, 0xC0, 0xFF, 0xE6, 0x03, 0xFC, 0x70,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xE6, 0x00, 0x07, 0x18, 0x00, 0x1C, 0x70,
  0x00, 0xE1, 0xC0, 0x03, 0x83, 0x00, 0x1C, 0x0C, 0x00, 0x60, 0x38, 0x03,
  0x80, 0xE0, 0x0C, 0x01, 0x80, 0x70, 0x06, 0x01, 0x80, 0x1C, 0x0E, 0x00,
  0x70, 0x70, 0x00, 0xC1, 0x80, 0x03, 0x0E, 0x00, 0x0C, 0x30, 0x00, 0x39,
  0xC0, 0x00, 0x66, 0x00, 0x01, 0xB8, 0x00, 0x06, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07,
  0xE0, 0x38, 0x06, 0xE0, 0x38, 0x0E, 0xE0, 0x78, 0x0C, 0xE0, 0x78, 0x0C,
  0xE0, 0x78, 0x1C, 0xE0, 0xD8, 0x18, 0x60, 0xCC, 0x18, 0x61, 0x8C, 0x30,
  0x61, 0x8C, 0x30, 0x63, 0x8C, 0x70, 0x63, 0x0C, 0x60, 0x63, 0x0C, 0x60,
  0x66, 0x0C, 0xC0, 0x66, 0x0C, 0xC0, 0x6C, 0x0C, 0xC0, 0x6C, 0x0D, 0x80,
  0x6C, 0x0D, 0x80, 0x78, 0x0D, 0x80, 0x78, 0x0F, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x06, 0x00, 0x70, 0x06, 0x00, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x0E,
  0x07, 0x00, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x01, 0xC0, 0xF0,
  0x00, 0xC1, 0xE0, 0x00, 0xE3, 0xC0, 0x00, 0x73, 0x80, 0x00, 0x77, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xEE, 0x00, 0x01, 0xE7, 0x00, 0x03, 0xC7, 0x00, 0x03, 0x83, 0x80,
  0x07, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x38, 0x00, 0xE0,
  0x70, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x1C, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0x30, 0x00, 0x38, 0x07,
  0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x1C,
  0x00, 0x38, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x00, 0x60, 0x1C, 0x00, 0x0E,
  0x07, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x03, 0x0E, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x1B,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0x00, 0x01,
  0x80, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x03, 0x03, 0x03, 0x07,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C,
  0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x38, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x70, 0x70, 0x60, 0x60, 0x60, 0x60, 0x60, 0xE0, 0xC0, 0xC0, 0xC0, 0x01,
  0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xC0, 0x02,
  0x3F, 0xE0, 0x03, 0x78, 0x78, 0x03, 0x60, 0x3C, 0x06, 0xE0, 0x1E, 0x0E,
  0xC0, 0x0F, 0xFC, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0xE0,
};

const GFXglyph RobotoMono_LightItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 8, 32, 26, 9, -32 },
  { 33, 11, 10, 26, 10, -34 },
  { 47, 26, 32, 26, 1, -32 },
  { 151, 22, 42, 26, 3, -37 },
  { 267, 21, 32, 26, 3, -32 },
  { 351, 22, 33, 26, 2, -33 },
  { 442, 4, 10, 26, 13, -34 },
  { 447, 14, 46, 26, 8, -36 },
  { 528, 14, 46, 26, 4, -36 },
  { 609, 19, 20, 26, 6, -32 },
  { 657, 21, 24, 26, 3, -27 },
  { 720, 6, 10, 26, 5, -4 },
  { 728, 16, 2, 26, 5, -15 },
  { 732, 4, 4, 26, 10, -4 },
  { 734, 22, 35, 26, 3, -32 },
  { 831, 21, 32, 26, 3, -32 },
  { 915, 12, 32, 26, 7, -32 },
  { 963, 22, 32, 26, 1, -32 },
  { 1051, 22, 32, 26, 1, -32 },
  { 1139, 22, 32, 26, 1, -32 },
  { 1227, 22, 32, 26, 4, -32 },
  { 1315, 19, 32, 26, 3, -32 },
  { 1391, 21, 32, 26, 5, -32 },
  { 1475, 22, 32, 26, 3, -32 },
  { 1563, 20, 32, 26, 4, -32 },
  { 1643, 8, 23, 26, 11, -23 },
  { 1666, 10, 29, 26, 8, -23 },
  { 1703, 20, 19, 26, 4, -24 },
  { 1751, 21, 11, 26, 3, -20 },
  { 1780, 21, 19, 26, 2, -24 },
  { 1830, 17, 32, 26, 7, -32 },
  { 1898, 25, 32, 26, 1, -32 },
  { 1998, 22, 32, 26, 0, -32 },
  { 2086, 23, 32, 26, 2, -32 },
  { 2178, 22, 32, 26, 3, -32 },
  { 2266, 24, 32, 26, 1, -32 },
  { 2362, 24, 32, 26, 2, -32 },
  { 2458, 24, 32, 26, 2, -32 },
  { 2554, 23, 33, 26, 2, -32 },
  { 2649, 25, 32, 26, 1, -32 },
  { 2749, 23, 32, 26, 2, -32 },
  { 2841, 23, 32, 26, 2, -32 },
  { 2933, 26, 32, 26, 2, -32 },
  { 3037, 19, 32, 26, 2, -32 },
  { 3113, 25, 32, 26, 1, -32 },
  { 3213, 25, 32, 26, 1, -32 },
  { 3313, 22, 32, 26, 3, -32 },
  { 3401, 24, 32, 26, 2, -32 },
  { 3497, 23, 38, 26, 2, -32 },
  { 3607, 23, 32, 26, 2, -32 },
  { 3699, 23, 32, 26, 2, -32 },
  { 3791, 23, 32, 26, 5, -32 },
  { 3883, 23, 32, 26, 3, -32 },
  { 3975, 22, 32, 26, 5, -32 },
  { 4063, 24, 32, 26, 4, -32 },
  { 4159, 27, 32, 26, 0, -32 },
  { 4267, 22, 32, 26, 5, -32 },
  { 4355, 24, 32, 26, 1, -32 },
  { 4451, 15, 44, 26, 6, -37 },
  { 4534, 9, 35, 26, 9, -32 },
  { 4574, 14, 44, 26, 6, -37 },
  { 4651, 16, 17, 26, 5, -32 },
  { 4685, 19, 2, 26, 1, 0 },
  { 4690, 6, 6, 26, 13, -33 },
  { 4695, 21, 24, 26, 2, -24 },
  { 4758, 21, 34, 26, 2, -34 },
  { 4848, 20, 24, 26, 3, -24 },
  { 4908, 23, 34, 26, 3, -34 },
  { 5006, 20, 24, 26, 3, -24 },
  { 5066, 22, 34, 26, 5, -34 },
  { 5160, 23, 34, 26, 1, -24 },
  { 5258, 21, 34, 26, 2, -34 },
  { 5348, 19, 32, 26, 2, -32 },
  { 5424, 21, 42, 26, 0, -32 },
  { 5535, 23, 34, 26, 2, -34 },
  { 5633, 19, 34, 26, 2, -34 },
  { 5714, 25, 24, 26, 0, -24 },
  { 5789, 21, 24, 26, 2, -24 },
  { 5852, 21, 24, 26, 2, -24 },
  { 5915, 23, 33, 26, 0, -24 },
  { 6010, 21, 33, 26, 3, -24 },
  { 6097, 20, 24, 26, 5, -24 },
  { 6157, 20, 24, 26, 3, -24 },
  { 6217, 18, 30, 26, 5, -30 },
  { 6285, 21, 24, 26, 3, -24 },
  { 6348, 22, 24, 26, 4, -24 },
  { 6414, 24, 24, 26, 3, -24 },
  { 6486, 24, 24, 26, 1, -24 },
  { 6558, 27, 34, 26, -1, -24 },
  { 6673, 23, 24, 26, 1, -24 },
  { 6742, 17, 44, 26, 7, -35 },
  { 6836, 8, 39, 26, 9, -32 },
  { 6875, 17, 44, 26, 4, -35 },
  { 6969, 24, 8, 26, 1, -17 },
};

const GFXfont RobotoMono_LightItalic45pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic45pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic45pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _ROBOTOMONO_LIGHTITALIC45PT7B_H_
