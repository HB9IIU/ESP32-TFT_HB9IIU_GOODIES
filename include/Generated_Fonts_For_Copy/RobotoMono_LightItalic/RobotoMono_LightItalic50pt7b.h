#ifndef _ROBOTOMONO_LIGHTITALIC50PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x78, 0x3C, 0x1C, 0x00, 0x38, 0x73, 0x87, 0x30, 0x73, 0x06,
  0x30, 0x67, 0x06, 0x70, 0xE6, 0x0E, 0x60, 0xC6, 0x0C, 0xE0, 0xC0, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06,
  0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x0E,
  0x00, 0x01, 0xC0, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x07, 0x01, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x1C,
  0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x60, 0x18,
  0x00, 0x03, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x0C, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30,
  0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x70,
  0x00, 0x0E, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x30, 0x0C, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x06, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xE0,
  0x1E, 0x03, 0xC0, 0x0E, 0x07, 0x80, 0x0E, 0x07, 0x00, 0x07, 0x07, 0x00,
  0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x1C, 0x60, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x78, 0x78, 0x00,
  0x70, 0x3C, 0x01, 0xF0, 0x1F, 0x07, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x3C, 0x70,
  0x00, 0x30, 0x30, 0x00, 0x70, 0x30, 0x08, 0x60, 0x38, 0x0C, 0x60, 0x38,
  0x1C, 0xE0, 0x30, 0x38, 0xE0, 0x30, 0x30, 0xE0, 0x30, 0x70, 0xE0, 0x30,
  0xE0, 0xE0, 0x70, 0xC0, 0x60, 0xE1, 0x80, 0x71, 0xC3, 0x80, 0x3F, 0x87,
  0x00, 0x1F, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x30, 0x00, 0x61, 0xFC, 0x00, 0xC3,
  0xFE, 0x01, 0xC7, 0x06, 0x03, 0x86, 0x07, 0x03, 0x0E, 0x03, 0x07, 0x0C,
  0x03, 0x0E, 0x0C, 0x03, 0x0C, 0x0C, 0x07, 0x1C, 0x0C, 0x07, 0x38, 0x1C,
  0x06, 0x10, 0x0C, 0x06, 0x00, 0x0C, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x03, 0x80, 0x0E,
  0x01, 0xC0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01,
  0xC0, 0x38, 0x00, 0xE0, 0x3C, 0x00, 0x30, 0x3C, 0x00, 0x1C, 0x3C, 0x00,
  0x0E, 0x3C, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0xF1, 0xC0,
  0x38, 0xE0, 0x70, 0x1C, 0xF0, 0x38, 0x0E, 0xF0, 0x0E, 0x06, 0x70, 0x07,
  0x87, 0x38, 0x01, 0xC3, 0xB8, 0x00, 0x73, 0x9C, 0x00, 0x39, 0xCE, 0x00,
  0x0F, 0xC7, 0x00, 0x07, 0xC3, 0x80, 0x01, 0xC0, 0xE0, 0x01, 0xF0, 0x78,
  0x03, 0xFC, 0x1F, 0x07, 0xCE, 0x07, 0xFF, 0xC3, 0x80, 0xFF, 0x81, 0xE0,
  0x33, 0x37, 0x77, 0x66, 0x6E, 0xE0, 0x00, 0x01, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xF0, 0x00, 0x40, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x18, 0x0E, 0x02, 0x78, 0x30, 0x7F, 0xFC, 0xCF, 0xF1, 0xFF, 0xFE,
  0x00, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1D, 0x80, 0x00,
  0xE7, 0x00, 0x07, 0x0E, 0x00, 0x38, 0x38, 0x01, 0xE0, 0x70, 0x0F, 0x01,
  0xE0, 0x78, 0x03, 0x80, 0x40, 0x04, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x38,
  0x70, 0xE1, 0xC7, 0x8E, 0x1C, 0x70, 0xE3, 0x86, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x27, 0xBF, 0xEF, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFD, 0xF8,
  0x01, 0xE0, 0x3C, 0x03, 0x80, 0x1E, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x06,
  0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x0F,
  0x18, 0x00, 0x1F, 0x38, 0x00, 0x3F, 0x38, 0x00, 0xF7, 0x38, 0x01, 0xE7,
  0x38, 0x03, 0xC6, 0x30, 0x07, 0x0E, 0x70, 0x1E, 0x0E, 0x70, 0x3C, 0x0E,
  0x70, 0x78, 0x0E, 0x70, 0xE0, 0x0E, 0x73, 0xC0, 0x0C, 0x77, 0x80, 0x1C,
  0x6F, 0x00, 0x1C, 0xFC, 0x00, 0x1C, 0xF8, 0x00, 0x1C, 0xF0, 0x00, 0x38,
  0x60, 0x00, 0x38, 0x60, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0xE0,
  0x38, 0x01, 0xE0, 0x38, 0x03, 0xC0, 0x1E, 0x0F, 0x80, 0x0F, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x70, 0x0F, 0xC0,
  0xFF, 0x1F, 0xD9, 0xFC, 0xE7, 0x83, 0x98, 0x0E, 0x80, 0x38, 0x00, 0xE0,
  0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0xFD, 0xFC, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x0E,
  0x07, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07,
  0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x3C, 0x03, 0xC0, 0x3C, 0x00,
  0xF0, 0x3C, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x1E, 0x00, 0x06, 0x0E, 0x00,
  0x03, 0x07, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03,
  0x8E, 0x00, 0x01, 0xC3, 0x80, 0x01, 0xC1, 0xC0, 0x01, 0xE0, 0xF0, 0x00,
  0xE0, 0x3C, 0x01, 0xE0, 0x0F, 0x03, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x70,
  0x00, 0x03, 0xB8, 0x00, 0x03, 0x98, 0x00, 0x03, 0x9C, 0x00, 0x03, 0x8E,
  0x00, 0x03, 0x87, 0x00, 0x03, 0xC3, 0x80, 0x01, 0xC1, 0xC0, 0x01, 0xC0,
  0xC0, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0x70, 0x01, 0xE0, 0x38, 0x00, 0xE0,
  0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0xE0, 0x07, 0x00, 0xE0,
  0x03, 0x80, 0xF0, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x71, 0xF0, 0x00, 0x37, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x1F, 0x81, 0xE0, 0x0E, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x1C, 0x00,
  0x07, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x03, 0x80, 0xE0,
  0x03, 0xC0, 0x38, 0x03, 0xC0, 0x1F, 0x07, 0xC0, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE1, 0xFE, 0x03, 0x9F, 0xFC, 0x0E,
  0xF0, 0xF8, 0x77, 0x00, 0xF1, 0xF0, 0x01, 0xE7, 0x80, 0x03, 0x9C, 0x00,
  0x0E, 0x70, 0x00, 0x39, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0,
  0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x0E, 0x1E, 0x00, 0x78, 0x3C, 0x03,
  0xC0, 0x78, 0x3E, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x40, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x3C, 0x03, 0xC0, 0x3C, 0x00, 0xF0,
  0x3C, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x07,
  0x07, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00,
  0xE0, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xF0, 0x3E, 0x00, 0xE0,
  0x07, 0x80, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70,
  0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E,
  0x00, 0x01, 0xC7, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0xE0,
  0x38, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF8,
  0x1E, 0x01, 0xC1, 0xE0, 0x07, 0x0E, 0x00, 0x38, 0xE0, 0x00, 0xEF, 0x00,
  0x07, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xDC, 0x00, 0x3C, 0xE0, 0x03, 0xE3, 0x80, 0x7F, 0x1F,
  0x0F, 0xB8, 0x7F, 0xF1, 0x80, 0xFF, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00,
  0xFC, 0x00, 0x00, 0x02, 0x07, 0x83, 0xE1, 0xE0, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x03, 0xE1, 0xF0, 0xF8, 0x78, 0x00, 0x00, 0x40, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03,
  0x80, 0x70, 0x1C, 0x07, 0x00, 0x40, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x60, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x18, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xC1, 0xE0,
  0x1C, 0x3C, 0x00, 0xE3, 0x80, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x06, 0xE0,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xC0, 0x3C, 0x00,
  0xF0, 0x00, 0xC0, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x60, 0x30, 0x00,
  0x06, 0x07, 0x03, 0xF0, 0x70, 0xE0, 0xFF, 0x83, 0x0C, 0x1E, 0x18, 0x31,
  0xC1, 0x81, 0x83, 0x18, 0x30, 0x18, 0x33, 0x87, 0x01, 0x03, 0x30, 0x60,
  0x30, 0x33, 0x06, 0x03, 0x03, 0x70, 0xC0, 0x30, 0x26, 0x0C, 0x06, 0x06,
  0x60, 0xC0, 0x60, 0x66, 0x1C, 0x06, 0x06, 0x61, 0x80, 0x60, 0x66, 0x18,
  0x0C, 0x0C, 0xE1, 0x80, 0xC0, 0xCC, 0x18, 0x1C, 0x0C, 0xE1, 0x83, 0xC1,
  0x8E, 0x1C, 0x7C, 0x38, 0xE0, 0xFE, 0xE7, 0x06, 0x0F, 0xC7, 0xE0, 0x60,
  0x60, 0x38, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x40, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0E,
  0xE0, 0x00, 0x07, 0x70, 0x00, 0x07, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x03,
  0x86, 0x00, 0x01, 0xC3, 0x00, 0x01, 0xC1, 0x80, 0x00, 0xE0, 0xE0, 0x00,
  0xE0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x06, 0x00,
  0x38, 0x03, 0x00, 0x1C, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70,
  0x0E, 0x00, 0x38, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x03, 0x80, 0x01, 0x81, 0xC0, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00,
  0x38, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x07, 0x38, 0x00,
  0x01, 0x9C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x70, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x70, 0x07, 0xC0, 0x30, 0x00, 0xF0,
  0x38, 0x00, 0x3C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x03,
  0x83, 0x80, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00,
  0x70, 0x70, 0x00, 0x78, 0x38, 0x00, 0x78, 0x18, 0x00, 0xF8, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0x80, 0x0F, 0x01, 0xC0,
  0x01, 0xC0, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x38,
  0x00, 0x06, 0x1C, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x86, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0xF0,
  0x70, 0x01, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x3C,
  0x03, 0xC0, 0x38, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x3C, 0x00, 0x1C, 0x1C,
  0x00, 0x0E, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x38, 0x00,
  0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x03, 0x83, 0x00, 0x03, 0xC1, 0xC0,
  0x01, 0xC0, 0xF0, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x0F, 0x03, 0xC0, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x04, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1C, 0x01, 0xF0, 0x07, 0x00,
  0x1E, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x00, 0x70, 0x18, 0x00, 0x1C, 0x0E,
  0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x06,
  0x0E, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x70, 0x00,
  0x07, 0x1C, 0x00, 0x01, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x60,
  0x00, 0x0E, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x70,
  0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x3C, 0x1C, 0x00, 0x1E, 0x07, 0x00,
  0x0F, 0x03, 0x80, 0x07, 0x80, 0xE0, 0x07, 0xC0, 0x3F, 0x3F, 0xE0, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3C, 0x03, 0xC0, 0x3C,
  0x00, 0xE0, 0x38, 0x00, 0x38, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x1C,
  0x00, 0x03, 0x8E, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x01, 0xFF,
  0xCE, 0x00, 0xFF, 0xE7, 0x00, 0x7F, 0xF3, 0x80, 0x00, 0x39, 0xC0, 0x00,
  0x1C, 0xE0, 0x00, 0x0C, 0x70, 0x00, 0x06, 0x38, 0x00, 0x07, 0x1C, 0x00,
  0x03, 0x8E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0x70,
  0x00, 0x70, 0x3C, 0x00, 0xF8, 0x0F, 0x81, 0xF0, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x1C,
  0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0xC0,
  0x00, 0x18, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x81, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x81, 0x80, 0x00, 0x30, 0x18,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x70, 0x38, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x03,
  0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x0E, 0x00,
  0x0F, 0x01, 0xC0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x0F, 0x83, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x78, 0x1C, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x78, 0x07, 0x00, 0x07, 0x80, 0x38, 0x00, 0x78,
  0x03, 0x80, 0x07, 0x80, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x07, 0x80, 0x07,
  0x00, 0x78, 0x00, 0x38, 0x07, 0x80, 0x01, 0x80, 0x78, 0x00, 0x1C, 0x07,
  0x80, 0x00, 0xE0, 0x78, 0x00, 0x07, 0x07, 0x80, 0x00, 0x38, 0x78, 0x00,
  0x01, 0xC7, 0x80, 0x00, 0x0C, 0x78, 0x00, 0x00, 0xE7, 0xC0, 0x00, 0x07,
  0x7F, 0x00, 0x00, 0x3F, 0xBC, 0x00, 0x01, 0xF0, 0xE0, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x38, 0x03, 0x80,
  0x01, 0xC0, 0x1E, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x70, 0x01, 0xC0, 0x03,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x0E, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x3C, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x07,
  0x81, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xE0, 0x01, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03,
  0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xF0, 0x36, 0x00,
  0x3E, 0x03, 0x60, 0x07, 0x60, 0x76, 0x00, 0x7E, 0x07, 0x70, 0x0E, 0xE0,
  0x77, 0x00, 0xCE, 0x07, 0x70, 0x1C, 0xE0, 0x63, 0x03, 0x8C, 0x0E, 0x30,
  0x38, 0xC0, 0xE3, 0x07, 0x1C, 0x0E, 0x38, 0x71, 0xC0, 0xE3, 0x8E, 0x1C,
  0x0E, 0x38, 0xE1, 0xC0, 0xC1, 0x9C, 0x18, 0x1C, 0x19, 0xC3, 0x81, 0xC1,
  0xB8, 0x38, 0x1C, 0x1F, 0x03, 0x81, 0xC1, 0xF0, 0x38, 0x1C, 0x1E, 0x03,
  0x81, 0x80, 0xE0, 0x30, 0x38, 0x0C, 0x07, 0x03, 0x80, 0x00, 0x70, 0x38,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x06, 0x03, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0xE0, 0x60, 0x00, 0x0C, 0x0E, 0x00, 0x01, 0xC0, 0x03, 0x80,
  0x00, 0x70, 0x3C, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x70, 0x3C, 0x00, 0x06,
  0x03, 0xE0, 0x00, 0xE0, 0x3E, 0x00, 0x0E, 0x07, 0x60, 0x00, 0xE0, 0x77,
  0x00, 0x0E, 0x07, 0x70, 0x00, 0xE0, 0x73, 0x00, 0x0C, 0x07, 0x38, 0x01,
  0xC0, 0x63, 0x80, 0x1C, 0x0E, 0x1C, 0x01, 0xC0, 0xE1, 0xC0, 0x1C, 0x0E,
  0x1C, 0x01, 0xC0, 0xE0, 0xE0, 0x38, 0x0E, 0x0E, 0x03, 0x81, 0xC0, 0xE0,
  0x38, 0x1C, 0x07, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x1C, 0x03, 0x03, 0x01,
  0xC0, 0x38, 0x70, 0x18, 0x03, 0x87, 0x03, 0x80, 0x18, 0x70, 0x38, 0x01,
  0xC7, 0x03, 0x80, 0x1C, 0x70, 0x38, 0x00, 0xC6, 0x03, 0x80, 0x0E, 0xE0,
  0x30, 0x00, 0xEE, 0x07, 0x00, 0x07, 0xE0, 0x70, 0x00, 0x7E, 0x07, 0x00,
  0x07, 0xE0, 0x70, 0x00, 0x3C, 0x07, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x3C,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xF8, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x1E, 0x07, 0x00, 0x0E, 0x0F, 0x00,
  0x06, 0x0E, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x38, 0x00,
  0x07, 0x38, 0x00, 0x07, 0x38, 0x00, 0x03, 0x70, 0x00, 0x07, 0x70, 0x00,
  0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x60, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0x60, 0x00, 0x70, 0x70, 0x00,
  0xE0, 0x78, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x1E, 0x0F, 0x80, 0x0F, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1C, 0x00, 0x7C, 0x07, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x18, 0x00, 0x07, 0x0E, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00,
  0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x78, 0x70, 0x00, 0x1C, 0x1C,
  0x00, 0x0E, 0x07, 0x00, 0x0F, 0x81, 0x80, 0x0F, 0xC0, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x07, 0xC0, 0x78, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x01, 0xC0,
  0x70, 0x00, 0x38, 0x3C, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0x87, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x1C, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03,
  0x98, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x33, 0x80, 0x00, 0x1C, 0xE0, 0x00,
  0x07, 0x18, 0x00, 0x01, 0xC6, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70,
  0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x01, 0xC0,
  0x1C, 0x01, 0xE0, 0x03, 0xC1, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x04, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0x80,
  0x0F, 0x00, 0xC0, 0x01, 0xE0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x07,
  0x00, 0x01, 0x81, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x18, 0x18, 0x00, 0x0E,
  0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x38, 0x00,
  0x3C, 0x0C, 0x00, 0x1E, 0x07, 0x00, 0x0F, 0x01, 0xC0, 0x1F, 0x80, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x07, 0x00, 0xE0, 0x01, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x03, 0x80, 0x0E,
  0x00, 0xE0, 0x03, 0x80, 0x30, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x07, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x0F, 0x06,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x07, 0x81, 0xE0,
  0x00, 0xE0, 0x70, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87, 0x80, 0x01, 0xC0, 0xE0,
  0x00, 0xF0, 0x3C, 0x00, 0x78, 0x07, 0xE0, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0,
  0x00, 0x1C, 0x38, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x87, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x18, 0x30, 0x00, 0x0E, 0x1C,
  0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E,
  0x1C, 0x00, 0x03, 0x06, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00,
  0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0xE0,
  0x00, 0x38, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x0F, 0x01, 0xC0, 0x07, 0x80,
  0x38, 0x03, 0xC0, 0x07, 0x83, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x71,
  0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C,
  0x0E, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x07,
  0x00, 0x60, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x01,
  0xC0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0x60,
  0x70, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07,
  0x0C, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x67, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x0C,
  0x01, 0xF8, 0x03, 0x80, 0x7E, 0x01, 0xE0, 0x1F, 0x80, 0x78, 0x06, 0xE0,
  0x1E, 0x03, 0xB8, 0x0F, 0x80, 0xEE, 0x03, 0xE0, 0x33, 0x80, 0xF8, 0x1C,
  0xE0, 0x7E, 0x07, 0x38, 0x1B, 0x81, 0xCE, 0x06, 0xE0, 0x63, 0x83, 0xB8,
  0x38, 0xE0, 0xCE, 0x0E, 0x38, 0x33, 0x83, 0x0E, 0x1C, 0xE1, 0xC3, 0x86,
  0x18, 0x70, 0xE3, 0x86, 0x18, 0x38, 0xE1, 0x86, 0x0E, 0x30, 0x63, 0x83,
  0x9C, 0x18, 0xE0, 0xC7, 0x06, 0x30, 0x31, 0x81, 0x9C, 0x0C, 0xE0, 0x67,
  0x03, 0x38, 0x19, 0x80, 0xCC, 0x06, 0x60, 0x37, 0x01, 0xB8, 0x0D, 0xC0,
  0x6E, 0x03, 0x60, 0x1B, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xE0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x80, 0x38, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x01, 0xC1, 0xE0,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x39, 0xE0, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x0E, 0x18,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1E, 0x03, 0x80,
  0x00, 0x70, 0x0E, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x1E, 0x00, 0x70, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0xF0,
  0x00, 0x1C, 0x07, 0x80, 0x00, 0x70, 0x3C, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x03, 0xB8, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xCF, 0x00, 0x01, 0xC3, 0x80,
  0x01, 0xE1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0xF0, 0x1C,
  0x00, 0x70, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x78, 0x01, 0xC0, 0x38, 0x00,
  0xE0, 0x38, 0x00, 0x38, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x1C, 0x00,
  0x03, 0x0E, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x37, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60,
  0x00, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xC0, 0x38, 0x0E, 0x03, 0x80,
  0x60, 0x18, 0x07, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0x00, 0xE0, 0x38, 0x0E,
  0x01, 0x80, 0x60, 0x1C, 0x07, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0xE0,
  0x38, 0x06, 0x01, 0x80, 0x70, 0x1C, 0x07, 0x00, 0xC0, 0x30, 0x0E, 0x03,
  0x80, 0xE0, 0x18, 0x06, 0x01, 0xC0, 0x70, 0x1C, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x6C, 0x00, 0x3B, 0x00, 0x0C, 0xE0, 0x07, 0x38, 0x03, 0x8E,
  0x00, 0xE1, 0x80, 0x70, 0x60, 0x1C, 0x1C, 0x0E, 0x07, 0x03, 0x00, 0xC1,
  0xC0, 0x30, 0xE0, 0x0E, 0x38, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x1B, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0xE0, 0xE1, 0xC1, 0xC1,
  0x83, 0x80, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xE0,
  0x1E, 0x0F, 0x00, 0x38, 0x78, 0x00, 0x71, 0xC0, 0x01, 0xCE, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x01,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xF0, 0x03, 0x8F, 0x00, 0x0E, 0x70, 0x00,
  0x3B, 0x80, 0x00, 0xEE, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x73,
  0x80, 0x03, 0xCE, 0x00, 0x1F, 0x3C, 0x01, 0xFC, 0x78, 0x1E, 0x70, 0xFF,
  0xF1, 0xC1, 0xFF, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x7E, 0x00, 0x63, 0xFF, 0x01, 0xCF, 0xFF, 0x03, 0xF8, 0x0F,
  0x07, 0xC0, 0x0E, 0x0F, 0x00, 0x1E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38,
  0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E,
  0x00, 0x07, 0x18, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0,
  0x00, 0x73, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x9C, 0x00, 0x0F, 0x38, 0x00,
  0x1C, 0x78, 0x00, 0x78, 0xF0, 0x01, 0xE1, 0xF0, 0x07, 0x83, 0x78, 0x3E,
  0x0E, 0x7F, 0xF8, 0x1C, 0x3F, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x3E, 0x03, 0xC0, 0xF0, 0x03,
  0xC1, 0xC0, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x38, 0x00, 0x0E,
  0x70, 0x00, 0x05, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x01, 0xC7, 0x00, 0x07, 0x0E, 0x00,
  0x0E, 0x0E, 0x00, 0x38, 0x1E, 0x00, 0xF0, 0x1E, 0x07, 0xC0, 0x1F, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x07, 0xC1, 0xC0, 0x1F, 0xF8, 0xE0,
  0x1F, 0xFF, 0x70, 0x1F, 0x03, 0xB8, 0x1E, 0x00, 0x7C, 0x1E, 0x00, 0x3E,
  0x0E, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0x80, 0x01,
  0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x60, 0x00,
  0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00,
  0x03, 0x07, 0x00, 0x03, 0x81, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x70,
  0x00, 0xF0, 0x3C, 0x00, 0xF8, 0x0E, 0x00, 0xF8, 0x07, 0xC1, 0xEC, 0x01,
  0xFF, 0xEE, 0x00, 0x3F, 0xC7, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x3E, 0x03, 0xC0, 0x70, 0x03, 0x81, 0xC0, 0x03, 0x87,
  0x00, 0x07, 0x1E, 0x00, 0x06, 0x38, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0,
  0x00, 0x3B, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xB8, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x04, 0x0E, 0x00, 0x1C,
  0x1E, 0x00, 0x78, 0x1F, 0x03, 0xE0, 0x1F, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xF0,
  0xC0, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xE3, 0x01, 0xFF, 0xF7, 0x03,
  0xE0, 0x77, 0x07, 0x80, 0x1F, 0x0F, 0x00, 0x1F, 0x0E, 0x00, 0x0E, 0x1E,
  0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38,
  0x00, 0x0E, 0x38, 0x00, 0x0C, 0x30, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70,
  0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x38, 0x30,
  0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x78, 0x3C, 0x00, 0xF8, 0x1C,
  0x01, 0xF8, 0x1F, 0x07, 0xB0, 0x0F, 0xFF, 0x70, 0x03, 0xFC, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x40,
  0x01, 0xC0, 0xC0, 0x03, 0xC0, 0xE0, 0x07, 0x80, 0x78, 0x1F, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x3F, 0x00, 0xE1, 0xFF, 0x81, 0xCF, 0xFF,
  0x83, 0xBC, 0x0F, 0x07, 0xE0, 0x0F, 0x0F, 0x80, 0x0E, 0x1E, 0x00, 0x1C,
  0x78, 0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC7,
  0x00, 0x03, 0x8C, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0,
  0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC6, 0x00, 0x03, 0x9C, 0x00,
  0x07, 0x38, 0x00, 0x0C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0, 0x00,
  0xE7, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x2F, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x01, 0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x3C, 0x0E, 0x00, 0x78, 0x1C, 0x00,
  0xF0, 0x1C, 0x03, 0xC0, 0x1C, 0x07, 0x80, 0x1C, 0x0F, 0x00, 0x1C, 0x1E,
  0x00, 0x1C, 0x7C, 0x00, 0x38, 0xF0, 0x00, 0x39, 0xE0, 0x00, 0x3B, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0x70, 0x00, 0x3C, 0x38, 0x00, 0x78, 0x3C,
  0x00, 0x70, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x0F, 0x00, 0x70, 0x07,
  0x00, 0x60, 0x03, 0x80, 0xE0, 0x03, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x00,
  0xE0, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x78, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x3C, 0x07, 0x80, 0xEF, 0xF1, 0xFE, 0x0D, 0xFF, 0x3F, 0xE0, 0xF0, 0x7E,
  0x0F, 0x1E, 0x03, 0xC0, 0x71, 0xC0, 0x38, 0x07, 0x1C, 0x03, 0x80, 0x71,
  0xC0, 0x38, 0x07, 0x1C, 0x03, 0x80, 0x71, 0x80, 0x30, 0x06, 0x38, 0x07,
  0x00, 0x63, 0x80, 0x70, 0x0E, 0x38, 0x07, 0x00, 0xE3, 0x80, 0x70, 0x0E,
  0x30, 0x07, 0x00, 0xE3, 0x00, 0x60, 0x0C, 0x70, 0x0E, 0x00, 0xC7, 0x00,
  0xE0, 0x1C, 0x70, 0x0E, 0x01, 0xC7, 0x00, 0xE0, 0x1C, 0x60, 0x0E, 0x01,
  0xC6, 0x00, 0xC0, 0x18, 0xE0, 0x1C, 0x01, 0x8E, 0x01, 0xC0, 0x38, 0xE0,
  0x1C, 0x03, 0x8E, 0x01, 0xC0, 0x38, 0xC0, 0x18, 0x03, 0x80, 0x00, 0x07,
  0xE0, 0x1C, 0x3F, 0xF0, 0x39, 0xFF, 0xF0, 0x77, 0x81, 0xE0, 0xFC, 0x01,
  0xE1, 0xF0, 0x01, 0xC3, 0xC0, 0x03, 0x8F, 0x00, 0x07, 0x1C, 0x00, 0x0E,
  0x38, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x71, 0x80, 0x00, 0xE7,
  0x00, 0x01, 0xCE, 0x00, 0x03, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70,
  0x00, 0x38, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xE7, 0x00, 0x01, 0x8E, 0x00,
  0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00,
  0x73, 0x80, 0x01, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x3C, 0x03, 0xC0, 0xF0, 0x03, 0x83, 0xC0, 0x03, 0x8F, 0x00, 0x07,
  0x1C, 0x00, 0x06, 0x78, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x06, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0xE7, 0x00,
  0x01, 0xCE, 0x00, 0x07, 0x8E, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x1C, 0x01,
  0xE0, 0x3E, 0x0F, 0x80, 0x3F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0xC7, 0xFE, 0x00, 0xEF, 0xFF, 0x80, 0x7F,
  0x03, 0xE0, 0x3E, 0x00, 0x70, 0x1E, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x0E,
  0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0,
  0xE0, 0x00, 0x70, 0x60, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E,
  0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x03, 0x83, 0x00, 0x01,
  0xC3, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x78, 0x00,
  0xF0, 0x3E, 0x00, 0xF0, 0x1F, 0xC1, 0xF0, 0x1C, 0xFF, 0xF0, 0x0E, 0x1F,
  0xE0, 0x07, 0x00, 0x80, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x03, 0xFF, 0x8C, 0x0F, 0xFF, 0xB8, 0x3E, 0x03, 0xF0, 0xF0, 0x03, 0xE3,
  0xC0, 0x03, 0xC7, 0x00, 0x07, 0x1E, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70,
  0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xE7, 0x00, 0x01, 0x8C, 0x00,
  0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00,
  0x73, 0x80, 0x01, 0xC3, 0x00, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x1E,
  0x1E, 0x00, 0x7C, 0x1C, 0x01, 0xF0, 0x3E, 0x0F, 0x60, 0x3F, 0xFD, 0xC0,
  0x1F, 0xE3, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xF8, 0x70,
  0xFF, 0xC3, 0x8F, 0xFE, 0x1D, 0xF0, 0x00, 0xFE, 0x00, 0x06, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x3C, 0x03, 0xE0, 0xF0, 0x01, 0xC1, 0xC0, 0x03,
  0xC7, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x9E, 0x00, 0x07, 0x1C, 0x00,
  0x1C, 0x3C, 0x00, 0x78, 0x3E, 0x03, 0xE0, 0x3F, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x01, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x1F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xE0, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x81, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x0E, 0x70, 0x00, 0x38, 0xE0,
  0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x8C, 0x00,
  0x06, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0, 0x00,
  0xE3, 0x80, 0x01, 0xC6, 0x00, 0x03, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C,
  0x70, 0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80, 0x03, 0x87,
  0x00, 0x07, 0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x7C, 0x1C, 0x01, 0xF8, 0x3C,
  0x1F, 0x70, 0x3F, 0xF8, 0xC0, 0x3F, 0xE3, 0x80, 0x04, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0x30,
  0x00, 0x1C, 0x38, 0x00, 0x38, 0x38, 0x00, 0x70, 0x38, 0x00, 0x70, 0x18,
  0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0C,
  0x03, 0x80, 0x0E, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x06,
  0x0E, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x38, 0x00, 0x03,
  0x38, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x1C, 0x01, 0xF0, 0x07, 0x00, 0x6C,
  0x03, 0xC0, 0x3B, 0x00, 0xF0, 0x0E, 0xC0, 0x3C, 0x07, 0x30, 0x1B, 0x01,
  0xCC, 0x06, 0xC0, 0x63, 0x03, 0xB0, 0x38, 0xC0, 0xCC, 0x0E, 0x30, 0x33,
  0x03, 0x0C, 0x1C, 0xE1, 0xC3, 0x06, 0x38, 0x60, 0xC3, 0x8E, 0x18, 0x38,
  0xC3, 0x8E, 0x0E, 0x70, 0x63, 0x03, 0x98, 0x19, 0xC0, 0xE6, 0x06, 0x60,
  0x3B, 0x81, 0x98, 0x0E, 0xC0, 0x6E, 0x03, 0xF0, 0x1B, 0x00, 0xF8, 0x06,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x1E, 0x00, 0x70,
  0x07, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x70, 0x0E, 0x00, 0x1E, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x01, 0xE0, 0x01,
  0xC0, 0x78, 0x00, 0x1C, 0x1E, 0x00, 0x03, 0x87, 0x80, 0x00, 0x39, 0xE0,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xDC, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x3C, 0x38, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0,
  0x70, 0x00, 0x70, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x07, 0x00, 0x0E, 0x01,
  0xE0, 0x00, 0xE0, 0x78, 0x00, 0x1C, 0x1E, 0x00, 0x01, 0xC0, 0x07, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x38, 0x03, 0x80, 0x00, 0xE0, 0x1E, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x30,
  0x70, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0,
  0x80, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x07, 0xE0, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x30, 0x00, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x06,
  0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x1C, 0x0E, 0x06, 0x03,
  0x01, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x81,
  0xC0, 0xC0, 0x60, 0x30, 0x38, 0x1C, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0xE0, 0x70, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x0C, 0xFB, 0xF0, 0x03, 0xBC, 0x0F, 0x00, 0x67, 0x00, 0xF0,
  0x1D, 0xC0, 0x0F, 0x07, 0x38, 0x00, 0xFF, 0xE6, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x38, 0x00,
};

const GFXglyph RobotoMono_LightItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 9, 36, 29, 10, -36 },
  { 42, 12, 11, 29, 11, -38 },
  { 59, 29, 36, 29, 1, -36 },
  { 190, 24, 46, 29, 3, -41 },
  { 328, 24, 37, 29, 3, -36 },
  { 439, 25, 36, 29, 2, -36 },
  { 552, 4, 11, 29, 14, -38 },
  { 558, 16, 51, 29, 8, -40 },
  { 660, 16, 51, 29, 4, -40 },
  { 762, 22, 22, 29, 6, -36 },
  { 823, 24, 25, 29, 3, -29 },
  { 898, 7, 12, 29, 6, -5 },
  { 909, 18, 2, 29, 5, -17 },
  { 914, 5, 5, 29, 11, -5 },
  { 918, 24, 39, 29, 3, -36 },
  { 1035, 24, 37, 29, 3, -36 },
  { 1146, 14, 36, 29, 7, -36 },
  { 1209, 24, 36, 29, 1, -36 },
  { 1317, 25, 37, 29, 1, -36 },
  { 1433, 25, 36, 29, 1, -36 },
  { 1546, 25, 37, 29, 4, -36 },
  { 1662, 22, 37, 29, 3, -36 },
  { 1764, 23, 36, 29, 6, -36 },
  { 1868, 25, 37, 29, 3, -36 },
  { 1984, 21, 36, 29, 5, -36 },
  { 2079, 9, 26, 29, 12, -26 },
  { 2109, 11, 33, 29, 9, -26 },
  { 2155, 22, 21, 29, 4, -27 },
  { 2213, 24, 12, 29, 3, -22 },
  { 2249, 23, 20, 29, 3, -26 },
  { 2307, 20, 36, 29, 7, -36 },
  { 2397, 28, 36, 29, 1, -36 },
  { 2523, 25, 36, 29, 0, -36 },
  { 2636, 25, 36, 29, 2, -36 },
  { 2749, 25, 37, 29, 3, -36 },
  { 2865, 26, 36, 29, 2, -36 },
  { 2982, 27, 36, 29, 2, -36 },
  { 3104, 27, 36, 29, 2, -36 },
  { 3226, 25, 37, 29, 3, -36 },
  { 3342, 28, 36, 29, 1, -36 },
  { 3468, 26, 36, 29, 2, -36 },
  { 3585, 26, 36, 29, 2, -36 },
  { 3702, 29, 36, 29, 2, -36 },
  { 3833, 21, 36, 29, 3, -36 },
  { 3928, 28, 36, 29, 1, -36 },
  { 4054, 28, 36, 29, 1, -36 },
  { 4180, 24, 37, 29, 3, -36 },
  { 4291, 26, 36, 29, 3, -36 },
  { 4408, 26, 42, 29, 2, -36 },
  { 4545, 26, 36, 29, 2, -36 },
  { 4662, 26, 37, 29, 2, -36 },
  { 4783, 26, 36, 29, 5, -36 },
  { 4900, 26, 37, 29, 3, -36 },
  { 5021, 25, 36, 29, 5, -36 },
  { 5134, 26, 36, 29, 5, -36 },
  { 5251, 30, 36, 29, 0, -36 },
  { 5386, 25, 36, 29, 5, -36 },
  { 5499, 27, 36, 29, 1, -36 },
  { 5621, 16, 49, 29, 7, -41 },
  { 5719, 10, 39, 29, 10, -36 },
  { 5768, 15, 49, 29, 7, -41 },
  { 5860, 18, 20, 29, 6, -36 },
  { 5905, 21, 2, 29, 1, 0 },
  { 5911, 7, 7, 29, 14, -37 },
  { 5918, 22, 27, 29, 3, -27 },
  { 5993, 23, 39, 29, 2, -38 },
  { 6106, 23, 28, 29, 3, -27 },
  { 6187, 25, 38, 29, 3, -38 },
  { 6306, 23, 28, 29, 3, -27 },
  { 6387, 25, 38, 29, 6, -38 },
  { 6506, 24, 38, 29, 2, -27 },
  { 6620, 23, 38, 29, 2, -38 },
  { 6730, 21, 36, 29, 3, -36 },
  { 6825, 23, 47, 29, 0, -36 },
  { 6961, 24, 38, 29, 3, -38 },
  { 7075, 21, 38, 29, 3, -38 },
  { 7175, 28, 27, 29, 0, -27 },
  { 7270, 23, 27, 29, 2, -27 },
  { 7348, 23, 28, 29, 3, -27 },
  { 7429, 25, 37, 29, 0, -27 },
  { 7545, 23, 37, 29, 3, -27 },
  { 7652, 21, 27, 29, 6, -27 },
  { 7723, 23, 28, 29, 3, -27 },
  { 7804, 20, 34, 29, 6, -33 },
  { 7889, 23, 27, 29, 4, -26 },
  { 7967, 24, 26, 29, 4, -26 },
  { 8045, 26, 26, 29, 4, -26 },
  { 8130, 27, 26, 29, 1, -26 },
  { 8218, 30, 37, 29, -1, -26 },
  { 8357, 26, 26, 29, 1, -26 },
  { 8442, 19, 49, 29, 8, -39 },
  { 8559, 9, 44, 29, 10, -36 },
  { 8609, 20, 49, 29, 4, -39 },
  { 8732, 27, 9, 29, 1, -19 },
};

const GFXfont RobotoMono_LightItalic50pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic50pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic50pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _ROBOTOMONO_LIGHTITALIC50PT7B_H_
