#ifndef _ROBOTOMONO_LIGHTITALIC15PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0x24, 0x92, 0x02, 0x00, 0x55, 0xA0, 0x05, 0x04, 0x82, 0x4F,
  0xF1, 0x20, 0x90, 0x91, 0xFE, 0x24, 0x24, 0x12, 0x00, 0x08, 0x38, 0x8A,
  0x14, 0x0C, 0x0E, 0x02, 0x05, 0x0A, 0x13, 0xC2, 0x04, 0x00, 0x61, 0x26,
  0x54, 0xAE, 0x82, 0x09, 0x15, 0x53, 0x24, 0x30, 0x18, 0x49, 0x12, 0x43,
  0x04, 0x14, 0xC5, 0x8D, 0x1B, 0xD8, 0x68, 0x12, 0x44, 0x88, 0x88, 0x88,
  0x88, 0x88, 0x40, 0x20, 0x82, 0x10, 0x84, 0x21, 0x08, 0x44, 0x22, 0x13,
  0x00, 0x10, 0x49, 0x5E, 0x31, 0x28, 0x80, 0x08, 0x20, 0x40, 0x8F, 0xE2,
  0x04, 0x10, 0x68, 0xF8, 0xC0, 0x02, 0x04, 0x10, 0x20, 0x82, 0x04, 0x10,
  0x20, 0x81, 0x04, 0x00, 0x1C, 0x45, 0x0A, 0x18, 0xF2, 0x68, 0xE1, 0x85,
  0x09, 0xE0, 0x17, 0x91, 0x11, 0x22, 0x22, 0x20, 0x1C, 0x22, 0x41, 0x02,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0xFE, 0x1C, 0x22, 0x21, 0x41, 0x02,
  0x1C, 0x02, 0x02, 0x82, 0x44, 0x78, 0x02, 0x06, 0x06, 0x0A, 0x12, 0x22,
  0x44, 0xFF, 0x04, 0x04, 0x04, 0x3F, 0x20, 0x20, 0x40, 0x78, 0x44, 0x02,
  0x02, 0x84, 0x84, 0x78, 0x0C, 0xC2, 0x10, 0xBB, 0x18, 0x61, 0x86, 0x17,
  0x80, 0xFE, 0x08, 0x10, 0x40, 0x82, 0x08, 0x10, 0x40, 0x82, 0x00, 0x1C,
  0x45, 0x0A, 0x14, 0x67, 0x11, 0x41, 0x83, 0x09, 0xE0, 0x18, 0x49, 0x0A,
  0x18, 0x28, 0xD2, 0x9A, 0x04, 0x11, 0xC0, 0x40, 0x08, 0x20, 0x00, 0x14,
  0x80, 0x02, 0x39, 0x86, 0x03, 0x01, 0x80, 0x7F, 0x00, 0x07, 0xE0, 0x40,
  0x60, 0x30, 0x73, 0x18, 0x00, 0x39, 0x18, 0x41, 0x08, 0x42, 0x08, 0x00,
  0x04, 0x00, 0x0E, 0x08, 0x89, 0x29, 0x55, 0x2C, 0xA6, 0x95, 0x4A, 0x9E,
  0x20, 0x0F, 0x00, 0x04, 0x08, 0x30, 0x61, 0x22, 0x48, 0x9F, 0x42, 0x86,
  0x08, 0x78, 0x8D, 0x0A, 0x14, 0x4F, 0x21, 0x41, 0x83, 0x0B, 0xE0, 0x1C,
  0x45, 0x0C, 0x18, 0x10, 0x20, 0x41, 0x85, 0x09, 0xE0, 0x3C, 0x22, 0x21,
  0x21, 0x21, 0x41, 0x41, 0x41, 0x42, 0x44, 0xF8, 0x7F, 0x40, 0x40, 0x40,
  0x40, 0x7C, 0x80, 0x80, 0x80, 0x80, 0xFC, 0x3F, 0x40, 0x40, 0x40, 0x40,
  0x7C, 0x80, 0x80, 0x80, 0x80, 0x80, 0x1C, 0x45, 0x0C, 0x08, 0x10, 0x27,
  0xC1, 0x83, 0x09, 0xE0, 0x20, 0x90, 0x48, 0x44, 0x24, 0x13, 0xF9, 0x04,
  0x82, 0x42, 0x21, 0x20, 0x80, 0x7E, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08,
  0x20, 0x43, 0xF0, 0x02, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x85, 0x13,
  0xC0, 0x41, 0x42, 0x44, 0x48, 0x50, 0x70, 0xD0, 0x88, 0x88, 0x84, 0x86,
  0x21, 0x04, 0x10, 0x41, 0x04, 0x20, 0x82, 0x0F, 0xC0, 0x20, 0x98, 0xCC,
  0xA6, 0x65, 0x52, 0xA9, 0x24, 0x92, 0x42, 0x21, 0x20, 0x80, 0x20, 0x90,
  0x4C, 0x46, 0x24, 0x92, 0x49, 0x24, 0x8A, 0x46, 0x23, 0x20, 0x80, 0x1C,
  0x45, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x85, 0x09, 0xE0, 0x3C, 0x42, 0x41,
  0x41, 0x42, 0x46, 0x78, 0x80, 0x80, 0x80, 0x80, 0x1C, 0x45, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x85, 0x09, 0xE0, 0x40, 0x40, 0x3C, 0x85, 0x0A, 0x14,
  0x28, 0xBE, 0x44, 0x89, 0x0A, 0x10, 0x1C, 0xC5, 0x0A, 0x04, 0x07, 0x01,
  0x01, 0x83, 0x09, 0xE0, 0xFE, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x81, 0x00, 0x41, 0x41, 0x42, 0x42, 0x82, 0x82, 0x82, 0x82, 0x84, 0x84,
  0x78, 0x83, 0x06, 0x14, 0x28, 0x91, 0x24, 0x28, 0x60, 0xC1, 0x00, 0x89,
  0x89, 0x99, 0x99, 0x9A, 0xAA, 0xAA, 0xAC, 0xCC, 0xCC, 0x88, 0x20, 0x90,
  0x84, 0x82, 0x40, 0xC0, 0x40, 0x50, 0x28, 0x24, 0x21, 0x20, 0xC0, 0x83,
  0x0A, 0x12, 0x45, 0x0A, 0x08, 0x10, 0x40, 0x81, 0x00, 0x3F, 0x01, 0x02,
  0x04, 0x04, 0x08, 0x10, 0x20, 0x20, 0x40, 0xFE, 0x39, 0x08, 0x42, 0x21,
  0x08, 0x42, 0x10, 0x88, 0x70, 0x92, 0x44, 0x92, 0x44, 0x90, 0x38, 0x44,
  0x21, 0x08, 0x42, 0x21, 0x08, 0x42, 0x70, 0x11, 0x8C, 0x94, 0xC4, 0xFE,
  0xD0, 0x3C, 0x88, 0x09, 0xEC, 0x50, 0xA3, 0x7A, 0x40, 0x81, 0x03, 0xE4,
  0x48, 0x60, 0xC1, 0x85, 0x0B, 0xE0, 0x3C, 0x86, 0x0C, 0x08, 0x10, 0x21,
  0x3C, 0x03, 0x02, 0x02, 0x3A, 0x46, 0x82, 0x84, 0x84, 0x84, 0x84, 0x7C,
  0x3C, 0x8A, 0x0F, 0xF8, 0x10, 0x21, 0x3C, 0x1E, 0x40, 0x87, 0xE2, 0x04,
  0x10, 0x20, 0x40, 0x81, 0x00, 0x1D, 0x23, 0x41, 0x42, 0x42, 0x42, 0x42,
  0x3E, 0x04, 0x84, 0x78, 0x40, 0x81, 0x03, 0xE4, 0x30, 0x60, 0xC2, 0x85,
  0x0A, 0x10, 0x08, 0x20, 0x1E, 0x08, 0x41, 0x04, 0x10, 0x4F, 0xC0, 0x02,
  0x04, 0x00, 0xE0, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x9E, 0x00,
  0x20, 0x81, 0x02, 0x34, 0x8A, 0x28, 0x68, 0x91, 0x12, 0x10, 0x38, 0x20,
  0x82, 0x08, 0x41, 0x04, 0x10, 0x4F, 0xC0, 0x7F, 0x49, 0x49, 0x49, 0x89,
  0x89, 0x91, 0x91, 0x7C, 0x86, 0x0C, 0x18, 0x50, 0xA1, 0x42, 0x3C, 0x8A,
  0x0C, 0x18, 0x30, 0xA1, 0x3C, 0x3E, 0x22, 0x21, 0x41, 0x42, 0x42, 0x42,
  0x7C, 0x80, 0x80, 0x80, 0x3A, 0x8E, 0x0C, 0x28, 0x50, 0xA1, 0x3E, 0x04,
  0x10, 0x20, 0x5D, 0x84, 0x10, 0x82, 0x08, 0x20, 0x3C, 0x85, 0x03, 0x80,
  0xC0, 0xA1, 0x3C, 0x20, 0x8F, 0xC8, 0x41, 0x04, 0x10, 0x41, 0xE0, 0x42,
  0x85, 0x0C, 0x28, 0x50, 0xA3, 0x3A, 0x83, 0x42, 0x44, 0x44, 0x48, 0x28,
  0x30, 0x20, 0x91, 0x91, 0x92, 0xAA, 0xAC, 0xCC, 0xCC, 0x88, 0x21, 0x22,
  0x14, 0x08, 0x18, 0x34, 0x24, 0xC2, 0x40, 0x90, 0x88, 0x84, 0x42, 0x40,
  0xA0, 0x60, 0x20, 0x10, 0x10, 0x30, 0x00, 0x3F, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0xFE, 0x04, 0x21, 0x04, 0x10, 0x42, 0x30, 0x20, 0x82, 0x08,
  0x20, 0x81, 0x00, 0x24, 0xA4, 0x92, 0x52, 0x48, 0x20, 0x40, 0x82, 0x08,
  0x20, 0x81, 0x08, 0x41, 0x04, 0x20, 0x8C, 0x00, 0x31, 0x49, 0x86,
};

const GFXglyph RobotoMono_LightItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 11, 9, 3, -11 },
  { 6, 4, 3, 9, 3, -11 },
  { 8, 9, 11, 9, 0, -11 },
  { 21, 7, 14, 9, 1, -12 },
  { 34, 7, 11, 9, 1, -11 },
  { 44, 7, 11, 9, 1, -11 },
  { 54, 2, 3, 9, 4, -11 },
  { 55, 4, 15, 9, 3, -12 },
  { 63, 5, 15, 9, 1, -12 },
  { 73, 6, 7, 9, 2, -11 },
  { 79, 7, 8, 9, 1, -9 },
  { 86, 2, 3, 9, 2, -1 },
  { 87, 5, 1, 9, 2, -5 },
  { 88, 2, 1, 9, 3, -1 },
  { 89, 7, 12, 9, 1, -11 },
  { 100, 7, 11, 9, 1, -11 },
  { 110, 4, 11, 9, 2, -11 },
  { 116, 8, 11, 9, 0, -11 },
  { 127, 8, 11, 9, 0, -11 },
  { 138, 8, 11, 9, 0, -11 },
  { 149, 8, 11, 9, 1, -11 },
  { 160, 6, 11, 9, 1, -11 },
  { 169, 7, 11, 9, 2, -11 },
  { 179, 7, 11, 9, 1, -11 },
  { 189, 7, 11, 9, 1, -11 },
  { 199, 2, 7, 9, 4, -7 },
  { 201, 3, 9, 9, 3, -7 },
  { 205, 7, 6, 9, 1, -8 },
  { 211, 7, 4, 9, 1, -7 },
  { 215, 7, 6, 9, 1, -8 },
  { 221, 6, 11, 9, 2, -11 },
  { 230, 9, 11, 9, 0, -11 },
  { 243, 7, 11, 9, 0, -11 },
  { 253, 7, 11, 9, 1, -11 },
  { 263, 7, 11, 9, 1, -11 },
  { 273, 8, 11, 9, 0, -11 },
  { 284, 8, 11, 9, 1, -11 },
  { 295, 8, 11, 9, 1, -11 },
  { 306, 7, 11, 9, 1, -11 },
  { 316, 9, 11, 9, 0, -11 },
  { 329, 7, 11, 9, 1, -11 },
  { 339, 7, 11, 9, 1, -11 },
  { 349, 8, 11, 9, 1, -11 },
  { 360, 6, 11, 9, 1, -11 },
  { 369, 9, 11, 9, 0, -11 },
  { 382, 9, 11, 9, 0, -11 },
  { 395, 7, 11, 9, 1, -11 },
  { 405, 8, 11, 9, 1, -11 },
  { 416, 7, 13, 9, 1, -11 },
  { 428, 7, 11, 9, 1, -11 },
  { 438, 7, 11, 9, 1, -11 },
  { 448, 7, 11, 9, 2, -11 },
  { 458, 8, 11, 9, 1, -11 },
  { 469, 7, 11, 9, 2, -11 },
  { 479, 8, 11, 9, 1, -11 },
  { 490, 9, 11, 9, 0, -11 },
  { 503, 7, 11, 9, 2, -11 },
  { 513, 8, 11, 9, 0, -11 },
  { 524, 5, 14, 9, 2, -12 },
  { 533, 3, 12, 9, 3, -11 },
  { 538, 5, 14, 9, 2, -12 },
  { 547, 5, 6, 9, 2, -11 },
  { 551, 7, 1, 9, 0, 0 },
  { 552, 2, 2, 9, 4, -11 },
  { 553, 7, 8, 9, 1, -8 },
  { 560, 7, 11, 9, 1, -11 },
  { 570, 7, 8, 9, 1, -8 },
  { 577, 8, 11, 9, 1, -11 },
  { 588, 7, 8, 9, 1, -8 },
  { 595, 7, 11, 9, 2, -11 },
  { 605, 8, 11, 9, 0, -8 },
  { 616, 7, 11, 9, 1, -11 },
  { 626, 6, 11, 9, 1, -11 },
  { 635, 7, 14, 9, 0, -11 },
  { 648, 7, 11, 9, 1, -11 },
  { 658, 6, 11, 9, 1, -11 },
  { 667, 8, 8, 9, 0, -8 },
  { 675, 7, 8, 9, 1, -8 },
  { 682, 7, 8, 9, 1, -8 },
  { 689, 8, 11, 9, 0, -8 },
  { 700, 7, 11, 9, 1, -8 },
  { 710, 6, 8, 9, 2, -8 },
  { 716, 7, 8, 9, 1, -8 },
  { 723, 6, 10, 9, 2, -10 },
  { 731, 7, 8, 9, 1, -8 },
  { 738, 8, 8, 9, 1, -8 },
  { 746, 8, 8, 9, 1, -8 },
  { 754, 8, 8, 9, 0, -8 },
  { 762, 9, 11, 9, 0, -8 },
  { 775, 8, 8, 9, 0, -8 },
  { 783, 6, 15, 9, 2, -12 },
  { 795, 3, 13, 9, 3, -11 },
  { 800, 6, 15, 9, 1, -12 },
  { 812, 8, 3, 9, 0, -6 },
};

const GFXfont RobotoMono_LightItalic15pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic15pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _ROBOTOMONO_LIGHTITALIC15PT7B_H_
