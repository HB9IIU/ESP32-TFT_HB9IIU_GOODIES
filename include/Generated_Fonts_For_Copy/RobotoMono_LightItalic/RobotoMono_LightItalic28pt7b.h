#ifndef _ROBOTOMONO_LIGHTITALIC28PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0x84, 0x23, 0x18, 0xC4, 0x23, 0x18, 0xC6, 0x20, 0x00, 0x00,
  0x31, 0x80, 0x66, 0xCD, 0x12, 0x24, 0x59, 0x80, 0x00, 0x43, 0x00, 0x61,
  0x00, 0x21, 0x80, 0x10, 0x80, 0x18, 0x40, 0x08, 0x60, 0x7F, 0xFE, 0x06,
  0x10, 0x02, 0x18, 0x03, 0x08, 0x01, 0x04, 0x00, 0x86, 0x00, 0xC2, 0x07,
  0xFF, 0xE0, 0x21, 0x80, 0x30, 0x80, 0x10, 0xC0, 0x08, 0x40, 0x0C, 0x20,
  0x04, 0x30, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x0F, 0xC0, 0xE7, 0x0C,
  0x0C, 0xC0, 0x66, 0x03, 0x30, 0x09, 0x80, 0x0C, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0x80, 0x04, 0x00, 0x36, 0x01, 0xB0, 0x0D, 0x80, 0x6C,
  0x06, 0x38, 0xE0, 0xFE, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x3C, 0x02,
  0x20, 0x31, 0x85, 0x0C, 0x68, 0x62, 0x42, 0x22, 0x13, 0x1B, 0x10, 0x71,
  0x00, 0x18, 0x01, 0x80, 0x08, 0xC0, 0x8F, 0x8C, 0x84, 0x4C, 0x24, 0x61,
  0x62, 0x0A, 0x18, 0xC0, 0xC4, 0x03, 0xC0, 0x03, 0xE0, 0x19, 0x80, 0xC3,
  0x02, 0x0C, 0x08, 0x30, 0x21, 0x80, 0x8C, 0x03, 0x60, 0x07, 0x00, 0x38,
  0x01, 0xB0, 0x0C, 0xC1, 0x61, 0x8D, 0x82, 0x3C, 0x0D, 0xB0, 0x1E, 0xC0,
  0x71, 0x01, 0xC7, 0x1D, 0x8F, 0xC6, 0x5F, 0xA0, 0x01, 0x03, 0x06, 0x0C,
  0x18, 0x10, 0x30, 0x20, 0x60, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xC0, 0x40, 0x40, 0x60, 0x20, 0x10,
  0x04, 0x03, 0x00, 0x80, 0x20, 0x10, 0x0C, 0x06, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x20,
  0x30, 0x10, 0x18, 0x18, 0x18, 0x18, 0x18, 0x00, 0x01, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x06, 0x23, 0x7D, 0xFC, 0x3E, 0x00, 0xE0, 0x09, 0x00, 0xCC,
  0x0C, 0x30, 0xC1, 0x80, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x03, 0xFF, 0xE0, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x06, 0x00, 0x33, 0x32, 0x64, 0xC0, 0xFF, 0xFF, 0xF0, 0x5F, 0x00,
  0x00, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00,
  0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x20,
  0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x00,
  0x07, 0xE0, 0x63, 0x86, 0x04, 0x60, 0x32, 0x01, 0xB0, 0x0D, 0x80, 0xE8,
  0x0F, 0x40, 0xDE, 0x18, 0xF1, 0x87, 0x98, 0x2D, 0x81, 0x70, 0x1B, 0x00,
  0xD8, 0x04, 0xC0, 0x62, 0x06, 0x18, 0x60, 0x7E, 0x00, 0x01, 0x0F, 0x3A,
  0xE2, 0x82, 0x06, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x0C, 0x0C, 0x0C, 0x08,
  0x08, 0x18, 0x18, 0x18, 0x18, 0x03, 0xF0, 0x18, 0xE0, 0xC0, 0xC6, 0x03,
  0x10, 0x0C, 0xC0, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x3F, 0xFE, 0x07, 0xE0, 0x71, 0x86, 0x06, 0x60, 0x33, 0x00,
  0x80, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x3E, 0x01, 0xF0, 0x00, 0xC0,
  0x03, 0x00, 0x18, 0x00, 0xD0, 0x06, 0xC0, 0x26, 0x03, 0x18, 0x70, 0x7F,
  0x00, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x34, 0x01, 0xB0, 0x04, 0xC0,
  0x33, 0x01, 0x8C, 0x0C, 0x20, 0x60, 0x81, 0x06, 0x0C, 0x18, 0x60, 0x63,
  0x01, 0x9F, 0xFF, 0x80, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20,
  0x0F, 0xFC, 0x3F, 0xF0, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00,
  0x0D, 0xE0, 0x3F, 0xE0, 0xC1, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x40, 0x03, 0x30, 0x0C, 0xC0, 0x61, 0x81, 0x87, 0x1C, 0x07, 0xE0, 0x00,
  0xE0, 0x3E, 0x0E, 0x01, 0x80, 0x10, 0x03, 0x00, 0x60, 0x06, 0xF8, 0x5D,
  0xCE, 0x06, 0xC0, 0x2C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x2C, 0x02, 0xC0,
  0x64, 0x0C, 0x71, 0x83, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0x04, 0x00, 0x60,
  0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C,
  0x00, 0x40, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x07, 0xE0, 0x71, 0x86, 0x06, 0x60, 0x13, 0x00, 0x98, 0x04,
  0xC0, 0x66, 0x02, 0x18, 0x60, 0x7E, 0x07, 0xF0, 0xE0, 0xC4, 0x03, 0x60,
  0x0B, 0x00, 0x50, 0x06, 0xC0, 0x36, 0x03, 0x18, 0x70, 0x7F, 0x00, 0x0F,
  0x83, 0x8C, 0x30, 0x66, 0x02, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x3C, 0x06, 0xC0, 0x66, 0x1E, 0x3F, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01,
  0x80, 0x70, 0x3C, 0x0F, 0x80, 0x11, 0xCC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x63, 0x00, 0x04, 0x30, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x30, 0xC3, 0x08, 0x61, 0x0C, 0x00, 0x00, 0x08, 0x03, 0xC0, 0x78, 0x0F,
  0x03, 0xC0, 0x78, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x40, 0x7F, 0xFB, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xDF, 0xFE, 0x40, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x07,
  0x00, 0x70, 0x3C, 0x0F, 0x07, 0x80, 0xE0, 0x08, 0x00, 0x1F, 0x87, 0x39,
  0x81, 0xA0, 0x3C, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x01, 0xF0, 0x0E, 0x38, 0x30, 0x10, 0xC0, 0x33, 0x1E, 0x24, 0x66,
  0x59, 0x88, 0xA2, 0x11, 0x4C, 0x23, 0x90, 0xC6, 0x21, 0x0C, 0x42, 0x28,
  0x8C, 0x51, 0x19, 0xA2, 0xD2, 0x47, 0x38, 0xC0, 0x00, 0x80, 0x01, 0xC3,
  0x00, 0xFC, 0x00, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x3C, 0x01, 0xB0,
  0x06, 0xC0, 0x31, 0x00, 0xC4, 0x06, 0x10, 0x18, 0x40, 0x41, 0x83, 0x06,
  0x08, 0x18, 0x7F, 0xE1, 0x00, 0x8C, 0x02, 0x20, 0x09, 0x80, 0x34, 0x00,
  0xF0, 0x03, 0x0F, 0xE0, 0x7F, 0xE1, 0x80, 0xC6, 0x03, 0x10, 0x04, 0x40,
  0x33, 0x00, 0xCC, 0x06, 0x30, 0x30, 0xFF, 0x02, 0x07, 0x08, 0x06, 0x60,
  0x19, 0x80, 0x26, 0x00, 0x98, 0x06, 0x40, 0x19, 0x00, 0xCC, 0x1E, 0x3F,
  0xE0, 0x07, 0xE0, 0x31, 0xC1, 0x81, 0x8C, 0x06, 0x20, 0x09, 0x80, 0x34,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x03, 0x20, 0x0C, 0xC0, 0x63, 0x03, 0x06, 0x1C, 0x0F, 0xC0,
  0x1F, 0xC0, 0x3F, 0xE0, 0x60, 0x60, 0x80, 0x61, 0x00, 0xC6, 0x00, 0x8C,
  0x01, 0x18, 0x02, 0x30, 0x04, 0x40, 0x08, 0x80, 0x13, 0x00, 0x66, 0x00,
  0xCC, 0x01, 0x18, 0x06, 0x20, 0x08, 0x40, 0x31, 0x81, 0xC3, 0x1F, 0x07,
  0xF0, 0x00, 0x0F, 0xFE, 0x3F, 0xFC, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x7F, 0xE0, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x1F, 0xFC, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x7F, 0xE0, 0xFF,
  0xC1, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x80, 0x01, 0x00, 0x06, 0x00, 0x00, 0x03, 0xF0, 0x0E, 0x70, 0x30, 0x30,
  0xC0, 0x23, 0x00, 0x66, 0x00, 0xC8, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x00, 0x02, 0x0F, 0xE4, 0x00, 0x88, 0x01, 0x10, 0x02, 0x20, 0x0C,
  0x60, 0x18, 0x40, 0x30, 0xE1, 0xC0, 0xFE, 0x00, 0x18, 0x02, 0x20, 0x0C,
  0x40, 0x18, 0x80, 0x33, 0x00, 0x46, 0x00, 0x8C, 0x01, 0x10, 0x06, 0x20,
  0x0C, 0x7F, 0xF9, 0x80, 0x23, 0x00, 0x46, 0x00, 0x88, 0x03, 0x10, 0x06,
  0x60, 0x0C, 0xC0, 0x11, 0x80, 0x22, 0x00, 0x44, 0x01, 0x80, 0x0F, 0xFE,
  0x3F, 0xFC, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x47, 0xFF, 0x00,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x00, 0x02, 0x30, 0x0C, 0x60, 0x18, 0xC0, 0x20, 0x80, 0xC1, 0xC7, 0x01,
  0xF8, 0x00, 0x08, 0x03, 0x18, 0x06, 0x18, 0x0C, 0x18, 0x18, 0x18, 0x30,
  0x10, 0x60, 0x10, 0xC0, 0x31, 0x80, 0x33, 0x00, 0x37, 0x00, 0x2F, 0x00,
  0x39, 0x80, 0x31, 0x80, 0x60, 0xC0, 0x60, 0xC0, 0x60, 0x60, 0x40, 0x60,
  0x40, 0x30, 0x40, 0x10, 0xC0, 0x18, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0F, 0xFF,
  0x18, 0x06, 0x38, 0x0C, 0x70, 0x38, 0xE0, 0xF3, 0x41, 0xE6, 0x86, 0x8D,
  0x09, 0x13, 0x32, 0x26, 0x4C, 0x4D, 0x99, 0x8A, 0x33, 0x1C, 0x46, 0x30,
  0x88, 0x61, 0x10, 0x06, 0x20, 0x0C, 0xC0, 0x19, 0x80, 0x23, 0x00, 0x44,
  0x01, 0x80, 0x18, 0x02, 0x30, 0x0C, 0x70, 0x18, 0xE0, 0x33, 0x40, 0x46,
  0xC0, 0x8D, 0x83, 0x11, 0x06, 0x23, 0x0C, 0x46, 0x19, 0x84, 0x23, 0x0C,
  0x46, 0x09, 0x88, 0x13, 0x10, 0x36, 0x20, 0x2C, 0xC0, 0x71, 0x80, 0xE3,
  0x00, 0xC4, 0x01, 0x80, 0x07, 0xE0, 0x73, 0x86, 0x04, 0x60, 0x32, 0x01,
  0xB0, 0x05, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0x40, 0x0A, 0x00, 0xD0, 0x04, 0xC0, 0x66, 0x06, 0x1C, 0x60, 0x7E,
  0x00, 0x0F, 0xF0, 0x1F, 0xF8, 0x60, 0x30, 0xC0, 0x31, 0x80, 0x63, 0x00,
  0xC4, 0x01, 0x88, 0x03, 0x30, 0x0C, 0x60, 0x30, 0xFF, 0xC1, 0xFE, 0x02,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00,
  0x06, 0x00, 0x00, 0x03, 0xF0, 0x0E, 0x70, 0x30, 0x30, 0xC0, 0x63, 0x00,
  0x46, 0x00, 0xC8, 0x01, 0xB0, 0x03, 0x60, 0x06, 0x80, 0x09, 0x00, 0x16,
  0x00, 0x6C, 0x00, 0xD8, 0x01, 0xB0, 0x06, 0x20, 0x0C, 0x60, 0x30, 0xC0,
  0xC0, 0xE3, 0x00, 0xFE, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0F,
  0xE0, 0x3F, 0xF0, 0x60, 0x30, 0xC0, 0x61, 0x80, 0x42, 0x00, 0x84, 0x01,
  0x18, 0x06, 0x30, 0x18, 0x60, 0x70, 0xFF, 0x81, 0xFE, 0x02, 0x0C, 0x0C,
  0x08, 0x18, 0x18, 0x30, 0x30, 0x40, 0x20, 0x80, 0x61, 0x00, 0xC6, 0x00,
  0xC0, 0x03, 0xF0, 0x1E, 0x70, 0x70, 0x30, 0xC0, 0x21, 0x00, 0x66, 0x00,
  0xC4, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x01, 0x80, 0x03, 0x30, 0x02, 0x60, 0x0C, 0x40, 0x18, 0xC0, 0x60, 0xE3,
  0x80, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0x80, 0x02, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x30, 0x04, 0x80, 0x32, 0x00, 0xC8, 0x03, 0x60, 0x0D, 0x80,
  0x26, 0x00, 0x90, 0x06, 0x40, 0x19, 0x00, 0x6C, 0x01, 0x30, 0x04, 0xC0,
  0x12, 0x00, 0xC8, 0x03, 0x20, 0x08, 0xC0, 0x63, 0x03, 0x07, 0x18, 0x0F,
  0xC0, 0xC0, 0x0F, 0x00, 0x6C, 0x01, 0x90, 0x04, 0x40, 0x31, 0x00, 0x86,
  0x06, 0x18, 0x10, 0x60, 0xC1, 0x83, 0x02, 0x18, 0x08, 0x60, 0x23, 0x00,
  0xCC, 0x03, 0x20, 0x0D, 0x80, 0x14, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0xE1, 0xC2, 0x85, 0x0A, 0x14, 0x68, 0xD1,
  0xA2, 0x44, 0x89, 0x12, 0x64, 0xC9, 0x12, 0x24, 0x48, 0xB1, 0x62, 0x85,
  0x8A, 0x14, 0x38, 0x50, 0xC1, 0xC3, 0x06, 0x0C, 0x18, 0x20, 0x60, 0x18,
  0x01, 0x86, 0x01, 0x81, 0x01, 0x80, 0xC0, 0x80, 0x60, 0xC0, 0x18, 0xC0,
  0x0C, 0xC0, 0x02, 0x40, 0x01, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x68,
  0x00, 0x36, 0x00, 0x33, 0x00, 0x30, 0xC0, 0x30, 0x60, 0x18, 0x10, 0x18,
  0x0C, 0x18, 0x02, 0x18, 0x01, 0x80, 0xC0, 0x0D, 0x00, 0x66, 0x01, 0x18,
  0x0C, 0x60, 0x60, 0x81, 0x03, 0x0C, 0x0C, 0x60, 0x11, 0x00, 0x6C, 0x01,
  0xE0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x04, 0x00, 0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xFF, 0xF8, 0x0F, 0x87, 0xC2,
  0x01, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x04, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x80,
  0xC0, 0x60, 0x3E, 0x00, 0xC1, 0x04, 0x18, 0x60, 0x82, 0x08, 0x30, 0xC1,
  0x04, 0x10, 0x61, 0x82, 0x08, 0x20, 0xC3, 0x04, 0x10, 0x0F, 0x87, 0x80,
  0x40, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x10, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30,
  0x18, 0x0C, 0x3C, 0x00, 0x03, 0x00, 0xC0, 0x70, 0x16, 0x0D, 0x86, 0x21,
  0x08, 0xC2, 0x20, 0xD8, 0x3C, 0x04, 0xFF, 0xF0, 0xC4, 0x63, 0x07, 0xE0,
  0x73, 0x86, 0x06, 0x60, 0x30, 0x01, 0x80, 0x0C, 0x0F, 0xE3, 0xFF, 0x30,
  0x13, 0x00, 0x90, 0x0D, 0x80, 0x64, 0x07, 0x38, 0xD8, 0xFC, 0xC0, 0x08,
  0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x4F, 0x82, 0xCE,
  0x38, 0x19, 0x80, 0xCC, 0x06, 0x40, 0x12, 0x00, 0x90, 0x0D, 0x80, 0x6C,
  0x03, 0x60, 0x13, 0x01, 0x98, 0x19, 0xE1, 0x8C, 0xF8, 0x00, 0x07, 0xC1,
  0xCE, 0x30, 0x36, 0x01, 0x60, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08,
  0x00, 0xC0, 0x2C, 0x06, 0x40, 0x67, 0x1C, 0x3F, 0x00, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0xF9, 0x87, 0x36, 0x30,
  0x31, 0x80, 0xC6, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0xC8, 0x02, 0x20,
  0x08, 0xC0, 0x63, 0x01, 0x8C, 0x0E, 0x18, 0x78, 0x3E, 0x40, 0x07, 0xC0,
  0xE7, 0x0C, 0x0C, 0xC0, 0x26, 0x01, 0x60, 0x0B, 0xFF, 0xDF, 0xFE, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x80, 0x04, 0x06, 0x38, 0xE0, 0xFE, 0x00, 0x01,
  0xFC, 0x0E, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x0F, 0xFF, 0x3F,
  0xFC, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x07, 0xCC, 0x39, 0xB1, 0x81, 0x8C, 0x06, 0x30, 0x19, 0x80, 0x66, 0x01,
  0x98, 0x06, 0x40, 0x11, 0x00, 0x46, 0x03, 0x18, 0x0C, 0x60, 0x70, 0xC3,
  0xC1, 0xF2, 0x00, 0x08, 0x00, 0x62, 0x01, 0x0C, 0x0C, 0x1F, 0xE0, 0x1E,
  0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x47,
  0x86, 0xEE, 0x3C, 0x19, 0x80, 0xCC, 0x02, 0x40, 0x12, 0x01, 0xB0, 0x0D,
  0x80, 0x6C, 0x02, 0x60, 0x12, 0x00, 0x90, 0x0D, 0x80, 0x6C, 0x03, 0x00,
  0x00, 0x60, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x08,
  0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x02, 0x0F, 0xFF, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x60, 0xDE, 0x07, 0xE0,
  0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0xC4, 0x0E, 0x10, 0x70, 0xC3, 0x03, 0x18, 0x0C, 0xC0, 0x3E, 0x00,
  0xF8, 0x03, 0x30, 0x18, 0x60, 0x61, 0x81, 0x83, 0x06, 0x06, 0x10, 0x18,
  0xC0, 0x30, 0x0F, 0xE0, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0xFF, 0xF0, 0x37, 0x9E,
  0x3D, 0xB6, 0x30, 0xC3, 0x20, 0xC3, 0x20, 0x83, 0x60, 0x82, 0x61, 0x82,
  0x61, 0x86, 0x41, 0x86, 0x41, 0x06, 0x41, 0x04, 0xC1, 0x04, 0xC3, 0x04,
  0xC3, 0x0C, 0x83, 0x0C, 0x11, 0xE1, 0xBB, 0x8E, 0x06, 0x60, 0x33, 0x00,
  0x90, 0x04, 0x80, 0x6C, 0x03, 0x60, 0x1B, 0x00, 0x98, 0x04, 0x80, 0x64,
  0x03, 0x60, 0x1B, 0x00, 0xC0, 0x07, 0xE0, 0x39, 0xC1, 0x81, 0x8C, 0x06,
  0x20, 0x09, 0x80, 0x34, 0x00, 0xD0, 0x02, 0x40, 0x0B, 0x00, 0x64, 0x01,
  0x98, 0x0C, 0x60, 0x60, 0xC3, 0x01, 0xF8, 0x00, 0x09, 0xF0, 0x2C, 0xE1,
  0xC0, 0xC6, 0x03, 0x18, 0x0C, 0x40, 0x31, 0x00, 0x4C, 0x03, 0x30, 0x0C,
  0xC0, 0x33, 0x00, 0x88, 0x06, 0x30, 0x31, 0xE1, 0x86, 0xFC, 0x18, 0x00,
  0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x0F, 0x98, 0xE6,
  0xCC, 0x0C, 0xC0, 0x66, 0x03, 0x60, 0x1B, 0x00, 0xD8, 0x06, 0x80, 0x24,
  0x01, 0x30, 0x19, 0x80, 0xCC, 0x0E, 0x30, 0xF0, 0xF9, 0x00, 0x08, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x11, 0xF1, 0x7F, 0x1C,
  0x03, 0x80, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x00, 0x0F, 0xC0, 0xE7, 0x0C, 0x0C,
  0x40, 0x26, 0x00, 0x98, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xC0, 0x03, 0x00,
  0x0D, 0x80, 0x4C, 0x06, 0x30, 0xE0, 0xFE, 0x00, 0x06, 0x00, 0x80, 0x10,
  0x06, 0x0F, 0xFF, 0xFF, 0xC3, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x03, 0x00, 0x3E, 0x00, 0x20,
  0x19, 0x00, 0xD8, 0x06, 0xC0, 0x26, 0x01, 0x20, 0x19, 0x00, 0xC8, 0x06,
  0xC0, 0x26, 0x01, 0x30, 0x09, 0x80, 0xCC, 0x0E, 0x31, 0xF0, 0xF9, 0x00,
  0xC0, 0x0D, 0x00, 0x66, 0x01, 0x98, 0x0C, 0x20, 0x20, 0x81, 0x83, 0x04,
  0x0C, 0x30, 0x10, 0x80, 0x46, 0x01, 0xB0, 0x06, 0xC0, 0x0E, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x81, 0x07, 0x06, 0x0B, 0x0C, 0x36, 0x38, 0x6C, 0x50,
  0x98, 0xA3, 0x33, 0x44, 0x64, 0x88, 0xD9, 0xB1, 0xA3, 0x43, 0x47, 0x87,
  0x06, 0x0E, 0x0C, 0x0C, 0x18, 0x10, 0x20, 0x00, 0x18, 0x07, 0x0C, 0x06,
  0x0C, 0x0C, 0x06, 0x18, 0x02, 0x30, 0x03, 0x60, 0x01, 0xC0, 0x01, 0x80,
  0x03, 0xC0, 0x06, 0x40, 0x0C, 0x60, 0x0C, 0x20, 0x18, 0x30, 0x30, 0x18,
  0xE0, 0x1C, 0x30, 0x03, 0x10, 0x03, 0x18, 0x06, 0x18, 0x04, 0x18, 0x0C,
  0x08, 0x18, 0x0C, 0x18, 0x0C, 0x30, 0x0C, 0x20, 0x04, 0x60, 0x06, 0xC0,
  0x06, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x3F, 0xFC, 0xFF, 0xF0,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x2F, 0xFF, 0x00, 0x00,
  0x20, 0x18, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x80, 0x30, 0x06, 0x01, 0x81, 0xC0, 0x3C, 0x00, 0x80, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x00, 0x0C, 0x20, 0x82, 0x08, 0x61, 0x86, 0x10, 0x41, 0x04, 0x30,
  0xC2, 0x08, 0x20, 0x86, 0x18, 0x41, 0x04, 0x10, 0xC0, 0x04, 0x01, 0xC0,
  0x0C, 0x00, 0x80, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x18, 0x01, 0xC0, 0x38, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x18, 0x06, 0x03, 0x80, 0x40, 0x00,
  0x18, 0x00, 0xFC, 0x0F, 0x0C, 0x14, 0x0C, 0x68, 0x0F, 0x80,
};

const GFXglyph RobotoMono_LightItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 5, 20, 16, 6, -20 },
  { 14, 7, 6, 16, 6, -21 },
  { 20, 17, 20, 16, 0, -20 },
  { 63, 13, 26, 16, 2, -23 },
  { 106, 13, 20, 16, 2, -20 },
  { 139, 14, 20, 16, 1, -20 },
  { 174, 2, 6, 16, 8, -21 },
  { 176, 8, 28, 16, 5, -22 },
  { 204, 9, 28, 16, 2, -22 },
  { 236, 13, 12, 16, 3, -20 },
  { 256, 13, 14, 16, 2, -16 },
  { 279, 4, 7, 16, 3, -3 },
  { 283, 10, 2, 16, 3, -10 },
  { 286, 3, 3, 16, 6, -3 },
  { 288, 13, 22, 16, 2, -20 },
  { 324, 13, 20, 16, 2, -20 },
  { 357, 8, 20, 16, 4, -20 },
  { 377, 14, 20, 16, 0, -20 },
  { 412, 13, 20, 16, 1, -20 },
  { 445, 14, 20, 16, 1, -20 },
  { 480, 14, 20, 16, 2, -20 },
  { 515, 12, 20, 16, 2, -20 },
  { 545, 13, 20, 16, 3, -20 },
  { 578, 13, 20, 16, 2, -20 },
  { 611, 12, 20, 16, 3, -20 },
  { 641, 5, 15, 16, 7, -15 },
  { 651, 6, 19, 16, 5, -15 },
  { 666, 13, 12, 16, 2, -15 },
  { 686, 13, 8, 16, 2, -13 },
  { 699, 12, 12, 16, 2, -15 },
  { 717, 11, 20, 16, 4, -20 },
  { 745, 15, 20, 16, 1, -20 },
  { 783, 14, 20, 16, 0, -20 },
  { 818, 14, 20, 16, 1, -20 },
  { 853, 14, 20, 16, 2, -20 },
  { 888, 15, 20, 16, 1, -20 },
  { 926, 15, 20, 16, 1, -20 },
  { 964, 15, 20, 16, 1, -20 },
  { 1002, 15, 20, 16, 1, -20 },
  { 1040, 15, 20, 16, 1, -20 },
  { 1078, 15, 20, 16, 1, -20 },
  { 1116, 15, 20, 16, 1, -20 },
  { 1154, 16, 20, 16, 1, -20 },
  { 1194, 12, 20, 16, 1, -20 },
  { 1224, 15, 20, 16, 1, -20 },
  { 1262, 15, 20, 16, 1, -20 },
  { 1300, 13, 20, 16, 2, -20 },
  { 1333, 15, 20, 16, 1, -20 },
  { 1371, 15, 23, 16, 1, -20 },
  { 1415, 15, 20, 16, 1, -20 },
  { 1453, 15, 20, 16, 1, -20 },
  { 1491, 14, 20, 16, 3, -20 },
  { 1526, 14, 20, 16, 2, -20 },
  { 1561, 14, 20, 16, 3, -20 },
  { 1596, 14, 20, 16, 3, -20 },
  { 1631, 17, 20, 16, 0, -20 },
  { 1674, 14, 20, 16, 3, -20 },
  { 1709, 16, 20, 16, 0, -20 },
  { 1749, 9, 27, 16, 4, -23 },
  { 1780, 6, 22, 16, 5, -20 },
  { 1797, 9, 27, 16, 4, -23 },
  { 1828, 10, 11, 16, 3, -20 },
  { 1842, 12, 1, 16, 1, 0 },
  { 1844, 4, 4, 16, 8, -21 },
  { 1846, 13, 15, 16, 1, -15 },
  { 1871, 13, 21, 16, 1, -21 },
  { 1906, 12, 15, 16, 2, -15 },
  { 1929, 14, 21, 16, 2, -21 },
  { 1966, 13, 15, 16, 2, -15 },
  { 1991, 14, 21, 16, 3, -21 },
  { 2028, 14, 21, 16, 1, -15 },
  { 2065, 13, 21, 16, 1, -21 },
  { 2100, 12, 20, 16, 1, -20 },
  { 2130, 13, 26, 16, 0, -20 },
  { 2173, 14, 21, 16, 1, -21 },
  { 2210, 12, 21, 16, 1, -21 },
  { 2242, 16, 15, 16, 0, -15 },
  { 2272, 13, 15, 16, 1, -15 },
  { 2297, 14, 15, 16, 1, -15 },
  { 2324, 14, 21, 16, 0, -15 },
  { 2361, 13, 21, 16, 2, -15 },
  { 2396, 12, 15, 16, 3, -15 },
  { 2419, 13, 15, 16, 2, -15 },
  { 2444, 11, 19, 16, 3, -19 },
  { 2471, 13, 15, 16, 2, -15 },
  { 2496, 14, 15, 16, 2, -15 },
  { 2523, 15, 15, 16, 2, -15 },
  { 2552, 16, 15, 16, 0, -15 },
  { 2582, 16, 21, 16, 0, -15 },
  { 2624, 14, 15, 16, 1, -15 },
  { 2651, 11, 28, 16, 4, -22 },
  { 2690, 6, 25, 16, 5, -20 },
  { 2709, 11, 28, 16, 2, -22 },
  { 2748, 15, 5, 16, 1, -11 },
};

const GFXfont RobotoMono_LightItalic28pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic28pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic28pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _ROBOTOMONO_LIGHTITALIC28PT7B_H_
