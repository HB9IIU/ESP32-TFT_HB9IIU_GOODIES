#ifndef _ROBOTOMONO_LIGHTITALIC18PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0x24, 0x92, 0x80, 0x08, 0x55, 0x99, 0x06, 0x40, 0x88, 0x12,
  0x04, 0x43, 0xFE, 0x12, 0x04, 0x40, 0x88, 0xDF, 0x84, 0x40, 0x90, 0x12,
  0x04, 0x40, 0x04, 0x02, 0x03, 0x86, 0x22, 0x09, 0x04, 0x80, 0x60, 0x1C,
  0x03, 0x00, 0x50, 0x28, 0x12, 0x11, 0xF0, 0x20, 0x10, 0x00, 0x70, 0x24,
  0x22, 0x51, 0x49, 0x43, 0x20, 0x20, 0x26, 0x14, 0x94, 0x52, 0x29, 0x20,
  0x70, 0x1E, 0x19, 0x08, 0x84, 0x42, 0x40, 0xC0, 0xC0, 0x91, 0x89, 0x42,
  0xA0, 0x90, 0xC7, 0x90, 0x5A, 0x0C, 0x41, 0x08, 0x41, 0x04, 0x30, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x10, 0x40, 0x80, 0x20, 0x82, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x21, 0x08, 0x8C, 0x44, 0x00, 0x08, 0x08, 0x08, 0xEF, 0x18,
  0x38, 0x64, 0x44, 0x04, 0x04, 0x02, 0x01, 0x0F, 0xFF, 0xFC, 0x20, 0x20,
  0x10, 0x08, 0x00, 0x69, 0x68, 0xFC, 0xB0, 0x00, 0x80, 0x80, 0x40, 0x40,
  0x60, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x06, 0x00, 0x0E,
  0x18, 0x88, 0x28, 0x14, 0x3A, 0x35, 0x25, 0x22, 0xA1, 0x60, 0xA0, 0x88,
  0x47, 0xC0, 0x0B, 0xA4, 0x21, 0x08, 0x44, 0x21, 0x08, 0x46, 0x00, 0x0F,
  0x08, 0xC8, 0x2C, 0x10, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x0F, 0xF0, 0x0F, 0x08, 0x48, 0x24, 0x10, 0x08, 0x08, 0x38, 0x02, 0x01,
  0x40, 0x90, 0x48, 0x43, 0xC0, 0x01, 0x80, 0xC0, 0xC0, 0xA0, 0x90, 0xC8,
  0x44, 0x42, 0x42, 0x7F, 0xC0, 0x80, 0x40, 0x20, 0x1F, 0x88, 0x08, 0x04,
  0x02, 0x01, 0xF1, 0x8C, 0x02, 0x01, 0x40, 0x90, 0x48, 0x43, 0xC0, 0x07,
  0x18, 0x30, 0x20, 0x40, 0x7E, 0xC3, 0x81, 0x81, 0x81, 0x82, 0x46, 0x3C,
  0xFF, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40,
  0x80, 0x0E, 0x18, 0x88, 0x24, 0x12, 0x19, 0x18, 0x70, 0xC6, 0x41, 0x40,
  0xA0, 0x58, 0x47, 0xC0, 0x3C, 0x62, 0xC2, 0x82, 0x83, 0x82, 0x82, 0xCE,
  0x72, 0x04, 0x0C, 0x18, 0xE0, 0x24, 0x00, 0x00, 0x58, 0x11, 0x00, 0x00,
  0x00, 0x26, 0x44, 0x80, 0x01, 0x03, 0x0C, 0x70, 0xC0, 0x30, 0x0E, 0x02,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x40, 0x60, 0x18, 0x07, 0x03, 0x0C, 0x70,
  0x80, 0x39, 0x8A, 0x18, 0x20, 0x41, 0x04, 0x10, 0x20, 0x80, 0x00, 0x04,
  0x00, 0x07, 0x82, 0x11, 0x04, 0x9D, 0x49, 0x54, 0x55, 0x26, 0x49, 0x92,
  0x67, 0xA4, 0x11, 0x00, 0x3E, 0x00, 0x02, 0x01, 0x01, 0x80, 0xA0, 0x90,
  0x48, 0x44, 0x22, 0x3F, 0x10, 0x90, 0x28, 0x18, 0x08, 0x3E, 0x10, 0x88,
  0x28, 0x14, 0x12, 0x19, 0xF8, 0x82, 0x41, 0x40, 0xA0, 0x50, 0x4F, 0xC0,
  0x0E, 0x18, 0x88, 0x28, 0x14, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0xA0,
  0xC8, 0x47, 0xC0, 0x3C, 0x11, 0x90, 0x48, 0x14, 0x0A, 0x05, 0x02, 0x81,
  0x81, 0x40, 0xA0, 0x90, 0x8F, 0x80, 0x3F, 0x90, 0x08, 0x08, 0x04, 0x02,
  0x01, 0xFC, 0x80, 0x40, 0x40, 0x20, 0x10, 0x0F, 0xE0, 0x3F, 0x90, 0x08,
  0x04, 0x04, 0x02, 0x01, 0xFC, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x00,
  0x0E, 0x18, 0x88, 0x28, 0x14, 0x04, 0x02, 0x03, 0x1E, 0x81, 0x40, 0xA0,
  0x48, 0x63, 0xC0, 0x10, 0x48, 0x12, 0x04, 0x81, 0x20, 0x48, 0x13, 0xF9,
  0x02, 0x40, 0x90, 0x24, 0x09, 0x04, 0xC1, 0x00, 0x3F, 0x82, 0x01, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x0F, 0xE0, 0x00,
  0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x41, 0x20, 0x90,
  0x87, 0x80, 0x20, 0xC8, 0x62, 0x31, 0x18, 0x4C, 0x16, 0x07, 0x81, 0xA0,
  0x44, 0x21, 0x08, 0x22, 0x08, 0x81, 0x00, 0x20, 0x40, 0x81, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x82, 0x04, 0x0F, 0xE0, 0x20, 0xD8, 0x66, 0x19, 0x4A,
  0x52, 0x95, 0x25, 0x52, 0x64, 0x89, 0x20, 0x48, 0x12, 0x04, 0x82, 0x00,
  0x10, 0x4C, 0x13, 0x04, 0xA1, 0x28, 0x49, 0x32, 0x49, 0x12, 0x42, 0x90,
  0xA4, 0x29, 0x04, 0xC1, 0x00, 0x0E, 0x18, 0x88, 0x28, 0x14, 0x0C, 0x06,
  0x03, 0x02, 0x81, 0x40, 0xA0, 0x88, 0xC7, 0xC0, 0x3E, 0x10, 0xC8, 0x24,
  0x14, 0x0A, 0x05, 0x0C, 0xF8, 0x40, 0x20, 0x20, 0x10, 0x08, 0x00, 0x0E,
  0x18, 0x98, 0x28, 0x14, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x40, 0xA0, 0xC8,
  0x47, 0xC0, 0x20, 0x08, 0x3E, 0x10, 0x88, 0x28, 0x14, 0x0A, 0x09, 0x08,
  0xF8, 0x44, 0x43, 0x20, 0x90, 0x48, 0x30, 0x1E, 0x18, 0x98, 0x28, 0x14,
  0x01, 0x80, 0x70, 0x04, 0x01, 0x40, 0xA0, 0x58, 0x47, 0xC0, 0xFF, 0x84,
  0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02,
  0x00, 0x20, 0xA0, 0x50, 0x28, 0x14, 0x0A, 0x05, 0x05, 0x02, 0x81, 0x40,
  0xA0, 0x88, 0xC7, 0xC0, 0x80, 0xC0, 0xA0, 0x50, 0x44, 0x22, 0x21, 0x10,
  0x90, 0x48, 0x2C, 0x0C, 0x06, 0x02, 0x00, 0x88, 0xC4, 0x66, 0x33, 0x29,
  0x95, 0x4A, 0xA9, 0x54, 0xCA, 0x65, 0x33, 0x11, 0x88, 0xC0, 0x30, 0x62,
  0x08, 0x42, 0x04, 0x80, 0x90, 0x0C, 0x01, 0x00, 0x50, 0x1A, 0x02, 0x40,
  0x84, 0x20, 0x8C, 0x08, 0x80, 0xE0, 0x90, 0x88, 0x44, 0x41, 0x40, 0xA0,
  0x60, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x3F, 0xC0, 0x30, 0x08, 0x04,
  0x02, 0x01, 0x80, 0x40, 0x20, 0x10, 0x0C, 0x02, 0x01, 0x00, 0xFF, 0x00,
  0x39, 0x08, 0x42, 0x21, 0x08, 0x42, 0x10, 0x88, 0x42, 0x10, 0x87, 0x00,
  0xC4, 0x44, 0x42, 0x22, 0x22, 0x11, 0x11, 0x1C, 0x10, 0x41, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x04, 0x13, 0x80, 0x08, 0x61, 0x89,
  0x25, 0x1C, 0x40, 0xFF, 0xD0, 0x0C, 0x33, 0x41, 0x01, 0x1F, 0x61, 0x82,
  0x82, 0x86, 0x7A, 0x20, 0x20, 0x20, 0x20, 0x4C, 0x72, 0x41, 0x41, 0x41,
  0x41, 0x81, 0x82, 0xC6, 0xBC, 0x0C, 0x33, 0x41, 0x41, 0x80, 0x80, 0x80,
  0x83, 0x42, 0x3C, 0x00, 0x80, 0x40, 0x20, 0x11, 0xD9, 0x99, 0x04, 0x82,
  0x81, 0x40, 0xA0, 0x90, 0x44, 0x63, 0xD0, 0x0C, 0x33, 0x41, 0x41, 0xFF,
  0x80, 0x80, 0x80, 0x42, 0x3C, 0x07, 0x84, 0x04, 0x02, 0x0F, 0xF0, 0x80,
  0xC0, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x00, 0x1C, 0x99, 0x90,
  0x48, 0x28, 0x14, 0x0A, 0x09, 0x04, 0x46, 0x3D, 0x00, 0x80, 0x88, 0xC3,
  0x80, 0x20, 0x20, 0x20, 0x20, 0x4E, 0x53, 0x61, 0x41, 0x41, 0x41, 0x81,
  0x82, 0x82, 0x82, 0x06, 0x04, 0x00, 0x3C, 0x44, 0x04, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x18, 0xFF, 0x01, 0x01, 0x00, 0x1F, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x18, 0xF0, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x1A, 0x19, 0x10, 0x90, 0x50, 0x3C, 0x12, 0x10, 0x88, 0x64,
  0x18, 0x3E, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0xFF, 0x59, 0x99, 0x94, 0x45, 0x11, 0x44, 0x51, 0x18, 0x8A,
  0x22, 0x88, 0xA2, 0x20, 0x4E, 0x53, 0x61, 0x41, 0x41, 0x41, 0x81, 0x82,
  0x82, 0x82, 0x0C, 0x32, 0x41, 0x41, 0x81, 0x81, 0x81, 0x83, 0x42, 0x7C,
  0x26, 0x1C, 0x88, 0x24, 0x12, 0x09, 0x05, 0x02, 0x82, 0x63, 0x2F, 0x10,
  0x18, 0x08, 0x04, 0x00, 0x1C, 0x99, 0x90, 0x48, 0x28, 0x14, 0x0A, 0x09,
  0x04, 0x46, 0x3D, 0x00, 0x80, 0x40, 0x40, 0x20, 0x27, 0x39, 0x60, 0x40,
  0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x0C, 0x33, 0x41, 0x40, 0x30, 0x0E,
  0x03, 0x81, 0xC2, 0x7C, 0x10, 0x23, 0xF8, 0x82, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0xE0, 0x40, 0xA0, 0x90, 0x48, 0x24, 0x12, 0x0A, 0x05, 0x04,
  0x46, 0x3D, 0x00, 0x81, 0x81, 0x82, 0x86, 0x44, 0x48, 0x48, 0x50, 0x30,
  0x20, 0x84, 0x62, 0x28, 0xCA, 0x52, 0x95, 0x29, 0x4A, 0x52, 0x98, 0x46,
  0x11, 0x00, 0x20, 0x44, 0x21, 0x10, 0x28, 0x0C, 0x03, 0x01, 0xA0, 0x48,
  0x21, 0x30, 0x60, 0x60, 0x64, 0x08, 0x82, 0x10, 0x41, 0x10, 0x26, 0x04,
  0x80, 0xA0, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x02, 0x01, 0x80, 0x00, 0x3F,
  0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xC0, 0x60, 0x3F, 0xE0,
  0x06, 0x10, 0x40, 0x81, 0x02, 0x0C, 0x10, 0xC0, 0x80, 0x81, 0x02, 0x08,
  0x10, 0x10, 0x20, 0x20, 0x24, 0xA4, 0x92, 0x52, 0x49, 0x24, 0x30, 0x20,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x06, 0x10, 0x40, 0x83, 0x04, 0x08, 0x10,
  0xC1, 0x00, 0x38, 0x53, 0x18, 0x78,
};

const GFXglyph RobotoMono_LightItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 13, 11, 4, -13 },
  { 6, 4, 4, 11, 4, -14 },
  { 8, 11, 13, 11, 0, -13 },
  { 26, 9, 17, 11, 1, -15 },
  { 46, 9, 13, 11, 1, -13 },
  { 61, 9, 13, 11, 1, -13 },
  { 76, 2, 4, 11, 5, -14 },
  { 77, 6, 18, 11, 3, -14 },
  { 91, 5, 18, 11, 2, -14 },
  { 103, 8, 8, 11, 2, -13 },
  { 111, 9, 10, 11, 1, -11 },
  { 123, 3, 5, 11, 2, -2 },
  { 125, 6, 1, 11, 2, -6 },
  { 126, 2, 2, 11, 4, -2 },
  { 127, 9, 14, 11, 1, -13 },
  { 143, 9, 13, 11, 1, -13 },
  { 158, 5, 13, 11, 3, -13 },
  { 167, 9, 13, 11, 0, -13 },
  { 182, 9, 13, 11, 0, -13 },
  { 197, 9, 13, 11, 0, -13 },
  { 212, 9, 13, 11, 1, -13 },
  { 227, 8, 13, 11, 1, -13 },
  { 240, 8, 13, 11, 2, -13 },
  { 253, 9, 13, 11, 1, -13 },
  { 268, 8, 13, 11, 2, -13 },
  { 281, 3, 10, 11, 4, -10 },
  { 285, 4, 13, 11, 3, -10 },
  { 292, 8, 8, 11, 1, -10 },
  { 300, 9, 4, 11, 1, -8 },
  { 305, 8, 8, 11, 1, -10 },
  { 313, 7, 13, 11, 3, -13 },
  { 325, 10, 13, 11, 0, -13 },
  { 342, 9, 13, 11, 0, -13 },
  { 357, 9, 13, 11, 1, -13 },
  { 372, 9, 13, 11, 1, -13 },
  { 387, 9, 13, 11, 1, -13 },
  { 402, 9, 13, 11, 1, -13 },
  { 417, 9, 13, 11, 1, -13 },
  { 432, 9, 13, 11, 1, -13 },
  { 447, 10, 13, 11, 0, -13 },
  { 464, 9, 13, 11, 1, -13 },
  { 479, 9, 13, 11, 1, -13 },
  { 494, 10, 13, 11, 1, -13 },
  { 511, 7, 13, 11, 1, -13 },
  { 523, 10, 13, 11, 1, -13 },
  { 540, 10, 13, 11, 0, -13 },
  { 557, 9, 13, 11, 1, -13 },
  { 572, 9, 13, 11, 1, -13 },
  { 587, 9, 15, 11, 1, -13 },
  { 604, 9, 13, 11, 1, -13 },
  { 619, 9, 13, 11, 1, -13 },
  { 634, 9, 13, 11, 2, -13 },
  { 649, 9, 13, 11, 1, -13 },
  { 664, 9, 13, 11, 2, -13 },
  { 679, 9, 13, 11, 2, -13 },
  { 694, 11, 13, 11, 0, -13 },
  { 712, 9, 13, 11, 2, -13 },
  { 727, 10, 13, 11, 0, -13 },
  { 744, 5, 18, 11, 3, -15 },
  { 756, 4, 14, 11, 3, -13 },
  { 763, 6, 18, 11, 2, -15 },
  { 777, 6, 7, 11, 2, -13 },
  { 783, 8, 1, 11, 0, 0 },
  { 784, 2, 2, 11, 5, -13 },
  { 785, 8, 10, 11, 1, -10 },
  { 795, 8, 14, 11, 1, -14 },
  { 809, 8, 10, 11, 1, -10 },
  { 819, 9, 14, 11, 1, -14 },
  { 835, 8, 10, 11, 1, -10 },
  { 845, 9, 14, 11, 2, -14 },
  { 861, 9, 14, 11, 1, -10 },
  { 877, 8, 14, 11, 1, -14 },
  { 891, 8, 13, 11, 1, -13 },
  { 904, 8, 17, 11, 0, -13 },
  { 921, 9, 14, 11, 1, -14 },
  { 937, 8, 14, 11, 1, -14 },
  { 951, 10, 10, 11, 0, -10 },
  { 964, 8, 10, 11, 1, -10 },
  { 974, 8, 10, 11, 1, -10 },
  { 984, 9, 14, 11, 0, -10 },
  { 1000, 9, 14, 11, 1, -10 },
  { 1016, 8, 10, 11, 2, -10 },
  { 1026, 8, 10, 11, 1, -10 },
  { 1036, 7, 12, 11, 2, -12 },
  { 1047, 9, 10, 11, 1, -10 },
  { 1059, 8, 10, 11, 2, -10 },
  { 1069, 10, 10, 11, 1, -10 },
  { 1082, 10, 10, 11, 0, -10 },
  { 1095, 11, 14, 11, 0, -10 },
  { 1115, 10, 10, 11, 0, -10 },
  { 1128, 7, 18, 11, 3, -14 },
  { 1144, 3, 16, 11, 4, -13 },
  { 1150, 7, 18, 11, 2, -14 },
  { 1166, 10, 3, 11, 0, -7 },
};

const GFXfont RobotoMono_LightItalic18pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic18pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic18pt7bGlyphs,
  0x20, 0x7E, 24
};

#endif // _ROBOTOMONO_LIGHTITALIC18PT7B_H_
