#ifndef _ROBOTOMONO_LIGHTITALIC52PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x07, 0x83, 0xE0, 0x70, 0x00,
  0x30, 0x77, 0x07, 0x70, 0x67, 0x06, 0x70, 0xE6, 0x0E, 0x60, 0xEE, 0x0C,
  0xE0, 0xCE, 0x0C, 0xC1, 0xC0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x06, 0x01,
  0xC0, 0x00, 0x38, 0x06, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0x1C, 0x03, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xC0, 0x30, 0x03, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x18, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x70, 0x0C, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x06, 0x01, 0xC0, 0x00, 0x38, 0x06, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x70, 0x1C, 0x00, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xC0,
  0x30, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x18, 0x07, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x70, 0x0C, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x06, 0x01, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0xFC, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0xF0, 0x01, 0xC0, 0x70,
  0x00, 0xF0, 0x78, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E,
  0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00,
  0x03, 0x8E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0xC0, 0x01, 0xE0, 0xE0,
  0x01, 0xE0, 0x78, 0x01, 0xE0, 0x1F, 0x07, 0xE0, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0x07, 0x00, 0x03, 0x03, 0x80, 0x03, 0x80, 0xC0,
  0x21, 0x80, 0x60, 0x18, 0xC0, 0x30, 0x1C, 0x60, 0x18, 0x1C, 0x70, 0x1C,
  0x1C, 0x38, 0x0E, 0x0C, 0x1C, 0x07, 0x0E, 0x0E, 0x03, 0x0E, 0x03, 0x03,
  0x86, 0x01, 0xC3, 0x87, 0x00, 0x7F, 0x87, 0x00, 0x1F, 0x83, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC1, 0xF0, 0x00, 0xC3, 0xFE, 0x00, 0xE3, 0xC7,
  0x00, 0xE1, 0x81, 0xC0, 0xE1, 0xC0, 0xE0, 0x60, 0xC0, 0x30, 0x70, 0x60,
  0x18, 0x70, 0x70, 0x0C, 0x30, 0x38, 0x0E, 0x38, 0x1C, 0x07, 0x38, 0x0E,
  0x03, 0x08, 0x07, 0x01, 0x80, 0x03, 0x81, 0xC0, 0x00, 0xE1, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0x3C,
  0x00, 0x38, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x01, 0xC0,
  0x1C, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x01,
  0xC0, 0xF0, 0x00, 0x70, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xBC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xDC, 0x00, 0x03, 0xC7, 0x80, 0x71, 0xE0, 0xE0, 0x1C, 0x70,
  0x3C, 0x07, 0x38, 0x07, 0x01, 0xDE, 0x00, 0xE0, 0xE7, 0x00, 0x3C, 0x39,
  0xC0, 0x07, 0x1C, 0xE0, 0x00, 0xE7, 0x38, 0x00, 0x3B, 0x8E, 0x00, 0x07,
  0xE3, 0x80, 0x01, 0xF0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x3F, 0x03, 0x80,
  0x1F, 0xE0, 0xF8, 0x3F, 0x38, 0x1F, 0xFF, 0x0F, 0x01, 0xFF, 0x01, 0xE0,
  0x04, 0x00, 0x00, 0x77, 0x77, 0x66, 0xEE, 0xEC, 0xC0, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x30, 0x0C, 0x07, 0x7C,
  0x18, 0x3F, 0xFE, 0x33, 0xFC, 0x7F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xE7, 0x00, 0x03, 0x8E,
  0x00, 0x0E, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x1C,
  0x03, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x1C, 0x78, 0xE1,
  0xC3, 0x87, 0x1C, 0x38, 0xE3, 0xC7, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x37, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xF8, 0x01, 0xF0, 0x78, 0x03, 0xC0, 0x1C, 0x07, 0x80, 0x0E,
  0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x06, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07,
  0x38, 0x00, 0x07, 0x38, 0x00, 0x0F, 0x38, 0x00, 0x1F, 0x30, 0x00, 0x3F,
  0x70, 0x00, 0xF7, 0x70, 0x01, 0xE7, 0x70, 0x03, 0xC7, 0x70, 0x07, 0x0E,
  0x70, 0x1E, 0x0E, 0xE0, 0x3C, 0x0E, 0xE0, 0x78, 0x0E, 0xE0, 0xE0, 0x0E,
  0xE3, 0xC0, 0x0E, 0xE7, 0x80, 0x1C, 0xEF, 0x00, 0x1C, 0xFC, 0x00, 0x1C,
  0xF8, 0x00, 0x1C, 0xF0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38,
  0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xE0, 0x70, 0x01, 0xC0,
  0x78, 0x03, 0xC0, 0x3E, 0x0F, 0x80, 0x1F, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0xF0, 0x1F, 0xC1, 0xFE, 0x3F, 0xBB,
  0xF8, 0xEF, 0x03, 0xB0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0x07, 0xC0, 0x1E, 0x00, 0xF0,
  0x1C, 0x00, 0x38, 0x1C, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x03,
  0x87, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xF0, 0xF8, 0x01, 0xE0, 0x0F, 0x00,
  0xF0, 0x01, 0xE0, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03,
  0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x8F, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x0F,
  0x00, 0x7C, 0x1F, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x0E,
  0x70, 0x00, 0x07, 0x38, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x70, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x0F, 0x07, 0x00,
  0x03, 0x81, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x07,
  0x00, 0x3C, 0x01, 0x80, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80,
  0x0E, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x78, 0x00, 0x70, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x87, 0x80,
  0x00, 0xEF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xC1, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0x40, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00,
  0x38, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x81, 0xC0, 0x01, 0xC0, 0x78,
  0x00, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x7C, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x87, 0xF0, 0x0E,
  0x3F, 0xF8, 0x1D, 0xF9, 0xF8, 0x3F, 0x80, 0x78, 0xFC, 0x00, 0x71, 0xF0,
  0x00, 0x73, 0xC0, 0x00, 0xE7, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x9C, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0D, 0xC0, 0x00, 0x3B, 0x80, 0x00,
  0x77, 0x00, 0x00, 0xEE, 0x00, 0x03, 0xCE, 0x00, 0x07, 0x1C, 0x00, 0x1E,
  0x3C, 0x00, 0x38, 0x38, 0x00, 0xE0, 0x78, 0x03, 0xC0, 0x7C, 0x1F, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xF0,
  0xF8, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x38, 0x00, 0x38, 0x1E,
  0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x38,
  0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0x70, 0x00,
  0x70, 0x1E, 0x00, 0x38, 0x03, 0xC0, 0x3C, 0x00, 0x7C, 0x3E, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xE1, 0xF0, 0x03, 0xC0, 0x1E, 0x01,
  0xE0, 0x01, 0xC0, 0xF0, 0x00, 0x78, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x03,
  0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x3C, 0x1E,
  0x00, 0x1E, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x7E, 0x1F, 0x03, 0xC0, 0x1C, 0x1E, 0x00, 0x38, 0x70, 0x00, 0xE3,
  0x80, 0x01, 0xCE, 0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0xF7, 0x00, 0x07, 0xDC,
  0x00, 0x3E, 0x38, 0x01, 0xF8, 0xF8, 0x1E, 0xE1, 0xFF, 0xF3, 0x83, 0xFF,
  0x1C, 0x03, 0xF0, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0x03, 0xC3, 0xE1, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0xF0, 0xFC, 0x7C, 0x1E, 0x00, 0x00, 0x60, 0x0F, 0x01,
  0xF0, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x06, 0x00, 0x1F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xC0, 0x10, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x81, 0xF8, 0x7C,
  0x3C, 0x01, 0xE7, 0x80, 0x0E, 0x70, 0x00, 0xEF, 0x00, 0x0E, 0xE0, 0x00,
  0xFE, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0xF0, 0x01, 0xC0, 0x0F, 0x00, 0x06, 0x00, 0xF0, 0x00, 0x38, 0x06,
  0x00, 0x00, 0xC0, 0x70, 0x08, 0x07, 0x07, 0x03, 0xF8, 0x18, 0x30, 0x3F,
  0xE0, 0xC3, 0x83, 0x83, 0x06, 0x38, 0x38, 0x18, 0x31, 0x83, 0x80, 0xC1,
  0x8C, 0x18, 0x0C, 0x0C, 0xE1, 0xC0, 0x60, 0x66, 0x0C, 0x03, 0x03, 0x30,
  0x60, 0x18, 0x1B, 0x87, 0x01, 0x81, 0x98, 0x30, 0x0C, 0x0C, 0xC1, 0x80,
  0x60, 0x66, 0x0C, 0x03, 0x03, 0x30, 0x60, 0x30, 0x19, 0x87, 0x01, 0x81,
  0x9C, 0x38, 0x1C, 0x0C, 0xE1, 0xC1, 0xE0, 0xC7, 0x0E, 0x1F, 0x06, 0x38,
  0x31, 0xD8, 0x60, 0xC1, 0xFC, 0xFE, 0x06, 0x07, 0xC3, 0xE0, 0x30, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x01, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x1D, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x0C, 0x00, 0x07,
  0x03, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x0E, 0x00,
  0x1C, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x18, 0x00, 0xE0, 0x06,
  0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3C, 0x00, 0x0C, 0x0E,
  0x00, 0x03, 0x87, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0xF0, 0x00, 0x0E,
  0x38, 0x00, 0x03, 0x9E, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x19, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x0E, 0x00, 0x3E, 0x03, 0x80, 0x07, 0x80, 0xE0, 0x00,
  0xF0, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0x83,
  0x80, 0x01, 0xE0, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0xF8, 0x0E, 0x01, 0xF8,
  0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x70, 0x01, 0xF0, 0x1C, 0x00,
  0x1E, 0x07, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C,
  0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x78, 0x70, 0x00, 0x3C, 0x1C, 0x00, 0x3E, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x03, 0xE0, 0xF8, 0x01, 0xE0, 0x0F, 0x00, 0xF0,
  0x01, 0xC0, 0x78, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x87,
  0x80, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x06, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0xE0, 0x70, 0x00, 0x78, 0x0E, 0x00, 0x3C, 0x03, 0xC0, 0x1E, 0x00,
  0x7C, 0x1F, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x01,
  0xC0, 0x1F, 0x00, 0x70, 0x00, 0xF0, 0x0E, 0x00, 0x0F, 0x01, 0xC0, 0x00,
  0xE0, 0x38, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x38, 0x38,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C,
  0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00,
  0x03, 0x87, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x07,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x0F, 0x03, 0x80, 0x03,
  0xC0, 0x70, 0x01, 0xF0, 0x1C, 0x00, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x83, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xF0, 0xF8, 0x01, 0xE0,
  0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0x38, 0x3C, 0x00, 0x0E, 0x0E,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x07, 0xFF, 0x38, 0x01, 0xFF, 0xCE, 0x00, 0x7F, 0xF3,
  0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x63, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x87, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x38, 0x78, 0x00, 0x1C, 0x0E, 0x00, 0x0F, 0x03,
  0xC0, 0x07, 0x80, 0x7C, 0x0F, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x01, 0xC0,
  0x00, 0x38, 0x0C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x18, 0x0E, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x18, 0x0E, 0x00, 0x01, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF0, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xC0,
  0x70, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x06, 0x03, 0x80, 0x00,
  0x70, 0x18, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x30, 0x1C, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x80,
  0x70, 0x00, 0xF0, 0x07, 0x00, 0x7C, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x0E, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x78,
  0x03, 0x80, 0x03, 0xC0, 0x0E, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0x80, 0x07, 0x00, 0x3C, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x70,
  0x0F, 0x00, 0x01, 0xC0, 0xF8, 0x00, 0x07, 0x07, 0xC0, 0x00, 0x38, 0x3E,
  0x00, 0x00, 0xE1, 0xF0, 0x00, 0x03, 0x8F, 0x80, 0x00, 0x0E, 0x78, 0x00,
  0x00, 0x3B, 0xF0, 0x00, 0x00, 0xDF, 0xC0, 0x00, 0x07, 0xF3, 0x80, 0x00,
  0x1F, 0x8F, 0x00, 0x00, 0x7C, 0x1C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x38, 0x03, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x03, 0x80,
  0x1E, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x38, 0x00, 0xF0, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x78, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0xC0,
  0xE0, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x07, 0x80,
  0x01, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x01,
  0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x3B, 0x00, 0xDC, 0x01, 0xDC,
  0x07, 0x70, 0x07, 0x70, 0x1C, 0xC0, 0x39, 0xC0, 0x73, 0x00, 0xE7, 0x01,
  0xCE, 0x07, 0x1C, 0x07, 0x38, 0x1C, 0x60, 0x18, 0xE0, 0xE3, 0x80, 0xE1,
  0x83, 0x8E, 0x03, 0x86, 0x1C, 0x38, 0x0E, 0x18, 0x70, 0xE0, 0x38, 0x73,
  0x83, 0x00, 0xE1, 0xDC, 0x1C, 0x03, 0x07, 0x70, 0x70, 0x1C, 0x0F, 0x81,
  0xC0, 0x70, 0x3E, 0x07, 0x01, 0xC0, 0xF0, 0x1C, 0x07, 0x03, 0xC0, 0xE0,
  0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x01, 0xC0, 0xF8, 0x00, 0x0E,
  0x07, 0xC0, 0x00, 0x70, 0x3E, 0x00, 0x07, 0x01, 0xF8, 0x00, 0x38, 0x0F,
  0xC0, 0x01, 0xC0, 0xEE, 0x00, 0x0E, 0x07, 0x38, 0x00, 0x70, 0x39, 0xC0,
  0x07, 0x01, 0xCE, 0x00, 0x38, 0x0E, 0x38, 0x01, 0xC0, 0x71, 0xC0, 0x0E,
  0x07, 0x0E, 0x00, 0x70, 0x38, 0x38, 0x03, 0x81, 0xC1, 0xC0, 0x38, 0x0E,
  0x06, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x07,
  0x03, 0x81, 0xC0, 0x38, 0x1C, 0x0E, 0x01, 0xC1, 0xC0, 0x70, 0x07, 0x0E,
  0x03, 0x80, 0x38, 0x70, 0x18, 0x01, 0xC3, 0x81, 0xC0, 0x07, 0x1C, 0x0E,
  0x00, 0x38, 0xE0, 0x70, 0x01, 0xCE, 0x03, 0x80, 0x07, 0x70, 0x1C, 0x00,
  0x3B, 0x81, 0xC0, 0x00, 0xDC, 0x0E, 0x00, 0x07, 0xE0, 0x70, 0x00, 0x3F,
  0x03, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x3C, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0x8F, 0x80, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x1E,
  0x00, 0x1C, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x8F, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x73, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x1C,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00,
  0x03, 0xB8, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x70, 0x1C,
  0x00, 0x78, 0x0F, 0x00, 0xF8, 0x03, 0xE1, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0x80, 0x07, 0xC0, 0x70, 0x00, 0x3C, 0x0E,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x1E, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C,
  0x1C, 0x00, 0x07, 0x83, 0x80, 0x01, 0xE0, 0x70, 0x00, 0xF8, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xF1, 0xF8,
  0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x01, 0xC0, 0x70, 0x00, 0x78, 0x3C, 0x00,
  0x0E, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0xE0,
  0x00, 0x07, 0x38, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x30, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x07,
  0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x78, 0x1E, 0x00,
  0x3C, 0x03, 0xC0, 0x1E, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xC0, 0x07, 0xC0,
  0x38, 0x00, 0x38, 0x07, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x70, 0x38, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83,
  0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00,
  0xE0, 0x70, 0x00, 0x3C, 0x0E, 0x00, 0x0F, 0x01, 0xC0, 0x03, 0xC0, 0x38,
  0x01, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x07, 0x00,
  0x70, 0x00, 0x70, 0x0C, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00,
  0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x00, 0x78, 0x07, 0x80, 0x07, 0x80,
  0xE0, 0x00, 0x70, 0x38, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xE1, 0xE0, 0x00,
  0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xC7, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x78, 0x78, 0x00, 0x0E, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x01,
  0xF0, 0x07, 0xC0, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x02, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0C, 0x1C, 0x00, 0x03,
  0x83, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x38, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x38,
  0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00,
  0x07, 0x07, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70,
  0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x0E,
  0x03, 0x80, 0x03, 0x80, 0x38, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x00, 0x7C,
  0x3F, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x70, 0xE0,
  0x00, 0x38, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x0E,
  0x00, 0x0E, 0x03, 0x80, 0x0F, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x07, 0x80,
  0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0x03, 0x80, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x38,
  0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x06, 0x1C, 0x00, 0x03, 0x8E,
  0x00, 0x01, 0xCF, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x3B,
  0x80, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0xFC, 0x01, 0xC0, 0x1F, 0x80, 0x38, 0x03, 0xF0, 0x0F, 0x00, 0x6E, 0x01,
  0xE0, 0x1D, 0xC0, 0x3C, 0x03, 0xB8, 0x0F, 0x80, 0x77, 0x01, 0xF0, 0x1C,
  0xE0, 0x36, 0x03, 0x9C, 0x0E, 0xE0, 0x73, 0x81, 0xDC, 0x0C, 0x70, 0x33,
  0x83, 0x8E, 0x0E, 0x70, 0x71, 0xC1, 0xCE, 0x0E, 0x38, 0x31, 0xC3, 0x87,
  0x0E, 0x38, 0x70, 0xE1, 0xC7, 0x0E, 0x1C, 0x30, 0xE1, 0x83, 0x8E, 0x1C,
  0x70, 0x71, 0xC3, 0x8E, 0x0E, 0x30, 0x71, 0x81, 0xCE, 0x0E, 0x70, 0x39,
  0xC1, 0xCE, 0x07, 0x30, 0x39, 0xC0, 0xEE, 0x07, 0x30, 0x1D, 0xC0, 0xEE,
  0x03, 0xB0, 0x1D, 0xC0, 0x7E, 0x03, 0xB0, 0x0F, 0xC0, 0x7E, 0x01, 0xF0,
  0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0xE0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x38,
  0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x07,
  0x78, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x3C,
  0x70, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xF0,
  0x38, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80,
  0x1E, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x78, 0x00,
  0x03, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x1E, 0x1E, 0x00,
  0x0F, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x70, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x03, 0x80,
  0x03, 0x81, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x1E,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x38, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x7F, 0xC0, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x01, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0x80,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x01, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x00,
  0xFF, 0x00, 0xFF, 0x01, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xCC, 0x00, 0x39, 0x80, 0x0E, 0x38, 0x01, 0xC7,
  0x00, 0x70, 0xE0, 0x0E, 0x0C, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x1C, 0x07,
  0x07, 0x00, 0x60, 0xE0, 0x0C, 0x38, 0x01, 0xC7, 0x00, 0x39, 0xC0, 0x07,
  0x78, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xE0, 0xE1, 0xC1, 0xC1, 0x83, 0x83, 0x80, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x3E, 0x01, 0xE0, 0xF0, 0x01, 0xC1, 0xC0, 0x01,
  0xC7, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x07, 0xFF, 0xC0, 0xFF, 0xFF, 0x83,
  0xFC, 0x07, 0x1F, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x3B, 0xC0,
  0x00, 0xE7, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x0F, 0x38, 0x00,
  0x3E, 0x70, 0x00, 0xFC, 0xF0, 0x07, 0xB8, 0xF8, 0x3E, 0x70, 0xFF, 0xF9,
  0xE0, 0xFF, 0xC3, 0xC0, 0x10, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x07, 0xE0, 0x07, 0x3F, 0xF8, 0x07, 0x7F,
  0xFC, 0x06, 0xF0, 0x3E, 0x0F, 0xC0, 0x1E, 0x0F, 0x80, 0x0E, 0x0F, 0x00,
  0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00,
  0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00,
  0x07, 0x38, 0x00, 0x07, 0x38, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x38, 0x00,
  0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x78, 0x00, 0x3C, 0x78, 0x00,
  0x38, 0x7C, 0x00, 0x78, 0x7E, 0x00, 0xF0, 0x77, 0x87, 0xE0, 0x63, 0xFF,
  0xC0, 0xE1, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x1C, 0x0F, 0x00,
  0x0E, 0x1E, 0x00, 0x0E, 0x1C, 0x00, 0x06, 0x3C, 0x00, 0x07, 0x38, 0x00,
  0x07, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x70, 0x00,
  0x38, 0x78, 0x00, 0x78, 0x38, 0x00, 0x70, 0x3C, 0x01, 0xE0, 0x1F, 0x07,
  0xC0, 0x0F, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0xFC,
  0x1C, 0x00, 0xFF, 0xC7, 0x00, 0xFF, 0xF9, 0xC0, 0x7C, 0x07, 0x70, 0x1E,
  0x00, 0xFC, 0x0E, 0x00, 0x1F, 0x07, 0x80, 0x03, 0x81, 0xC0, 0x00, 0xE0,
  0xE0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x1E, 0x00, 0x03, 0x87, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x0E, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x07,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x1E,
  0x03, 0x80, 0x0F, 0x80, 0xF0, 0x0F, 0xC0, 0x1F, 0x0F, 0xF0, 0x03, 0xFF,
  0x9C, 0x00, 0x7F, 0xC7, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0x1C, 0x0F,
  0x00, 0x0E, 0x1E, 0x00, 0x0E, 0x1C, 0x00, 0x06, 0x38, 0x00, 0x07, 0x38,
  0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFE, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x10, 0x38, 0x00, 0x38, 0x1C, 0x00, 0xF0, 0x1F,
  0x03, 0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x40, 0x1F, 0xF8, 0xE0, 0x1F, 0xFF, 0xB8, 0x0F, 0x80, 0xEE, 0x03, 0xC0,
  0x1F, 0x81, 0xE0, 0x03, 0xE0, 0xF0, 0x00, 0x78, 0x38, 0x00, 0x1C, 0x1C,
  0x00, 0x07, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x1C,
  0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0xC0, 0x00,
  0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x03, 0xC0,
  0x70, 0x01, 0xF0, 0x1E, 0x01, 0xF8, 0x03, 0xE1, 0xFE, 0x00, 0x7F, 0xF3,
  0x80, 0x0F, 0xF8, 0xE0, 0x00, 0x40, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x40, 0x00, 0xE0, 0x30, 0x00, 0x78, 0x0E,
  0x00, 0x3C, 0x01, 0xE0, 0x3E, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x7E, 0x00, 0x71, 0xFF, 0xC0, 0x31, 0xFF, 0xF0,
  0x39, 0xC0, 0x78, 0x1D, 0xC0, 0x1E, 0x0F, 0x80, 0x07, 0x07, 0x80, 0x03,
  0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00,
  0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x1C, 0x00,
  0x03, 0x8E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0,
  0x00, 0x70, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x38,
  0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x10, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0x38, 0x00, 0xF0, 0x1C,
  0x01, 0xF0, 0x0E, 0x01, 0xE0, 0x0E, 0x01, 0xE0, 0x07, 0x01, 0xE0, 0x03,
  0x83, 0xE0, 0x01, 0xC3, 0xE0, 0x00, 0xE3, 0xC0, 0x00, 0x73, 0xC0, 0x00,
  0x73, 0xC0, 0x00, 0x3B, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0x8E, 0x00,
  0x07, 0x83, 0x80, 0x03, 0x81, 0xE0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x3C,
  0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xE0, 0x38, 0x00,
  0x78, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0F, 0x07, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x06, 0x3E, 0x07, 0xC0, 0x77, 0xF8, 0x7F, 0x83, 0xFF, 0xEF,
  0xFC, 0x1F, 0x07, 0x60, 0xF0, 0xF0, 0x3E, 0x03, 0x8F, 0x00, 0xE0, 0x1C,
  0x70, 0x07, 0x00, 0xE3, 0x80, 0x30, 0x07, 0x1C, 0x03, 0x80, 0x38, 0xE0,
  0x1C, 0x01, 0xC6, 0x00, 0xE0, 0x0C, 0x70, 0x07, 0x00, 0xE3, 0x80, 0x38,
  0x07, 0x1C, 0x01, 0x80, 0x38, 0xE0, 0x1C, 0x01, 0xC7, 0x00, 0xE0, 0x0E,
  0x30, 0x07, 0x00, 0x63, 0x80, 0x38, 0x07, 0x1C, 0x01, 0xC0, 0x38, 0xE0,
  0x0C, 0x01, 0xC7, 0x00, 0xE0, 0x0E, 0x38, 0x07, 0x00, 0x71, 0x80, 0x38,
  0x03, 0x1C, 0x01, 0xC0, 0x38, 0xE0, 0x0E, 0x01, 0xC7, 0x00, 0x60, 0x0E,
  0x38, 0x07, 0x00, 0x71, 0x80, 0x38, 0x03, 0x80, 0x03, 0x07, 0xF0, 0x06,
  0x1F, 0xF8, 0x06, 0x3F, 0xFE, 0x0E, 0x70, 0x1E, 0x0E, 0xC0, 0x0F, 0x0F,
  0x80, 0x07, 0x0F, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x1E, 0x00, 0x07, 0x1C,
  0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C,
  0x00, 0x07, 0x38, 0x00, 0x06, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38,
  0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0x70,
  0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70,
  0x00, 0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x07, 0xC0, 0x78, 0x0F, 0x00, 0x3C, 0x1E,
  0x00, 0x1E, 0x1C, 0x00, 0x0E, 0x3C, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x70,
  0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xF0,
  0x00, 0x38, 0x70, 0x00, 0x78, 0x78, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x1E,
  0x07, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC1, 0xF8, 0x00, 0x73, 0xFF, 0x80, 0x19, 0xFF, 0xF0, 0x0E, 0xE0, 0x3C,
  0x03, 0xF0, 0x07, 0x80, 0xF8, 0x00, 0xE0, 0x3C, 0x00, 0x3C, 0x0E, 0x00,
  0x07, 0x03, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x1C,
  0x00, 0x07, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C,
  0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE0, 0xE0, 0x00,
  0x38, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0xE0, 0x7C, 0x00, 0x78, 0x1F, 0x80, 0x3C, 0x07, 0xF0, 0x7E, 0x03,
  0xDF, 0xFF, 0x00, 0xE1, 0xFF, 0x00, 0x38, 0x04, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x80, 0x7F, 0xE3,
  0x80, 0xFF, 0xFD, 0xC0, 0xF8, 0x0E, 0xE0, 0x78, 0x03, 0xF0, 0x78, 0x00,
  0xF8, 0x78, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00,
  0x07, 0x0E, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0xE1, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70,
  0x00, 0x0E, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x03, 0x83,
  0x80, 0x01, 0xC1, 0xC0, 0x01, 0xE0, 0x70, 0x01, 0xF0, 0x3C, 0x01, 0xF0,
  0x0F, 0x87, 0xF8, 0x03, 0xFF, 0x9C, 0x00, 0xFF, 0x8E, 0x00, 0x0C, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFE, 0x0E,
  0x1F, 0xF8, 0x1C, 0xFF, 0xF0, 0x73, 0xE0, 0x00, 0xEF, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x07, 0xC0, 0x3C, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x0F, 0x0E,
  0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xF0, 0x00, 0x1C, 0x70,
  0x00, 0x3C, 0x70, 0x00, 0x38, 0x3C, 0x00, 0xF8, 0x3F, 0x03, 0xF0, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x01, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x80, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x80, 0x1F,
  0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x10, 0x00, 0x1C, 0x00, 0x07, 0x1C, 0x00,
  0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00,
  0x0E, 0x38, 0x00, 0x1E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00,
  0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x38, 0x70, 0x00,
  0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00,
  0x38, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xF0, 0xE0, 0x00,
  0xF0, 0x70, 0x01, 0xF0, 0x70, 0x07, 0x70, 0x7C, 0x1E, 0x60, 0x3F, 0xFC,
  0xE0, 0x0F, 0xF0, 0xE0, 0x01, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xB8, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0xE1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0xF0, 0x30, 0x00, 0x70, 0x1C,
  0x00, 0x70, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00,
  0xE0, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x0C, 0x0F, 0x00,
  0x07, 0x07, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x63, 0x80,
  0x00, 0x39, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x0E, 0x00, 0xF8, 0x01, 0xC0, 0x1B, 0x00, 0x78, 0x07, 0x70, 0x0F, 0x00,
  0xEE, 0x03, 0xE0, 0x19, 0xC0, 0x6C, 0x07, 0x38, 0x1D, 0x80, 0xE7, 0x03,
  0x30, 0x38, 0xE0, 0x66, 0x07, 0x1C, 0x1C, 0xC0, 0xC3, 0x83, 0x18, 0x38,
  0x70, 0xE3, 0x07, 0x0E, 0x18, 0x60, 0xC1, 0xC7, 0x0C, 0x38, 0x38, 0xE1,
  0xC6, 0x07, 0x18, 0x38, 0xC0, 0xE7, 0x07, 0x38, 0x1C, 0xC0, 0xE6, 0x03,
  0xB8, 0x1D, 0xC0, 0x36, 0x01, 0xB8, 0x06, 0xC0, 0x36, 0x00, 0xF8, 0x07,
  0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E,
  0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x10, 0x78,
  0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0x3C, 0x00, 0x3C, 0x01, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0xF0, 0x00, 0xE0, 0x1E, 0x00, 0x07, 0x03, 0xC0, 0x00,
  0x78, 0x78, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0x9C, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x38, 0x07, 0x00,
  0x07, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x1C, 0x03, 0xC0,
  0x01, 0xE0, 0x78, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x01, 0x07, 0x80, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x3C, 0x03, 0x80, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x78, 0x01, 0xC0, 0x00,
  0xF0, 0x01, 0xC0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0xE0, 0x03, 0x80, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0x78,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x10, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x1C,
  0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x03, 0x3F, 0xFC, 0x00, 0x73, 0x81,
  0xE0, 0x07, 0x70, 0x0F, 0x00, 0xE6, 0x00, 0x78, 0x1E, 0xE0, 0x03, 0xF7,
  0xCE, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0x00,
};

const GFXglyph RobotoMono_LightItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 10, 37, 31, 10, -37 },
  { 48, 12, 11, 31, 12, -39 },
  { 65, 30, 37, 31, 1, -37 },
  { 204, 25, 48, 31, 3, -43 },
  { 354, 25, 39, 31, 3, -38 },
  { 476, 26, 39, 31, 2, -38 },
  { 603, 4, 11, 31, 15, -39 },
  { 609, 16, 53, 31, 9, -41 },
  { 715, 17, 53, 31, 4, -41 },
  { 828, 23, 23, 31, 6, -37 },
  { 895, 25, 27, 31, 3, -31 },
  { 980, 7, 12, 31, 6, -5 },
  { 991, 18, 3, 31, 6, -18 },
  { 998, 5, 5, 31, 11, -5 },
  { 1002, 24, 40, 31, 4, -37 },
  { 1122, 24, 39, 31, 4, -38 },
  { 1239, 14, 37, 31, 8, -37 },
  { 1304, 25, 38, 31, 1, -38 },
  { 1423, 26, 39, 31, 1, -38 },
  { 1550, 26, 37, 31, 1, -37 },
  { 1671, 26, 38, 31, 4, -37 },
  { 1795, 23, 38, 31, 3, -37 },
  { 1905, 24, 37, 31, 6, -37 },
  { 2016, 26, 39, 31, 3, -38 },
  { 2143, 22, 37, 31, 5, -37 },
  { 2245, 9, 27, 31, 12, -27 },
  { 2276, 12, 34, 31, 9, -27 },
  { 2327, 23, 22, 31, 4, -28 },
  { 2391, 25, 13, 31, 3, -23 },
  { 2432, 24, 22, 31, 3, -28 },
  { 2498, 20, 38, 31, 8, -38 },
  { 2593, 29, 37, 31, 1, -37 },
  { 2728, 26, 37, 31, 0, -37 },
  { 2849, 26, 37, 31, 2, -37 },
  { 2970, 26, 39, 31, 3, -38 },
  { 3097, 27, 37, 31, 2, -37 },
  { 3222, 28, 37, 31, 2, -37 },
  { 3352, 27, 37, 31, 3, -37 },
  { 3477, 26, 39, 31, 3, -38 },
  { 3604, 29, 37, 31, 1, -37 },
  { 3739, 27, 37, 31, 2, -37 },
  { 3864, 27, 38, 31, 2, -37 },
  { 3993, 30, 37, 31, 2, -37 },
  { 4132, 21, 37, 31, 3, -37 },
  { 4230, 30, 37, 31, 1, -37 },
  { 4369, 29, 37, 31, 1, -37 },
  { 4504, 25, 39, 31, 3, -38 },
  { 4626, 27, 37, 31, 3, -37 },
  { 4751, 26, 44, 31, 3, -38 },
  { 4894, 27, 37, 31, 2, -37 },
  { 5019, 27, 39, 31, 2, -38 },
  { 5151, 26, 37, 31, 6, -37 },
  { 5272, 27, 38, 31, 3, -37 },
  { 5401, 25, 37, 31, 6, -37 },
  { 5517, 27, 37, 31, 5, -37 },
  { 5642, 32, 37, 31, 0, -37 },
  { 5790, 26, 37, 31, 6, -37 },
  { 5911, 28, 37, 31, 1, -37 },
  { 6041, 17, 50, 31, 7, -42 },
  { 6148, 11, 40, 31, 10, -37 },
  { 6203, 16, 50, 31, 7, -42 },
  { 6303, 19, 20, 31, 6, -37 },
  { 6351, 22, 3, 31, 1, 0 },
  { 6360, 7, 7, 31, 15, -38 },
  { 6367, 23, 29, 31, 3, -28 },
  { 6451, 24, 40, 31, 2, -39 },
  { 6571, 24, 29, 31, 3, -28 },
  { 6658, 26, 40, 31, 3, -39 },
  { 6788, 24, 29, 31, 3, -28 },
  { 6875, 26, 40, 31, 6, -40 },
  { 7005, 26, 39, 31, 2, -28 },
  { 7132, 25, 39, 31, 2, -39 },
  { 7254, 22, 37, 31, 3, -37 },
  { 7356, 24, 48, 31, 0, -37 },
  { 7500, 25, 39, 31, 3, -39 },
  { 7622, 22, 39, 31, 3, -39 },
  { 7730, 29, 28, 31, 0, -28 },
  { 7832, 24, 28, 31, 2, -28 },
  { 7916, 24, 29, 31, 3, -28 },
  { 8003, 26, 39, 31, 0, -28 },
  { 8130, 25, 39, 31, 3, -28 },
  { 8252, 23, 28, 31, 6, -28 },
  { 8333, 24, 29, 31, 3, -28 },
  { 8420, 21, 36, 31, 6, -35 },
  { 8515, 24, 28, 31, 4, -27 },
  { 8599, 25, 28, 31, 5, -28 },
  { 8687, 27, 27, 31, 4, -27 },
  { 8779, 28, 28, 31, 1, -28 },
  { 8877, 32, 39, 31, -1, -28 },
  { 9033, 27, 27, 31, 1, -27 },
  { 9125, 20, 51, 31, 8, -41 },
  { 9253, 10, 45, 31, 10, -37 },
  { 9310, 21, 51, 31, 4, -41 },
  { 9444, 28, 9, 31, 1, -20 },
};

const GFXfont RobotoMono_LightItalic52pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic52pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic52pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _ROBOTOMONO_LIGHTITALIC52PT7B_H_
