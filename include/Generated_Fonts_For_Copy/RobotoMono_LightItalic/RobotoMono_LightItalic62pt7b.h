#ifndef _ROBOTOMONO_LIGHTITALIC62PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x78, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x38, 0x1C, 0xE0, 0x73, 0x81,
  0xCE, 0x07, 0x38, 0x1C, 0xE0, 0xF7, 0x03, 0x9C, 0x0E, 0x70, 0x39, 0xC0,
  0xE7, 0x03, 0x18, 0x1C, 0xE0, 0x73, 0x81, 0xC0, 0x00, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x38,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x07, 0x00, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00,
  0x3C, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x1C, 0x00,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x38, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x38, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0xF8, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0xE0,
  0x00, 0x0E, 0x07, 0x80, 0x00, 0x38, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x07, 0x81, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0x87, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x07, 0x00,
  0xE0, 0x04, 0x1C, 0x03, 0x80, 0x38, 0xE0, 0x0E, 0x01, 0xE3, 0x80, 0x38,
  0x07, 0x0E, 0x00, 0xE0, 0x38, 0x38, 0x03, 0x81, 0xC0, 0xE0, 0x0E, 0x07,
  0x03, 0x80, 0x70, 0x38, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x0F, 0x0F, 0x00,
  0x70, 0x78, 0x38, 0x01, 0xF7, 0xC1, 0xC0, 0x03, 0xFE, 0x0F, 0x00, 0x07,
  0xF0, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xC0, 0xFC, 0x00, 0x0E, 0x0F, 0xF8, 0x00, 0x78, 0x7C,
  0xF0, 0x01, 0xC3, 0xC1, 0xE0, 0x0E, 0x0E, 0x03, 0x80, 0x70, 0x70, 0x0E,
  0x03, 0xC1, 0xC0, 0x18, 0x0E, 0x07, 0x00, 0x60, 0x70, 0x38, 0x03, 0x83,
  0xC0, 0xE0, 0x0E, 0x0E, 0x03, 0x80, 0x38, 0x70, 0x0E, 0x00, 0xE3, 0x80,
  0x38, 0x03, 0x86, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x78, 0x01,
  0xE0, 0x00, 0x70, 0x01, 0xC0, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0xF0, 0x01,
  0xC0, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xF0, 0x07,
  0x80, 0x00, 0x70, 0x1F, 0x00, 0x00, 0x70, 0x3E, 0x00, 0x00, 0x78, 0x7C,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x07, 0xC3, 0xC0,
  0x0F, 0x0F, 0x81, 0xC0, 0x0E, 0x0F, 0x01, 0xE0, 0x0E, 0x1E, 0x00, 0xF0,
  0x0E, 0x3C, 0x00, 0xF0, 0x1E, 0x3C, 0x00, 0x78, 0x1C, 0x78, 0x00, 0x3C,
  0x3C, 0x78, 0x00, 0x3C, 0x3C, 0x78, 0x00, 0x1E, 0x78, 0x70, 0x00, 0x1E,
  0x78, 0x70, 0x00, 0x0F, 0xF0, 0x70, 0x00, 0x07, 0xE0, 0x78, 0x00, 0x07,
  0xC0, 0x78, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x0F, 0xE0, 0x3C, 0x00, 0x3F,
  0xE0, 0x1F, 0x00, 0x7C, 0xF0, 0x0F, 0xFF, 0xF8, 0xF0, 0x07, 0xFF, 0xE0,
  0x78, 0x01, 0xFF, 0x80, 0x3C, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x73, 0xCE,
  0x38, 0xE3, 0x8E, 0x71, 0xC7, 0x1C, 0x73, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x40, 0x0E, 0x00, 0xDF, 0x01, 0xC0, 0x7B, 0xF8, 0x38,
  0x7F, 0x7F, 0xE7, 0x7F, 0xE1, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x07, 0x9E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x1C, 0x00, 0x1E,
  0x03, 0xC0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x7C, 0x00, 0x78,
  0x07, 0x00, 0x0E, 0x00, 0x40, 0x00, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x83, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x3C, 0x1E, 0x1E, 0x0F,
  0x0F, 0x07, 0x07, 0x81, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x39, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x3F, 0x80, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x00, 0x70, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x0E,
  0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0E, 0x1E,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x3C, 0x70, 0x00,
  0x07, 0xE3, 0x80, 0x00, 0x7F, 0x3C, 0x00, 0x07, 0xB9, 0xE0, 0x00, 0x79,
  0xCF, 0x00, 0x0F, 0x9E, 0x70, 0x00, 0xF8, 0xF3, 0x80, 0x0F, 0x07, 0x9C,
  0x00, 0xF0, 0x3D, 0xE0, 0x1F, 0x01, 0xCF, 0x01, 0xF0, 0x0E, 0x78, 0x1E,
  0x00, 0xF3, 0x81, 0xE0, 0x07, 0x9C, 0x3E, 0x00, 0x3C, 0xE3, 0xE0, 0x01,
  0xEF, 0x3C, 0x00, 0x0E, 0x7B, 0xC0, 0x00, 0x73, 0xFC, 0x00, 0x07, 0x9F,
  0xC0, 0x00, 0x3C, 0xF8, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x78, 0x38, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x3C, 0x07, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x00,
  0xF8, 0x07, 0xC0, 0x03, 0xFB, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x0F,
  0xE0, 0x1F, 0xF0, 0x7F, 0xF0, 0xFF, 0x39, 0xFC, 0x1C, 0xF8, 0x1E, 0xE0,
  0x0F, 0x40, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x03,
  0xC0, 0x03, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0E, 0x03, 0xC0,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0xFC, 0x01, 0xF0,
  0x07, 0xC0, 0x03, 0xC0, 0x3E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x38, 0x1E, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x07,
  0x8E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0x7C,
  0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xDC, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E, 0x0E,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0x00,
  0x01, 0xE0, 0x0E, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x0F,
  0x00, 0x07, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x78, 0x07, 0x00, 0x00, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF0, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x1F, 0xF0, 0x00, 0x1E, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x7F, 0x81, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x07,
  0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x07, 0x00, 0x00, 0xF0,
  0x0E, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x7F, 0x00, 0x1C, 0x3F, 0xF8, 0x07, 0x9F, 0xFF, 0xC0, 0xE7, 0xE1, 0xFC,
  0x1D, 0xE0, 0x07, 0x87, 0xF0, 0x00, 0x78, 0xFC, 0x00, 0x0F, 0x1F, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x3B,
  0xC0, 0x00, 0x07, 0x78, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x73, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xC7, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x81, 0xF0, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xF3, 0xF8, 0x00,
  0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00,
  0xF0, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0,
  0x0E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x00,
  0xFC, 0x3F, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xF0, 0x1F, 0x00, 0x3E, 0x00, 0x1E, 0x01, 0xF0, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x70, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03,
  0x87, 0x80, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0xE3,
  0xC0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xFF, 0x7F,
  0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0x7F, 0x00, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x1F, 0x03, 0xC0, 0x01,
  0xE0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x38, 0xE0,
  0x00, 0x07, 0x3C, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0x78, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3C,
  0xE0, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x7E, 0x7C, 0x00,
  0x1F, 0x87, 0x80, 0x0F, 0x70, 0x7C, 0x03, 0xCE, 0x0F, 0xFF, 0xF3, 0xC0,
  0x7F, 0xFC, 0x70, 0x07, 0xFE, 0x1E, 0x00, 0x0C, 0x03, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0x80, 0xF8,
  0x1F, 0x07, 0xE0, 0x7C, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x07,
  0x81, 0xF8, 0x3F, 0x07, 0xE0, 0x78, 0x00, 0x00, 0x38, 0x01, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x20, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xF8, 0x04, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x1F, 0x80, 0x7C, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x78, 0x00,
  0x0F, 0x78, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0x9F, 0xC0, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x38, 0x07, 0x80,
  0x00, 0x0E, 0x03, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x1F, 0x80, 0x60, 0x70,
  0x1F, 0xF8, 0x1C, 0x3C, 0x0F, 0xDF, 0x07, 0x0E, 0x07, 0x81, 0xC1, 0xC7,
  0x03, 0xC0, 0x60, 0x71, 0xC0, 0xE0, 0x18, 0x1C, 0x60, 0x70, 0x0E, 0x07,
  0x38, 0x1C, 0x03, 0x81, 0xCE, 0x0E, 0x00, 0xC0, 0x77, 0x03, 0x80, 0x30,
  0x19, 0xC0, 0xC0, 0x1C, 0x06, 0x70, 0x70, 0x07, 0x01, 0x98, 0x1C, 0x01,
  0x80, 0x6E, 0x06, 0x00, 0x60, 0x3B, 0x81, 0x80, 0x38, 0x0E, 0xE0, 0xE0,
  0x0E, 0x03, 0x38, 0x38, 0x03, 0x00, 0xCC, 0x0E, 0x01, 0xC0, 0x73, 0x03,
  0x80, 0x70, 0x18, 0xC0, 0xE0, 0x3C, 0x06, 0x30, 0x38, 0x1F, 0x03, 0x0C,
  0x0E, 0x0F, 0xC1, 0xC3, 0x03, 0xC7, 0x70, 0xE0, 0xE0, 0x7F, 0x8F, 0xF8,
  0x38, 0x1F, 0xC3, 0xF8, 0x0E, 0x03, 0xC0, 0x7C, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x10, 0x00, 0x1F, 0x00, 0x18, 0x00, 0x03, 0xFE,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1E,
  0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xC0,
  0xF0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x3C, 0x03,
  0x80, 0x00, 0x70, 0x07, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x1E,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x03, 0x80,
  0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x70, 0x3C,
  0x00, 0x00, 0xE0, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0E, 0x78, 0x00,
  0x00, 0x1C, 0xF0, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x0E, 0x00, 0x3F, 0x80, 0x3C, 0x00, 0x0F, 0x80, 0x78, 0x00,
  0x0F, 0x80, 0xF0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x1E, 0x07, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x0F,
  0x03, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xE0,
  0x3C, 0x00, 0x1F, 0x00, 0x70, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x07, 0xE0, 0x1C,
  0x00, 0x03, 0xE0, 0x38, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x03, 0x83, 0xC0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x0F, 0x0E, 0x00,
  0x00, 0x1E, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0xF0, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0x1E, 0x0E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x0F,
  0xC0, 0xF0, 0x00, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x70,
  0xF0, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x03, 0x8F,
  0x00, 0x00, 0x00, 0x9E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x07, 0x07, 0x80, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x01, 0xF8, 0x00,
  0x3F, 0xBF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x07, 0xE0, 0x01, 0xC0, 0x01, 0xF0,
  0x01, 0xC0, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07,
  0x07, 0x80, 0x00, 0x07, 0x07, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x0F,
  0x0E, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x01, 0xE0,
  0x38, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x0F, 0x80,
  0x78, 0x00, 0x1F, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x70, 0x03, 0xFC, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xC0, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0E,
  0x0F, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFC, 0x70, 0x00, 0xFF, 0xF8,
  0x70, 0x00, 0xFF, 0xF8, 0xF0, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x38,
  0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x70, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x0E, 0x03, 0xC0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x00, 0x78, 0x0E, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0xE0,
  0x3C, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x78, 0x0F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x00,
  0x00, 0xF0, 0x1C, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x0F, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x1E, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x0E,
  0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0xFC, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x3C, 0x00,
  0x00, 0xF8, 0x07, 0x80, 0x00, 0x3E, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x1C,
  0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0x80, 0x03, 0xE0, 0x00, 0x70, 0x00, 0xF8,
  0x00, 0x0E, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0x78, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x3E, 0x00, 0x00, 0x38,
  0x0F, 0x80, 0x00, 0x07, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x00,
  0x3C, 0x3E, 0x00, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x00, 0xE3, 0xF0, 0x00,
  0x00, 0x1C, 0xFE, 0x00, 0x00, 0x07, 0xBD, 0xE0, 0x00, 0x00, 0xFF, 0x3C,
  0x00, 0x00, 0x1F, 0xC3, 0xC0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0x7C,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x1C, 0x00, 0x01, 0xF0, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x0E,
  0xE0, 0x01, 0xEE, 0x03, 0xB8, 0x00, 0x7B, 0x80, 0xEF, 0x00, 0x3D, 0xE0,
  0x39, 0xC0, 0x0E, 0x78, 0x1E, 0x70, 0x07, 0x9C, 0x07, 0x9C, 0x01, 0xC7,
  0x01, 0xC7, 0x00, 0xF1, 0xC0, 0x71, 0xC0, 0x38, 0xF0, 0x1C, 0x78, 0x1E,
  0x3C, 0x07, 0x0E, 0x07, 0x0E, 0x03, 0xC3, 0x83, 0xC3, 0x80, 0xF0, 0xE0,
  0xE0, 0xE0, 0x38, 0x38, 0x78, 0x38, 0x0E, 0x0E, 0x3C, 0x1E, 0x03, 0x83,
  0xCE, 0x07, 0x81, 0xE0, 0x77, 0x81, 0xC0, 0x78, 0x1D, 0xC0, 0x70, 0x1E,
  0x07, 0xF0, 0x1C, 0x07, 0x01, 0xF8, 0x0F, 0x01, 0xC0, 0x7E, 0x03, 0xC0,
  0x70, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0x38, 0x0F, 0x00, 0xE0, 0x0E,
  0x03, 0xC0, 0x38, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00,
  0x78, 0x0E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x78, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x3C, 0x07, 0x00,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xE0, 0x3C,
  0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00,
  0x38, 0x07, 0xC0, 0x00, 0x0E, 0x03, 0xF0, 0x00, 0x03, 0x80, 0xFE, 0x00,
  0x01, 0xE0, 0x3F, 0x80, 0x00, 0x78, 0x0E, 0xE0, 0x00, 0x1E, 0x03, 0xBC,
  0x00, 0x07, 0x00, 0xE7, 0x00, 0x01, 0xC0, 0x79, 0xC0, 0x00, 0x70, 0x1E,
  0x78, 0x00, 0x3C, 0x07, 0x8E, 0x00, 0x0F, 0x01, 0xC3, 0x80, 0x03, 0xC0,
  0x70, 0xF0, 0x00, 0xE0, 0x1C, 0x1C, 0x00, 0x38, 0x0F, 0x07, 0x80, 0x1E,
  0x03, 0xC1, 0xE0, 0x07, 0x80, 0xF0, 0x38, 0x01, 0xE0, 0x38, 0x0F, 0x00,
  0x78, 0x0E, 0x03, 0xC0, 0x1C, 0x07, 0x80, 0x70, 0x07, 0x01, 0xE0, 0x1E,
  0x03, 0xC0, 0x78, 0x03, 0x80, 0xF0, 0x1E, 0x00, 0xE0, 0x3C, 0x07, 0x00,
  0x3C, 0x0E, 0x01, 0xC0, 0x07, 0x03, 0x80, 0xF0, 0x01, 0xC0, 0xE0, 0x3C,
  0x00, 0x78, 0x78, 0x0F, 0x00, 0x0E, 0x1E, 0x03, 0x80, 0x03, 0xC7, 0x80,
  0xE0, 0x00, 0xF1, 0xC0, 0x38, 0x00, 0x1C, 0x70, 0x1E, 0x00, 0x07, 0x9C,
  0x07, 0x80, 0x01, 0xEF, 0x01, 0xE0, 0x00, 0x3B, 0xC0, 0x70, 0x00, 0x0F,
  0xF0, 0x1C, 0x00, 0x01, 0xF8, 0x07, 0x00, 0x00, 0x7E, 0x03, 0xC0, 0x00,
  0x1F, 0x80, 0xF0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0xF8, 0x0E, 0x00,
  0x00, 0x3E, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFC,
  0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x3E, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x1C, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03,
  0x87, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x0F, 0x70, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x03, 0xCE,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xE3, 0x80,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x07, 0x81, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x0E, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x3C, 0x00, 0x1F, 0x80, 0x1E, 0x00, 0x03, 0xE0, 0x0E, 0x00, 0x00,
  0xF0, 0x07, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x07, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x00, 0xF0, 0x38, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x38, 0x1E, 0x00,
  0x00, 0x1C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x03, 0x80,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x0F, 0x80, 0xF0,
  0x00, 0x0F, 0x80, 0x78, 0x00, 0x1F, 0x80, 0x38, 0x00, 0x7F, 0x80, 0x1F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x1C, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x0E, 0x3C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x38, 0x00,
  0x00, 0x0F, 0x38, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x0E, 0x78, 0x00,
  0x00, 0x0E, 0x78, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1E, 0x70, 0x00,
  0x00, 0x1E, 0x70, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1C, 0xF0, 0x00,
  0x00, 0x1C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x38, 0xF0, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x00, 0x70, 0xF0, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0xF0, 0x70, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x18, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0E, 0x00,
  0x1F, 0x80, 0x1C, 0x00, 0x0F, 0x80, 0x38, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x1E, 0x07, 0x00, 0x00,
  0x3C, 0x0E, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x70, 0x78, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x3E, 0x01, 0xC0, 0x00, 0xF8, 0x03,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x70, 0x01, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0x0F, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x00, 0x78, 0x0E, 0x00, 0x00,
  0xF0, 0x1C, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x00,
  0x7C, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0xC0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0x0F, 0x07, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0x70, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x3F,
  0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x07, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x0E,
  0x0F, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1E,
  0x0E, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1C,
  0x1E, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x3C,
  0x1C, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x38,
  0x3C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x78,
  0x38, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x70,
  0x78, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0xF0,
  0x70, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0xE0,
  0xF0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0xF1, 0xC0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x1E, 0x1C, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x38, 0x1E, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x3C,
  0x03, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0x78, 0x01, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0x80,
  0x38, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x3C,
  0x00, 0x03, 0x80, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x1C, 0x78, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07,
  0xB8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x07, 0xB8, 0x01, 0xE0,
  0x03, 0xBC, 0x00, 0xF0, 0x01, 0xDE, 0x00, 0x78, 0x01, 0xEF, 0x00, 0x7C,
  0x00, 0xE7, 0x80, 0x3E, 0x00, 0x73, 0xC0, 0x1F, 0x00, 0x79, 0xE0, 0x1F,
  0x80, 0x38, 0xF0, 0x0E, 0xC0, 0x1C, 0x78, 0x07, 0x60, 0x0E, 0x3C, 0x07,
  0xB0, 0x0F, 0x1E, 0x03, 0x98, 0x07, 0x0F, 0x01, 0xCC, 0x03, 0x87, 0x81,
  0xE7, 0x03, 0xC3, 0xC0, 0xE3, 0x81, 0xC1, 0xE0, 0x71, 0xC0, 0xE0, 0xE0,
  0x78, 0xE0, 0x70, 0x70, 0x38, 0x70, 0x78, 0x38, 0x1C, 0x38, 0x38, 0x1C,
  0x1E, 0x1C, 0x1C, 0x0E, 0x0E, 0x0E, 0x1E, 0x07, 0x07, 0x07, 0x0E, 0x03,
  0x87, 0x83, 0x87, 0x01, 0xC3, 0x81, 0xC3, 0x80, 0xE1, 0xC0, 0xE3, 0xC0,
  0x71, 0xE0, 0x71, 0xC0, 0x38, 0xE0, 0x38, 0xE0, 0x1C, 0x70, 0x1C, 0xF0,
  0x0E, 0x78, 0x0E, 0x70, 0x07, 0x38, 0x07, 0x38, 0x03, 0x9C, 0x03, 0x9C,
  0x01, 0xDC, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x77,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F,
  0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00,
  0x78, 0xE0, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x07, 0x00,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1F, 0x07, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xE0, 0x1C, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0,
  0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xC0, 0x1E, 0x00, 0x03, 0x80,
  0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x0E, 0x0F,
  0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x39, 0xE0,
  0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3F, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x77, 0x00, 0x03, 0xDC, 0x00, 0x0E, 0x78, 0x00, 0x78,
  0xE0, 0x01, 0xC3, 0x80, 0x0F, 0x0E, 0x00, 0x78, 0x38, 0x01, 0xC0, 0xF0,
  0x0F, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x1C, 0x07, 0x00, 0x78, 0x3C,
  0x00, 0xE1, 0xE0, 0x03, 0x87, 0x00, 0x0E, 0x3C, 0x00, 0x38, 0xE0, 0x00,
  0xF7, 0x80, 0x01, 0xFC, 0x00, 0x07, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x78, 0x78, 0x3C, 0x1C, 0x1E, 0x0E,
  0x07, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x0E, 0x07, 0x80,
  0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0E, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0xFE, 0x00, 0x1E, 0x1F, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x1C, 0x3C,
  0x00, 0x01, 0xC7, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x87,
  0x00, 0x01, 0xF8, 0x78, 0x00, 0x7B, 0x87, 0xE0, 0x1F, 0x38, 0x3F, 0xFF,
  0xE7, 0x81, 0xFF, 0xFC, 0x78, 0x07, 0xFE, 0x07, 0x80, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x83, 0xFC, 0x00, 0x78, 0xFF, 0xF0, 0x07, 0x3F, 0xFF, 0x80,
  0x77, 0xC0, 0x7C, 0x07, 0xF0, 0x03, 0xE0, 0xFC, 0x00, 0x1E, 0x0F, 0x80,
  0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x71, 0xE0,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x73, 0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0F, 0x38,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x1E, 0x38, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x3C, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x78, 0x7C, 0x00, 0x07, 0x87,
  0xC0, 0x00, 0xF0, 0xFE, 0x00, 0x3E, 0x0F, 0x78, 0x07, 0xE0, 0xF7, 0xFF,
  0xF8, 0x0E, 0x1F, 0xFF, 0x00, 0xE0, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0x80, 0xF8, 0x03, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0xF3, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x70, 0x00, 0x03, 0x87, 0x80, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x03, 0xC0,
  0x01, 0xF0, 0x3C, 0x00, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x0F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xFC, 0x1E, 0x00, 0x3F, 0xFE,
  0x3C, 0x01, 0xFF, 0xFE, 0x70, 0x07, 0xE0, 0x3E, 0xE0, 0x1F, 0x00, 0x1F,
  0xC0, 0x3C, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x3E,
  0x07, 0x80, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07, 0x03, 0xC0,
  0x00, 0x0E, 0x07, 0x80, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0xF0, 0x1C, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0xF0, 0x01, 0xFC, 0x01, 0xF0, 0x0F,
  0xF8, 0x01, 0xFF, 0xFE, 0xF0, 0x01, 0xFF, 0xF1, 0xC0, 0x00, 0xFF, 0xC3,
  0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0xF8, 0x03, 0xE0, 0x03, 0xC0, 0x7C,
  0x00, 0x1C, 0x0F, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x0E, 0x1E, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0x78,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x02, 0x03, 0xC0, 0x00, 0x78, 0x3E, 0x00, 0x0F, 0x01, 0xF0,
  0x03, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x1E, 0x00, 0x3F, 0xFE, 0x3C, 0x01, 0xFF, 0xFE, 0x70, 0x07, 0xE0,
  0x3E, 0xE0, 0x1F, 0x00, 0x1F, 0xC0, 0x3C, 0x00, 0x1F, 0x80, 0xF0, 0x00,
  0x1F, 0x03, 0xC0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x38, 0x1E, 0x00, 0x00,
  0x70, 0x3C, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38,
  0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x1C, 0x0F,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x01, 0xE0, 0x38,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0xF0,
  0x01, 0xFC, 0x01, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0xFE, 0xF0, 0x01, 0xFF,
  0xF9, 0xC0, 0x00, 0xFF, 0xC3, 0x80, 0x00, 0x30, 0x07, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x08, 0x00, 0x07, 0x80, 0x30, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x07, 0xFC, 0x00, 0xE0, 0xFF, 0xF0, 0x07, 0x1F, 0xFF, 0xC0, 0x39,
  0xF0, 0x1F, 0x03, 0xDE, 0x00, 0x78, 0x1F, 0xC0, 0x01, 0xE0, 0xEC, 0x00,
  0x0F, 0x07, 0xC0, 0x00, 0x38, 0x3C, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x0E,
  0x1E, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0F,
  0x0E, 0x00, 0x00, 0x78, 0x70, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0xE1, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x78, 0x70, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x10, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x07, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x81, 0xC0, 0x00, 0x7C,
  0x07, 0x80, 0x01, 0xF0, 0x0F, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x1F, 0x00,
  0x3C, 0x00, 0xFC, 0x00, 0x70, 0x03, 0xE0, 0x00, 0xE0, 0x0F, 0x80, 0x03,
  0xC0, 0x3E, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x1E,
  0x1F, 0x00, 0x00, 0x38, 0x7C, 0x00, 0x00, 0x71, 0xF0, 0x00, 0x01, 0xE7,
  0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xE7,
  0x80, 0x00, 0x1F, 0x87, 0x80, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0xF0, 0x0F,
  0x00, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x78, 0x03, 0x80, 0x00, 0x78,
  0x07, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x8F,
  0xF0, 0x3F, 0x80, 0x39, 0xFF, 0x8F, 0xFC, 0x03, 0xBF, 0xF9, 0xFF, 0xE0,
  0x3F, 0x07, 0xFC, 0x1E, 0x07, 0xE0, 0x3F, 0x00, 0xE0, 0x7C, 0x03, 0xE0,
  0x0F, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x70, 0x01, 0xC0, 0x0F, 0x07, 0x00,
  0x3C, 0x00, 0xF0, 0x70, 0x03, 0xC0, 0x0E, 0x0F, 0x00, 0x38, 0x00, 0xE0,
  0xF0, 0x03, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x80,
  0x1E, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0xE0, 0x07, 0x80, 0x1C, 0x1E, 0x00,
  0x70, 0x01, 0xC1, 0xE0, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x03, 0xC1,
  0xC0, 0x07, 0x00, 0x3C, 0x1C, 0x00, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x00,
  0x38, 0x3C, 0x00, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x00, 0x38, 0x38, 0x00,
  0xE0, 0x07, 0x83, 0x80, 0x0E, 0x00, 0x78, 0x38, 0x01, 0xE0, 0x07, 0x07,
  0x80, 0x1E, 0x00, 0x70, 0x78, 0x01, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x70, 0x01, 0xC0, 0x0F, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0xF0, 0x03,
  0xC0, 0x0E, 0x00, 0x07, 0x01, 0xFF, 0x00, 0x38, 0x3F, 0xFC, 0x01, 0xC7,
  0xFF, 0xF0, 0x0E, 0x7C, 0x07, 0xC0, 0xF7, 0x80, 0x1E, 0x07, 0xF0, 0x00,
  0x78, 0x3F, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x70,
  0x78, 0x00, 0x03, 0x87, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xE1, 0xE0,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x78, 0x70, 0x00, 0x03, 0xC3, 0x80, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x07, 0x0F, 0x00, 0x00, 0x38, 0x78, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x1E, 0x1C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x38,
  0x78, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xF0, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xE0, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0xF0, 0x3E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x03, 0xBC, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x1E, 0x0E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xF0,
  0x0F, 0x80, 0x3F, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0xFF, 0x80, 0x01,
  0xC7, 0xFF, 0xC0, 0x03, 0x9F, 0xFF, 0xC0, 0x07, 0x7C, 0x0F, 0xC0, 0x0F,
  0xE0, 0x07, 0xC0, 0x3F, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x3C, 0x07, 0x00,
  0x00, 0x38, 0x1E, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0xE0, 0x78, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x07, 0x07, 0x80, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00,
  0xF0, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x01, 0xFC, 0x00, 0x7C, 0x03,
  0xFC, 0x01, 0xF0, 0x07, 0xBF, 0xFF, 0xC0, 0x0F, 0x3F, 0xFF, 0x00, 0x1C,
  0x1F, 0xF8, 0x00, 0x38, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x78, 0x03, 0xFF,
  0xE3, 0xC0, 0x7F, 0xFF, 0x9C, 0x07, 0xE0, 0x3E, 0xE0, 0x7C, 0x00, 0x7F,
  0x03, 0xC0, 0x01, 0xF8, 0x3C, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3E, 0x1E,
  0x00, 0x00, 0xE1, 0xE0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x78, 0x70, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x38, 0x78, 0x00,
  0x01, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07,
  0x83, 0x80, 0x00, 0x38, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3E, 0x03,
  0xC0, 0x07, 0xF0, 0x1F, 0x00, 0x7F, 0x80, 0x7F, 0xFF, 0xBC, 0x01, 0xFF,
  0xF9, 0xC0, 0x03, 0xFF, 0x0E, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x7F, 0xE0, 0x70, 0x7F, 0xFC,
  0x0E, 0x1F, 0xFF, 0x81, 0xCF, 0xE0, 0x20, 0x7B, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0xFC, 0x07,
  0xC0, 0x03, 0xE0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0xE0, 0x00,
  0x0F, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x78, 0x7C,
  0x00, 0x0F, 0x03, 0xE0, 0x03, 0xF0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0xE3, 0xC0, 0x00, 0x0E, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E,
  0x3C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC7, 0x80,
  0x00, 0x3C, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C, 0x70, 0x00, 0x03,
  0xC7, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0F, 0x0E,
  0x00, 0x01, 0xF0, 0xF0, 0x00, 0x3F, 0x0F, 0x00, 0x07, 0xE0, 0x78, 0x00,
  0xEE, 0x07, 0xC0, 0x3E, 0xE0, 0x3F, 0xFF, 0x9E, 0x01, 0xFF, 0xF1, 0xE0,
  0x0F, 0xFC, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3D, 0xC0,
  0x00, 0x00, 0xE7, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0xF0, 0x1C, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x70,
  0x07, 0x80, 0x03, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x07, 0x00, 0x78, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x70, 0x0F, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x03, 0x81,
  0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0xF0, 0xE0,
  0x00, 0x01, 0xC7, 0x80, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x01, 0xC0, 0x03, 0xF8, 0x00, 0xE0, 0x03, 0xFC, 0x00, 0x70, 0x01, 0xCE,
  0x00, 0x78, 0x00, 0xE7, 0x00, 0x3C, 0x00, 0xF3, 0x80, 0x3E, 0x00, 0x71,
  0xC0, 0x1F, 0x00, 0x38, 0xE0, 0x1D, 0xC0, 0x38, 0x70, 0x0E, 0xE0, 0x1C,
  0x38, 0x07, 0x70, 0x1E, 0x1C, 0x07, 0x38, 0x0E, 0x0E, 0x03, 0x9C, 0x07,
  0x07, 0x03, 0x8E, 0x07, 0x03, 0x81, 0xC7, 0x03, 0x81, 0xC0, 0xC3, 0x81,
  0xC0, 0xE0, 0xE1, 0xC1, 0xC0, 0x70, 0x70, 0xE0, 0xE0, 0x38, 0x70, 0x70,
  0xF0, 0x1C, 0x38, 0x18, 0x70, 0x0E, 0x38, 0x0C, 0x38, 0x07, 0x1C, 0x06,
  0x38, 0x03, 0x8E, 0x03, 0x1C, 0x01, 0xCE, 0x01, 0xCE, 0x00, 0xE7, 0x00,
  0xEE, 0x00, 0x77, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x3B, 0x00, 0x1D, 0x80,
  0x1F, 0x80, 0x07, 0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x01, 0xE0,
  0x03, 0xE0, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x03,
  0xE0, 0x1E, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00,
  0xF0, 0xF8, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x07, 0xBE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x0F, 0x8F,
  0x00, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x00, 0x78, 0x03,
  0xE0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x01, 0xE1, 0xC0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0x39, 0xE0,
  0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x70, 0xFF, 0xF0, 0x00, 0x1C,
  0x7E, 0xFE, 0x00, 0x0E, 0x3C, 0x07, 0xC0, 0x03, 0x9E, 0x00, 0xF8, 0x01,
  0xE7, 0x00, 0x0F, 0x00, 0xF1, 0xC0, 0x01, 0xF0, 0x7C, 0xE0, 0x00, 0x3F,
  0xFE, 0x38, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00,
};

const GFXglyph RobotoMono_LightItalic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 36, 0, -1 },
  { 1, 12, 44, 36, 12, -44 },
  { 67, 14, 14, 36, 14, -47 },
  { 92, 36, 44, 36, 1, -44 },
  { 290, 30, 57, 36, 4, -51 },
  { 504, 30, 46, 36, 4, -45 },
  { 677, 32, 46, 36, 2, -45 },
  { 861, 6, 14, 36, 17, -47 },
  { 872, 20, 63, 36, 10, -49 },
  { 1030, 20, 63, 36, 5, -49 },
  { 1188, 27, 27, 36, 8, -44 },
  { 1280, 30, 33, 36, 4, -37 },
  { 1404, 9, 15, 36, 7, -6 },
  { 1421, 22, 3, 36, 7, -21 },
  { 1430, 6, 6, 36, 13, -6 },
  { 1435, 30, 48, 36, 4, -44 },
  { 1615, 29, 46, 36, 4, -45 },
  { 1782, 17, 44, 36, 9, -44 },
  { 1876, 30, 45, 36, 1, -45 },
  { 2045, 30, 46, 36, 2, -45 },
  { 2218, 31, 44, 36, 1, -44 },
  { 2389, 31, 45, 36, 5, -44 },
  { 2564, 27, 45, 36, 4, -44 },
  { 2716, 29, 44, 36, 7, -44 },
  { 2876, 30, 46, 36, 4, -45 },
  { 3049, 27, 45, 36, 6, -45 },
  { 3201, 11, 33, 36, 15, -33 },
  { 3247, 14, 42, 36, 11, -33 },
  { 3321, 28, 26, 36, 5, -33 },
  { 3412, 29, 16, 36, 4, -28 },
  { 3470, 29, 26, 36, 3, -33 },
  { 3565, 24, 45, 36, 9, -45 },
  { 3700, 34, 44, 36, 2, -44 },
  { 3887, 31, 44, 36, 0, -44 },
  { 4058, 31, 44, 36, 3, -44 },
  { 4229, 31, 46, 36, 4, -45 },
  { 4408, 32, 44, 36, 2, -44 },
  { 4584, 33, 44, 36, 3, -44 },
  { 4766, 33, 44, 36, 3, -44 },
  { 4948, 32, 46, 36, 3, -45 },
  { 5132, 34, 44, 36, 2, -44 },
  { 5319, 32, 44, 36, 3, -44 },
  { 5495, 33, 45, 36, 2, -44 },
  { 5681, 35, 44, 36, 3, -44 },
  { 5874, 26, 44, 36, 3, -44 },
  { 6017, 34, 44, 36, 2, -44 },
  { 6204, 34, 44, 36, 2, -44 },
  { 6391, 30, 46, 36, 4, -45 },
  { 6564, 33, 44, 36, 3, -44 },
  { 6746, 32, 53, 36, 3, -45 },
  { 6958, 31, 44, 36, 3, -44 },
  { 7129, 32, 46, 36, 3, -45 },
  { 7313, 31, 44, 36, 7, -44 },
  { 7484, 32, 45, 36, 4, -44 },
  { 7664, 30, 44, 36, 7, -44 },
  { 7829, 33, 44, 36, 6, -44 },
  { 8011, 38, 44, 36, 0, -44 },
  { 8220, 31, 44, 36, 7, -44 },
  { 8391, 33, 44, 36, 1, -44 },
  { 8573, 19, 59, 36, 9, -50 },
  { 8714, 13, 48, 36, 12, -44 },
  { 8792, 20, 59, 36, 8, -50 },
  { 8940, 22, 24, 36, 7, -44 },
  { 9006, 27, 3, 36, 1, 0 },
  { 9017, 8, 8, 36, 18, -45 },
  { 9025, 28, 34, 36, 3, -33 },
  { 9144, 28, 48, 36, 3, -47 },
  { 9312, 28, 34, 36, 4, -33 },
  { 9431, 31, 48, 36, 4, -47 },
  { 9617, 28, 34, 36, 4, -33 },
  { 9736, 31, 48, 36, 7, -48 },
  { 9922, 31, 46, 36, 2, -33 },
  { 10101, 29, 47, 36, 3, -47 },
  { 10272, 26, 45, 36, 3, -45 },
  { 10419, 29, 58, 36, 0, -45 },
  { 10630, 31, 47, 36, 3, -47 },
  { 10813, 26, 47, 36, 3, -47 },
  { 10966, 36, 33, 36, -1, -33 },
  { 11115, 29, 33, 36, 3, -33 },
  { 11235, 29, 34, 36, 3, -33 },
  { 11359, 31, 46, 36, 0, -33 },
  { 11538, 29, 46, 36, 4, -33 },
  { 11705, 27, 33, 36, 7, -33 },
  { 11817, 28, 34, 36, 4, -33 },
  { 11936, 25, 42, 36, 7, -41 },
  { 12068, 28, 34, 36, 5, -33 },
  { 12187, 30, 33, 36, 5, -33 },
  { 12311, 33, 33, 36, 4, -33 },
  { 12448, 34, 33, 36, 1, -33 },
  { 12589, 37, 46, 36, -1, -33 },
  { 12802, 31, 33, 36, 2, -33 },
  { 12930, 25, 60, 36, 9, -48 },
  { 13118, 12, 54, 36, 12, -44 },
  { 13199, 24, 60, 36, 5, -48 },
  { 13379, 34, 11, 36, 1, -24 },
};

const GFXfont RobotoMono_LightItalic62pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic62pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic62pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _ROBOTOMONO_LIGHTITALIC62PT7B_H_
