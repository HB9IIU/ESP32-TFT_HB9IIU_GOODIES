#ifndef _ROBOTOMONO_LIGHTITALIC64PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC64PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0,
  0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0x38, 0x1C,
  0xE0, 0x77, 0x81, 0xDE, 0x07, 0x70, 0x3D, 0xC0, 0xE7, 0x03, 0x9C, 0x0E,
  0xF0, 0x3B, 0x80, 0xEE, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x07, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x3C, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x03, 0x80, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0x07, 0x00, 0x78, 0x00, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0x07, 0xE0, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x1F, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x08,
  0x38, 0x03, 0x80, 0x38, 0xF0, 0x07, 0x00, 0xE1, 0xC0, 0x0E, 0x03, 0xC3,
  0x80, 0x1C, 0x07, 0x07, 0x00, 0x38, 0x1C, 0x0E, 0x00, 0xE0, 0x78, 0x1C,
  0x01, 0xC0, 0xE0, 0x38, 0x03, 0x83, 0x80, 0x78, 0x0E, 0x0F, 0x00, 0x70,
  0x3C, 0x3C, 0x00, 0xF9, 0xF0, 0x70, 0x00, 0xFF, 0xC1, 0xC0, 0x00, 0xFE,
  0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0xE0, 0xFF, 0x80, 0x03, 0x83,
  0xFF, 0x80, 0x0F, 0x0F, 0x07, 0x80, 0x1C, 0x1C, 0x07, 0x00, 0x70, 0x70,
  0x0E, 0x01, 0xE0, 0xE0, 0x1C, 0x03, 0x83, 0x80, 0x1C, 0x0E, 0x07, 0x00,
  0x38, 0x38, 0x0E, 0x00, 0xE0, 0xF0, 0x1C, 0x01, 0xC1, 0xC0, 0x38, 0x03,
  0x87, 0x00, 0x70, 0x07, 0x1E, 0x00, 0xE0, 0x0E, 0x08, 0x01, 0xC0, 0x38,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x07, 0x8F, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x01, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x0F,
  0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x01, 0xE0,
  0x3E, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x1E,
  0x7C, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x01,
  0xF0, 0x78, 0x01, 0xE1, 0xF0, 0x3E, 0x00, 0xE1, 0xF0, 0x0F, 0x00, 0x70,
  0xF0, 0x03, 0xC0, 0x78, 0xF0, 0x01, 0xE0, 0x3C, 0x78, 0x00, 0x78, 0x1C,
  0x78, 0x00, 0x3E, 0x1E, 0x3C, 0x00, 0x0F, 0x0E, 0x1E, 0x00, 0x03, 0xCF,
  0x0F, 0x00, 0x01, 0xEF, 0x07, 0x80, 0x00, 0x7F, 0x83, 0xC0, 0x00, 0x3F,
  0x81, 0xE0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x0F,
  0xF0, 0x1F, 0x00, 0x0F, 0xF8, 0x07, 0xC0, 0x1F, 0x9E, 0x01, 0xFF, 0xFF,
  0x8F, 0x00, 0x7F, 0xFF, 0x03, 0xC0, 0x0F, 0xFE, 0x01, 0xF0, 0x00, 0x70,
  0x00, 0x00, 0x3C, 0xE3, 0x8E, 0x39, 0xE7, 0x9C, 0x71, 0xC7, 0x38, 0xE3,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x70, 0x06, 0x7C, 0x07, 0x03, 0xEF, 0xF0, 0x60,
  0xFF, 0xFF, 0xCE, 0x7F, 0xE0, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF3,
  0x80, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x3C, 0x1E, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x07, 0xC0,
  0x07, 0xC0, 0x3C, 0x00, 0x38, 0x00, 0x80, 0x03, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x1E, 0x0F, 0x0F, 0x07, 0x87, 0x87, 0x81, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x73, 0xEF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x1F, 0xC0, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x03, 0xC0, 0x01,
  0xE0, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0xC7, 0x80,
  0x00, 0x7F, 0x1C, 0x00, 0x03, 0xDC, 0xF0, 0x00, 0x1E, 0x73, 0xC0, 0x01,
  0xF3, 0xCF, 0x00, 0x0F, 0x8F, 0x3C, 0x00, 0x78, 0x3C, 0xE0, 0x03, 0xC0,
  0xF3, 0x80, 0x3E, 0x03, 0x9E, 0x01, 0xF0, 0x0E, 0x78, 0x0F, 0x00, 0x79,
  0xE0, 0x78, 0x01, 0xE7, 0x87, 0xC0, 0x07, 0x9C, 0x3E, 0x00, 0x1E, 0x71,
  0xE0, 0x00, 0x71, 0xCF, 0x00, 0x01, 0xCF, 0xF8, 0x00, 0x0F, 0x3F, 0xC0,
  0x00, 0x3C, 0xFC, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x1E, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0E,
  0x07, 0x80, 0x00, 0x78, 0x0E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x70, 0x00, 0xFC, 0x00, 0xFF, 0x01, 0xFF, 0x81, 0xFE,
  0xE3, 0xFE, 0x79, 0xFC, 0x1E, 0x7C, 0x07, 0x98, 0x01, 0xE8, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x07,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x0E, 0x03, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x78, 0x38, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xC0,
  0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x3E,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xBC, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x78, 0x01,
  0xE0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x07, 0x80, 0x03, 0xC0, 0x07, 0x00, 0x03,
  0xC0, 0x0F, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x0F, 0xF0,
  0x00, 0x07, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0x7F,
  0x80, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x07, 0xF0, 0x01, 0xC1, 0xFF, 0xC0,
  0x1C, 0x7F, 0xFE, 0x03, 0xDF, 0xC7, 0xF0, 0x3B, 0xE0, 0x0F, 0x83, 0xF8,
  0x00, 0x7C, 0x7F, 0x00, 0x03, 0xC7, 0xE0, 0x00, 0x1E, 0x7C, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0x0E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x07, 0x87, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x1F, 0x01, 0xE0, 0x03, 0xE0,
  0x1F, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x01,
  0xFC, 0x1F, 0x80, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07, 0x03, 0xC0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x78, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x03,
  0xC0, 0x0F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xF8, 0x3F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1C, 0x3C,
  0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x00, 0xE3, 0xC0,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x3F, 0x00, 0x7C, 0x01, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0x83, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x00, 0x3C, 0x0F,
  0x00, 0x03, 0xC1, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x0E, 0x3C, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xE7, 0x80,
  0x00, 0x7E, 0x3C, 0x00, 0x0F, 0xC3, 0xC0, 0x01, 0xDC, 0x1F, 0x00, 0x79,
  0xC1, 0xF8, 0x3F, 0x3C, 0x0F, 0xFF, 0xE3, 0x80, 0x3F, 0xFC, 0x38, 0x00,
  0xFE, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x7C, 0x1F, 0x83,
  0xF0, 0x7E, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x07, 0xC1, 0xFC,
  0x3F, 0x87, 0xE0, 0x7C, 0x00, 0x00, 0x1C, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x40, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF8, 0x08, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x0F, 0xE0, 0xFC, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x1E, 0x7C, 0x00,
  0x1E, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x07, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x0E, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x00, 0x18, 0x0E, 0x00, 0xFC, 0x03, 0x83, 0x80,
  0x7F, 0xE0, 0x70, 0x70, 0x1F, 0x3E, 0x0E, 0x1C, 0x07, 0x81, 0x81, 0xC3,
  0x81, 0xC0, 0x30, 0x38, 0xE0, 0x78, 0x06, 0x07, 0x1C, 0x0E, 0x01, 0xC0,
  0xE7, 0x03, 0x80, 0x30, 0x1C, 0xE0, 0x70, 0x06, 0x03, 0x98, 0x1C, 0x01,
  0xC0, 0x77, 0x03, 0x80, 0x38, 0x0E, 0xE0, 0x70, 0x06, 0x01, 0x9C, 0x1C,
  0x00, 0xC0, 0x33, 0x03, 0x80, 0x38, 0x0E, 0xE0, 0x70, 0x07, 0x01, 0xDC,
  0x0E, 0x00, 0xC0, 0x3B, 0x81, 0x80, 0x18, 0x06, 0x70, 0x70, 0x07, 0x01,
  0xCE, 0x0E, 0x00, 0xE0, 0x39, 0x81, 0xC0, 0x3C, 0x06, 0x30, 0x38, 0x0F,
  0x01, 0xC6, 0x07, 0x03, 0xE0, 0x30, 0xE0, 0x70, 0xEE, 0x0E, 0x1C, 0x0F,
  0x39, 0xC3, 0x83, 0x81, 0xFE, 0x1F, 0xE0, 0x70, 0x1F, 0x83, 0xF8, 0x0E,
  0x00, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x80, 0x00, 0x3E, 0x00, 0x70, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x39, 0xE0,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xF0, 0xE0,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x78, 0x00, 0x38,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x38, 0x01, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x1C,
  0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x0E,
  0x78, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x01, 0xF8, 0x01, 0xC0, 0x00, 0x7C,
  0x03, 0xC0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0E,
  0x03, 0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x7C,
  0x0F, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x03, 0xF0, 0x0F, 0x00, 0x1F, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x1E, 0x00, 0x0F, 0xC0, 0x1E, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x38,
  0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C,
  0x38, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xF0,
  0x70, 0x00, 0x03, 0xE0, 0x70, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x1F, 0x80,
  0xF0, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xF8,
  0x01, 0xF0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x3F, 0x80, 0x0F, 0x00, 0x07,
  0xC0, 0x07, 0x80, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x3C, 0x01, 0xC0, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x3C, 0x0E, 0x00,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0x01, 0xC1, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0x87, 0x00, 0x00, 0x03, 0x87,
  0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x1F,
  0x80, 0x3C, 0x00, 0x3F, 0x80, 0x1C, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x02,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x07,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78,
  0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x7F,
  0xFE, 0x3C, 0x00, 0x3F, 0xFF, 0x1C, 0x00, 0x3F, 0xFF, 0x0E, 0x00, 0x1F,
  0xFF, 0x87, 0x00, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0x1C, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x07, 0x81, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xC0, 0x78,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x01, 0xF0, 0x03,
  0xF0, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0x00, 0xF0, 0x1C, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x03, 0x80, 0xF0,
  0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x78, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x0F, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x38, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x00, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x1E, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x0E, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x70, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0xC0, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x10, 0x0E, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x1E, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x01, 0xC0, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x07,
  0xC0, 0x00, 0x38, 0x00, 0xF8, 0x00, 0x03, 0x80, 0x1F, 0x00, 0x00, 0x78,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00,
  0x07, 0x81, 0xF0, 0x00, 0x00, 0x70, 0x3E, 0x00, 0x00, 0x07, 0x07, 0xC0,
  0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x00, 0xF3,
  0xF0, 0x00, 0x00, 0x0F, 0x7F, 0x80, 0x00, 0x00, 0xEF, 0xF8, 0x00, 0x00,
  0x0F, 0xF3, 0xC0, 0x00, 0x01, 0xFE, 0x3C, 0x00, 0x00, 0x1F, 0xC1, 0xE0,
  0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x0F, 0x80, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0x03, 0xE0, 0x07, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x3E,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x1F, 0x80, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x3D, 0xC0, 0x3D, 0xC0, 0x03, 0x9C,
  0x03, 0x9C, 0x00, 0x7B, 0xC0, 0x39, 0xC0, 0x07, 0x3C, 0x03, 0x9C, 0x00,
  0xF3, 0x80, 0x79, 0xE0, 0x0E, 0x38, 0x07, 0x8E, 0x01, 0xE3, 0x80, 0x78,
  0xE0, 0x3C, 0x78, 0x07, 0x0E, 0x03, 0xC7, 0x80, 0x70, 0xE0, 0x78, 0x78,
  0x07, 0x0E, 0x07, 0x87, 0x00, 0xF0, 0xF0, 0xF0, 0x70, 0x0F, 0x07, 0x0E,
  0x07, 0x00, 0xF0, 0x71, 0xE0, 0xF0, 0x0E, 0x07, 0x1C, 0x0F, 0x00, 0xE0,
  0x73, 0xC0, 0xF0, 0x0E, 0x07, 0x38, 0x0E, 0x01, 0xE0, 0x7F, 0x80, 0xE0,
  0x1E, 0x03, 0xF0, 0x1E, 0x01, 0xE0, 0x3F, 0x01, 0xE0, 0x1C, 0x03, 0xE0,
  0x1E, 0x01, 0xC0, 0x3E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x1C, 0x03, 0xC0,
  0x38, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x38, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00,
  0x38, 0x07, 0x80, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x07, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0xF0,
  0x1F, 0x00, 0x00, 0x1C, 0x03, 0xF0, 0x00, 0x03, 0x80, 0xFE, 0x00, 0x00,
  0xF0, 0x1F, 0xE0, 0x00, 0x1E, 0x03, 0xFC, 0x00, 0x03, 0xC0, 0x7B, 0x80,
  0x00, 0x78, 0x0E, 0x78, 0x00, 0x0E, 0x01, 0xCF, 0x00, 0x03, 0xC0, 0x78,
  0xE0, 0x00, 0x78, 0x0F, 0x1E, 0x00, 0x0F, 0x01, 0xE3, 0xC0, 0x01, 0xE0,
  0x3C, 0x38, 0x00, 0x38, 0x07, 0x07, 0x80, 0x07, 0x00, 0xE0, 0xF0, 0x01,
  0xE0, 0x3C, 0x0E, 0x00, 0x3C, 0x07, 0x81, 0xE0, 0x07, 0x80, 0xF0, 0x1C,
  0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x1C, 0x03, 0x80, 0x78, 0x03, 0x80, 0x70,
  0x07, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x1E, 0x03, 0xC0,
  0x78, 0x01, 0xC0, 0x78, 0x0F, 0x00, 0x3C, 0x0E, 0x01, 0xC0, 0x07, 0x81,
  0xC0, 0x78, 0x00, 0x70, 0x78, 0x0F, 0x00, 0x0F, 0x0F, 0x01, 0xE0, 0x01,
  0xE1, 0xE0, 0x3C, 0x00, 0x1C, 0x3C, 0x07, 0x00, 0x03, 0xC7, 0x00, 0xE0,
  0x00, 0x39, 0xE0, 0x3C, 0x00, 0x07, 0xBC, 0x07, 0x80, 0x00, 0xF7, 0x80,
  0xF0, 0x00, 0x0E, 0xF0, 0x1E, 0x00, 0x01, 0xFC, 0x03, 0x80, 0x00, 0x3F,
  0x80, 0x70, 0x00, 0x03, 0xF0, 0x1E, 0x00, 0x00, 0x7E, 0x03, 0xC0, 0x00,
  0x0F, 0xC0, 0x78, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x1E, 0x70, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x01, 0xEE, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x0F,
  0x38, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xF1,
  0xC0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0,
  0x01, 0xE0, 0x00, 0x7E, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x70, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x3C, 0x0E,
  0x00, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x1E,
  0x01, 0xC0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x1F,
  0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x07, 0xF8, 0x7F, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0,
  0x07, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0E,
  0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00,
  0xE0, 0xF0, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0x1E, 0x38, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x03, 0xCE, 0x00, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x00, 0xE7, 0x80, 0x00,
  0x00, 0x73, 0xC0, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x1E, 0x70, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x03, 0x9E, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x0E,
  0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x38, 0xF8,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x0F, 0x00, 0x03, 0xE0, 0x07, 0x00, 0x00, 0x78, 0x03,
  0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x0F, 0x80, 0x1C, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xC0, 0x07,
  0x80, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0xF0, 0x03, 0x80,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0xF0, 0x1C,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x78, 0x07, 0xC0, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0x81, 0xE0, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x03, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x83, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xE0,
  0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x38, 0x3C,
  0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0x07, 0x83, 0x80, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x01, 0xC1,
  0xE0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78,
  0x38, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0E,
  0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03,
  0xC1, 0xC0, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00,
  0x70, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x1E, 0x0E, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x07, 0x07, 0x80, 0x00,
  0x03, 0x83, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x07, 0x03, 0xC0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x07, 0x07, 0x80, 0x00,
  0x07, 0x0F, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x07, 0x8E, 0x00, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xDC, 0x00, 0x78, 0x00,
  0xF7, 0x00, 0x1E, 0x00, 0x39, 0xC0, 0x07, 0x80, 0x0E, 0x70, 0x03, 0xE0,
  0x07, 0x9C, 0x00, 0xF8, 0x01, 0xC7, 0x00, 0x3E, 0x00, 0x71, 0xC0, 0x1F,
  0x80, 0x3C, 0x70, 0x07, 0xE0, 0x0F, 0x1C, 0x01, 0xF8, 0x03, 0x87, 0x00,
  0xFE, 0x00, 0xE1, 0xC0, 0x3B, 0x80, 0x78, 0x70, 0x0E, 0xE0, 0x1C, 0x3C,
  0x07, 0xB8, 0x07, 0x0F, 0x01, 0xCE, 0x03, 0xC3, 0xC0, 0x73, 0x80, 0xF0,
  0xF0, 0x3C, 0xE0, 0x38, 0x3C, 0x0E, 0x38, 0x0E, 0x0F, 0x03, 0x8E, 0x07,
  0x83, 0xC1, 0xC3, 0x81, 0xC0, 0xF0, 0x70, 0xE0, 0x70, 0x3C, 0x1C, 0x38,
  0x3C, 0x0F, 0x0E, 0x0F, 0x0E, 0x03, 0xC3, 0x83, 0xC3, 0x80, 0xF0, 0xE0,
  0x70, 0xE0, 0x3C, 0x70, 0x1C, 0x78, 0x0F, 0x1C, 0x07, 0x1C, 0x03, 0xC7,
  0x01, 0xC7, 0x00, 0xF3, 0x80, 0x73, 0xC0, 0x38, 0xE0, 0x1C, 0xE0, 0x0E,
  0x78, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x77, 0x80,
  0x3B, 0xC0, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x01, 0xFC,
  0x00, 0xEE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3E, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0xE0,
  0xF8, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x00, 0x7C, 0x70, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x1F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01,
  0xE0, 0x1C, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x07,
  0x80, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x03, 0x80, 0xF0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xF0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x77, 0x00, 0x03, 0xDC, 0x00, 0x0E,
  0x70, 0x00, 0x79, 0xC0, 0x01, 0xC7, 0x80, 0x0F, 0x0E, 0x00, 0x38, 0x38,
  0x01, 0xE0, 0xE0, 0x0F, 0x03, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x1C, 0x07,
  0x00, 0x70, 0x3C, 0x01, 0xC1, 0xE0, 0x07, 0x87, 0x80, 0x0E, 0x3C, 0x00,
  0x38, 0xE0, 0x00, 0xE7, 0x80, 0x03, 0xDC, 0x00, 0x0F, 0xF0, 0x00, 0x1C,
  0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8,
  0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0E, 0x03, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xF0, 0x07,
  0xC0, 0x3E, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0x08, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0,
  0x3F, 0xE0, 0x07, 0x83, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x0E, 0x3E, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00,
  0x3C, 0x70, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xF1,
  0xE0, 0x00, 0x1F, 0x87, 0x80, 0x01, 0xFC, 0x3E, 0x00, 0x1F, 0xE0, 0xF8,
  0x07, 0xEF, 0x07, 0xFF, 0xFE, 0x78, 0x0F, 0xFF, 0xC3, 0xC0, 0x3F, 0xF8,
  0x1E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x3F,
  0xE0, 0x01, 0xE3, 0xFF, 0xE0, 0x07, 0x9F, 0xFF, 0xC0, 0x1E, 0xF8, 0x1F,
  0x80, 0x77, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0xF0,
  0x3E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x87, 0x80,
  0x00, 0x0E, 0x1E, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0xE1, 0xE0, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0xF0,
  0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x03, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0xF8, 0x1F, 0xC0,
  0x07, 0xC0, 0xF7, 0x80, 0x7E, 0x03, 0xCF, 0xFF, 0xF0, 0x0F, 0x1F, 0xFF,
  0x80, 0x38, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x23, 0x80, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x07, 0x83, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x7C, 0x03, 0xE0, 0x0F, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xF8, 0x3C, 0x00, 0x7F, 0xFC, 0x3C,
  0x00, 0xFF, 0xFF, 0x38, 0x01, 0xF8, 0x0F, 0x78, 0x03, 0xE0, 0x03, 0xF8,
  0x07, 0xC0, 0x01, 0xF8, 0x0F, 0x80, 0x01, 0xF8, 0x0F, 0x00, 0x00, 0xF8,
  0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xC0,
  0xF0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x03, 0x80,
  0x78, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x1F, 0x80,
  0x3E, 0x00, 0x3F, 0x80, 0x1F, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xE7, 0x00,
  0x07, 0xFF, 0xC7, 0x00, 0x03, 0xFF, 0x07, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xF0, 0x0F, 0x80, 0x3F, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF0, 0x1E, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x3D, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x02, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x07,
  0xC0, 0x7E, 0x00, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x60, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x0F, 0x00, 0x1F, 0xFF, 0x0F, 0x00, 0x3F, 0xFF, 0xCE, 0x00, 0x7E, 0x03,
  0xCE, 0x00, 0xF8, 0x00, 0xFE, 0x01, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x00,
  0x7E, 0x03, 0xC0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x1C, 0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00,
  0xF0, 0x1C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x03,
  0xE0, 0x0F, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x0F, 0xE0, 0x07, 0xC0, 0x3F,
  0xE0, 0x03, 0xFF, 0xF9, 0xE0, 0x01, 0xFF, 0xF1, 0xC0, 0x00, 0xFF, 0xC1,
  0xC0, 0x00, 0x0C, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x20, 0x00, 0x0F,
  0x00, 0x60, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3E, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x78, 0x1F, 0xF8, 0x01, 0xE1, 0xFF, 0xF0, 0x07, 0x8F, 0xFF,
  0xE0, 0x1C, 0x78, 0x0F, 0xC0, 0x73, 0x80, 0x0F, 0x01, 0xDC, 0x00, 0x1E,
  0x0F, 0xE0, 0x00, 0x78, 0x3F, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x03, 0x83,
  0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xE1, 0xE0,
  0x00, 0x03, 0x87, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x01, 0xE1, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00,
  0x70, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x3C,
  0x38, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x0E, 0x1E,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x07, 0x87, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x01, 0xC3, 0xC0, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x3F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x27, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0x03, 0xC0, 0x00, 0x7C, 0x03, 0x80,
  0x00, 0xF8, 0x03, 0x80, 0x01, 0xF0, 0x07, 0x80, 0x03, 0xE0, 0x07, 0x80,
  0x0F, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x07, 0x00,
  0x7C, 0x00, 0x07, 0x01, 0xF8, 0x00, 0x0F, 0x03, 0xF0, 0x00, 0x0F, 0x07,
  0xC0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x0E, 0x7E,
  0x00, 0x00, 0x0E, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xEF,
  0x00, 0x00, 0x1F, 0xC7, 0x80, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x38, 0x00, 0x7C, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x07, 0x80, 0x70, 0x00, 0x07, 0xC0, 0x70, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xC7, 0xF0, 0x3F, 0xC0, 0x1C, 0xFF, 0xC3, 0xFF, 0x00, 0xEF, 0xFF,
  0x3F, 0xFC, 0x07, 0xE0, 0x7B, 0xC1, 0xE0, 0x3E, 0x01, 0xF8, 0x07, 0x83,
  0xE0, 0x0F, 0x80, 0x3C, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC0,
  0x0F, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x38, 0x00, 0xE0, 0x03, 0xC1, 0xC0,
  0x07, 0x00, 0x1C, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0xF0, 0x03, 0xC0, 0x07,
  0x07, 0x00, 0x1E, 0x00, 0x78, 0x38, 0x00, 0xE0, 0x03, 0xC1, 0xC0, 0x07,
  0x00, 0x1E, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0xF0, 0x03, 0xC0, 0x07, 0x07,
  0x80, 0x1E, 0x00, 0x38, 0x38, 0x00, 0xF0, 0x03, 0xC1, 0xC0, 0x07, 0x00,
  0x1E, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0xF0, 0x01, 0xC0, 0x07, 0x07, 0x80,
  0x1E, 0x00, 0x38, 0x3C, 0x00, 0xF0, 0x01, 0xC1, 0xC0, 0x07, 0x80, 0x1E,
  0x0E, 0x00, 0x38, 0x00, 0xF0, 0x70, 0x01, 0xC0, 0x07, 0x07, 0x80, 0x0E,
  0x00, 0x38, 0x3C, 0x00, 0xF0, 0x01, 0xC1, 0xE0, 0x07, 0x80, 0x1E, 0x0E,
  0x00, 0x3C, 0x00, 0xF0, 0x70, 0x01, 0xC0, 0x07, 0x87, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0x07, 0x81, 0xFF, 0x00, 0x1E, 0x1F, 0xFF, 0x00, 0x70, 0xFF,
  0xFE, 0x01, 0xCF, 0x80, 0xFC, 0x07, 0x38, 0x00, 0xF0, 0x1D, 0xC0, 0x01,
  0xE0, 0xFC, 0x00, 0x07, 0x83, 0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x38,
  0x3C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x0E, 0x1E,
  0x00, 0x00, 0x38, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x87, 0x00,
  0x00, 0x1E, 0x1C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xC3, 0xC0, 0x00,
  0x07, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0xE1,
  0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x78, 0x70,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x3C, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xE1,
  0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x07, 0x78, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x3E, 0x01, 0xE0, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x80, 0x07, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x70, 0x7F, 0xC0, 0x00, 0xF1, 0xFF, 0xF0, 0x00, 0xF7, 0xFF,
  0xF8, 0x00, 0xEF, 0x80, 0xFC, 0x00, 0xFE, 0x00, 0x3C, 0x00, 0xFC, 0x00,
  0x1E, 0x01, 0xF8, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x0F, 0x01, 0xC0, 0x00,
  0x07, 0x03, 0xC0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x07, 0x03, 0xC0, 0x00,
  0x07, 0x03, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0F, 0x03, 0x80, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x0E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00,
  0x78, 0x0F, 0x80, 0x00, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0xC0, 0x03,
  0xE0, 0x1E, 0xF0, 0x0F, 0xC0, 0x1E, 0xFF, 0xFF, 0x80, 0x1E, 0x3F, 0xFF,
  0x00, 0x1E, 0x1F, 0xFC, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x3C, 0x01, 0xFF, 0xF8, 0xF0, 0x0F, 0xFF, 0xF3, 0x80, 0x7E, 0x03, 0xEE,
  0x03, 0xE0, 0x03, 0xF8, 0x1F, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x0F, 0x83,
  0xC0, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x70, 0x78, 0x00, 0x01, 0xC3, 0xC0,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0xF0, 0x70, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0E, 0x07, 0x80,
  0x00, 0x78, 0x1E, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x1F, 0x80, 0xF8, 0x00,
  0xFE, 0x01, 0xF0, 0x0F, 0xF8, 0x03, 0xFF, 0xFD, 0xC0, 0x07, 0xFF, 0xC7,
  0x00, 0x0F, 0xFC, 0x1C, 0x00, 0x03, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xFF, 0xE0, 0xF0, 0x7F,
  0xFC, 0x1E, 0x3F, 0xFF, 0x83, 0x8F, 0xE0, 0x60, 0x73, 0xE0, 0x00, 0x0E,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0,
  0x07, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x78, 0x3C,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0x70, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x7C, 0x1E, 0x00,
  0x07, 0xC0, 0xFC, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x78, 0x70, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x38, 0x78, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x7C, 0x3C, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x3E, 0x07, 0x80, 0x03,
  0xF0, 0x3C, 0x00, 0x3B, 0x81, 0xF0, 0x0F, 0xBC, 0x07, 0xFF, 0xF9, 0xE0,
  0x1F, 0xFF, 0x8F, 0x00, 0x7F, 0xF0, 0x70, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x1E, 0x0E, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x0E, 0x00,
  0x78, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x0E,
  0x00, 0x78, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x0E, 0x3C, 0x00,
  0x00, 0x3C, 0xE0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xF0,
  0x00, 0xE0, 0x03, 0xF8, 0x00, 0xF0, 0x01, 0xFC, 0x00, 0x78, 0x00, 0xEE,
  0x00, 0x7C, 0x00, 0xF7, 0x00, 0x3E, 0x00, 0x73, 0x80, 0x3B, 0x00, 0x39,
  0xC0, 0x1D, 0x80, 0x3C, 0xE0, 0x0E, 0xC0, 0x1C, 0x70, 0x0E, 0x60, 0x0E,
  0x38, 0x07, 0x30, 0x0E, 0x1C, 0x07, 0x1C, 0x07, 0x0E, 0x03, 0x8E, 0x07,
  0x87, 0x01, 0xC7, 0x03, 0x83, 0x81, 0xC3, 0x81, 0xC1, 0xC0, 0xE1, 0xC1,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x70, 0x70, 0x38, 0x78, 0x38,
  0x70, 0x1C, 0x38, 0x1C, 0x38, 0x0E, 0x1C, 0x0E, 0x3C, 0x07, 0x1C, 0x07,
  0x1C, 0x03, 0x8E, 0x03, 0x8E, 0x00, 0xCE, 0x00, 0xCE, 0x00, 0x67, 0x00,
  0x67, 0x00, 0x33, 0x80, 0x33, 0x80, 0x1B, 0x80, 0x1B, 0x80, 0x0D, 0xC0,
  0x0D, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00,
  0xF8, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x7C, 0x00,
  0x00, 0x3C, 0x1F, 0x00, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x00, 0x79, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFB, 0xC0, 0x00,
  0x00, 0x3E, 0x3C, 0x00, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x03, 0xE0, 0x78,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x1F, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x07, 0xC0, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0x00, 0x3E, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x00,
  0xE0, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x08, 0x00,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x10, 0x3F, 0xFC, 0x00, 0x03, 0x8F,
  0xFF, 0xC0, 0x00, 0x73, 0xE0, 0x7C, 0x00, 0x1C, 0x78, 0x07, 0xE0, 0x03,
  0x9E, 0x00, 0x3E, 0x00, 0xE3, 0x80, 0x03, 0xE0, 0x3C, 0x70, 0x00, 0x3F,
  0xFF, 0x1C, 0x00, 0x03, 0xFF, 0xC0, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00,
};

const GFXglyph RobotoMono_LightItalic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 12, 46, 38, 13, -46 },
  { 70, 14, 14, 38, 15, -48 },
  { 95, 37, 46, 38, 1, -46 },
  { 308, 31, 59, 38, 4, -52 },
  { 537, 31, 47, 38, 4, -46 },
  { 720, 33, 47, 38, 2, -46 },
  { 914, 6, 14, 38, 18, -48 },
  { 925, 20, 66, 38, 11, -51 },
  { 1090, 20, 66, 38, 6, -51 },
  { 1255, 28, 28, 38, 8, -46 },
  { 1353, 31, 33, 38, 4, -38 },
  { 1481, 9, 15, 38, 7, -6 },
  { 1498, 23, 3, 38, 7, -22 },
  { 1507, 6, 6, 38, 14, -6 },
  { 1512, 31, 50, 38, 4, -46 },
  { 1706, 30, 47, 38, 4, -46 },
  { 1883, 18, 46, 38, 9, -46 },
  { 1987, 31, 46, 38, 1, -46 },
  { 2166, 31, 47, 38, 2, -46 },
  { 2349, 32, 46, 38, 1, -46 },
  { 2533, 32, 47, 38, 5, -46 },
  { 2721, 28, 47, 38, 4, -46 },
  { 2886, 30, 46, 38, 7, -46 },
  { 3059, 31, 47, 38, 4, -46 },
  { 3242, 28, 46, 38, 6, -46 },
  { 3403, 11, 33, 38, 15, -33 },
  { 3449, 15, 42, 38, 11, -33 },
  { 3528, 29, 27, 38, 5, -34 },
  { 3626, 30, 16, 38, 4, -29 },
  { 3686, 29, 27, 38, 4, -34 },
  { 3784, 24, 46, 38, 10, -46 },
  { 3922, 35, 46, 38, 2, -46 },
  { 4124, 32, 46, 38, 0, -46 },
  { 4308, 32, 46, 38, 3, -46 },
  { 4492, 32, 47, 38, 4, -46 },
  { 4680, 33, 46, 38, 2, -46 },
  { 4870, 34, 46, 38, 3, -46 },
  { 5066, 34, 46, 38, 3, -46 },
  { 5262, 33, 47, 38, 3, -46 },
  { 5456, 35, 46, 38, 2, -46 },
  { 5658, 33, 46, 38, 3, -46 },
  { 5848, 34, 47, 38, 2, -46 },
  { 6048, 36, 46, 38, 3, -46 },
  { 6255, 27, 46, 38, 3, -46 },
  { 6411, 36, 46, 38, 2, -46 },
  { 6618, 35, 46, 38, 2, -46 },
  { 6820, 31, 47, 38, 4, -46 },
  { 7003, 34, 46, 38, 3, -46 },
  { 7199, 33, 54, 38, 3, -46 },
  { 7422, 33, 46, 38, 3, -46 },
  { 7612, 33, 47, 38, 3, -46 },
  { 7806, 32, 46, 38, 7, -46 },
  { 7990, 33, 47, 38, 4, -46 },
  { 8184, 32, 46, 38, 7, -46 },
  { 8368, 34, 46, 38, 6, -46 },
  { 8564, 39, 46, 38, 0, -46 },
  { 8789, 32, 46, 38, 7, -46 },
  { 8973, 34, 46, 38, 1, -46 },
  { 9169, 20, 62, 38, 9, -52 },
  { 9324, 14, 50, 38, 12, -46 },
  { 9412, 20, 62, 38, 9, -52 },
  { 9567, 22, 25, 38, 8, -46 },
  { 9636, 28, 3, 38, 1, 0 },
  { 9647, 9, 9, 38, 18, -47 },
  { 9658, 29, 35, 38, 3, -34 },
  { 9785, 30, 49, 38, 3, -48 },
  { 9969, 29, 36, 38, 4, -35 },
  { 10100, 32, 49, 38, 4, -48 },
  { 10296, 29, 35, 38, 4, -34 },
  { 10423, 31, 49, 38, 8, -49 },
  { 10613, 32, 49, 38, 2, -35 },
  { 10809, 30, 48, 38, 3, -48 },
  { 10989, 27, 46, 38, 3, -46 },
  { 11145, 30, 60, 38, 0, -46 },
  { 11370, 32, 48, 38, 3, -48 },
  { 11562, 27, 48, 38, 3, -48 },
  { 11724, 37, 34, 38, -1, -34 },
  { 11882, 30, 34, 38, 3, -34 },
  { 12010, 30, 36, 38, 3, -35 },
  { 12145, 32, 47, 38, 0, -34 },
  { 12333, 30, 47, 38, 4, -34 },
  { 12510, 27, 34, 38, 8, -34 },
  { 12625, 29, 35, 38, 4, -34 },
  { 12752, 26, 43, 38, 7, -42 },
  { 12892, 29, 35, 38, 5, -34 },
  { 13019, 30, 34, 38, 6, -34 },
  { 13147, 33, 34, 38, 5, -34 },
  { 13288, 35, 34, 38, 1, -34 },
  { 13437, 39, 48, 38, -1, -34 },
  { 13671, 32, 34, 38, 2, -34 },
  { 13807, 25, 63, 38, 10, -50 },
  { 14004, 11, 56, 38, 13, -46 },
  { 14081, 25, 63, 38, 5, -50 },
  { 14278, 35, 12, 38, 1, -25 },
};

const GFXfont RobotoMono_LightItalic64pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic64pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic64pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _ROBOTOMONO_LIGHTITALIC64PT7B_H_
