#ifndef _ROBOTOMONO_LIGHTITALIC34PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x30, 0xC6, 0x18, 0x61, 0x86, 0x18, 0xC3, 0x0C, 0x30, 0xC2,
  0x18, 0x60, 0x00, 0x00, 0x01, 0x0E, 0x30, 0x63, 0x62, 0x42, 0xC6, 0xC6,
  0xC6, 0xC4, 0x84, 0x00, 0x30, 0x60, 0x03, 0x04, 0x00, 0x20, 0xC0, 0x06,
  0x0C, 0x00, 0x60, 0x80, 0x04, 0x18, 0x00, 0xC1, 0x81, 0xFF, 0xFF, 0x00,
  0x83, 0x00, 0x18, 0x30, 0x01, 0x82, 0x00, 0x10, 0x60, 0x03, 0x06, 0x00,
  0x20, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0x80, 0x7F, 0xFF, 0x88, 0xC1, 0x80,
  0x0C, 0x10, 0x00, 0x83, 0x00, 0x18, 0x30, 0x01, 0x82, 0x00, 0x10, 0x60,
  0x03, 0x06, 0x00, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x1F, 0xC0, 0x3C, 0x70, 0x38, 0x1C, 0x18, 0x06, 0x18, 0x03, 0x0C, 0x01,
  0x86, 0x00, 0xC3, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x66,
  0x00, 0x33, 0x00, 0x19, 0xC0, 0x18, 0x60, 0x0C, 0x38, 0x0C, 0x0F, 0xBC,
  0x03, 0xFC, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x3F,
  0x00, 0x63, 0x00, 0x61, 0x00, 0x41, 0x86, 0xC1, 0x84, 0xC1, 0x0C, 0xC1,
  0x18, 0xC3, 0x10, 0x66, 0x30, 0x7C, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01,
  0x80, 0x03, 0x08, 0x02, 0x3E, 0x06, 0x63, 0x0C, 0x41, 0x18, 0xC1, 0x18,
  0xC1, 0x30, 0xC1, 0x60, 0x83, 0x00, 0xC3, 0x00, 0xC6, 0x00, 0x7C, 0x00,
  0x20, 0x00, 0xFC, 0x00, 0xE3, 0x00, 0xE1, 0xC0, 0x60, 0x60, 0x30, 0x30,
  0x18, 0x30, 0x0C, 0x18, 0x06, 0x18, 0x03, 0x38, 0x00, 0xF8, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x63, 0x02, 0x61, 0xC3, 0x70, 0x61, 0xB0,
  0x18, 0xD8, 0x0C, 0xC8, 0x03, 0xE6, 0x01, 0xE3, 0x00, 0x61, 0xC0, 0xF8,
  0x79, 0xEE, 0x1F, 0xC3, 0x00, 0x6B, 0x6D, 0xA4, 0x00, 0x40, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x06, 0x00, 0xC0,
  0x30, 0x06, 0x00, 0x80, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01,
  0x00, 0x30, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60,
  0x0C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x04, 0x18, 0x3E, 0x23, 0xDF, 0xFF, 0x03, 0xE0, 0x03, 0x80, 0x0F, 0x00,
  0x33, 0x00, 0xC3, 0x03, 0x06, 0x0C, 0x06, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80,
  0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x39, 0x8C,
  0x66, 0x33, 0x10, 0xFF, 0xFF, 0xFF, 0x6F, 0xE0, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x20, 0x03, 0xFC, 0x07, 0x0E, 0x0E, 0x06,
  0x1C, 0x03, 0x18, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x07, 0x60, 0x1F,
  0x60, 0x3B, 0x60, 0x63, 0x60, 0xC3, 0x63, 0x83, 0x67, 0x06, 0xCC, 0x06,
  0xD8, 0x06, 0xF0, 0x06, 0xE0, 0x06, 0xC0, 0x0C, 0x60, 0x0C, 0x60, 0x18,
  0x70, 0x30, 0x3C, 0xE0, 0x1F, 0xC0, 0x01, 0x83, 0xCF, 0xFE, 0x3C, 0x18,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x00, 0x40, 0x03,
  0xF8, 0x07, 0x1E, 0x0C, 0x06, 0x18, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30,
  0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xFF, 0xFE, 0xFF, 0xFC, 0x00,
  0x20, 0x03, 0xFC, 0x07, 0x0E, 0x0C, 0x07, 0x18, 0x03, 0x18, 0x03, 0x30,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x38, 0x03,
  0xF0, 0x03, 0xF8, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0xC0,
  0x06, 0xC0, 0x0C, 0xC0, 0x0C, 0xE0, 0x1C, 0x60, 0x38, 0x3C, 0xF0, 0x1F,
  0xC0, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0x60,
  0x03, 0x30, 0x03, 0x18, 0x03, 0x08, 0x01, 0x8C, 0x01, 0x86, 0x01, 0x83,
  0x01, 0x81, 0x81, 0x80, 0xC1, 0xC0, 0xC0, 0xC0, 0x60, 0xC0, 0x30, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x07, 0xFF, 0x87, 0xFF, 0x83, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x1F,
  0xF8, 0x0F, 0x1E, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x30, 0x03, 0x18, 0x03, 0x0C, 0x03,
  0x83, 0x03, 0x81, 0xE7, 0x80, 0x3F, 0x80, 0x00, 0x7C, 0x03, 0xF0, 0x0E,
  0x00, 0x38, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x31, 0xE0,
  0xCF, 0xF1, 0xF0, 0x73, 0x80, 0x66, 0x00, 0xDC, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x1B, 0x00, 0x37, 0x00, 0x66, 0x01, 0x8E, 0x06,
  0x0F, 0x38, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0xFE, 0x01, 0xE3, 0x81, 0xC0,
  0x60, 0xC0, 0x30, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x06, 0x18, 0x03, 0x0C,
  0x03, 0x83, 0x03, 0x81, 0xE7, 0x80, 0x3F, 0x00, 0x7B, 0xC0, 0xE0, 0x30,
  0x60, 0x0C, 0x60, 0x06, 0x70, 0x03, 0x30, 0x01, 0x98, 0x00, 0xCC, 0x00,
  0x67, 0x00, 0x61, 0x80, 0x60, 0x79, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x80,
  0x0F, 0xE0, 0x38, 0xE0, 0xC0, 0x63, 0x00, 0xCE, 0x00, 0xD8, 0x01, 0xB0,
  0x03, 0x40, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x76, 0x00, 0xCC, 0x03,
  0x8C, 0x0F, 0x1F, 0xF6, 0x0F, 0x88, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0xE0, 0x3F, 0x80, 0x7C, 0x00, 0x1C, 0x71, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0xE3, 0x80, 0x07,
  0x07, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x38, 0x30, 0x30, 0x30, 0x60, 0xE0, 0x40, 0x00, 0x02,
  0x00, 0x3C, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0x00, 0x3F, 0xFF, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x20, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x07, 0x00, 0x7C, 0x03, 0xC0,
  0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x7F, 0x0F,
  0x1C, 0xE0, 0x76, 0x01, 0xE0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x07, 0x00, 0x30,
  0x00, 0x00, 0xFE, 0x00, 0x38, 0x70, 0x1C, 0x02, 0x06, 0x00, 0x60, 0x80,
  0x04, 0x30, 0xF8, 0x8C, 0x33, 0x19, 0x0C, 0x23, 0x63, 0x0C, 0x6C, 0x41,
  0x0D, 0x18, 0x21, 0x63, 0x04, 0x2C, 0x41, 0x85, 0x88, 0x21, 0xA1, 0x04,
  0x24, 0x61, 0x84, 0x84, 0x71, 0x90, 0xFB, 0x63, 0x1E, 0x78, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x20, 0x0F, 0x3C, 0x00, 0x7F, 0x00, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x03,
  0x10, 0x01, 0x8C, 0x01, 0x86, 0x00, 0xC3, 0x00, 0xC1, 0x80, 0x60, 0xC0,
  0x60, 0x60, 0x30, 0x10, 0x30, 0x0C, 0x1F, 0xFE, 0x0F, 0xFF, 0x0C, 0x01,
  0x86, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x33, 0x00, 0x0D, 0x80, 0x07, 0x80,
  0x03, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xC0, 0x38, 0x30, 0x06, 0x0C, 0x01,
  0x83, 0x00, 0x61, 0x80, 0x18, 0x60, 0x06, 0x18, 0x03, 0x86, 0x01, 0xC1,
  0x83, 0xC0, 0x7F, 0xE0, 0x30, 0x1E, 0x0C, 0x01, 0x83, 0x00, 0x30, 0xC0,
  0x0C, 0x30, 0x03, 0x08, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x1C, 0x60, 0x0E,
  0x18, 0x07, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0x00, 0x20, 0x01, 0xFE, 0x01,
  0xC3, 0x81, 0xC0, 0xE1, 0xC0, 0x30, 0xC0, 0x0C, 0xC0, 0x06, 0x60, 0x03,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x01, 0x98,
  0x00, 0xCC, 0x00, 0xC3, 0x00, 0xC1, 0xC0, 0xE0, 0x79, 0xE0, 0x1F, 0xC0,
  0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0xC0, 0x70, 0x30, 0x0C, 0x08, 0x01,
  0x86, 0x00, 0x61, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x33,
  0x00, 0x0C, 0xC0, 0x03, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0,
  0x06, 0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x61, 0x80, 0x38, 0x60, 0x1C,
  0x18, 0x1E, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0x8F, 0xFF, 0xC6,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0x86, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xF1, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC3, 0xFF, 0xE1, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xFF,
  0xF0, 0x3F, 0xFC, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x01, 0xFE, 0x01, 0xE7, 0x81, 0xC0,
  0xE1, 0xC0, 0x30, 0xC0, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x03, 0xFB, 0x03, 0xFD,
  0x80, 0x06, 0xC0, 0x02, 0x60, 0x03, 0x30, 0x01, 0x98, 0x00, 0xCC, 0x00,
  0x63, 0x00, 0x31, 0xC0, 0x70, 0x7D, 0xF0, 0x0F, 0xE0, 0x00, 0x0C, 0x00,
  0x61, 0x80, 0x08, 0x20, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01,
  0x86, 0x00, 0x30, 0xC0, 0x04, 0x10, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x06,
  0x1F, 0xFF, 0xC3, 0x00, 0x18, 0x60, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x18,
  0x60, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x08, 0x20, 0x03, 0x0C, 0x00, 0x61,
  0x80, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x30, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x07, 0xFF, 0xC3, 0xFF,
  0xF0, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x30, 0x01, 0x8C, 0x00, 0xE3, 0x00, 0x30, 0x60, 0x1C,
  0x1C, 0x0E, 0x03, 0xCF, 0x00, 0x7F, 0x00, 0x0C, 0x00, 0xE3, 0x00, 0x30,
  0x60, 0x0C, 0x0C, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x30, 0x04, 0x0C, 0x01,
  0x83, 0x00, 0x30, 0xC0, 0x06, 0x30, 0x00, 0xCC, 0x00, 0x1F, 0xC0, 0x07,
  0xD8, 0x00, 0xF3, 0x80, 0x1C, 0x30, 0x03, 0x07, 0x00, 0x60, 0x60, 0x0C,
  0x06, 0x03, 0x00, 0xC0, 0x60, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x18, 0x30,
  0x03, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x0E, 0x00,
  0xE1, 0xC0, 0x3C, 0x38, 0x07, 0x05, 0x01, 0xA1, 0xA0, 0x3C, 0x36, 0x0D,
  0x86, 0xC1, 0xB0, 0xD8, 0x66, 0x1B, 0x0C, 0x86, 0x23, 0x30, 0xC4, 0x66,
  0x18, 0xD8, 0xC3, 0x1E, 0x18, 0x63, 0xC3, 0x0C, 0x70, 0xC3, 0x06, 0x18,
  0x60, 0x83, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01, 0x84, 0x00, 0x61,
  0x80, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x30, 0x0C, 0x00, 0x61, 0xC0, 0x18,
  0x38, 0x03, 0x0F, 0x00, 0x61, 0xB0, 0x0C, 0x36, 0x01, 0x86, 0xC0, 0x30,
  0xCC, 0x0C, 0x19, 0x81, 0x86, 0x30, 0x30, 0xC3, 0x06, 0x18, 0x60, 0xC3,
  0x04, 0x10, 0x60, 0xC6, 0x08, 0x18, 0xC3, 0x01, 0x98, 0x60, 0x33, 0x0C,
  0x06, 0x61, 0x80, 0x78, 0x30, 0x0F, 0x0C, 0x01, 0xE1, 0x80, 0x1C, 0x30,
  0x03, 0x86, 0x00, 0x70, 0x00, 0x20, 0x01, 0xFE, 0x01, 0xE7, 0x81, 0xC0,
  0xC1, 0xC0, 0x30, 0xC0, 0x18, 0xC0, 0x0C, 0x60, 0x03, 0x60, 0x01, 0xB0,
  0x00, 0xD8, 0x00, 0x4C, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x0D,
  0x80, 0x06, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x01, 0x98, 0x01, 0x8C, 0x00,
  0xC3, 0x00, 0xC1, 0xC0, 0xC0, 0x7B, 0xC0, 0x1F, 0xC0, 0x00, 0x0F, 0xFC,
  0x03, 0xFF, 0xC1, 0x80, 0x38, 0x60, 0x06, 0x18, 0x01, 0x86, 0x00, 0x31,
  0x80, 0x0C, 0x60, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x30, 0xC0,
  0x38, 0x3F, 0xFC, 0x0F, 0xFC, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x01, 0xFE, 0x01, 0xE7, 0x81, 0xC0,
  0xE1, 0x80, 0x31, 0xC0, 0x18, 0xC0, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0,
  0x00, 0xD0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1B, 0x00, 0x0D,
  0x80, 0x06, 0xC0, 0x03, 0x60, 0x03, 0x30, 0x01, 0x98, 0x00, 0xCC, 0x00,
  0xC3, 0x00, 0xC1, 0xC0, 0xC0, 0x7B, 0xC0, 0x1F, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0x80, 0x0F, 0xF8, 0x0F, 0xFF, 0x06, 0x01,
  0xC3, 0x00, 0x61, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x60, 0x03, 0x30,
  0x03, 0x18, 0x01, 0x8C, 0x01, 0x86, 0x03, 0x83, 0xFF, 0x83, 0xFF, 0x01,
  0x81, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x10, 0x06, 0x18, 0x03,
  0x0C, 0x01, 0x86, 0x00, 0x63, 0x00, 0x31, 0x80, 0x1C, 0x00, 0x20, 0x01,
  0xFE, 0x01, 0xE7, 0x81, 0x80, 0x61, 0x80, 0x31, 0xC0, 0x0C, 0xC0, 0x06,
  0x60, 0x03, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x30,
  0x01, 0x98, 0x00, 0xCC, 0x00, 0x67, 0x00, 0x61, 0xC0, 0x70, 0x7D, 0xF0,
  0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0xC6, 0x00, 0x21, 0x00,
  0x18, 0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x0C,
  0x20, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x18,
  0x01, 0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00,
  0xC3, 0x00, 0x30, 0x60, 0x18, 0x1C, 0x0C, 0x03, 0xDE, 0x00, 0x7F, 0x00,
  0xC0, 0x03, 0xE0, 0x01, 0xB0, 0x01, 0x98, 0x00, 0xCC, 0x00, 0xC3, 0x00,
  0x61, 0x80, 0x60, 0xC0, 0x30, 0x60, 0x30, 0x30, 0x18, 0x18, 0x1C, 0x0C,
  0x0C, 0x03, 0x06, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x63, 0x00, 0x31, 0x80,
  0x19, 0x80, 0x04, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x40, 0xC0, 0xD0, 0x30, 0x34, 0x0C, 0x09, 0x07, 0x06,
  0x41, 0xC1, 0xB0, 0x50, 0x6C, 0x34, 0x33, 0x0D, 0x0C, 0xC2, 0x43, 0x31,
  0x98, 0x8C, 0x66, 0x63, 0x11, 0x98, 0xCC, 0x66, 0x33, 0x1B, 0x0C, 0x86,
  0xC3, 0x61, 0xB0, 0xD8, 0x68, 0x34, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x01, 0x80, 0x0E, 0x00, 0x38,
  0x30, 0x03, 0x01, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x30, 0x18, 0x00, 0xC1,
  0x80, 0x06, 0x1C, 0x00, 0x18, 0xC0, 0x00, 0xCC, 0x00, 0x06, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x06, 0x60,
  0x00, 0x33, 0x00, 0x03, 0x0C, 0x00, 0x30, 0x60, 0x03, 0x83, 0x80, 0x38,
  0x0C, 0x01, 0x80, 0x60, 0x18, 0x01, 0x81, 0xC0, 0x0C, 0x1C, 0x00, 0x30,
  0xC0, 0x03, 0xE0, 0x03, 0x98, 0x01, 0x8C, 0x01, 0x86, 0x01, 0xC1, 0x80,
  0xC0, 0xC0, 0xC0, 0x60, 0xE0, 0x10, 0x60, 0x0C, 0x60, 0x06, 0x60, 0x01,
  0x30, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x0F, 0xFF, 0xC7, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0x07, 0xE0, 0xF8,
  0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x01, 0x80, 0x30, 0x07, 0xE0, 0xFC, 0x00, 0xC1, 0x83, 0x06, 0x04, 0x0C,
  0x18, 0x30, 0x60, 0x40, 0xC1, 0x83, 0x06, 0x04, 0x0C, 0x18, 0x30, 0x60,
  0x40, 0xC1, 0x83, 0x06, 0x04, 0x0C, 0x07, 0xC1, 0xF0, 0x0C, 0x03, 0x00,
  0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC3, 0xE0, 0xF8, 0x00,
  0x01, 0x80, 0x18, 0x03, 0xC0, 0x6C, 0x06, 0xC0, 0xC4, 0x0C, 0x61, 0x86,
  0x18, 0x63, 0x06, 0x60, 0x26, 0x03, 0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xF0,
  0xC6, 0x63, 0x30, 0x07, 0xF8, 0x1E, 0x78, 0x60, 0x39, 0x80, 0x33, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x0F, 0xFE, 0x78, 0x19, 0x80, 0x36,
  0x00, 0x6C, 0x00, 0xD8, 0x03, 0xB0, 0x0F, 0x70, 0x34, 0x7B, 0xD8, 0x7F,
  0x38, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x09, 0xFC, 0x1B, 0xFE, 0x1E, 0x06, 0x1C,
  0x03, 0x18, 0x03, 0x18, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30,
  0x03, 0x30, 0x03, 0x30, 0x07, 0x60, 0x06, 0x60, 0x06, 0x70, 0x0C, 0x78,
  0x18, 0x7E, 0xF8, 0xC7, 0xE0, 0x03, 0xF8, 0x1E, 0x78, 0x70, 0x39, 0xC0,
  0x33, 0x00, 0x6C, 0x00, 0x58, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0xCC, 0x01, 0x98, 0x06, 0x38, 0x1C, 0x3C,
  0xF0, 0x3F, 0x80, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x07, 0xF3, 0x07, 0xBD,
  0x87, 0x03, 0xC7, 0x00, 0xC3, 0x00, 0x63, 0x00, 0x31, 0x80, 0x18, 0xC0,
  0x0C, 0xC0, 0x06, 0x60, 0x06, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xC6,
  0x00, 0x61, 0x80, 0x60, 0xE0, 0x70, 0x3D, 0xF8, 0x0F, 0xCC, 0x00, 0x03,
  0xF8, 0x0F, 0x3C, 0x1C, 0x0C, 0x38, 0x06, 0x30, 0x06, 0x60, 0x02, 0x60,
  0x02, 0x7F, 0xFE, 0xFF, 0xFE, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x60, 0x08, 0x70, 0x1C, 0x3C, 0xF0, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x7F, 0x80, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0xFF, 0xFC, 0x7F, 0xFE, 0x01, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x00, 0x03, 0xF9, 0x83, 0xDE, 0xC3,
  0x81, 0xE3, 0x80, 0x61, 0x80, 0x31, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06,
  0x60, 0x03, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x61, 0x00,
  0x30, 0xC0, 0x38, 0x70, 0x38, 0x1E, 0xFC, 0x07, 0xE6, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x01, 0x82, 0x01, 0xC3, 0x81, 0xC0, 0xFF, 0xC0, 0x1F, 0x80,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0xFC, 0x19, 0xDE, 0x1A, 0x07, 0x1C,
  0x03, 0x18, 0x03, 0x18, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30,
  0x03, 0x30, 0x02, 0x20, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60,
  0x06, 0x60, 0x04, 0xC0, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x60, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x03, 0xFC, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x4F, 0x80, 0xFE,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x07, 0x8C, 0x07, 0x0C, 0x07,
  0x06, 0x06, 0x03, 0x0E, 0x01, 0x8E, 0x00, 0xCE, 0x00, 0x6E, 0x00, 0x6F,
  0x00, 0x3D, 0xC0, 0x1C, 0x60, 0x0C, 0x18, 0x06, 0x0E, 0x03, 0x03, 0x03,
  0x01, 0xC1, 0x80, 0x60, 0xC0, 0x18, 0x60, 0x0E, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x1B, 0xE7, 0xC2, 0xDD, 0xDC,
  0xE1, 0xE1, 0x98, 0x18, 0x33, 0x02, 0x06, 0x60, 0xC0, 0xCC, 0x18, 0x19,
  0x03, 0x02, 0x60, 0x60, 0xCC, 0x0C, 0x19, 0x81, 0x03, 0x30, 0x60, 0x66,
  0x0C, 0x0C, 0x81, 0x81, 0x30, 0x30, 0x66, 0x06, 0x0C, 0xC1, 0x81, 0x98,
  0x30, 0x30, 0x18, 0xFC, 0x19, 0xDE, 0x1E, 0x07, 0x1C, 0x03, 0x18, 0x03,
  0x18, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x06,
  0x20, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x0C,
  0xC0, 0x0C, 0x03, 0xF0, 0x0F, 0x3C, 0x1C, 0x0C, 0x30, 0x06, 0x70, 0x06,
  0x60, 0x06, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x06,
  0xC0, 0x06, 0xC0, 0x0E, 0xC0, 0x0C, 0x60, 0x18, 0x60, 0x38, 0x38, 0xF0,
  0x1F, 0xC0, 0x0C, 0xFC, 0x06, 0xFF, 0x83, 0xC0, 0xC1, 0xC0, 0x70, 0xC0,
  0x18, 0x60, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xC6,
  0x00, 0x63, 0x00, 0x63, 0x00, 0x31, 0x80, 0x38, 0xE0, 0x18, 0x70, 0x18,
  0x3E, 0x7C, 0x19, 0xF8, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xF3, 0x0F, 0x3B,
  0x1C, 0x0F, 0x38, 0x06, 0x30, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06,
  0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C,
  0x60, 0x18, 0x70, 0x38, 0x3C, 0xF8, 0x1F, 0x98, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x18, 0xFE,
  0x37, 0xF8, 0x7C, 0x00, 0xA0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x03, 0xF8, 0x0F, 0xBC,
  0x1C, 0x06, 0x38, 0x06, 0x30, 0x03, 0x30, 0x00, 0x18, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x0C, 0xC0, 0x0C,
  0xE0, 0x0C, 0x60, 0x1C, 0x3C, 0xF8, 0x1F, 0xE0, 0x03, 0x00, 0x18, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x7F, 0xFF, 0xFF, 0xE0, 0xC0, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0F, 0x30, 0x3F, 0x80, 0x70, 0x06,
  0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x36, 0x00, 0xCC, 0x01, 0xB0, 0x03, 0x60,
  0x06, 0xC0, 0x0D, 0x80, 0x13, 0x00, 0x66, 0x00, 0xCC, 0x01, 0x98, 0x03,
  0x30, 0x0E, 0x60, 0x28, 0x73, 0xB0, 0x7E, 0x60, 0xC0, 0x03, 0xC0, 0x06,
  0x60, 0x06, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x18, 0x30, 0x18, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x60, 0x10, 0xC0, 0x18, 0xC0, 0x19, 0x80, 0x19, 0x80,
  0x0B, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0xC0, 0xC0, 0xF0, 0x30,
  0x3C, 0x0C, 0x09, 0x07, 0x06, 0x41, 0x41, 0x90, 0xD0, 0x44, 0x36, 0x31,
  0x09, 0x8C, 0x46, 0x66, 0x11, 0x19, 0x84, 0xC6, 0x41, 0x31, 0xB0, 0x78,
  0x6C, 0x16, 0x0A, 0x05, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x00, 0x0C, 0x00, 0xE0, 0xC0, 0x38, 0x18, 0x0E, 0x01, 0x81, 0x80, 0x30,
  0x60, 0x03, 0x18, 0x00, 0x36, 0x00, 0x07, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x07, 0xC0, 0x01, 0xDC, 0x00, 0x71, 0x80, 0x0C, 0x18, 0x03, 0x03,
  0x00, 0xC0, 0x30, 0x30, 0x07, 0x1C, 0x00, 0x60, 0x0C, 0x00, 0x38, 0x60,
  0x01, 0x83, 0x00, 0x18, 0x0C, 0x00, 0xC0, 0x60, 0x0C, 0x03, 0x00, 0xE0,
  0x18, 0x06, 0x00, 0x60, 0x60, 0x03, 0x03, 0x00, 0x18, 0x30, 0x00, 0x63,
  0x80, 0x03, 0x18, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0xFF, 0xFE, 0x7F, 0xFF, 0x00, 0x00, 0x08, 0x01, 0xC0, 0x1C, 0x01, 0x80,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x60, 0x03, 0x00, 0x38, 0x03, 0x80, 0xF0, 0x07, 0x80, 0x0E, 0x00,
  0x30, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x08,
  0x00, 0x0C, 0x30, 0xC2, 0x08, 0x61, 0x86, 0x18, 0x41, 0x0C, 0x30, 0xC3,
  0x08, 0x20, 0x86, 0x18, 0x61, 0x84, 0x10, 0xC3, 0x0C, 0x30, 0x82, 0x00,
  0x04, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03,
  0x00, 0x1C, 0x00, 0x78, 0x03, 0xC0, 0x38, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0x60, 0x06, 0x00, 0xE0, 0x04, 0x00, 0x00, 0x1E, 0x00, 0x9F, 0xE0,
  0x36, 0x1C, 0x0F, 0x03, 0x86, 0x80, 0x7F, 0x00, 0x07, 0x80,
};

const GFXglyph RobotoMono_LightItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 6, 24, 20, 7, -24 },
  { 19, 8, 8, 20, 8, -26 },
  { 27, 20, 24, 20, 0, -24 },
  { 87, 17, 31, 20, 2, -28 },
  { 153, 16, 25, 20, 2, -25 },
  { 203, 17, 25, 20, 1, -25 },
  { 257, 3, 8, 20, 10, -26 },
  { 260, 10, 35, 20, 6, -27 },
  { 304, 11, 35, 20, 3, -27 },
  { 353, 15, 15, 20, 4, -24 },
  { 382, 16, 18, 20, 2, -20 },
  { 418, 5, 8, 20, 4, -3 },
  { 423, 12, 2, 20, 4, -12 },
  { 426, 4, 3, 20, 7, -3 },
  { 428, 17, 26, 20, 2, -24 },
  { 484, 16, 25, 20, 2, -25 },
  { 534, 9, 24, 20, 5, -24 },
  { 561, 16, 25, 20, 1, -25 },
  { 611, 16, 25, 20, 1, -25 },
  { 661, 17, 24, 20, 1, -24 },
  { 712, 17, 24, 20, 3, -24 },
  { 763, 15, 24, 20, 2, -24 },
  { 808, 16, 24, 20, 4, -24 },
  { 856, 17, 25, 20, 2, -25 },
  { 910, 15, 25, 20, 3, -25 },
  { 957, 6, 18, 20, 8, -18 },
  { 971, 8, 23, 20, 6, -18 },
  { 994, 15, 14, 20, 3, -18 },
  { 1021, 16, 8, 20, 2, -15 },
  { 1037, 15, 14, 20, 2, -18 },
  { 1064, 13, 25, 20, 5, -25 },
  { 1105, 19, 24, 20, 1, -24 },
  { 1162, 17, 24, 20, 0, -24 },
  { 1213, 18, 24, 20, 1, -24 },
  { 1267, 17, 25, 20, 2, -25 },
  { 1321, 18, 24, 20, 1, -24 },
  { 1375, 17, 24, 20, 2, -24 },
  { 1426, 18, 24, 20, 2, -24 },
  { 1480, 17, 25, 20, 2, -25 },
  { 1534, 19, 24, 20, 1, -24 },
  { 1591, 18, 24, 20, 1, -24 },
  { 1645, 18, 24, 20, 1, -24 },
  { 1699, 19, 24, 20, 2, -24 },
  { 1756, 14, 24, 20, 2, -24 },
  { 1798, 19, 24, 20, 1, -24 },
  { 1855, 19, 24, 20, 1, -24 },
  { 1912, 17, 25, 20, 2, -25 },
  { 1966, 18, 24, 20, 2, -24 },
  { 2020, 17, 29, 20, 2, -25 },
  { 2082, 17, 24, 20, 2, -24 },
  { 2133, 17, 25, 20, 2, -25 },
  { 2187, 17, 24, 20, 4, -24 },
  { 2238, 18, 24, 20, 2, -24 },
  { 2292, 17, 24, 20, 4, -24 },
  { 2343, 18, 24, 20, 3, -24 },
  { 2397, 21, 24, 20, 0, -24 },
  { 2460, 17, 24, 20, 4, -24 },
  { 2511, 18, 24, 20, 1, -24 },
  { 2565, 11, 33, 20, 5, -28 },
  { 2611, 7, 26, 20, 7, -24 },
  { 2634, 10, 33, 20, 5, -28 },
  { 2676, 12, 13, 20, 4, -24 },
  { 2696, 14, 2, 20, 1, 0 },
  { 2700, 4, 5, 20, 10, -25 },
  { 2703, 15, 18, 20, 2, -18 },
  { 2737, 16, 26, 20, 1, -26 },
  { 2789, 15, 18, 20, 2, -18 },
  { 2823, 17, 26, 20, 2, -26 },
  { 2879, 16, 18, 20, 2, -18 },
  { 2915, 17, 26, 20, 4, -26 },
  { 2971, 17, 25, 20, 1, -18 },
  { 3025, 16, 26, 20, 1, -26 },
  { 3077, 14, 24, 20, 2, -24 },
  { 3119, 16, 31, 20, 0, -24 },
  { 3181, 17, 26, 20, 2, -26 },
  { 3237, 14, 26, 20, 2, -26 },
  { 3283, 19, 18, 20, 0, -18 },
  { 3326, 16, 18, 20, 1, -18 },
  { 3362, 16, 18, 20, 2, -18 },
  { 3398, 17, 25, 20, 0, -18 },
  { 3452, 16, 25, 20, 2, -18 },
  { 3502, 15, 18, 20, 4, -18 },
  { 3536, 16, 18, 20, 2, -18 },
  { 3572, 13, 23, 20, 4, -23 },
  { 3610, 15, 18, 20, 3, -18 },
  { 3644, 16, 18, 20, 3, -18 },
  { 3680, 18, 18, 20, 2, -18 },
  { 3721, 19, 18, 20, 0, -18 },
  { 3764, 21, 25, 20, -1, -18 },
  { 3830, 17, 18, 20, 1, -18 },
  { 3869, 13, 34, 20, 5, -27 },
  { 3925, 6, 30, 20, 7, -24 },
  { 3948, 13, 34, 20, 3, -27 },
  { 4004, 18, 6, 20, 1, -13 },
};

const GFXfont RobotoMono_LightItalic34pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic34pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic34pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _ROBOTOMONO_LIGHTITALIC34PT7B_H_
