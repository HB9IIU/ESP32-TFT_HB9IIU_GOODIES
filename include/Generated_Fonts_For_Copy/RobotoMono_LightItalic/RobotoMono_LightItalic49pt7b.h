#ifndef _ROBOTOMONO_LIGHTITALIC49PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0xF0, 0x78, 0x38, 0x00, 0x30, 0x66, 0x0C, 0xC1, 0xB8, 0x77, 0x0E,
  0xC1, 0x98, 0x33, 0x06, 0x60, 0xDC, 0x3B, 0x06, 0x00, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x70, 0x18, 0x00,
  0x06, 0x03, 0x80, 0x00, 0x60, 0x38, 0x00, 0x0E, 0x03, 0x00, 0x00, 0xC0,
  0x70, 0x00, 0x1C, 0x06, 0x00, 0x01, 0x80, 0x60, 0x0F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x70,
  0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x38, 0x00, 0x0E, 0x03, 0x00,
  0x00, 0xC0, 0x70, 0x00, 0x0C, 0x07, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x18,
  0x0E, 0x00, 0x03, 0x80, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x00, 0x70, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x38, 0x00, 0x0E,
  0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x07, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x38, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xF8, 0x7C,
  0x03, 0xC0, 0x1C, 0x03, 0x80, 0x1E, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E,
  0x0E, 0x00, 0x06, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38,
  0xE0, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x70, 0x78, 0x00, 0xF0,
  0x38, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x38, 0x70, 0x00,
  0x70, 0x30, 0x00, 0x60, 0x30, 0x08, 0x60, 0x30, 0x1C, 0xE0, 0x30, 0x38,
  0xE0, 0x30, 0x30, 0xC0, 0x30, 0x70, 0xC0, 0x70, 0xE0, 0xC0, 0x60, 0xC0,
  0xE0, 0x61, 0x80, 0x60, 0xC3, 0x80, 0x7F, 0xC7, 0x00, 0x3F, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x61, 0xF8, 0x00, 0xC3, 0xFC, 0x01, 0xC7, 0x0E,
  0x03, 0x86, 0x06, 0x03, 0x0C, 0x06, 0x07, 0x0C, 0x06, 0x0E, 0x0C, 0x06,
  0x0C, 0x1C, 0x06, 0x18, 0x1C, 0x06, 0x38, 0x1C, 0x06, 0x10, 0x1C, 0x0E,
  0x00, 0x1C, 0x0C, 0x00, 0x0C, 0x1C, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3E, 0x3C,
  0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x03, 0x00, 0x0E, 0x01, 0xC0, 0x0E, 0x00,
  0xC0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x70, 0x00, 0xE0,
  0x78, 0x00, 0x30, 0x78, 0x00, 0x1C, 0x78, 0x00, 0x0E, 0x70, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xEE, 0x00, 0x01, 0xE3, 0x80, 0x71, 0xE1, 0xC0, 0x31, 0xE0, 0x70, 0x38,
  0xE0, 0x3C, 0x1C, 0xE0, 0x0E, 0x0E, 0x70, 0x03, 0x8E, 0x70, 0x01, 0xC7,
  0x38, 0x00, 0x77, 0x1C, 0x00, 0x3F, 0x8E, 0x00, 0x0F, 0x87, 0x00, 0x03,
  0x81, 0xC0, 0x03, 0xC0, 0xF0, 0x07, 0xF0, 0x3C, 0x0F, 0x9C, 0x0F, 0xFF,
  0x0E, 0x03, 0xFE, 0x03, 0x80, 0x37, 0x77, 0x66, 0x6E, 0xEC, 0xC0, 0x00,
  0x02, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01,
  0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x2E, 0x06, 0x07, 0xFC, 0x31, 0xFB, 0xF9, 0xBF, 0xC3, 0xFF, 0xE0,
  0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x0E, 0x60, 0x00, 0xE3,
  0x80, 0x0E, 0x0E, 0x00, 0xF0, 0x70, 0x0F, 0x01, 0xC0, 0xF0, 0x0F, 0x03,
  0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x1C, 0x38,
  0x70, 0xE3, 0x87, 0x0E, 0x38, 0xE3, 0xC3, 0x00, 0x7F, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x23, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x07, 0xC1, 0xE0, 0x1E, 0x01,
  0xE0, 0x78, 0x01, 0xC0, 0xE0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x07,
  0x1C, 0x00, 0x06, 0x38, 0x00, 0x1C, 0x60, 0x00, 0x79, 0xC0, 0x01, 0xF3,
  0x80, 0x07, 0xE7, 0x00, 0x3D, 0xCE, 0x00, 0xF3, 0x98, 0x03, 0x87, 0x70,
  0x0E, 0x0E, 0xE0, 0x78, 0x1D, 0xC1, 0xE0, 0x33, 0x87, 0x00, 0xE7, 0x1C,
  0x01, 0xCC, 0xF0, 0x03, 0xBB, 0xC0, 0x07, 0x7E, 0x00, 0x0C, 0xF8, 0x00,
  0x39, 0xE0, 0x00, 0x73, 0x80, 0x00, 0xC3, 0x00, 0x03, 0x86, 0x00, 0x07,
  0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x1C, 0x01, 0xE0, 0x1E, 0x0F, 0x80,
  0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0xE0, 0x1F, 0x81, 0xFE, 0x3F, 0xB9, 0xF0, 0xE7, 0x03, 0xA0, 0x0C, 0x00,
  0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xF0, 0x78, 0x03, 0xC0, 0x1C, 0x07,
  0x80, 0x1E, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1C,
  0x00, 0x06, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0xF8, 0x7C, 0x01, 0xC0, 0x1E, 0x03, 0x80, 0x0E, 0x07,
  0x00, 0x07, 0x07, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x18, 0xE0, 0x00, 0x38, 0x60, 0x00, 0x38, 0x70,
  0x00, 0x70, 0x70, 0x00, 0xF0, 0x38, 0x01, 0xE0, 0x1E, 0x07, 0xC0, 0x0F,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xEC, 0x00,
  0x00, 0xEC, 0x00, 0x01, 0xDC, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x1C, 0x00,
  0x0E, 0x1C, 0x00, 0x0E, 0x18, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x38, 0x00,
  0x70, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x30, 0x03,
  0x80, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x1E, 0x00, 0x70, 0x1C,
  0x00, 0x70, 0x38, 0x00, 0x60, 0x70, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x1F, 0xC7, 0xE0, 0x1E, 0x01, 0xE0, 0x08, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0xE0,
  0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x70,
  0x01, 0xC0, 0x78, 0x03, 0xC0, 0x3C, 0x0F, 0x80, 0x1F, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x80, 0x0F,
  0xFC, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x83, 0xE0, 0x1C, 0xFF, 0xC0, 0xCF, 0xFF, 0x8E, 0xE0, 0x3C, 0x7E,
  0x00, 0x73, 0xC0, 0x03, 0x9C, 0x00, 0x0E, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x1D, 0xC0, 0x00, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x71,
  0xE0, 0x07, 0x07, 0x00, 0x78, 0x1E, 0x0F, 0x80, 0x7F, 0xF0, 0x01, 0xFF,
  0x00, 0x00, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xF8, 0x01, 0xF8, 0x7C, 0x03, 0xC0, 0x1E, 0x03, 0x80, 0x0E,
  0x07, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07,
  0x0E, 0x00, 0x07, 0x0E, 0x00, 0x06, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x1E,
  0x07, 0x00, 0x1C, 0x07, 0x80, 0x78, 0x03, 0xC1, 0xF0, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x07, 0xE3, 0xE0, 0x0F, 0x00, 0xF0, 0x1C, 0x00, 0x78,
  0x38, 0x00, 0x38, 0x70, 0x00, 0x18, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38,
  0xE0, 0x00, 0x70, 0x70, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x3E, 0x07, 0xC0,
  0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0x00,
  0x1F, 0xFC, 0x01, 0xF0, 0xF0, 0x1E, 0x01, 0xC1, 0xC0, 0x0F, 0x1C, 0x00,
  0x38, 0xE0, 0x01, 0xCE, 0x00, 0x07, 0x70, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x07, 0x9C, 0x00, 0x7C, 0xF0,
  0x07, 0xE3, 0xC0, 0xF6, 0x0F, 0xFE, 0x70, 0x3F, 0xE3, 0x80, 0x18, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0xE0, 0x03,
  0xFE, 0x00, 0x1F, 0x80, 0x00, 0x04, 0x0F, 0x1F, 0x1F, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x20, 0xF0, 0xF8, 0xF0, 0xF0, 0x00, 0x80, 0x3C, 0x0F, 0x81,
  0xF0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0,
  0x1C, 0x07, 0x00, 0x40, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x30,
  0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xC0, 0x10,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0xFF, 0xE0, 0x7E, 0x1E, 0x1E, 0x00, 0xE3, 0x80, 0x1C, 0xE0, 0x01, 0xDC,
  0x00, 0x3F, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0x80, 0x38, 0x00,
  0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x0C, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x1E,
  0x06, 0x06, 0x07, 0xF0, 0x60, 0xC0, 0xE3, 0x86, 0x1C, 0x1C, 0x18, 0x61,
  0x83, 0x81, 0x06, 0x18, 0x70, 0x30, 0x63, 0x06, 0x03, 0x06, 0x30, 0x60,
  0x30, 0x63, 0x0C, 0x06, 0x06, 0x60, 0xC0, 0x60, 0x66, 0x0C, 0x06, 0x06,
  0x61, 0xC0, 0x60, 0xC6, 0x18, 0x0C, 0x0C, 0xE1, 0x80, 0xC0, 0xCC, 0x18,
  0x0C, 0x0C, 0xC1, 0x81, 0xC1, 0x8C, 0x18, 0x3C, 0x18, 0xC1, 0x86, 0xC3,
  0x0E, 0x1E, 0xEC, 0x60, 0x60, 0xFC, 0xFE, 0x06, 0x07, 0x07, 0x80, 0x60,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x04,
  0x00, 0x1F, 0x01, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xB0, 0x00, 0x03, 0xB0, 0x00, 0x07, 0x30,
  0x00, 0x07, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x38,
  0x00, 0x1C, 0x18, 0x00, 0x38, 0x18, 0x00, 0x38, 0x18, 0x00, 0x70, 0x1C,
  0x00, 0x70, 0x1C, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x0C, 0x03, 0x80, 0x0C, 0x03, 0x80, 0x0E, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x06,
  0x1C, 0x00, 0x06, 0x38, 0x00, 0x07, 0x38, 0x00, 0x07, 0x30, 0x00, 0x07,
  0x70, 0x00, 0x07, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xE0, 0x03, 0xC0, 0x70, 0x00,
  0xF0, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x0C, 0x0E, 0x00, 0x07, 0x06, 0x00,
  0x03, 0x87, 0x00, 0x01, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0,
  0x00, 0xE0, 0x70, 0x00, 0xF0, 0x30, 0x00, 0xF0, 0x38, 0x03, 0xE0, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0x00, 0x3E, 0x03, 0x80, 0x07, 0x01,
  0x80, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C,
  0x38, 0x00, 0x0E, 0x18, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x03,
  0x87, 0x00, 0x01, 0xC3, 0x80, 0x01, 0xC1, 0xC0, 0x01, 0xE0, 0xC0, 0x03,
  0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xF0, 0x01, 0xF0, 0x7C, 0x03, 0xC0, 0x1C, 0x07,
  0x80, 0x0E, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C,
  0x00, 0x07, 0x38, 0x00, 0x07, 0x38, 0x00, 0x07, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0xE0, 0x00, 0x18, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0,
  0x00, 0x70, 0x70, 0x00, 0xF0, 0x70, 0x01, 0xE0, 0x38, 0x03, 0xC0, 0x1E,
  0x0F, 0x80, 0x0F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0xE0, 0x0F, 0x80,
  0x70, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x18, 0x00, 0x1C, 0x1C, 0x00, 0x0E,
  0x0E, 0x00, 0x03, 0x07, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00,
  0x70, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00,
  0x07, 0x1C, 0x00, 0x03, 0x8C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xC7, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x60,
  0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E,
  0x00, 0x07, 0x07, 0x00, 0x07, 0x03, 0x00, 0x07, 0x83, 0x80, 0x07, 0x81,
  0xC0, 0x0F, 0x80, 0xE0, 0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xF8, 0x7C, 0x03, 0xC0,
  0x1C, 0x07, 0x80, 0x0E, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x1C, 0x00,
  0x07, 0x1C, 0x00, 0x07, 0x38, 0x00, 0x03, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x0F, 0xFE, 0xE0, 0x0F,
  0xFE, 0xE0, 0x0F, 0xFE, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x1C, 0xC0, 0x00,
  0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x18, 0x60, 0x00, 0x38, 0x70, 0x00, 0x38, 0x78, 0x00, 0x78, 0x3C, 0x00,
  0xF0, 0x1E, 0x03, 0xE0, 0x0F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x70, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x81,
  0x80, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0x81, 0xC0, 0x00,
  0x30, 0x38, 0x00, 0x0E, 0x06, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x38, 0x38,
  0x00, 0x07, 0x07, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x18, 0x1C, 0x00, 0x07,
  0x03, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x1C, 0x1F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE0, 0x70, 0x00, 0x0C, 0x0E, 0x00, 0x03, 0x81, 0x80, 0x00, 0x70,
  0x30, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x30, 0x38, 0x00,
  0x06, 0x07, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x38, 0x18, 0x00, 0x07, 0x07,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x18, 0x1C, 0x00, 0x03, 0x03, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x60, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07,
  0x07, 0x00, 0x07, 0x01, 0xC0, 0x07, 0x80, 0xF0, 0x07, 0x80, 0x3E, 0x0F,
  0x80, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x38, 0x00, 0x1E, 0x03, 0x80, 0x03, 0xC0, 0x30, 0x00, 0x78, 0x07, 0x00,
  0x0F, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0x70, 0x07, 0x80,
  0x07, 0x00, 0xF0, 0x00, 0x60, 0x1E, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0xE0,
  0x78, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0E, 0x3C, 0x00,
  0x00, 0xC7, 0x80, 0x00, 0x1C, 0xF8, 0x00, 0x01, 0xDF, 0x80, 0x00, 0x1F,
  0xDC, 0x00, 0x01, 0xF9, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0x78, 0x00, 0x38, 0x03, 0x80, 0x03,
  0x80, 0x1C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0xE0, 0x07, 0x00, 0x07, 0x00, 0x70, 0x00, 0x70, 0x07, 0x00, 0x03, 0x80,
  0x60, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x1F, 0x03, 0xC0,
  0x01, 0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x7E,
  0x07, 0x60, 0x06, 0xE0, 0x76, 0x00, 0xEC, 0x07, 0x60, 0x1C, 0xC0, 0x67,
  0x01, 0xCC, 0x06, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x30, 0x71,
  0xC0, 0xE3, 0x07, 0x18, 0x0E, 0x30, 0xE1, 0x80, 0xC3, 0x8C, 0x38, 0x0C,
  0x39, 0xC3, 0x81, 0xC3, 0x98, 0x38, 0x1C, 0x1B, 0x83, 0x81, 0xC1, 0xF0,
  0x30, 0x1C, 0x1F, 0x07, 0x01, 0x81, 0xE0, 0x70, 0x18, 0x1E, 0x07, 0x03,
  0x80, 0xC0, 0x70, 0x38, 0x0C, 0x07, 0x03, 0x80, 0x00, 0x60, 0x38, 0x00,
  0x0E, 0x03, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x0C, 0x07, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x1C, 0x06, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00,
  0x1C, 0x0F, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x70, 0x3E, 0x00, 0x0E, 0x0F,
  0xC0, 0x01, 0x81, 0xF8, 0x00, 0x70, 0x3B, 0x80, 0x0E, 0x07, 0x70, 0x01,
  0xC0, 0xC6, 0x00, 0x38, 0x38, 0xE0, 0x07, 0x07, 0x1C, 0x00, 0xC0, 0xE1,
  0x80, 0x38, 0x1C, 0x38, 0x07, 0x03, 0x87, 0x00, 0xE0, 0x60, 0x60, 0x1C,
  0x1C, 0x0E, 0x03, 0x83, 0x81, 0xC0, 0x60, 0x70, 0x1C, 0x1C, 0x0E, 0x03,
  0x83, 0x81, 0xC0, 0x70, 0x70, 0x30, 0x07, 0x0E, 0x0E, 0x00, 0xE1, 0xC1,
  0xC0, 0x0C, 0x70, 0x38, 0x01, 0xCE, 0x07, 0x00, 0x39, 0xC0, 0xE0, 0x03,
  0x38, 0x18, 0x00, 0x77, 0x07, 0x00, 0x0E, 0xC0, 0xE0, 0x00, 0xF8, 0x1C,
  0x00, 0x1F, 0x03, 0x80, 0x03, 0xE0, 0x70, 0x00, 0x3C, 0x0C, 0x00, 0x07,
  0x83, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x01,
  0xF8, 0xF8, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x1C, 0x07, 0x00, 0x0E, 0x0E,
  0x00, 0x0E, 0x1C, 0x00, 0x06, 0x1C, 0x00, 0x07, 0x38, 0x00, 0x07, 0x38,
  0x00, 0x07, 0x38, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70,
  0x00, 0x07, 0x70, 0x00, 0x06, 0x60, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0C, 0xE0,
  0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38, 0xE0,
  0x00, 0x38, 0xE0, 0x00, 0x70, 0x60, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x70,
  0x01, 0xC0, 0x38, 0x03, 0xC0, 0x1E, 0x0F, 0x80, 0x0F, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x40, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0xE0, 0x03, 0xC0, 0x70, 0x00, 0x70, 0x30, 0x00, 0x3C,
  0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0xE1, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0, 0x00,
  0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x0C, 0x00,
  0x3C, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0x1F, 0x00, 0x3C, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x3C,
  0x00, 0x38, 0x1C, 0x00, 0x0C, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x8E,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x33, 0x80, 0x00, 0x19,
  0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03,
  0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0C, 0xE0, 0x00,
  0x0E, 0x30, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00,
  0x03, 0x81, 0xC0, 0x03, 0x80, 0xE0, 0x03, 0xC0, 0x38, 0x03, 0xC0, 0x1F,
  0x07, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x20, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x60, 0x03, 0xC0, 0x30, 0x00, 0xF0, 0x38, 0x00, 0x38, 0x1C,
  0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38,
  0x38, 0x00, 0x38, 0x18, 0x00, 0x3C, 0x1C, 0x00, 0x3C, 0x0E, 0x00, 0x7C,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x01, 0xC0, 0x38, 0x00, 0xC0, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00,
  0x70, 0x0C, 0x00, 0x38, 0x06, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x03, 0x80,
  0x03, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x60, 0x00, 0x38, 0x30,
  0x00, 0x1C, 0x38, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x3E, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x38, 0x00, 0x70, 0x38, 0x00,
  0x1C, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00,
  0x00, 0xC3, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x07, 0x38, 0x00, 0x03, 0x8C, 0x00, 0x01, 0xC7, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x78, 0x01, 0xF0, 0x1F, 0x03,
  0xF0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x01, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0x80,
  0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0C, 0x38,
  0x00, 0x0E, 0x18, 0x00, 0x07, 0x0C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0x61, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x38,
  0x60, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x06, 0x1C, 0x00, 0x03,
  0x0E, 0x00, 0x03, 0x86, 0x00, 0x01, 0xC3, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x71, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x38, 0x00,
  0x0E, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x07, 0x01, 0xC0,
  0x07, 0x80, 0x70, 0x07, 0x80, 0x3E, 0x0F, 0x80, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x08, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0x9C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xE3, 0x80, 0x00,
  0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x30, 0x00, 0x38, 0x1C, 0x00,
  0x38, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x01, 0xC0,
  0x0E, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x0E,
  0x01, 0x80, 0x07, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0xE0, 0x00,
  0x60, 0x70, 0x00, 0x30, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x38, 0x00,
  0x07, 0x1C, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x37, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0xEE,
  0x01, 0xC0, 0x19, 0xC0, 0x38, 0x07, 0x38, 0x0F, 0x00, 0xE7, 0x01, 0xE0,
  0x18, 0xE0, 0x3C, 0x07, 0x1C, 0x0F, 0x80, 0xE3, 0x81, 0xF0, 0x18, 0x70,
  0x36, 0x03, 0x0E, 0x0E, 0xC0, 0xE1, 0xC1, 0xD8, 0x1C, 0x38, 0x33, 0x03,
  0x07, 0x0E, 0x60, 0xE0, 0xC1, 0xCC, 0x1C, 0x18, 0x31, 0x83, 0x03, 0x0E,
  0x30, 0x60, 0x61, 0xC7, 0x1C, 0x0C, 0x30, 0xE3, 0x81, 0x8E, 0x1C, 0x60,
  0x31, 0xC3, 0x9C, 0x06, 0x30, 0x73, 0x80, 0xCE, 0x0E, 0x60, 0x19, 0xC1,
  0xDC, 0x03, 0x30, 0x3B, 0x80, 0x6E, 0x07, 0x60, 0x0D, 0xC0, 0xEC, 0x01,
  0xB0, 0x1F, 0x80, 0x3E, 0x03, 0xF0, 0x07, 0xC0, 0x7C, 0x00, 0xF0, 0x0F,
  0x80, 0x1E, 0x01, 0xF0, 0x03, 0xC0, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E,
  0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x07,
  0x00, 0x01, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0x38, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x07, 0x00, 0x38, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x3B, 0xC0, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1C, 0x18,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xE0, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x01, 0xE0,
  0x00, 0x1C, 0x0F, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x07, 0xB8, 0x00,
  0x03, 0x9C, 0x00, 0x03, 0x8E, 0x00, 0x03, 0xC3, 0x80, 0x01, 0xC1, 0xC0,
  0x01, 0xC0, 0xE0, 0x01, 0xE0, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x70, 0x00,
  0x30, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x1C, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xFF, 0x80, 0xFF,
  0x00, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0xE0, 0x18, 0x06, 0x01, 0xC0, 0x70,
  0x1C, 0x03, 0x00, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0x60, 0x18, 0x07, 0x01,
  0xC0, 0x70, 0x0C, 0x03, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0x80, 0x60, 0x1C,
  0x07, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0xE0, 0x38, 0x06, 0x01, 0x80,
  0x70, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x70, 0x00, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x70, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x06, 0x60, 0x07, 0x30, 0x07, 0x1C, 0x03,
  0x8E, 0x03, 0x87, 0x01, 0xC1, 0x81, 0xC0, 0xC0, 0xC0, 0x70, 0xE0, 0x38,
  0xE0, 0x1C, 0x70, 0x06, 0x70, 0x03, 0xB8, 0x01, 0xF8, 0x00, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE1, 0xC7, 0x0E, 0x18, 0x70, 0xC0, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0x81, 0xE0, 0x3C, 0x01, 0xE0, 0xF0,
  0x01, 0xC1, 0xC0, 0x01, 0x87, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x03, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC1, 0xF8, 0x03, 0x87, 0x80, 0x06, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x38,
  0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x00, 0x03, 0xC7, 0x00, 0x0F, 0x0E,
  0x00, 0x3E, 0x1E, 0x00, 0xFC, 0x1E, 0x0F, 0xB8, 0x1F, 0xFE, 0x70, 0x1F,
  0xF0, 0xE0, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0xFE,
  0x00, 0xE7, 0xFF, 0x01, 0xDE, 0x1F, 0x03, 0xF0, 0x0E, 0x07, 0x80, 0x0E,
  0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x71,
  0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC6, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x38,
  0x00, 0x0E, 0x70, 0x00, 0x18, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x00,
  0x01, 0xCE, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x3C, 0x00, 0x38, 0x78, 0x00,
  0xF0, 0xF8, 0x03, 0xC1, 0xBC, 0x1F, 0x07, 0x3F, 0xFC, 0x0E, 0x1F, 0xE0,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x3E, 0x0F,
  0x01, 0xE0, 0x1E, 0x0E, 0x00, 0x38, 0x70, 0x00, 0x71, 0xC0, 0x01, 0xCE,
  0x00, 0x07, 0x38, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x03, 0x1C, 0x00, 0x1C, 0x70,
  0x00, 0x71, 0xC0, 0x03, 0x83, 0x80, 0x1C, 0x07, 0x81, 0xE0, 0x0F, 0xFF,
  0x00, 0x1F, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x1F, 0xE1, 0xC0, 0x1F, 0xFC, 0xE0,
  0x3E, 0x0F, 0x60, 0x3C, 0x01, 0xF0, 0x1C, 0x00, 0x78, 0x1C, 0x00, 0x3C,
  0x1E, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x03, 0x07, 0x00, 0x03,
  0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00,
  0x38, 0x70, 0x00, 0x18, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00,
  0x07, 0x07, 0x00, 0x03, 0x81, 0x80, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0x70,
  0x01, 0xE0, 0x1C, 0x01, 0xF0, 0x0F, 0x83, 0xF8, 0x03, 0xFF, 0x9C, 0x00,
  0xFF, 0x8E, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x3E, 0x0F, 0x01,
  0xE0, 0x1E, 0x0E, 0x00, 0x38, 0x70, 0x00, 0x73, 0xC0, 0x01, 0xCE, 0x00,
  0x07, 0x70, 0x00, 0x0D, 0xC0, 0x00, 0x37, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x01, 0xC3, 0xC0, 0x1E, 0x07, 0x81, 0xF0, 0x0F, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x1F, 0x01, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x7F, 0x87, 0x01, 0xFF, 0xE7, 0x03, 0xE0, 0xF7, 0x07, 0x80, 0x36,
  0x07, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x1E, 0x00, 0x0E, 0x1C, 0x00, 0x0E,
  0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C,
  0x30, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x18, 0x70, 0x00, 0x38,
  0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x30, 0x00, 0x38,
  0x38, 0x00, 0x70, 0x38, 0x00, 0xF0, 0x1C, 0x01, 0xF0, 0x1F, 0x07, 0xF0,
  0x0F, 0xFE, 0x70, 0x03, 0xFC, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x40, 0x01, 0xC0, 0xC0, 0x03, 0x80,
  0xF0, 0x0F, 0x00, 0x78, 0x3E, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x7F, 0x00, 0xE3,
  0xFF, 0x81, 0xCF, 0x0F, 0x83, 0xB0, 0x07, 0x06, 0xC0, 0x0E, 0x0F, 0x00,
  0x0E, 0x3C, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0, 0x00,
  0xE3, 0x80, 0x01, 0xC6, 0x00, 0x03, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C,
  0x70, 0x00, 0x38, 0xE0, 0x00, 0x71, 0x80, 0x00, 0xE7, 0x00, 0x01, 0x8E,
  0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xC0,
  0x00, 0x73, 0x80, 0x00, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x1F, 0x0E, 0x00, 0x3C, 0x0C, 0x00, 0x78, 0x1C, 0x00, 0xF0, 0x1C, 0x03,
  0xC0, 0x1C, 0x07, 0x80, 0x1C, 0x0F, 0x00, 0x1C, 0x1E, 0x00, 0x18, 0x3C,
  0x00, 0x38, 0xF0, 0x00, 0x39, 0xE0, 0x00, 0x3B, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0x70, 0x00, 0x3C, 0x78, 0x00, 0x78, 0x38, 0x00, 0x70, 0x1C,
  0x00, 0x70, 0x1E, 0x00, 0x70, 0x0E, 0x00, 0x60, 0x07, 0x00, 0xE0, 0x07,
  0x80, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0xC0, 0xE0, 0x01, 0xE0, 0xE0, 0x00,
  0xE0, 0xC0, 0x00, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0E, 0x7E, 0x1F, 0x81, 0xBF, 0xE7, 0xF8, 0x3E, 0x1D, 0xC7, 0x8F,
  0x03, 0xE0, 0x71, 0xE0, 0x38, 0x06, 0x38, 0x07, 0x00, 0xC7, 0x00, 0xC0,
  0x18, 0xC0, 0x18, 0x07, 0x18, 0x07, 0x00, 0xE7, 0x00, 0xE0, 0x1C, 0xE0,
  0x1C, 0x03, 0x9C, 0x03, 0x80, 0x63, 0x80, 0x60, 0x0C, 0x60, 0x0C, 0x03,
  0x8C, 0x03, 0x80, 0x73, 0x80, 0x70, 0x0E, 0x70, 0x0E, 0x01, 0xCE, 0x01,
  0xC0, 0x31, 0xC0, 0x30, 0x06, 0x30, 0x06, 0x01, 0xC6, 0x01, 0xC0, 0x39,
  0xC0, 0x38, 0x07, 0x38, 0x07, 0x00, 0xE7, 0x00, 0xE0, 0x18, 0xC0, 0x18,
  0x03, 0x18, 0x07, 0x00, 0xE0, 0x0E, 0x0F, 0xE0, 0x1C, 0x7F, 0xF0, 0x3B,
  0xE1, 0xF0, 0x6E, 0x00, 0xE0, 0xD8, 0x01, 0xC1, 0xE0, 0x01, 0xC7, 0x80,
  0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00,
  0x31, 0xC0, 0x00, 0x63, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x07,
  0x1C, 0x00, 0x0E, 0x30, 0x00, 0x18, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE3,
  0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x18, 0x00, 0x0C, 0x70,
  0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x1F, 0x07, 0xC0, 0x78, 0x03, 0x81, 0xE0, 0x03, 0x83, 0x80,
  0x07, 0x8E, 0x00, 0x07, 0x3C, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00,
  0x1B, 0x80, 0x00, 0x37, 0x00, 0x00, 0x6E, 0x00, 0x01, 0xDC, 0x00, 0x03,
  0xB0, 0x00, 0x07, 0x60, 0x00, 0x0E, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0x73,
  0x80, 0x00, 0xE7, 0x00, 0x03, 0x8E, 0x00, 0x0F, 0x0E, 0x00, 0x3C, 0x1E,
  0x00, 0xF0, 0x1E, 0x07, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0x00, 0x00, 0x03, 0x87, 0xF0, 0x01, 0xCF, 0xFE, 0x00, 0xEF, 0x0F, 0x80,
  0x7E, 0x01, 0xC0, 0x3C, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x1E, 0x00, 0x1C,
  0x0E, 0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00,
  0xE0, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x18, 0x38, 0x00,
  0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x06, 0x00, 0x07, 0x07, 0x00,
  0x03, 0x83, 0x80, 0x03, 0xC1, 0xC0, 0x01, 0xC0, 0xF0, 0x01, 0xC0, 0x7C,
  0x01, 0xE0, 0x37, 0x03, 0xE0, 0x39, 0xFF, 0xE0, 0x1C, 0x7F, 0xC0, 0x0E,
  0x02, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x0E, 0x03, 0xFF,
  0x9C, 0x1F, 0x07, 0xB0, 0x78, 0x03, 0xE0, 0xE0, 0x03, 0xC3, 0x80, 0x07,
  0x8F, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x18, 0xE0, 0x00, 0x71,
  0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC6, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x38,
  0x00, 0x0C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80,
  0x01, 0xC3, 0x00, 0x03, 0x87, 0x00, 0x0E, 0x0E, 0x00, 0x3C, 0x0E, 0x00,
  0xF8, 0x1F, 0x07, 0xF0, 0x1F, 0xFE, 0xE0, 0x0F, 0xF1, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x0E, 0x0F, 0xF8, 0x71, 0xFF, 0xC3, 0x9F, 0xDC, 0x19,
  0xC0, 0x00, 0xDC, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x7C, 0x0F, 0x83, 0xC0, 0x0E, 0x0E,
  0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x00, 0xC7, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x71, 0xC0, 0x01,
  0xC7, 0x80, 0x0E, 0x0F, 0x81, 0xF0, 0x1F, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0x40, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x38,
  0x00, 0x38, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00,
  0x39, 0xC0, 0x00, 0xC7, 0x00, 0x07, 0x18, 0x00, 0x1C, 0xE0, 0x00, 0x73,
  0x80, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x18, 0xE0, 0x00, 0xE3, 0x80,
  0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x01, 0xE3, 0x80, 0x0F,
  0x07, 0x00, 0x6C, 0x1E, 0x0F, 0x70, 0x3F, 0xF9, 0xC0, 0x7F, 0x87, 0x00,
  0x10, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x0E, 0x70, 0x00, 0x1C,
  0x70, 0x00, 0x1C, 0x70, 0x00, 0x38, 0x30, 0x00, 0x38, 0x38, 0x00, 0x70,
  0x38, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x18, 0x00, 0xE0, 0x1C, 0x01, 0xC0,
  0x1C, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x0C, 0x07, 0x00, 0x0E, 0x07, 0x00,
  0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x06, 0x1C, 0x00, 0x07, 0x18, 0x00,
  0x07, 0x38, 0x00, 0x03, 0x30, 0x00, 0x03, 0x70, 0x00, 0x03, 0x60, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x0C, 0x00,
  0xD8, 0x03, 0x00, 0x76, 0x01, 0xE0, 0x1D, 0x80, 0x78, 0x06, 0x60, 0x1E,
  0x03, 0x98, 0x0D, 0x80, 0xC6, 0x03, 0x60, 0x71, 0x81, 0xD8, 0x1C, 0x60,
  0x66, 0x06, 0x18, 0x39, 0x83, 0x86, 0x0C, 0x60, 0xC1, 0x83, 0x18, 0x30,
  0x61, 0xC6, 0x1C, 0x18, 0x61, 0x86, 0x06, 0x38, 0x63, 0x81, 0x8C, 0x18,
  0xC0, 0x63, 0x07, 0x30, 0x19, 0x81, 0xDC, 0x06, 0x60, 0x36, 0x01, 0xB8,
  0x0D, 0x80, 0x6C, 0x03, 0xE0, 0x1B, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x80,
  0x1C, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0x38, 0x1E, 0x00, 0x03, 0x87,
  0x80, 0x00, 0x71, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x3C, 0x38, 0x00, 0x0F,
  0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x78, 0x00, 0x1C, 0x1E, 0x00,
  0x03, 0xC0, 0x07, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x07,
  0x80, 0x1C, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x00,
  0xE0, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0xE0, 0x00, 0x38, 0x00, 0x01, 0x00, 0x03, 0x81, 0x80,
  0xC0, 0x60, 0x30, 0x38, 0x1C, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xE0,
  0x70, 0x30, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30,
  0x38, 0x1C, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x70, 0x30, 0x18,
  0x0C, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x04, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x1C, 0xFF,
  0xE0, 0x03, 0x3C, 0x1E, 0x00, 0xE7, 0x01, 0xE0, 0x1D, 0xC0, 0x1E, 0x07,
  0x38, 0x01, 0xFF, 0xC6, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x78, 0x00,
};

const GFXglyph RobotoMono_LightItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 9, 35, 29, 10, -35 },
  { 41, 11, 11, 29, 11, -37 },
  { 57, 28, 35, 29, 1, -35 },
  { 180, 24, 45, 29, 3, -40 },
  { 315, 24, 36, 29, 3, -35 },
  { 423, 25, 35, 29, 2, -35 },
  { 533, 4, 11, 29, 14, -37 },
  { 539, 16, 50, 29, 8, -39 },
  { 639, 16, 50, 29, 4, -39 },
  { 739, 21, 21, 29, 6, -35 },
  { 795, 24, 26, 29, 3, -29 },
  { 873, 7, 12, 29, 5, -5 },
  { 884, 18, 3, 29, 5, -17 },
  { 891, 5, 5, 29, 10, -5 },
  { 895, 24, 38, 29, 3, -35 },
  { 1009, 23, 36, 29, 3, -35 },
  { 1113, 14, 35, 29, 7, -35 },
  { 1175, 24, 35, 29, 1, -35 },
  { 1280, 24, 36, 29, 1, -35 },
  { 1388, 24, 35, 29, 1, -35 },
  { 1493, 24, 36, 29, 4, -35 },
  { 1601, 21, 36, 29, 3, -35 },
  { 1696, 23, 35, 29, 5, -35 },
  { 1797, 24, 36, 29, 3, -35 },
  { 1905, 21, 35, 29, 5, -35 },
  { 1997, 8, 26, 29, 12, -26 },
  { 2023, 11, 33, 29, 9, -26 },
  { 2069, 22, 20, 29, 4, -26 },
  { 2124, 23, 12, 29, 3, -22 },
  { 2159, 22, 21, 29, 3, -26 },
  { 2217, 19, 35, 29, 7, -35 },
  { 2301, 28, 35, 29, 1, -35 },
  { 2424, 24, 35, 29, 0, -35 },
  { 2529, 25, 35, 29, 2, -35 },
  { 2639, 24, 36, 29, 3, -35 },
  { 2747, 25, 35, 29, 2, -35 },
  { 2857, 26, 35, 29, 2, -35 },
  { 2971, 26, 35, 29, 2, -35 },
  { 3085, 24, 36, 29, 3, -35 },
  { 3193, 27, 35, 29, 1, -35 },
  { 3312, 26, 35, 29, 2, -35 },
  { 3426, 25, 35, 29, 2, -35 },
  { 3536, 28, 35, 29, 2, -35 },
  { 3659, 20, 35, 29, 3, -35 },
  { 3747, 28, 35, 29, 1, -35 },
  { 3870, 27, 35, 29, 1, -35 },
  { 3989, 24, 36, 29, 3, -35 },
  { 4097, 25, 35, 29, 3, -35 },
  { 4207, 25, 41, 29, 2, -35 },
  { 4336, 25, 35, 29, 2, -35 },
  { 4446, 25, 36, 29, 2, -35 },
  { 4559, 25, 35, 29, 5, -35 },
  { 4669, 25, 36, 29, 3, -35 },
  { 4782, 25, 35, 29, 5, -35 },
  { 4892, 27, 35, 29, 4, -35 },
  { 5011, 30, 35, 29, 0, -35 },
  { 5143, 25, 35, 29, 5, -35 },
  { 5253, 26, 35, 29, 1, -35 },
  { 5367, 16, 47, 29, 7, -40 },
  { 5461, 10, 38, 29, 10, -35 },
  { 5509, 15, 47, 29, 7, -40 },
  { 5598, 17, 19, 29, 6, -35 },
  { 5639, 21, 2, 29, 1, 0 },
  { 5645, 6, 7, 29, 14, -36 },
  { 5651, 23, 26, 29, 2, -26 },
  { 5726, 23, 38, 29, 2, -37 },
  { 5836, 22, 27, 29, 3, -26 },
  { 5911, 25, 37, 29, 3, -37 },
  { 6027, 22, 27, 29, 3, -26 },
  { 6102, 24, 38, 29, 6, -38 },
  { 6216, 24, 36, 29, 2, -26 },
  { 6324, 23, 37, 29, 2, -37 },
  { 6431, 20, 35, 29, 3, -35 },
  { 6519, 23, 45, 29, 0, -35 },
  { 6649, 24, 37, 29, 3, -37 },
  { 6760, 20, 37, 29, 3, -37 },
  { 6853, 27, 26, 29, 0, -26 },
  { 6941, 23, 26, 29, 2, -26 },
  { 7016, 23, 27, 29, 3, -26 },
  { 7094, 25, 36, 29, 0, -26 },
  { 7207, 23, 36, 29, 3, -26 },
  { 7311, 21, 26, 29, 6, -26 },
  { 7380, 22, 27, 29, 3, -26 },
  { 7455, 19, 34, 29, 6, -33 },
  { 7536, 22, 27, 29, 4, -26 },
  { 7611, 24, 26, 29, 4, -26 },
  { 7689, 26, 26, 29, 3, -26 },
  { 7774, 27, 26, 29, 1, -26 },
  { 7862, 30, 36, 29, -1, -26 },
  { 7997, 25, 26, 29, 1, -26 },
  { 8079, 19, 48, 29, 8, -38 },
  { 8193, 9, 43, 29, 10, -35 },
  { 8242, 19, 48, 29, 4, -38 },
  { 8356, 27, 9, 29, 1, -19 },
};

const GFXfont RobotoMono_LightItalic49pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic49pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic49pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _ROBOTOMONO_LIGHTITALIC49PT7B_H_
