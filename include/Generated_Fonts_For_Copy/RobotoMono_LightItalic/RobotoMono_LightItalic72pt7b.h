#ifndef _ROBOTOMONO_LIGHTITALIC72PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x01, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x07, 0xC0, 0x1F,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x8E, 0x03, 0xC7,
  0x01, 0xE7, 0x80, 0xE3, 0xC0, 0x71, 0xE0, 0x78, 0xE0, 0x3C, 0x70, 0x1E,
  0x38, 0x0E, 0x3C, 0x07, 0x1E, 0x03, 0x8E, 0x03, 0xC7, 0x01, 0xE3, 0x80,
  0xE1, 0xC0, 0x71, 0xE0, 0x38, 0x00, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0x80, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x78, 0x01,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x03, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x01,
  0xE0, 0x07, 0x80, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFE, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF8, 0x00,
  0x01, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x03, 0xC1, 0xF0, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x0F,
  0x8F, 0x00, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00,
  0x3C, 0x3E, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00,
  0x38, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x0E, 0x00,
  0x30, 0x78, 0x01, 0xC0, 0x07, 0x0F, 0x00, 0x38, 0x01, 0xE1, 0xC0, 0x07,
  0x00, 0x78, 0x38, 0x00, 0xE0, 0x1E, 0x07, 0x00, 0x1C, 0x03, 0x80, 0xE0,
  0x03, 0x80, 0xF0, 0x1C, 0x00, 0xF0, 0x3C, 0x03, 0x80, 0x1C, 0x07, 0x00,
  0x70, 0x07, 0x81, 0xE0, 0x0E, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x3C, 0x1E,
  0x00, 0x1E, 0x0F, 0x03, 0xC0, 0x03, 0xFF, 0xC0, 0xF0, 0x00, 0x3F, 0xF0,
  0x3C, 0x00, 0x01, 0xFC, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x7F, 0x80, 0x00, 0x78, 0x1F, 0xF8, 0x00, 0x0E,
  0x07, 0xFF, 0x80, 0x03, 0xC1, 0xE0, 0x78, 0x00, 0xF0, 0x78, 0x07, 0x00,
  0x1C, 0x0E, 0x00, 0xE0, 0x07, 0x83, 0xC0, 0x1E, 0x01, 0xE0, 0x70, 0x03,
  0xC0, 0x78, 0x0E, 0x00, 0x78, 0x0E, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x78,
  0x01, 0xE0, 0xF0, 0x0E, 0x00, 0x3C, 0x1C, 0x01, 0xC0, 0x07, 0x07, 0x80,
  0x38, 0x00, 0xE1, 0xE0, 0x07, 0x00, 0x3C, 0x18, 0x00, 0xE0, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x7C, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x03, 0xC3, 0xF0, 0x00,
  0x00, 0x1E, 0x7E, 0x00, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0x03, 0xF1, 0xF0, 0x00, 0x00, 0x7E, 0x0F, 0x00, 0x0F, 0x07, 0xC0, 0xF8,
  0x00, 0xF0, 0xF8, 0x07, 0x80, 0x0F, 0x1F, 0x00, 0x7C, 0x01, 0xE3, 0xE0,
  0x03, 0xE0, 0x1E, 0x3C, 0x00, 0x1E, 0x01, 0xE7, 0xC0, 0x01, 0xF0, 0x3C,
  0x78, 0x00, 0x0F, 0x03, 0xC7, 0x80, 0x00, 0xF8, 0x7C, 0xF8, 0x00, 0x07,
  0xC7, 0x8F, 0x00, 0x00, 0x3C, 0xF8, 0xF0, 0x00, 0x03, 0xFF, 0x0F, 0x00,
  0x00, 0x1F, 0xE0, 0xF0, 0x00, 0x01, 0xFE, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x78, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x1F, 0xC0, 0x3C, 0x00, 0x07,
  0xFE, 0x03, 0xF0, 0x01, 0xFD, 0xE0, 0x1F, 0xC0, 0x7F, 0x1F, 0x00, 0xFF,
  0xFF, 0xE0, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0x80, 0x1F, 0xFE, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1C, 0x38, 0x71, 0xE3, 0xC7, 0x8F, 0x1C,
  0x38, 0xF1, 0xE3, 0x87, 0x0E, 0x3C, 0x78, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x80, 0x03, 0x80,
  0x09, 0xE0, 0x0F, 0x00, 0x7B, 0xF0, 0x1E, 0x07, 0xFF, 0xFC, 0x38, 0x7F,
  0xEF, 0xFE, 0x73, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00,
  0x7C, 0x1E, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x01, 0xF8, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0xF8, 0x03, 0x80, 0x01, 0xC0, 0x02, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x81,
  0xE0, 0x78, 0x3E, 0x0F, 0x03, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x07, 0x83,
  0xC0, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFE, 0x18, 0xFD, 0xFF, 0xFF, 0xEF, 0xDF, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0,
  0x7C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x03,
  0x83, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00,
  0x3F, 0x1E, 0x00, 0x00, 0x1F, 0xC7, 0x80, 0x00, 0x0F, 0xF1, 0xE0, 0x00,
  0x0F, 0xFC, 0xF0, 0x00, 0x07, 0xDF, 0x3C, 0x00, 0x03, 0xE7, 0x8F, 0x00,
  0x01, 0xF1, 0xE3, 0xC0, 0x01, 0xF8, 0x78, 0xF0, 0x00, 0xF8, 0x1E, 0x7C,
  0x00, 0x7C, 0x07, 0x9E, 0x00, 0x3E, 0x01, 0xE7, 0x80, 0x3F, 0x00, 0xF1,
  0xE0, 0x1F, 0x00, 0x3C, 0x78, 0x0F, 0x80, 0x0F, 0x1E, 0x07, 0xC0, 0x03,
  0xC7, 0x87, 0xE0, 0x00, 0xF3, 0xC3, 0xE0, 0x00, 0x7C, 0xF1, 0xF0, 0x00,
  0x1E, 0x3C, 0xF8, 0x00, 0x07, 0x8F, 0xFC, 0x00, 0x01, 0xE3, 0xFC, 0x00,
  0x00, 0x78, 0xFE, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x0F, 0x0F, 0x80,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x3F, 0x80, 0x3F,
  0xF0, 0x1F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFC, 0xF7, 0xFC, 0x1E, 0xFE, 0x03,
  0xDE, 0x00, 0x7B, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF8, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03,
  0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x01, 0xE0,
  0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x00, 0x3E, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x03, 0xE0, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x3F, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x07, 0xC7, 0x80, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0xF8,
  0x0F, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0xF8, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x00,
  0x78, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x07, 0xE0, 0x00, 0x03, 0xCF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x40, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF8, 0x1E, 0x00,
  0x00, 0x1E, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x70, 0x00, 0x0F, 0x07, 0xFF, 0x00, 0x0F, 0x1F, 0xFF, 0xC0, 0x1E,
  0x3F, 0xFF, 0xE0, 0x1E, 0xFE, 0x07, 0xF0, 0x1D, 0xF0, 0x01, 0xF8, 0x3F,
  0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x3C, 0x3E,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1E, 0xF8,
  0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3E, 0x78,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x78, 0x7C,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x3F, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x1F, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x1E, 0x00,
  0x00, 0x78, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x0F, 0x07, 0xC0, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x3E,
  0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xE0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x7E, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0x7C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0xF9,
  0xE0, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x0F, 0xE3, 0xE0, 0x00, 0x7B, 0x87,
  0xE0, 0x01, 0xEF, 0x07, 0xE0, 0x0F, 0x9E, 0x07, 0xF9, 0xFE, 0x3C, 0x07,
  0xFF, 0xF8, 0xF0, 0x07, 0xFF, 0xC1, 0xE0, 0x03, 0xFE, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x40, 0x0F, 0x80, 0xFC, 0x07, 0xF0,
  0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x7C, 0x03, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3E, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x20, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFE, 0x01,
  0xF8, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x7C,
  0x00, 0x03, 0xEF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x01,
  0xE0, 0x07, 0xE0, 0x0E, 0x01, 0xC0, 0x1F, 0xF0, 0x0E, 0x03, 0xC0, 0x3F,
  0xFC, 0x0E, 0x07, 0x80, 0x7C, 0x3C, 0x0E, 0x07, 0x00, 0xF0, 0x1C, 0x06,
  0x0F, 0x01, 0xE0, 0x1C, 0x07, 0x0E, 0x03, 0xC0, 0x18, 0x07, 0x1E, 0x03,
  0x80, 0x38, 0x06, 0x1C, 0x07, 0x80, 0x38, 0x06, 0x1C, 0x07, 0x00, 0x38,
  0x06, 0x3C, 0x0E, 0x00, 0x30, 0x0E, 0x38, 0x0E, 0x00, 0x70, 0x0E, 0x38,
  0x1E, 0x00, 0x70, 0x0E, 0x78, 0x1C, 0x00, 0x70, 0x0E, 0x70, 0x1C, 0x00,
  0x60, 0x0E, 0x70, 0x1C, 0x00, 0xE0, 0x0E, 0x70, 0x3C, 0x00, 0xE0, 0x1C,
  0x70, 0x38, 0x00, 0xE0, 0x1C, 0xE0, 0x38, 0x00, 0xC0, 0x1C, 0xE0, 0x38,
  0x01, 0xC0, 0x1C, 0xE0, 0x38, 0x01, 0xC0, 0x38, 0xE0, 0x38, 0x03, 0xC0,
  0x38, 0xE0, 0x38, 0x03, 0xC0, 0x30, 0xE0, 0x38, 0x07, 0x80, 0x70, 0xE0,
  0x38, 0x0F, 0x80, 0x70, 0xE0, 0x38, 0x1D, 0xC0, 0xE0, 0xE0, 0x3C, 0x39,
  0xC1, 0xC0, 0xE0, 0x3F, 0xF1, 0xFF, 0xC0, 0xF0, 0x1F, 0xE0, 0xFF, 0x80,
  0x70, 0x0F, 0xC0, 0xFE, 0x00, 0x70, 0x00, 0x00, 0x10, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x01, 0x80, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x1F,
  0x3C, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3E,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x03, 0xC1, 0xF0, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x01, 0xE3, 0xE0,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x00, 0x1F,
  0xC0, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0x00,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x3E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x3C, 0x00,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x3E, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x78, 0x00, 0x07, 0xE0, 0x07, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0x00, 0x07, 0xFC, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x81, 0xE0, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x7C, 0x1E,
  0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x07,
  0xC3, 0xC0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0xFC,
  0x07, 0x80, 0x00, 0x1F, 0x80, 0x78, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x0F, 0x80, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x1F, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1E, 0x01, 0xFF, 0x80, 0x00, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x3E,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x07, 0x83,
  0xE0, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x07, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x3C,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x00, 0xF0, 0xF8,
  0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xCF, 0x00,
  0x03, 0xFF, 0xFC, 0xF0, 0x00, 0x3F, 0xFF, 0xCF, 0x00, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x0F, 0x8F, 0x00,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00,
  0x1F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x03, 0x80, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x0E, 0x00, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x38, 0x00, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x1F,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x00, 0x7C, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x80,
  0x3C, 0x00, 0x00, 0x1F, 0x80, 0x1E, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x0F, 0x00, 0x00, 0x1F, 0x80, 0x07, 0x80, 0x00, 0x1F,
  0x80, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x78, 0x00,
  0x1F, 0x80, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x00, 0x1E, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x00, 0x07,
  0x80, 0x1F, 0x80, 0x00, 0x03, 0xC0, 0x1F, 0x80, 0x00, 0x01, 0xE0, 0x1F,
  0x80, 0x00, 0x00, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0x78, 0x1F, 0x80, 0x00,
  0x00, 0x7C, 0x1F, 0x80, 0x00, 0x00, 0x3C, 0x1F, 0x80, 0x00, 0x00, 0x1E,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0x9F, 0xE0,
  0x00, 0x00, 0x03, 0xDF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x3C, 0x00, 0x00,
  0x01, 0xFF, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0x07, 0x80, 0x00, 0x00, 0x7F,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x3C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0xEE, 0x00, 0x01, 0xFE, 0x01, 0xEF, 0x00, 0x03,
  0xDE, 0x01, 0xEF, 0x00, 0x07, 0xDE, 0x01, 0xEF, 0x00, 0x07, 0x9C, 0x01,
  0xE7, 0x00, 0x0F, 0xBC, 0x01, 0xE7, 0x00, 0x0F, 0x3C, 0x01, 0xC7, 0x00,
  0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x3C, 0x3C,
  0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC3, 0x80, 0x78, 0x78, 0x03, 0xC3,
  0x80, 0x78, 0x78, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x07, 0x83, 0xC1, 0xF0,
  0x78, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x07, 0x83, 0xC3, 0xE0, 0xF0, 0x07,
  0x81, 0xC3, 0xC0, 0xF0, 0x07, 0x81, 0xC7, 0x80, 0xF0, 0x0F, 0x01, 0xE7,
  0x80, 0xF0, 0x0F, 0x01, 0xEF, 0x00, 0xF0, 0x0F, 0x01, 0xEF, 0x01, 0xE0,
  0x0F, 0x01, 0xFE, 0x01, 0xE0, 0x0F, 0x00, 0xFE, 0x01, 0xE0, 0x0F, 0x00,
  0xFC, 0x01, 0xE0, 0x1E, 0x00, 0xFC, 0x01, 0xE0, 0x1E, 0x00, 0xF8, 0x01,
  0xE0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E,
  0x00, 0x60, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0xFC,
  0x00, 0x00, 0x1E, 0x00, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0xFE, 0x00, 0x00,
  0x1E, 0x00, 0xFE, 0x00, 0x00, 0x3E, 0x01, 0xFE, 0x00, 0x00, 0x3C, 0x01,
  0xEF, 0x00, 0x00, 0x3C, 0x01, 0xEF, 0x00, 0x00, 0x3C, 0x01, 0xEF, 0x80,
  0x00, 0x3C, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0x03, 0xE7, 0x80, 0x00, 0x7C,
  0x03, 0xC3, 0xC0, 0x00, 0x78, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x03, 0xC3,
  0xC0, 0x00, 0x78, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x03, 0xC1, 0xE0, 0x00,
  0xF8, 0x07, 0xC1, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x07,
  0x80, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x78,
  0x00, 0xF0, 0x07, 0x80, 0x78, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xE0,
  0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x1E, 0x03,
  0xE0, 0x1F, 0x00, 0x0F, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x1E,
  0x00, 0x0F, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x1E, 0x00, 0x07,
  0x83, 0xC0, 0x1E, 0x00, 0x07, 0x87, 0xC0, 0x3C, 0x00, 0x03, 0xC7, 0x80,
  0x3C, 0x00, 0x03, 0xC7, 0x80, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x3C, 0x00,
  0x01, 0xE7, 0x80, 0x3C, 0x00, 0x01, 0xEF, 0x80, 0x7C, 0x00, 0x01, 0xFF,
  0x00, 0x78, 0x00, 0x00, 0xFF, 0x00, 0x78, 0x00, 0x00, 0xFF, 0x00, 0x78,
  0x00, 0x00, 0x7F, 0x00, 0x78, 0x00, 0x00, 0x7F, 0x00, 0x78, 0x00, 0x00,
  0x7F, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x3C, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xE0,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x7C, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x3F, 0xF0, 0x00, 0xF0, 0x00,
  0x0F, 0xC0, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x1E, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x78,
  0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x0F, 0x00, 0x00, 0x3F,
  0x80, 0x3C, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x3E, 0x00,
  0x00, 0x3E, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x1E, 0x0F,
  0x80, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0xF3, 0xE0, 0x00,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0x00, 0x1E, 0xF8, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x03,
  0xEF, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xF0, 0x03, 0xFF, 0x00, 0x0F,
  0x00, 0x01, 0xFC, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x1E, 0x00,
  0x00, 0x3E, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x7E, 0x00,
  0x3C, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x78, 0x00,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x00, 0x1F,
  0x0F, 0x00, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x00, 0x3C, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00,
  0x07, 0x81, 0xF0, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x00, 0xF8, 0x78, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x0F, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x1F, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0xF8, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x3D, 0xC0, 0x01, 0xE0, 0x00, 0xE7, 0x00, 0x0F, 0x80,
  0x07, 0x9C, 0x00, 0x3E, 0x00, 0x1E, 0x70, 0x00, 0xF8, 0x00, 0x7B, 0xC0,
  0x07, 0xE0, 0x03, 0xCF, 0x00, 0x1F, 0x80, 0x0F, 0x3C, 0x00, 0x7E, 0x00,
  0x3C, 0xF0, 0x03, 0xF8, 0x00, 0xE3, 0xC0, 0x0F, 0xE0, 0x07, 0x8F, 0x00,
  0x3B, 0x80, 0x1E, 0x3C, 0x01, 0xEE, 0x00, 0x78, 0xF0, 0x07, 0xB8, 0x03,
  0xC3, 0xC0, 0x1C, 0xE0, 0x0F, 0x0F, 0x00, 0xF3, 0x80, 0x3C, 0x3C, 0x03,
  0xCE, 0x00, 0xE0, 0xF0, 0x0E, 0x38, 0x07, 0x83, 0xC0, 0x78, 0xF0, 0x1E,
  0x0F, 0x01, 0xE3, 0xC0, 0x70, 0x3C, 0x07, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0xF0, 0x3C, 0x0F, 0x03, 0x83, 0xC1, 0xE0,
  0x3C, 0x1E, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x3C, 0x1E, 0x03, 0xC1, 0xC0,
  0xF0, 0x70, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x0F, 0x0F, 0x00,
  0xF0, 0xE0, 0x3C, 0x3C, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x0F, 0x1E, 0x03,
  0xC7, 0x80, 0x3C, 0x70, 0x0F, 0x1E, 0x00, 0xF3, 0xC0, 0x3C, 0x70, 0x03,
  0xCF, 0x00, 0xF3, 0xC0, 0x0F, 0x38, 0x03, 0xCF, 0x00, 0x3D, 0xE0, 0x07,
  0x38, 0x00, 0xF7, 0x80, 0x1D, 0xE0, 0x03, 0xDC, 0x00, 0x77, 0x80, 0x0F,
  0xF0, 0x01, 0xDE, 0x00, 0x3B, 0xC0, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x07,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0x00,
  0x03, 0xCF, 0x80, 0x00, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x01, 0xF0, 0x3C, 0x00,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x7C, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x00,
  0x3C, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x00, 0x77, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3D, 0xC0, 0x00,
  0x3C, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x1F, 0x1E, 0x00,
  0x0F, 0x07, 0x00, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x07, 0x80, 0xF0,
  0x03, 0xC0, 0x78, 0x03, 0xC0, 0x1C, 0x03, 0xE0, 0x0F, 0x01, 0xE0, 0x07,
  0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x00, 0xE0, 0xF0, 0x00, 0x78, 0x78, 0x00,
  0x3C, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xBC, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0x03, 0xC0,
  0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xE0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x0F, 0x0F, 0x80, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x00, 0x1E, 0x0F, 0xE0, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x7C, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00,
  0xF8, 0xF0, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x07, 0xF8, 0xF8, 0x00, 0x0F,
  0xF8, 0x7C, 0x00, 0x3F, 0x78, 0x3F, 0x81, 0xFC, 0xF8, 0x3F, 0xFF, 0xF8,
  0xF8, 0x0F, 0xFF, 0xE0, 0xF8, 0x07, 0xFF, 0x80, 0xF8, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x01, 0xE0, 0xFF,
  0xE0, 0x00, 0xF0, 0xFF, 0xFE, 0x00, 0x3C, 0xFF, 0xFF, 0xC0, 0x0F, 0x7E,
  0x03, 0xF8, 0x03, 0xFE, 0x00, 0x3E, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x3F,
  0x00, 0x00, 0xF0, 0x1F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00,
  0x7C, 0x3C, 0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0xC3,
  0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x0F, 0x81, 0xFC, 0x00, 0x07,
  0xE0, 0x7F, 0x80, 0x03, 0xF0, 0x1F, 0xF0, 0x01, 0xF8, 0x07, 0xBF, 0x03,
  0xFC, 0x01, 0xE7, 0xFF, 0xFE, 0x00, 0xF0, 0xFF, 0xFF, 0x00, 0x3C, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0xFE, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x3C, 0x07,
  0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x1F,
  0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x01, 0xF0, 0x3C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x1F,
  0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x7F, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x78, 0x00,
  0x0F, 0xFE, 0x07, 0x80, 0x03, 0xFF, 0xF8, 0x78, 0x00, 0xFF, 0xFF, 0xCF,
  0x80, 0x1F, 0xE0, 0x3E, 0xF0, 0x03, 0xF0, 0x01, 0xFF, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x1F,
  0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xF8,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x3E,
  0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0xFD, 0xE0,
  0x00, 0xFF, 0xFF, 0x9E, 0x00, 0x07, 0xFF, 0xF1, 0xE0, 0x00, 0x3F, 0xFC,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07,
  0x83, 0xE0, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00,
  0x79, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x0F, 0x7C, 0x00, 0x00, 0x07, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x60, 0x1E, 0x00, 0x00, 0x78, 0x0F,
  0x80, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x0F, 0x00, 0x07, 0xFF, 0xF0, 0xF0, 0x01, 0xFF, 0xFF, 0x8F, 0x00,
  0x3F, 0xC0, 0x7D, 0xF0, 0x07, 0xE0, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x0F, 0x80, 0x00, 0xFE, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x3E, 0x00,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x1E,
  0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x3E,
  0x00, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x7C, 0x00,
  0x1F, 0xE0, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x81, 0xFB, 0xC0, 0x01,
  0xFF, 0xFF, 0x3C, 0x00, 0x0F, 0xFF, 0xE3, 0xC0, 0x00, 0x3F, 0xF8, 0x3C,
  0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x02, 0x00, 0x00, 0x3E, 0x00, 0x70, 0x00, 0x03, 0xE0,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x03,
  0xF0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x3E, 0x00, 0x03, 0xC0, 0x7F, 0xF0, 0x00, 0xF0, 0x7F, 0xFF,
  0x00, 0x3C, 0x3F, 0xFF, 0xE0, 0x0F, 0x1F, 0x01, 0xFC, 0x03, 0xCF, 0x00,
  0x1F, 0x00, 0xF7, 0x00, 0x03, 0xE0, 0x7B, 0x80, 0x00, 0xF8, 0x1F, 0xC0,
  0x00, 0x1E, 0x07, 0xE0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00,
  0xF8, 0x78, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x1F, 0x0F, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x78, 0x00, 0x01, 0xF0,
  0x0F, 0x00, 0x00, 0xFC, 0x01, 0xE0, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0x0F,
  0xC0, 0x0F, 0x80, 0x03, 0xF0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x7E, 0x00, 0x07, 0x80, 0x1F, 0x80, 0x00, 0xF0, 0x07, 0xE0, 0x00, 0x3E,
  0x01, 0xF8, 0x00, 0x07, 0x80, 0xFC, 0x00, 0x00, 0xF0, 0x3F, 0x00, 0x00,
  0x1E, 0x0F, 0xC0, 0x00, 0x03, 0xC3, 0xF0, 0x00, 0x00, 0x78, 0xFC, 0x00,
  0x00, 0x1F, 0x7F, 0x00, 0x00, 0x03, 0xDF, 0xF0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x0F, 0xFB, 0xE0, 0x00, 0x01, 0xFE, 0x3E, 0x00, 0x00, 0x3F,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF1, 0xFF, 0x03, 0xFE, 0x00,
  0x73, 0xFF, 0xC3, 0xFF, 0xC0, 0x3B, 0xFF, 0xF3, 0xFF, 0xE0, 0x3F, 0xC1,
  0xFB, 0xC1, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0x3C, 0x0F, 0x80, 0x1F, 0x80,
  0x1E, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x81,
  0xE0, 0x03, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03,
  0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xE0, 0x00,
  0xE0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x00, 0x78, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x07, 0x00, 0x0F, 0x00, 0x07, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x83, 0xC0, 0x03, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x00, 0x78, 0x38, 0x00, 0x78,
  0x00, 0x38, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x80, 0x07, 0x83, 0xC0,
  0x03, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x1F, 0xFC, 0x00, 0x3C, 0x1F, 0xFF, 0xC0, 0x0F, 0x0F,
  0xFF, 0xF8, 0x03, 0xCF, 0xC0, 0x7F, 0x00, 0xF7, 0xC0, 0x07, 0xC0, 0x3B,
  0xC0, 0x00, 0xF8, 0x1E, 0xE0, 0x00, 0x3E, 0x07, 0xF0, 0x00, 0x07, 0x81,
  0xF8, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x01, 0xE1, 0xF0, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x7C, 0x3C, 0x00,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x0F, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x07,
  0x87, 0xC0, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x03, 0xE1, 0xE0,
  0x00, 0x01, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xF0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0x07, 0xFF,
  0x00, 0x03, 0xC3, 0xFF, 0xF0, 0x00, 0x79, 0xFF, 0xFF, 0x80, 0x0F, 0x7E,
  0x03, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x01, 0xF0, 0x07,
  0xE0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x7C,
  0x07, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x1E, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF8, 0x3C, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF8, 0x1E,
  0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x01, 0xF0,
  0x1F, 0x80, 0x00, 0x7C, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x7F, 0x80, 0x07,
  0xE0, 0x0F, 0x7C, 0x03, 0xF8, 0x03, 0xE7, 0xFF, 0xFE, 0x00, 0x7C, 0x7F,
  0xFF, 0x00, 0x0F, 0x03, 0xFF, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x03, 0xC0, 0x0F, 0xFF,
  0xE1, 0xE0, 0x1F, 0xFF, 0xF8, 0xF0, 0x1F, 0xC0, 0x3E, 0xF0, 0x1F, 0x80,
  0x07, 0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x0F, 0x80, 0x00, 0x7E, 0x0F, 0x80,
  0x00, 0x3F, 0x0F, 0x80, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x07, 0x87, 0xC0,
  0x00, 0x03, 0xC3, 0xE0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF1, 0xF0,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x07,
  0xE0, 0x7C, 0x00, 0x07, 0xF0, 0x1F, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x07,
  0xF8, 0x03, 0xF0, 0x1F, 0xBC, 0x00, 0xFF, 0xFF, 0x9E, 0x00, 0x3F, 0xFF,
  0x8F, 0x00, 0x0F, 0xFF, 0x07, 0x80, 0x00, 0x70, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x07, 0x80, 0x7F, 0xFC, 0x0F, 0x03, 0xFF, 0xF0, 0x1E, 0x1F, 0xFF, 0xE0,
  0x3C, 0x7F, 0xC3, 0xC0, 0xF3, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x01, 0xFC,
  0x03, 0xF0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0x78,
  0xF8, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xE0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x30, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x87, 0xC0,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x3E,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE1,
  0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x7C,
  0x3C, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F,
  0x0F, 0x80, 0x00, 0x07, 0x87, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x03,
  0xE1, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0x78, 0x7C, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00,
  0x1F, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x81, 0xE0, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x0F, 0xE0, 0x3C, 0x00, 0x0F, 0xF0, 0x1F, 0x00,
  0x1F, 0x78, 0x07, 0xE0, 0x7F, 0x38, 0x03, 0xFF, 0xFF, 0x3C, 0x00, 0xFF,
  0xFE, 0x1E, 0x00, 0x1F, 0xFC, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0x3E, 0x0F, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xF0, 0x1E, 0x00,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x07, 0x80, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x78, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0x77, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3F, 0xC0, 0x01, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0x80, 0x07,
  0xBC, 0x00, 0x3E, 0x00, 0x1E, 0xF0, 0x00, 0xF8, 0x00, 0x73, 0xC0, 0x07,
  0xE0, 0x03, 0xCF, 0x00, 0x1F, 0x80, 0x0F, 0x3C, 0x00, 0xFE, 0x00, 0x38,
  0xF0, 0x03, 0xB8, 0x01, 0xE3, 0xC0, 0x0E, 0xE0, 0x07, 0x87, 0x00, 0x7B,
  0x80, 0x3C, 0x1C, 0x01, 0xCE, 0x00, 0xF0, 0x70, 0x0F, 0x38, 0x03, 0x81,
  0xC0, 0x38, 0xE0, 0x1E, 0x07, 0x00, 0xE3, 0xC0, 0x78, 0x1C, 0x07, 0x8F,
  0x01, 0xC0, 0x70, 0x1C, 0x3C, 0x0F, 0x01, 0xC0, 0xF0, 0x70, 0x38, 0x07,
  0x03, 0x81, 0xC1, 0xE0, 0x1C, 0x1E, 0x07, 0x07, 0x80, 0x70, 0x70, 0x1C,
  0x1C, 0x01, 0xC1, 0xC0, 0x70, 0xF0, 0x07, 0x0F, 0x01, 0xC3, 0xC0, 0x1C,
  0x38, 0x07, 0x0E, 0x00, 0x79, 0xE0, 0x1C, 0x78, 0x01, 0xE7, 0x00, 0x71,
  0xC0, 0x07, 0x9C, 0x01, 0xC7, 0x00, 0x1E, 0xF0, 0x07, 0x3C, 0x00, 0x7B,
  0x80, 0x1C, 0xE0, 0x01, 0xFE, 0x00, 0x77, 0x80, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0xF8,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0x00,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE1, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x08, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x09,
  0x07, 0xFF, 0xC0, 0x00, 0x0E, 0x0F, 0xFF, 0xE0, 0x00, 0x0E, 0x1F, 0x83,
  0xF0, 0x00, 0x1E, 0x3E, 0x00, 0xFC, 0x00, 0x1E, 0x3C, 0x00, 0x7E, 0x00,
  0x3C, 0x78, 0x00, 0x3F, 0x00, 0x7C, 0x78, 0x00, 0x1F, 0x80, 0xF8, 0x70,
  0x00, 0x0F, 0xFF, 0xF0, 0x70, 0x00, 0x07, 0xFF, 0xE0, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00,
};

const GFXglyph RobotoMono_LightItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 42, 0, -1 },
  { 1, 14, 51, 42, 14, -51 },
  { 91, 17, 16, 42, 16, -54 },
  { 125, 42, 51, 42, 1, -51 },
  { 393, 34, 66, 42, 5, -59 },
  { 674, 35, 53, 42, 4, -52 },
  { 906, 36, 53, 42, 3, -52 },
  { 1145, 7, 16, 42, 20, -54 },
  { 1159, 23, 73, 42, 12, -57 },
  { 1369, 23, 74, 42, 6, -57 },
  { 1582, 31, 31, 42, 9, -51 },
  { 1703, 35, 37, 42, 4, -42 },
  { 1865, 10, 17, 42, 8, -7 },
  { 1887, 26, 4, 42, 8, -25 },
  { 1900, 7, 7, 42, 15, -7 },
  { 1907, 34, 55, 42, 5, -51 },
  { 2141, 34, 53, 42, 5, -52 },
  { 2367, 19, 51, 42, 11, -51 },
  { 2489, 35, 52, 42, 1, -52 },
  { 2717, 35, 53, 42, 2, -52 },
  { 2949, 36, 51, 42, 1, -51 },
  { 3179, 35, 52, 42, 6, -51 },
  { 3407, 32, 53, 42, 4, -52 },
  { 3619, 34, 51, 42, 8, -51 },
  { 3836, 36, 53, 42, 4, -52 },
  { 4075, 31, 52, 42, 7, -52 },
  { 4277, 13, 38, 42, 17, -38 },
  { 4339, 17, 48, 42, 13, -38 },
  { 4441, 32, 30, 42, 6, -38 },
  { 4561, 33, 18, 42, 5, -32 },
  { 4636, 33, 30, 42, 4, -38 },
  { 4760, 27, 52, 42, 11, -52 },
  { 4936, 40, 52, 42, 2, -52 },
  { 5196, 36, 51, 42, 0, -51 },
  { 5426, 36, 51, 42, 3, -51 },
  { 5656, 36, 53, 42, 4, -52 },
  { 5895, 38, 51, 42, 2, -51 },
  { 6138, 38, 51, 42, 3, -51 },
  { 6381, 38, 51, 42, 4, -51 },
  { 6624, 36, 53, 42, 4, -52 },
  { 6863, 40, 51, 42, 2, -51 },
  { 7118, 38, 51, 42, 3, -51 },
  { 7361, 37, 52, 42, 3, -51 },
  { 7602, 41, 51, 42, 3, -51 },
  { 7864, 30, 51, 42, 4, -51 },
  { 8056, 40, 51, 42, 2, -51 },
  { 8311, 40, 51, 42, 2, -51 },
  { 8566, 35, 53, 42, 4, -52 },
  { 8798, 38, 51, 42, 4, -51 },
  { 9041, 36, 61, 42, 4, -52 },
  { 9316, 37, 51, 42, 3, -51 },
  { 9552, 37, 53, 42, 3, -52 },
  { 9798, 36, 51, 42, 8, -51 },
  { 10028, 38, 52, 42, 4, -51 },
  { 10275, 35, 51, 42, 8, -51 },
  { 10499, 38, 51, 42, 7, -51 },
  { 10742, 44, 51, 42, 0, -51 },
  { 11023, 36, 51, 42, 8, -51 },
  { 11253, 39, 51, 42, 1, -51 },
  { 11502, 23, 70, 42, 10, -59 },
  { 11704, 15, 55, 42, 14, -51 },
  { 11808, 22, 70, 42, 10, -59 },
  { 12001, 25, 28, 42, 9, -51 },
  { 12089, 30, 4, 42, 2, 0 },
  { 12104, 10, 10, 42, 20, -53 },
  { 12117, 32, 40, 42, 4, -39 },
  { 12277, 34, 55, 42, 3, -54 },
  { 12511, 32, 40, 42, 5, -39 },
  { 12671, 36, 55, 42, 5, -54 },
  { 12919, 33, 40, 42, 4, -39 },
  { 13084, 35, 55, 42, 9, -55 },
  { 13325, 36, 54, 42, 2, -39 },
  { 13568, 34, 54, 42, 3, -54 },
  { 13798, 30, 52, 42, 4, -52 },
  { 13993, 32, 67, 42, 1, -52 },
  { 14261, 35, 54, 42, 4, -54 },
  { 14498, 30, 54, 42, 4, -54 },
  { 14701, 41, 39, 42, -1, -39 },
  { 14901, 34, 39, 42, 3, -39 },
  { 15067, 33, 40, 42, 4, -39 },
  { 15232, 35, 54, 42, 1, -39 },
  { 15469, 33, 54, 42, 5, -39 },
  { 15692, 31, 39, 42, 9, -39 },
  { 15844, 32, 40, 42, 5, -39 },
  { 16004, 29, 49, 42, 8, -48 },
  { 16182, 33, 39, 42, 5, -38 },
  { 16343, 35, 38, 42, 6, -38 },
  { 16510, 38, 38, 42, 5, -38 },
  { 16691, 40, 38, 42, 1, -38 },
  { 16881, 43, 53, 42, -1, -38 },
  { 17166, 36, 38, 42, 2, -38 },
  { 17337, 28, 70, 42, 11, -56 },
  { 17582, 13, 63, 42, 14, -51 },
  { 17685, 28, 70, 42, 6, -56 },
  { 17930, 40, 13, 42, 1, -28 },
};

const GFXfont RobotoMono_LightItalic72pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic72pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic72pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _ROBOTOMONO_LIGHTITALIC72PT7B_H_
