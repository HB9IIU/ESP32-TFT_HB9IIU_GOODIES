#ifndef _ROBOTOMONO_LIGHTITALIC13PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0xA0, 0x80, 0xB6, 0x80, 0x0A, 0x12, 0x7F, 0x14, 0x24, 0x28,
  0xFE, 0x48, 0x50, 0x08, 0x42, 0xD1, 0x41, 0x03, 0x02, 0x86, 0x27, 0x08,
  0xE2, 0xBA, 0xB4, 0x20, 0xF5, 0x65, 0x18, 0x1C, 0x48, 0x90, 0xC3, 0x09,
  0x52, 0xA2, 0x7E, 0xE0, 0x12, 0x44, 0x48, 0x88, 0x88, 0x84, 0x40, 0x21,
  0x11, 0x11, 0x11, 0x12, 0x24, 0x80, 0x25, 0x5C, 0xC9, 0x00, 0x10, 0x41,
  0x3F, 0x20, 0x82, 0x00, 0x58, 0xF8, 0x80, 0x04, 0x20, 0x84, 0x10, 0x82,
  0x10, 0x82, 0x00, 0x39, 0x18, 0x67, 0xA7, 0x18, 0xA2, 0x70, 0x7A, 0x22,
  0x22, 0x44, 0x40, 0x3C, 0x84, 0x10, 0x20, 0x82, 0x08, 0x20, 0xFC, 0x3C,
  0x84, 0x08, 0x21, 0x80, 0xA1, 0x42, 0x78, 0x04, 0x18, 0x51, 0x22, 0x48,
  0xBF, 0x84, 0x08, 0x3D, 0x04, 0x1E, 0x08, 0x10, 0x62, 0x70, 0x3A, 0x11,
  0xF8, 0xC6, 0x31, 0x70, 0x7E, 0x08, 0x20, 0x41, 0x04, 0x08, 0x20, 0xC0,
  0x3D, 0x14, 0x52, 0x7A, 0x18, 0x62, 0x70, 0x79, 0x18, 0x61, 0x8D, 0xE0,
  0x84, 0x60, 0x40, 0x08, 0x20, 0x00, 0x12, 0x80, 0x04, 0xEC, 0x18, 0x10,
  0x20, 0xFC, 0x0F, 0x80, 0x40, 0xC0, 0xC6, 0xE2, 0x00, 0x7C, 0x42, 0x22,
  0x20, 0x00, 0x40, 0x1E, 0x29, 0x55, 0x65, 0xA9, 0xAA, 0xBE, 0x80, 0x78,
  0x08, 0x51, 0x45, 0x24, 0x95, 0xD1, 0x84, 0x7D, 0x14, 0x62, 0xFA, 0x18,
  0x62, 0xF0, 0x3D, 0x18, 0x60, 0x82, 0x08, 0x62, 0x70, 0x3C, 0x45, 0x0A,
  0x14, 0x28, 0x50, 0xA2, 0xF8, 0x7D, 0x04, 0x20, 0xFA, 0x08, 0x20, 0xF8,
  0x7E, 0x81, 0x04, 0x0F, 0x90, 0x20, 0x40, 0x80, 0x3D, 0x18, 0x20, 0x9A,
  0x18, 0x61, 0x78, 0x21, 0x42, 0x42, 0x42, 0x7E, 0x42, 0x42, 0x84, 0x84,
  0x7C, 0x41, 0x04, 0x20, 0x82, 0x08, 0xF8, 0x02, 0x04, 0x08, 0x10, 0x20,
  0xA1, 0x42, 0x78, 0x46, 0x91, 0x45, 0x0E, 0x12, 0x24, 0x44, 0x8C, 0x42,
  0x10, 0x88, 0x42, 0x10, 0xF8, 0x23, 0x22, 0x56, 0x5A, 0x5A, 0x52, 0x42,
  0x84, 0x84, 0x21, 0x22, 0x52, 0x52, 0x52, 0x4A, 0x4C, 0x84, 0x84, 0x39,
  0x18, 0x61, 0x86, 0x18, 0x62, 0x70, 0x7C, 0x85, 0x0C, 0x2F, 0x90, 0x20,
  0x40, 0x80, 0x3D, 0x18, 0x61, 0x86, 0x18, 0x62, 0x70, 0x20, 0x80, 0x7D,
  0x14, 0x61, 0xFA, 0x48, 0xA2, 0x88, 0x7D, 0x18, 0x10, 0x30, 0x28, 0x62,
  0x78, 0xFE, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x43, 0x0A, 0x14,
  0x28, 0x50, 0xA2, 0x44, 0x70, 0x82, 0x89, 0x12, 0x44, 0x8A, 0x14, 0x10,
  0x20, 0x93, 0x26, 0xD5, 0xAB, 0x5A, 0xB2, 0x44, 0x88, 0x23, 0x22, 0x14,
  0x18, 0x18, 0x18, 0x28, 0x44, 0x86, 0xC6, 0x89, 0x21, 0x83, 0x04, 0x08,
  0x10, 0x20, 0x3E, 0x08, 0x10, 0x41, 0x04, 0x08, 0x20, 0xFC, 0x32, 0x44,
  0x44, 0x44, 0x88, 0x88, 0xC0, 0xAA, 0x95, 0x50, 0x31, 0x12, 0x22, 0x22,
  0x22, 0x44, 0xC0, 0x25, 0x59, 0x90, 0xFC, 0xC0, 0x7A, 0x10, 0x5E, 0x8A,
  0x2F, 0x80, 0x41, 0x04, 0x1E, 0x46, 0x18, 0x62, 0x8B, 0xC0, 0x39, 0x18,
  0x20, 0x82, 0x27, 0x00, 0x04, 0x10, 0x4F, 0x46, 0x18, 0xA2, 0x89, 0xE0,
  0x39, 0x18, 0x7F, 0x82, 0x07, 0x80, 0x1C, 0x84, 0x3E, 0x41, 0x04, 0x10,
  0x82, 0x00, 0x1E, 0x45, 0x0A, 0x24, 0x48, 0x8F, 0x02, 0x88, 0xE0, 0x41,
  0x04, 0x1E, 0xC6, 0x18, 0x62, 0x8A, 0x20, 0x10, 0x1C, 0x21, 0x08, 0x84,
  0xF8, 0x04, 0x03, 0xC2, 0x08, 0x20, 0x82, 0x08, 0x41, 0x38, 0x41, 0x04,
  0x11, 0x9A, 0x8E, 0x24, 0x92, 0x20, 0x78, 0x84, 0x21, 0x08, 0x44, 0x27,
  0xC0, 0x76, 0x95, 0x4C, 0x99, 0x32, 0x64, 0x80, 0xBB, 0x18, 0x61, 0x8A,
  0x28, 0x80, 0x7A, 0x18, 0x61, 0x86, 0x27, 0x00, 0x3C, 0xC9, 0x0A, 0x14,
  0x48, 0x9E, 0x40, 0x81, 0x00, 0x3D, 0x18, 0x62, 0x8A, 0x27, 0x82, 0x08,
  0x40, 0x7A, 0x21, 0x08, 0x42, 0x00, 0x79, 0x14, 0x0C, 0x0A, 0x2F, 0x80,
  0x10, 0x8F, 0xC8, 0x20, 0x82, 0x10, 0x38, 0x46, 0x18, 0x62, 0x8A, 0x2F,
  0x80, 0x86, 0x14, 0x92, 0x51, 0x82, 0x00, 0x93, 0x2A, 0xD6, 0xAD, 0x93,
  0x24, 0x00, 0x62, 0x48, 0x60, 0x82, 0x85, 0x31, 0x00, 0x43, 0x42, 0x24,
  0x24, 0x28, 0x30, 0x10, 0x20, 0x20, 0xC0, 0x7E, 0x08, 0x20, 0x82, 0x08,
  0x3F, 0x00, 0x08, 0x88, 0x42, 0x22, 0x08, 0x42, 0x10, 0x82, 0x00, 0x55,
  0xAA, 0xA8, 0x20, 0x84, 0x21, 0x08, 0x64, 0x21, 0x08, 0x88, 0x00, 0x73,
  0x1C,
};

const GFXglyph RobotoMono_LightItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 9, 8, 3, -9 },
  { 4, 3, 3, 8, 3, -10 },
  { 6, 8, 9, 8, 0, -9 },
  { 15, 6, 12, 8, 1, -11 },
  { 24, 6, 9, 8, 1, -9 },
  { 31, 7, 9, 8, 0, -9 },
  { 39, 1, 3, 8, 4, -10 },
  { 40, 4, 13, 8, 2, -10 },
  { 47, 4, 13, 8, 1, -10 },
  { 54, 5, 5, 8, 2, -9 },
  { 58, 6, 7, 8, 1, -8 },
  { 64, 2, 3, 8, 1, -1 },
  { 65, 5, 1, 8, 1, -5 },
  { 66, 1, 1, 8, 3, -1 },
  { 67, 6, 10, 8, 1, -9 },
  { 75, 6, 9, 8, 1, -9 },
  { 82, 4, 9, 8, 2, -9 },
  { 87, 7, 9, 8, 0, -9 },
  { 95, 7, 9, 8, 0, -9 },
  { 103, 7, 9, 8, 0, -9 },
  { 111, 6, 9, 8, 1, -9 },
  { 118, 5, 9, 8, 1, -9 },
  { 124, 7, 9, 8, 1, -9 },
  { 132, 6, 9, 8, 1, -9 },
  { 139, 6, 9, 8, 1, -9 },
  { 146, 2, 7, 8, 3, -7 },
  { 148, 3, 9, 8, 2, -7 },
  { 152, 6, 6, 8, 1, -7 },
  { 157, 6, 3, 8, 1, -6 },
  { 160, 6, 6, 8, 1, -7 },
  { 165, 5, 9, 8, 2, -9 },
  { 171, 8, 9, 8, 0, -9 },
  { 180, 6, 9, 8, 0, -9 },
  { 187, 6, 9, 8, 1, -9 },
  { 194, 6, 9, 8, 1, -9 },
  { 201, 7, 9, 8, 0, -9 },
  { 209, 6, 9, 8, 1, -9 },
  { 216, 7, 9, 8, 1, -9 },
  { 224, 6, 9, 8, 1, -9 },
  { 231, 8, 9, 8, 0, -9 },
  { 240, 6, 9, 8, 1, -9 },
  { 247, 7, 9, 8, 0, -9 },
  { 255, 7, 9, 8, 1, -9 },
  { 263, 5, 9, 8, 1, -9 },
  { 269, 8, 9, 8, 0, -9 },
  { 278, 8, 9, 8, 0, -9 },
  { 287, 6, 9, 8, 1, -9 },
  { 294, 7, 9, 8, 1, -9 },
  { 302, 6, 11, 8, 1, -9 },
  { 311, 6, 9, 8, 1, -9 },
  { 318, 6, 9, 8, 1, -9 },
  { 325, 7, 9, 8, 1, -9 },
  { 333, 7, 9, 8, 1, -9 },
  { 341, 7, 9, 8, 1, -9 },
  { 349, 7, 9, 8, 1, -9 },
  { 357, 8, 9, 8, 0, -9 },
  { 366, 7, 9, 8, 1, -9 },
  { 374, 7, 9, 8, 0, -9 },
  { 382, 4, 13, 8, 2, -11 },
  { 389, 2, 10, 8, 3, -9 },
  { 392, 4, 13, 8, 2, -11 },
  { 399, 4, 5, 8, 2, -9 },
  { 402, 6, 1, 8, 0, 0 },
  { 403, 1, 2, 8, 4, -10 },
  { 404, 6, 7, 8, 1, -7 },
  { 410, 6, 10, 8, 1, -10 },
  { 418, 6, 7, 8, 1, -7 },
  { 424, 6, 10, 8, 1, -10 },
  { 432, 6, 7, 8, 1, -7 },
  { 438, 6, 10, 8, 2, -10 },
  { 446, 7, 10, 8, 0, -7 },
  { 455, 6, 10, 8, 1, -10 },
  { 463, 5, 9, 8, 1, -9 },
  { 469, 6, 12, 8, 0, -9 },
  { 478, 6, 10, 8, 1, -10 },
  { 486, 5, 10, 8, 1, -10 },
  { 493, 7, 7, 8, 0, -7 },
  { 500, 6, 7, 8, 1, -7 },
  { 506, 6, 7, 8, 1, -7 },
  { 512, 7, 10, 8, 0, -7 },
  { 521, 6, 10, 8, 1, -7 },
  { 529, 5, 7, 8, 2, -7 },
  { 534, 6, 7, 8, 1, -7 },
  { 540, 6, 9, 8, 1, -9 },
  { 547, 6, 7, 8, 1, -7 },
  { 553, 6, 7, 8, 1, -7 },
  { 559, 7, 7, 8, 1, -7 },
  { 566, 7, 7, 8, 0, -7 },
  { 573, 8, 10, 8, 0, -7 },
  { 583, 7, 7, 8, 0, -7 },
  { 590, 5, 13, 8, 2, -10 },
  { 599, 2, 11, 8, 3, -9 },
  { 602, 5, 13, 8, 1, -10 },
  { 611, 7, 2, 8, 0, -5 },
};

const GFXfont RobotoMono_LightItalic13pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic13pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic13pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _ROBOTOMONO_LIGHTITALIC13PT7B_H_
