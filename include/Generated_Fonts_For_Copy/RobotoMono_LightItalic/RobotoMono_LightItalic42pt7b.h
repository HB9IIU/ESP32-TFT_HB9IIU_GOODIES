#ifndef _ROBOTOMONO_LIGHTITALIC42PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x07, 0x07, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x0C,
  0x0C, 0x0C, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x38, 0x38, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0xF0, 0x60, 0x61, 0xB0, 0xD8, 0x6C, 0x3C,
  0x3E, 0x1B, 0x0D, 0x86, 0xC3, 0x41, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x0C,
  0x0C, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x30,
  0x18, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x60, 0x70, 0x1F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x01, 0xC0,
  0xC0, 0x01, 0x81, 0x80, 0x01, 0x81, 0x80, 0x03, 0x01, 0x80, 0x03, 0x03,
  0x00, 0x03, 0x03, 0x00, 0x06, 0x03, 0x08, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF0, 0x0C, 0x0E, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18,
  0x00, 0x18, 0x18, 0x00, 0x38, 0x18, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x7F, 0x00, 0x1F, 0xFC, 0x03, 0xC1, 0xC0, 0x70, 0x0E, 0x0E, 0x00, 0x60,
  0xC0, 0x06, 0x1C, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xCC, 0x00, 0x1C, 0xC0, 0x01, 0xCC, 0x00, 0x1C, 0xE0,
  0x01, 0x8E, 0x00, 0x38, 0x70, 0x07, 0x07, 0x81, 0xF0, 0x3F, 0xFC, 0x00,
  0xFF, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x1F, 0x00, 0x03, 0xF8, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x08, 0xC0, 0xC0,
  0xCC, 0x0C, 0x1C, 0xC0, 0xC1, 0x8C, 0x0C, 0x30, 0xC0, 0xC6, 0x0C, 0x18,
  0x60, 0xC3, 0x8C, 0x07, 0xF1, 0x80, 0x3E, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x7C, 0x03, 0x0F, 0xE0,
  0x31, 0x86, 0x06, 0x30, 0x60, 0xC3, 0x03, 0x1C, 0x30, 0x31, 0x86, 0x03,
  0x30, 0x60, 0x66, 0x06, 0x06, 0x20, 0x60, 0x60, 0x03, 0x0C, 0x00, 0x3B,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xF8, 0x00, 0x70, 0xE0, 0x07,
  0x03, 0x00, 0x70, 0x18, 0x03, 0x80, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x70,
  0x06, 0x07, 0x00, 0x38, 0x70, 0x01, 0xC7, 0x00, 0x06, 0x70, 0x00, 0x3F,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x01, 0xFC, 0x00, 0x1E, 0x60, 0x01,
  0xC3, 0x81, 0xCC, 0x0E, 0x0C, 0xE0, 0x70, 0x6E, 0x01, 0xC7, 0x70, 0x06,
  0x33, 0x00, 0x3B, 0x98, 0x00, 0xF8, 0xC0, 0x07, 0xC7, 0x00, 0x1C, 0x38,
  0x01, 0xF0, 0xE0, 0x3F, 0x83, 0xFF, 0x8E, 0x0F, 0xF0, 0x38, 0x76, 0x66,
  0x66, 0xCC, 0xCC, 0x00, 0x08, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0xC0,
  0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01,
  0x80, 0x04, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00,
  0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01,
  0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0xC0,
  0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x20,
  0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x06, 0x06, 0x1F, 0xF1, 0x1F, 0x3F, 0xFF, 0x81, 0xFE, 0x00,
  0x1C, 0x00, 0x0F, 0x80, 0x07, 0x70, 0x03, 0x8C, 0x01, 0xC3, 0x80, 0xE0,
  0x70, 0x78, 0x0E, 0x0C, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x1F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xE8, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x61, 0x8E, 0x38, 0xC7, 0x18, 0xE3, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x6F, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x07, 0x81,
  0xC0, 0x60, 0x0C, 0x0C, 0x00, 0xE1, 0xC0, 0x06, 0x18, 0x00, 0x63, 0x80,
  0x07, 0x30, 0x00, 0x73, 0x00, 0x1F, 0x70, 0x03, 0xF7, 0x00, 0x76, 0x60,
  0x0E, 0x66, 0x03, 0x86, 0x60, 0x70, 0x66, 0x0E, 0x0E, 0xE1, 0xC0, 0xEE,
  0x70, 0x0C, 0xCE, 0x00, 0xCD, 0xC0, 0x0C, 0xF8, 0x01, 0xCE, 0x00, 0x1C,
  0xC0, 0x01, 0x8C, 0x00, 0x38, 0xE0, 0x03, 0x06, 0x00, 0x70, 0x70, 0x0E,
  0x03, 0x81, 0xC0, 0x3F, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x30, 0x0F, 0x07,
  0xE1, 0xFE, 0x7C, 0x6F, 0x0E, 0x80, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03,
  0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0xE0, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x03, 0x81,
  0xE0, 0x70, 0x0E, 0x0E, 0x00, 0x71, 0xC0, 0x07, 0x18, 0x00, 0x71, 0x80,
  0x07, 0x38, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xFE, 0x00, 0xF0, 0x38, 0x0E, 0x00, 0xE0, 0xE0, 0x07, 0x06, 0x00, 0x18,
  0x70, 0x00, 0xC3, 0x80, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x63, 0x80, 0x03, 0x1C, 0x00, 0x18, 0xE0,
  0x01, 0xC3, 0x00, 0x1C, 0x1C, 0x01, 0xE0, 0x70, 0x1E, 0x01, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x76, 0x00, 0x03, 0x70, 0x00, 0x33, 0x80, 0x03, 0x98,
  0x00, 0x38, 0xC0, 0x03, 0x86, 0x00, 0x18, 0x30, 0x01, 0x83, 0x80, 0x1C,
  0x1C, 0x01, 0xC0, 0xC0, 0x1C, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x80,
  0xE0, 0x1C, 0x0E, 0x00, 0xE0, 0xE0, 0x06, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x01, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x1B, 0xF8, 0x01, 0xFF, 0xF0, 0x0F, 0x87, 0xC0, 0x70,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x63, 0x80, 0x07, 0x1C, 0x00,
  0x30, 0x60, 0x03, 0x83, 0x00, 0x1C, 0x1C, 0x01, 0xC0, 0x70, 0x3C, 0x01,
  0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x01, 0xF8,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0xC0, 0x1C, 0xFF, 0x03, 0x3F, 0xF8,
  0x7C, 0x07, 0x0F, 0x00, 0x73, 0xC0, 0x06, 0x70, 0x00, 0xCC, 0x00, 0x1D,
  0x80, 0x03, 0xB0, 0x00, 0x76, 0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00, 0x33,
  0x00, 0x0E, 0x70, 0x01, 0x8E, 0x00, 0x70, 0xE0, 0x1C, 0x0E, 0x07, 0x00,
  0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x03, 0x81,
  0xE0, 0x70, 0x0E, 0x0E, 0x00, 0x70, 0xC0, 0x07, 0x1C, 0x00, 0x31, 0xC0,
  0x03, 0x18, 0x00, 0x71, 0x80, 0x06, 0x1C, 0x00, 0xE0, 0xC0, 0x0C, 0x0E,
  0x03, 0x80, 0x7D, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x1E, 0x07, 0x03,
  0x80, 0x38, 0x70, 0x01, 0xC6, 0x00, 0x0C, 0xE0, 0x00, 0xCC, 0x00, 0x0C,
  0xC0, 0x00, 0xCC, 0x00, 0x1C, 0xC0, 0x01, 0xCE, 0x00, 0x38, 0xE0, 0x07,
  0x07, 0x80, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x01, 0xFF,
  0x80, 0xF0, 0x70, 0x70, 0x0E, 0x38, 0x01, 0x8C, 0x00, 0x77, 0x00, 0x1D,
  0x80, 0x03, 0x60, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3D, 0x80, 0x0E, 0x70, 0x0F, 0x8E, 0x07,
  0x61, 0xFF, 0xB8, 0x3F, 0x8C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x1F, 0x80, 0x7F,
  0x80, 0x1F, 0x80, 0x00, 0x0C, 0x3C, 0x78, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x87, 0x8F, 0x1E, 0x00,
  0x01, 0x80, 0xF0, 0x3C, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x30, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x60, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x38, 0x00, 0x01, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x0F, 0xFC, 0x1C, 0x0E, 0x38, 0x07, 0x70, 0x07, 0x60, 0x03,
  0xE0, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x03, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x18, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0xC0, 0xE0, 0x0E, 0x00, 0x60,
  0x30, 0x00, 0xC0, 0xC0, 0x00, 0xC3, 0x83, 0xC1, 0x86, 0x0F, 0xC3, 0x18,
  0x70, 0xC6, 0x30, 0xC1, 0x04, 0xC3, 0x02, 0x09, 0x86, 0x0C, 0x36, 0x18,
  0x18, 0x6C, 0x30, 0x20, 0xD8, 0x40, 0x41, 0xA1, 0x81, 0x83, 0xC3, 0x03,
  0x05, 0x86, 0x04, 0x1B, 0x0C, 0x18, 0x36, 0x18, 0x70, 0x4C, 0x30, 0xE1,
  0x98, 0x63, 0xC6, 0x30, 0xFC, 0xF8, 0x20, 0xE0, 0xE0, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x30, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x06, 0xC0, 0x00, 0x77, 0x00, 0x03, 0x38,
  0x00, 0x38, 0xC0, 0x01, 0x86, 0x00, 0x1C, 0x30, 0x00, 0xC1, 0x80, 0x0E,
  0x0C, 0x00, 0x60, 0x70, 0x07, 0x03, 0x80, 0x30, 0x0C, 0x03, 0x80, 0x60,
  0x18, 0x03, 0x01, 0xC0, 0x18, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x70, 0x01, 0xC3, 0x80, 0x06, 0x18, 0x00, 0x31, 0xC0, 0x01, 0x8C,
  0x00, 0x0C, 0xE0, 0x00, 0x66, 0x00, 0x03, 0xF0, 0x00, 0x1C, 0x07, 0xFE,
  0x00, 0x3F, 0xFE, 0x03, 0x80, 0xF8, 0x1C, 0x00, 0xE0, 0xE0, 0x03, 0x06,
  0x00, 0x1C, 0x30, 0x00, 0xE1, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01,
  0x87, 0x00, 0x1C, 0x30, 0x01, 0xC1, 0x80, 0x1C, 0x0C, 0x0F, 0xC0, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x30, 0x01, 0xC1, 0x80, 0x07, 0x0C, 0x00, 0x18,
  0x60, 0x00, 0xC7, 0x00, 0x06, 0x38, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00,
  0x1C, 0x60, 0x00, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0xE1, 0xC0, 0x3E, 0x0F,
  0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00, 0xF0,
  0x38, 0x0E, 0x00, 0xE0, 0x60, 0x03, 0x07, 0x00, 0x1C, 0x70, 0x00, 0x63,
  0x00, 0x03, 0x38, 0x00, 0x19, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x31, 0x80, 0x03, 0x8C, 0x00, 0x18, 0x60, 0x01, 0xC3, 0x80,
  0x1C, 0x0E, 0x01, 0xE0, 0x78, 0x1E, 0x01, 0xFF, 0xC0, 0x03, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x70, 0x3E, 0x01, 0x80, 0x3C, 0x06,
  0x00, 0x30, 0x18, 0x00, 0xE0, 0xE0, 0x01, 0x83, 0x80, 0x07, 0x0E, 0x00,
  0x1C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x1C, 0x00, 0x0C,
  0x70, 0x00, 0x31, 0xC0, 0x01, 0xC6, 0x00, 0x07, 0x18, 0x00, 0x1C, 0x60,
  0x00, 0x63, 0x80, 0x01, 0x8E, 0x00, 0x0E, 0x30, 0x00, 0x30, 0xC0, 0x01,
  0xC3, 0x00, 0x07, 0x0C, 0x00, 0x38, 0x70, 0x01, 0xC1, 0xC0, 0x0E, 0x06,
  0x00, 0x70, 0x18, 0x0F, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x07, 0xFE, 0x00, 0xF0, 0x38, 0x0F, 0x00, 0xE0, 0x60, 0x03, 0x87, 0x00,
  0x1C, 0x70, 0x00, 0x63, 0x00, 0x03, 0x38, 0x00, 0x19, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x1F, 0xF7, 0x00, 0xFF, 0xB8, 0x00, 0x1D, 0xC0,
  0x00, 0xEE, 0x00, 0x06, 0x70, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x0C,
  0x70, 0x00, 0xE3, 0x80, 0x07, 0x0E, 0x00, 0x70, 0x38, 0x0F, 0x00, 0xFF,
  0xF0, 0x03, 0xFE, 0x00, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00,
  0x18, 0x30, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0x83, 0x00, 0x03,
  0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x38, 0x70, 0x00, 0x70,
  0xE0, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x38, 0x00, 0x38, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80,
  0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x0E, 0x1C, 0x00, 0x18, 0x30, 0x00,
  0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x87, 0x00, 0x07,
  0x0E, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0x81, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x86, 0x00, 0x0C, 0x18, 0x00, 0x30,
  0x60, 0x01, 0xC1, 0xC0, 0x0E, 0x03, 0x00, 0x70, 0x0F, 0x03, 0x80, 0x1F,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x06, 0x00, 0x0F, 0x06, 0x00, 0x1E, 0x06,
  0x00, 0x3C, 0x0E, 0x00, 0x78, 0x0E, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x0C,
  0x03, 0xC0, 0x0C, 0x07, 0x00, 0x0C, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x1C,
  0x38, 0x00, 0x18, 0x70, 0x00, 0x18, 0xE0, 0x00, 0x19, 0xC0, 0x00, 0x1B,
  0xE0, 0x00, 0x3F, 0x70, 0x00, 0x3E, 0x70, 0x00, 0x3C, 0x38, 0x00, 0x38,
  0x38, 0x00, 0x30, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x70,
  0x06, 0x00, 0x60, 0x07, 0x00, 0x60, 0x03, 0x00, 0x60, 0x03, 0x80, 0xE0,
  0x01, 0x80, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0xC0, 0x00, 0xE0, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x0F, 0x07, 0x80,
  0x0E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x36, 0x0F, 0x80,
  0x3E, 0x0D, 0x80, 0x6E, 0x0C, 0xC0, 0xEC, 0x0C, 0xC0, 0xCC, 0x0C, 0xC1,
  0xCC, 0x0C, 0xC1, 0x8C, 0x1C, 0xC3, 0x9C, 0x1C, 0xE3, 0x18, 0x18, 0x67,
  0x18, 0x18, 0x66, 0x18, 0x18, 0x6C, 0x18, 0x18, 0x6C, 0x38, 0x38, 0x78,
  0x38, 0x38, 0x78, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x00,
  0x30, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0x60, 0x60, 0x00,
  0x60, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0xE0, 0x00, 0xE0, 0xE0, 0x00,
  0xE0, 0x07, 0x00, 0x06, 0x0E, 0x00, 0x0C, 0x1C, 0x00, 0x38, 0x3C, 0x00,
  0x70, 0xF8, 0x00, 0xE1, 0xF0, 0x01, 0x83, 0xF0, 0x03, 0x06, 0x60, 0x06,
  0x0C, 0xE0, 0x1C, 0x18, 0xC0, 0x38, 0x71, 0x80, 0x70, 0xE3, 0x80, 0xC1,
  0xC3, 0x01, 0x83, 0x06, 0x03, 0x06, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C, 0x38,
  0x18, 0x38, 0x70, 0x38, 0x60, 0xC0, 0x30, 0xC1, 0x80, 0x61, 0x83, 0x00,
  0xE7, 0x06, 0x00, 0xCE, 0x1C, 0x01, 0xD8, 0x38, 0x01, 0xB0, 0x60, 0x03,
  0x60, 0xC0, 0x07, 0xC1, 0x80, 0x07, 0x83, 0x00, 0x0F, 0x0E, 0x00, 0x1C,
  0x1C, 0x00, 0x18, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFE, 0x00, 0xF0, 0x78,
  0x0F, 0x00, 0xC0, 0x60, 0x07, 0x07, 0x00, 0x18, 0x70, 0x00, 0xE3, 0x00,
  0x07, 0x18, 0x00, 0x19, 0xC0, 0x00, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x37,
  0x00, 0x03, 0xB8, 0x00, 0x1D, 0x80, 0x00, 0xEC, 0x00, 0x06, 0x60, 0x00,
  0x33, 0x00, 0x01, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x06, 0x70,
  0x00, 0x71, 0x80, 0x03, 0x0C, 0x00, 0x38, 0x60, 0x01, 0x83, 0x80, 0x1C,
  0x0E, 0x01, 0xC0, 0x78, 0x3C, 0x01, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x60, 0x0F, 0x01, 0x80, 0x0E, 0x06, 0x00,
  0x18, 0x38, 0x00, 0x70, 0xE0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C,
  0x30, 0x00, 0x30, 0xC0, 0x01, 0xC7, 0x00, 0x06, 0x1C, 0x00, 0x38, 0x60,
  0x01, 0xC1, 0x80, 0x0E, 0x06, 0x01, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xF0,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x0F, 0xFE, 0x00, 0xF0, 0x78, 0x0E, 0x00, 0xE0, 0xE0, 0x03, 0x06,
  0x00, 0x1C, 0x70, 0x00, 0x63, 0x00, 0x03, 0x38, 0x00, 0x19, 0x80, 0x00,
  0xCC, 0x00, 0x06, 0xE0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80,
  0x00, 0x6C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xB0, 0x00, 0x0D,
  0x80, 0x00, 0x6C, 0x00, 0x07, 0x70, 0x00, 0x33, 0x80, 0x03, 0x8C, 0x00,
  0x18, 0x60, 0x01, 0xC3, 0x80, 0x1C, 0x0C, 0x01, 0xC0, 0x78, 0x1C, 0x01,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x60, 0x07, 0xFE, 0x00, 0x3F, 0xFE, 0x01,
  0x80, 0x78, 0x0C, 0x00, 0xE0, 0xE0, 0x03, 0x07, 0x00, 0x1C, 0x30, 0x00,
  0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x38,
  0x00, 0x61, 0x80, 0x07, 0x0C, 0x00, 0x70, 0x60, 0x0F, 0x07, 0xFF, 0xF0,
  0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00,
  0x60, 0x38, 0x03, 0x81, 0xC0, 0x1C, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x83,
  0x00, 0x1C, 0x18, 0x00, 0x61, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x60, 0x00,
  0x60, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x3C, 0x0F, 0x01, 0xC0, 0x1C,
  0x0E, 0x00, 0x38, 0x30, 0x00, 0x61, 0xC0, 0x01, 0x87, 0x00, 0x06, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x8E, 0x00, 0x06, 0x38, 0x00, 0x18, 0xE0, 0x00, 0xE1, 0xC0, 0x03,
  0x07, 0x00, 0x1C, 0x0F, 0x01, 0xE0, 0x1F, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x0C, 0x30, 0x00,
  0x30, 0xC0, 0x00, 0xC3, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x61,
  0x80, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0xE3, 0x80,
  0x03, 0x8E, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03,
  0x0C, 0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x01, 0x86, 0x00, 0x06, 0x18,
  0x00, 0x18, 0x60, 0x00, 0xE1, 0x80, 0x03, 0x86, 0x00, 0x0C, 0x18, 0x00,
  0x70, 0x60, 0x01, 0xC1, 0xC0, 0x0E, 0x03, 0x80, 0x70, 0x0F, 0x03, 0x80,
  0x1F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x6E, 0x00, 0x0E, 0xE0, 0x00, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0x86,
  0x00, 0x38, 0x60, 0x03, 0x06, 0x00, 0x70, 0x70, 0x07, 0x07, 0x00, 0xE0,
  0x70, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x03, 0x01, 0x80, 0x30, 0x38,
  0x03, 0x83, 0x00, 0x38, 0x70, 0x01, 0x86, 0x00, 0x18, 0xE0, 0x01, 0x8C,
  0x00, 0x19, 0xC0, 0x01, 0x98, 0x00, 0x1D, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x30, 0x0F,
  0x80, 0xC0, 0x3E, 0x07, 0x01, 0xF8, 0x1C, 0x06, 0xE0, 0x70, 0x1B, 0x83,
  0xC0, 0xEE, 0x0D, 0x83, 0x38, 0x36, 0x0C, 0xC1, 0xD8, 0x33, 0x06, 0x61,
  0x8C, 0x19, 0x86, 0x30, 0xE6, 0x18, 0xC3, 0x18, 0xE3, 0x0C, 0x63, 0x0C,
  0x71, 0x8C, 0x31, 0x86, 0x30, 0xC6, 0x19, 0x83, 0x30, 0x66, 0x0C, 0xC1,
  0x98, 0x33, 0x06, 0xE0, 0xD8, 0x1B, 0x03, 0x60, 0x6C, 0x0D, 0x81, 0xF0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x70, 0x00, 0x07, 0x00, 0x03, 0x81,
  0x80, 0x01, 0x80, 0xE0, 0x01, 0xC0, 0x30, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x06, 0x00, 0xC0, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0x60, 0xE0,
  0x00, 0x38, 0x60, 0x00, 0x0C, 0x70, 0x00, 0x07, 0x70, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x1C, 0x60, 0x00, 0x1C,
  0x38, 0x00, 0x0C, 0x0C, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x01, 0x80, 0x0E,
  0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x18, 0x07, 0x00, 0x0E, 0x07,
  0x00, 0x03, 0x07, 0x80, 0x01, 0xC0, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xB8,
  0x00, 0x38, 0xC0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x01, 0xC0, 0xC0, 0x1C,
  0x06, 0x00, 0xE0, 0x38, 0x0E, 0x00, 0xC0, 0x60, 0x06, 0x07, 0x00, 0x38,
  0x70, 0x00, 0xC3, 0x00, 0x06, 0x38, 0x00, 0x3B, 0x80, 0x00, 0xD8, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x80, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x08, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x00,
  0x03, 0xF8, 0x1F, 0xC0, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00,
  0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x70, 0x03, 0xF8, 0x1F, 0xC0, 0xC0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x07, 0x01, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07,
  0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x03, 0xF8, 0x1F, 0xC0,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0xC0, 0x0F, 0x80, 0x1B, 0x00, 0x76, 0x00,
  0xCE, 0x03, 0x0C, 0x06, 0x18, 0x18, 0x30, 0x70, 0x60, 0xC0, 0xE3, 0x80,
  0xC6, 0x01, 0x9C, 0x03, 0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE3,
  0x1C, 0x61, 0x8C, 0x00, 0x18, 0x00, 0x3F, 0xE0, 0x1F, 0xBE, 0x07, 0x80,
  0xE1, 0xC0, 0x0E, 0x38, 0x01, 0xC6, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x03, 0xFF, 0x87, 0xFF, 0xE1, 0xF0, 0x0C, 0x70, 0x01,
  0x9C, 0x00, 0x73, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x33, 0x80, 0x0E,
  0x70, 0x07, 0xC7, 0x01, 0xD8, 0x7F, 0xF3, 0x07, 0xF8, 0x60, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x83, 0x80, 0x33, 0xFC,
  0x0E, 0xFF, 0xC1, 0xF0, 0x1C, 0x3C, 0x01, 0x87, 0x00, 0x38, 0xC0, 0x03,
  0x18, 0x00, 0x67, 0x00, 0x0C, 0xE0, 0x01, 0x98, 0x00, 0x33, 0x00, 0x06,
  0x60, 0x00, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0xCC, 0x00, 0x39,
  0x80, 0x06, 0x38, 0x01, 0xCF, 0x00, 0x71, 0xF8, 0x1C, 0x33, 0xFF, 0x06,
  0x3F, 0xC0, 0x00, 0x70, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x07, 0x01, 0xC1,
  0xC0, 0x1C, 0x70, 0x01, 0x8C, 0x00, 0x33, 0x80, 0x07, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x01, 0x9C, 0x00, 0x71, 0x80, 0x0C, 0x38,
  0x03, 0x83, 0x81, 0xE0, 0x7F, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x03, 0x03, 0x00,
  0xFF, 0x18, 0x0F, 0xFD, 0xC0, 0xE0, 0x3E, 0x0E, 0x00, 0xF0, 0xE0, 0x07,
  0x06, 0x00, 0x18, 0x70, 0x00, 0xC3, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0,
  0x03, 0x8C, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x70,
  0xC0, 0x03, 0x86, 0x00, 0x18, 0x38, 0x00, 0xC1, 0xC0, 0x0E, 0x07, 0x00,
  0xF0, 0x3C, 0x1D, 0x80, 0xFF, 0xDC, 0x03, 0xFC, 0xC0, 0x00, 0x18, 0x00,
  0x0F, 0xF0, 0x03, 0xFF, 0x80, 0x70, 0x1C, 0x0E, 0x00, 0xE1, 0xC0, 0x06,
  0x18, 0x00, 0x63, 0x80, 0x07, 0x30, 0x00, 0x77, 0x00, 0x07, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFE, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x83, 0x80, 0x1C, 0x1C,
  0x07, 0x80, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x01, 0xFF,
  0x80, 0x1E, 0x02, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x07, 0xF8,
  0xC0, 0x7F, 0xE6, 0x07, 0x01, 0xF0, 0x70, 0x07, 0x87, 0x00, 0x38, 0x30,
  0x00, 0xC3, 0x80, 0x06, 0x18, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x1C,
  0x60, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x03, 0x86, 0x00,
  0x1C, 0x30, 0x00, 0xE1, 0xC0, 0x06, 0x0E, 0x00, 0x70, 0x38, 0x07, 0x81,
  0xE0, 0xEC, 0x07, 0xFE, 0xE0, 0x1F, 0xE7, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0xC0, 0x0E, 0x0F, 0x00, 0xE0, 0x1E,
  0x3E, 0x00, 0x7F, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x71, 0xFE, 0x0E, 0xFF, 0xE1,
  0xB8, 0x1E, 0x34, 0x01, 0xC7, 0x00, 0x18, 0xE0, 0x03, 0x38, 0x00, 0x67,
  0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00, 0x33, 0x00, 0x0E, 0x60, 0x01, 0xDC,
  0x00, 0x33, 0x80, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x39, 0x80, 0x07, 0x70,
  0x00, 0xEE, 0x00, 0x19, 0xC0, 0x03, 0x30, 0x00, 0x66, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0xFF,
  0x80, 0x3F, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x43, 0x00, 0x1C, 0x18, 0x01, 0xC0,
  0xC0, 0x3C, 0x0E, 0x03, 0x80, 0x70, 0x38, 0x03, 0x03, 0x80, 0x18, 0x78,
  0x00, 0xC7, 0x80, 0x06, 0x70, 0x00, 0x77, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0x70, 0x00, 0xF1, 0xC0, 0x06, 0x0E, 0x00, 0x70, 0x38, 0x03, 0x80, 0xE0,
  0x1C, 0x07, 0x00, 0xC0, 0x1C, 0x06, 0x00, 0x70, 0x30, 0x03, 0x83, 0x80,
  0x0E, 0x1C, 0x00, 0x38, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x10, 0x1D, 0xF8, 0xFC, 0x1B, 0xFD,
  0xFE, 0x1E, 0x1F, 0x06, 0x1C, 0x0E, 0x06, 0x18, 0x0C, 0x06, 0x38, 0x0C,
  0x06, 0x38, 0x0C, 0x06, 0x30, 0x1C, 0x06, 0x30, 0x1C, 0x06, 0x30, 0x18,
  0x0E, 0x30, 0x18, 0x0E, 0x70, 0x18, 0x0C, 0x70, 0x18, 0x0C, 0x60, 0x38,
  0x0C, 0x60, 0x38, 0x0C, 0x60, 0x30, 0x1C, 0x60, 0x30, 0x1C, 0xE0, 0x30,
  0x18, 0xE0, 0x30, 0x18, 0xC0, 0x70, 0x18, 0xC0, 0x70, 0x18, 0xC0, 0x60,
  0x38, 0x00, 0x0C, 0x03, 0x8F, 0xF0, 0x67, 0xFF, 0x0D, 0xC0, 0xF1, 0xE0,
  0x0E, 0x38, 0x00, 0xC7, 0x00, 0x19, 0xC0, 0x03, 0x38, 0x00, 0x66, 0x00,
  0x0C, 0xC0, 0x03, 0x98, 0x00, 0x73, 0x00, 0x0E, 0xE0, 0x01, 0x9C, 0x00,
  0x33, 0x00, 0x06, 0x60, 0x01, 0xCC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00,
  0xCE, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1F,
  0xF0, 0x03, 0xFF, 0x80, 0xF0, 0x1C, 0x1E, 0x00, 0xE1, 0xC0, 0x0E, 0x38,
  0x00, 0x63, 0x00, 0x07, 0x70, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x0E,
  0xE0, 0x00, 0xC6, 0x00, 0x1C, 0x70, 0x03, 0x83, 0x00, 0x70, 0x38, 0x0E,
  0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x39, 0xFE, 0x01,
  0xDF, 0xF8, 0x0D, 0x80, 0xE0, 0x78, 0x03, 0x03, 0x80, 0x1C, 0x18, 0x00,
  0xE1, 0xC0, 0x03, 0x0E, 0x00, 0x18, 0x70, 0x00, 0xC3, 0x00, 0x06, 0x18,
  0x00, 0x30, 0xC0, 0x01, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0xC3, 0x00, 0x06,
  0x18, 0x00, 0x70, 0xC0, 0x03, 0x07, 0x00, 0x38, 0x78, 0x03, 0x83, 0xE0,
  0x38, 0x1D, 0xFF, 0x80, 0xC7, 0xF8, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x7F, 0x8C, 0x3F,
  0xF9, 0x8F, 0x01, 0xF1, 0xC0, 0x1E, 0x70, 0x03, 0x8C, 0x00, 0x33, 0x80,
  0x06, 0x60, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0x60, 0x00, 0xCC, 0x00,
  0x19, 0x80, 0x03, 0x30, 0x00, 0xE6, 0x00, 0x1C, 0xC0, 0x03, 0x9C, 0x00,
  0x63, 0x80, 0x1C, 0x38, 0x07, 0x87, 0x81, 0xB0, 0x7F, 0xEE, 0x07, 0xF9,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x03, 0x0F, 0xF0, 0xCF, 0xFC, 0x77, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xE0, 0x3F, 0xFE, 0x0F, 0x00, 0xE1,
  0xC0, 0x0C, 0x70, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x98, 0x00, 0x33, 0x80, 0x0E, 0x70,
  0x01, 0xC7, 0x00, 0xF0, 0x7F, 0xFC, 0x03, 0xFE, 0x00, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x07, 0xFF, 0xFD,
  0xFF, 0xFE, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x18, 0x00, 0x67,
  0x00, 0x0C, 0xE0, 0x03, 0x98, 0x00, 0x73, 0x00, 0x0E, 0x60, 0x01, 0x8C,
  0x00, 0x33, 0x80, 0x06, 0x70, 0x01, 0xCC, 0x00, 0x39, 0x80, 0x07, 0x30,
  0x00, 0xCE, 0x00, 0x19, 0xC0, 0x03, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0xE0,
  0x03, 0x9C, 0x00, 0xE1, 0x80, 0x3C, 0x38, 0x1D, 0x83, 0xFF, 0x30, 0x3F,
  0x8E, 0x00, 0xC0, 0x00, 0x7E, 0x00, 0x0E, 0xE0, 0x00, 0xC6, 0x00, 0x1C,
  0x60, 0x01, 0x86, 0x00, 0x38, 0x70, 0x03, 0x03, 0x00, 0x70, 0x30, 0x0E,
  0x03, 0x00, 0xC0, 0x38, 0x1C, 0x01, 0x81, 0x80, 0x18, 0x38, 0x01, 0x83,
  0x00, 0x1C, 0x70, 0x00, 0xC6, 0x00, 0x0C, 0xC0, 0x00, 0xDC, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x30, 0x0F,
  0x01, 0xC0, 0x7C, 0x07, 0x01, 0xB0, 0x1C, 0x06, 0xC0, 0xF0, 0x33, 0x03,
  0xC0, 0xCC, 0x1B, 0x07, 0x30, 0x64, 0x18, 0xC1, 0x98, 0x63, 0x0C, 0x63,
  0x0C, 0x31, 0x8C, 0x31, 0x86, 0x30, 0xE6, 0x19, 0x81, 0xB0, 0x66, 0x06,
  0xC1, 0x98, 0x1B, 0x06, 0xC0, 0x78, 0x1B, 0x01, 0xE0, 0x78, 0x07, 0x01,
  0xE0, 0x1C, 0x07, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x00, 0x0E, 0x00,
  0x1E, 0x0C, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0x18, 0x07, 0x00, 0x38, 0x1C,
  0x00, 0x38, 0x70, 0x00, 0x30, 0xE0, 0x00, 0x73, 0x80, 0x00, 0x6E, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x39, 0x80, 0x00, 0xE3, 0x80, 0x03, 0x83, 0x00, 0x07, 0x07, 0x00, 0x1C,
  0x07, 0x00, 0x70, 0x06, 0x01, 0xC0, 0x0E, 0x07, 0x00, 0x0C, 0x1C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x03, 0xC1, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x70,
  0x1C, 0x00, 0x18, 0x03, 0x00, 0x0E, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x01, 0x80, 0x30, 0x00, 0x60, 0x1C, 0x00, 0x1C,
  0x06, 0x00, 0x07, 0x03, 0x80, 0x00, 0xC1, 0xC0, 0x00, 0x38, 0x60, 0x00,
  0x0E, 0x38, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x67, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x03, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x03, 0x03, 0x03,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C,
  0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x38, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0xC0, 0xC0, 0x02, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x78, 0x00, 0xE0, 0x00, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0xC0, 0x0D, 0xC3, 0xC0, 0x33, 0x03, 0xC0, 0xEC, 0x01, 0xC3, 0x98, 0x01,
  0xFE, 0x10, 0x01, 0xF8, 0x00,
};

const GFXglyph RobotoMono_LightItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 8, 30, 25, 8, -30 },
  { 31, 9, 10, 25, 10, -32 },
  { 43, 24, 30, 25, 1, -30 },
  { 133, 20, 38, 25, 3, -34 },
  { 228, 20, 30, 25, 3, -30 },
  { 303, 21, 30, 25, 2, -30 },
  { 382, 4, 10, 25, 12, -32 },
  { 387, 13, 44, 25, 7, -34 },
  { 459, 13, 43, 25, 4, -33 },
  { 529, 18, 18, 25, 5, -30 },
  { 570, 21, 22, 25, 2, -25 },
  { 628, 6, 10, 25, 5, -4 },
  { 636, 15, 2, 25, 5, -14 },
  { 640, 4, 4, 25, 9, -4 },
  { 642, 20, 33, 25, 3, -30 },
  { 725, 20, 30, 25, 3, -30 },
  { 800, 12, 30, 25, 6, -30 },
  { 845, 20, 30, 25, 1, -30 },
  { 920, 21, 30, 25, 1, -30 },
  { 999, 21, 30, 25, 1, -30 },
  { 1078, 21, 30, 25, 3, -30 },
  { 1157, 19, 30, 25, 2, -30 },
  { 1229, 19, 30, 25, 5, -30 },
  { 1301, 20, 30, 25, 3, -30 },
  { 1376, 18, 30, 25, 4, -30 },
  { 1444, 7, 22, 25, 10, -22 },
  { 1464, 10, 28, 25, 7, -22 },
  { 1499, 19, 17, 25, 3, -22 },
  { 1540, 19, 11, 25, 3, -19 },
  { 1567, 19, 17, 25, 2, -22 },
  { 1608, 16, 30, 25, 6, -30 },
  { 1668, 23, 30, 25, 1, -30 },
  { 1755, 21, 30, 25, 0, -30 },
  { 1834, 21, 30, 25, 2, -30 },
  { 1913, 21, 30, 25, 2, -30 },
  { 1992, 22, 30, 25, 1, -30 },
  { 2075, 22, 30, 25, 2, -30 },
  { 2158, 22, 30, 25, 2, -30 },
  { 2241, 21, 30, 25, 2, -30 },
  { 2320, 23, 30, 25, 1, -30 },
  { 2407, 22, 30, 25, 2, -30 },
  { 2490, 22, 30, 25, 1, -30 },
  { 2573, 24, 30, 25, 2, -30 },
  { 2663, 18, 30, 25, 2, -30 },
  { 2731, 24, 30, 25, 1, -30 },
  { 2821, 23, 30, 25, 1, -30 },
  { 2908, 21, 30, 25, 2, -30 },
  { 2987, 22, 30, 25, 2, -30 },
  { 3070, 21, 35, 25, 2, -30 },
  { 3162, 21, 30, 25, 2, -30 },
  { 3241, 22, 30, 25, 2, -30 },
  { 3324, 21, 30, 25, 5, -30 },
  { 3403, 22, 30, 25, 2, -30 },
  { 3486, 20, 30, 25, 5, -30 },
  { 3561, 22, 30, 25, 4, -30 },
  { 3644, 25, 30, 25, 0, -30 },
  { 3738, 21, 30, 25, 5, -30 },
  { 3817, 22, 30, 25, 1, -30 },
  { 3900, 13, 40, 25, 6, -34 },
  { 3965, 9, 33, 25, 8, -30 },
  { 4003, 13, 40, 25, 6, -34 },
  { 4068, 15, 16, 25, 5, -30 },
  { 4098, 18, 2, 25, 1, 0 },
  { 4103, 5, 6, 25, 12, -31 },
  { 4107, 19, 23, 25, 2, -23 },
  { 4162, 19, 32, 25, 2, -32 },
  { 4238, 19, 23, 25, 3, -23 },
  { 4293, 21, 32, 25, 3, -32 },
  { 4377, 20, 23, 25, 2, -23 },
  { 4435, 21, 32, 25, 5, -32 },
  { 4519, 21, 32, 25, 1, -23 },
  { 4603, 19, 32, 25, 2, -32 },
  { 4679, 18, 30, 25, 2, -30 },
  { 4747, 19, 39, 25, 0, -30 },
  { 4840, 21, 32, 25, 2, -32 },
  { 4924, 18, 32, 25, 2, -32 },
  { 4996, 24, 23, 25, 0, -23 },
  { 5065, 19, 23, 25, 2, -23 },
  { 5120, 20, 23, 25, 2, -23 },
  { 5178, 21, 32, 25, 0, -23 },
  { 5262, 19, 32, 25, 3, -23 },
  { 5338, 18, 23, 25, 5, -23 },
  { 5390, 19, 23, 25, 3, -23 },
  { 5445, 17, 28, 25, 5, -28 },
  { 5505, 19, 22, 25, 3, -22 },
  { 5558, 20, 22, 25, 4, -22 },
  { 5613, 22, 22, 25, 3, -22 },
  { 5674, 23, 22, 25, 1, -22 },
  { 5738, 26, 31, 25, -1, -22 },
  { 5839, 21, 22, 25, 1, -22 },
  { 5897, 17, 41, 25, 6, -33 },
  { 5985, 8, 37, 25, 8, -30 },
  { 6022, 16, 41, 25, 4, -33 },
  { 6104, 23, 7, 25, 1, -16 },
};

const GFXfont RobotoMono_LightItalic42pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic42pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic42pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _ROBOTOMONO_LIGHTITALIC42PT7B_H_
