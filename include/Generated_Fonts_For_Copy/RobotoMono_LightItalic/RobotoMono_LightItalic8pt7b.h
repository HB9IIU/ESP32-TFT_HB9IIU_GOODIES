#ifndef _ROBOTOMONO_LIGHTITALIC8PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xE0, 0x29, 0x96, 0xAE, 0x50, 0x2E, 0xC7, 0x6A, 0x4B, 0x63,
  0x73, 0x25, 0x27, 0xBF, 0xC0, 0x6A, 0x49, 0x22, 0x55, 0x5A, 0x5D, 0x50,
  0x22, 0xF2, 0xC0, 0xE0, 0x80, 0x25, 0x29, 0x00, 0x76, 0xFB, 0x80, 0x75,
  0x50, 0x69, 0x12, 0x4F, 0x35, 0x13, 0x9E, 0x13, 0x55, 0xF2, 0x78, 0xC2,
  0xAE, 0x34, 0x69, 0x96, 0xF2, 0x24, 0x48, 0x35, 0x57, 0x97, 0x76, 0xF3,
  0x80, 0x90, 0x41, 0x80, 0x71, 0x80, 0xFC, 0x61, 0xE0, 0x74, 0xA1, 0x00,
  0x33, 0x77, 0xDF, 0x70, 0x22, 0x55, 0xB9, 0x75, 0x5B, 0x9F, 0x35, 0x88,
  0x97, 0x65, 0x59, 0x9E, 0x7A, 0x10, 0xE8, 0x78, 0x7A, 0x10, 0xE8, 0x40,
  0x35, 0x8B, 0x97, 0x4A, 0x53, 0x69, 0x48, 0x79, 0x08, 0x42, 0x78, 0x11,
  0x11, 0x9E, 0x4A, 0x98, 0xCA, 0x48, 0x44, 0x44, 0x8F, 0x4A, 0x95, 0x69,
  0x48, 0x4A, 0x53, 0x69, 0x48, 0x35, 0x99, 0x96, 0x72, 0x52, 0xE8, 0x40,
  0x35, 0x99, 0x96, 0x10, 0x75, 0x56, 0x99, 0x35, 0x43, 0x97, 0xF4, 0x44,
  0x44, 0x4A, 0x53, 0x29, 0x30, 0x99, 0xAA, 0x44, 0xDD, 0xDA, 0xAA, 0x4A,
  0x88, 0x45, 0x48, 0x9A, 0xA4, 0x48, 0x71, 0x22, 0x4F, 0x69, 0x29, 0x26,
  0xFC, 0x64, 0xA4, 0x96, 0x4A, 0x80, 0xF0, 0x80, 0x77, 0x9F, 0x46, 0x55,
  0x9E, 0xF2, 0x70, 0x15, 0xAA, 0xAE, 0x7F, 0x87, 0x7E, 0x44, 0x88, 0x79,
  0x97, 0x96, 0x46, 0x59, 0x99, 0x14, 0x22, 0x2F, 0x16, 0x12, 0x22, 0x2C,
  0x44, 0x56, 0xA9, 0x72, 0x22, 0x2F, 0xFB, 0xBB, 0x79, 0x99, 0x79, 0x97,
  0x79, 0x9E, 0x88, 0xF6, 0xF2, 0x40, 0x72, 0x40, 0xF8, 0xF0, 0xE9, 0x4E,
  0xB6, 0xF0, 0xBA, 0xC4, 0xDE, 0xAA, 0x59, 0x19, 0x20, 0x5A, 0x98, 0x44,
  0x40, 0x72, 0x4F, 0x29, 0x44, 0x92, 0xFE, 0x49, 0x14, 0xA4, 0xF8,
};

const GFXglyph RobotoMono_LightItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 2, 2, 5, 2, -6 },
  { 3, 5, 6, 5, 0, -6 },
  { 7, 3, 8, 5, 1, -7 },
  { 10, 4, 6, 5, 0, -6 },
  { 13, 4, 6, 5, 0, -6 },
  { 16, 1, 2, 5, 2, -6 },
  { 17, 3, 8, 5, 1, -6 },
  { 20, 2, 8, 5, 1, -6 },
  { 22, 3, 4, 5, 1, -6 },
  { 24, 4, 4, 5, 0, -5 },
  { 26, 1, 2, 5, 1, -1 },
  { 27, 3, 1, 5, 1, -3 },
  { 28, 1, 1, 5, 2, -1 },
  { 29, 3, 6, 5, 1, -6 },
  { 32, 3, 6, 5, 1, -6 },
  { 35, 2, 6, 5, 1, -6 },
  { 37, 4, 6, 5, 0, -6 },
  { 40, 4, 6, 5, 0, -6 },
  { 43, 4, 6, 5, 0, -6 },
  { 46, 4, 6, 5, 1, -6 },
  { 49, 4, 6, 5, 0, -6 },
  { 52, 4, 6, 5, 1, -6 },
  { 55, 4, 6, 5, 0, -6 },
  { 58, 3, 6, 5, 1, -6 },
  { 61, 1, 4, 5, 2, -4 },
  { 62, 2, 5, 5, 1, -4 },
  { 64, 3, 3, 5, 1, -4 },
  { 66, 3, 2, 5, 1, -4 },
  { 67, 4, 3, 5, 0, -4 },
  { 69, 3, 6, 5, 1, -6 },
  { 72, 5, 6, 5, 0, -6 },
  { 76, 4, 6, 5, 0, -6 },
  { 79, 4, 6, 5, 0, -6 },
  { 82, 4, 6, 5, 0, -6 },
  { 85, 4, 6, 5, 0, -6 },
  { 88, 5, 6, 5, 0, -6 },
  { 92, 5, 6, 5, 0, -6 },
  { 96, 4, 6, 5, 0, -6 },
  { 99, 5, 6, 5, 0, -6 },
  { 103, 5, 6, 5, 0, -6 },
  { 107, 4, 6, 5, 0, -6 },
  { 110, 5, 6, 5, 0, -6 },
  { 114, 4, 6, 5, 0, -6 },
  { 117, 5, 6, 5, 0, -6 },
  { 121, 5, 6, 5, 0, -6 },
  { 125, 4, 6, 5, 0, -6 },
  { 128, 5, 6, 5, 0, -6 },
  { 132, 4, 7, 5, 0, -6 },
  { 136, 4, 6, 5, 0, -6 },
  { 139, 4, 6, 5, 0, -6 },
  { 142, 4, 6, 5, 1, -6 },
  { 145, 5, 6, 5, 0, -6 },
  { 149, 4, 6, 5, 1, -6 },
  { 152, 4, 6, 5, 1, -6 },
  { 155, 5, 6, 5, 0, -6 },
  { 159, 4, 6, 5, 1, -6 },
  { 162, 4, 6, 5, 0, -6 },
  { 165, 3, 8, 5, 1, -7 },
  { 168, 1, 6, 5, 2, -6 },
  { 169, 3, 8, 5, 1, -7 },
  { 172, 3, 3, 5, 1, -6 },
  { 174, 4, 1, 5, 0, 0 },
  { 175, 1, 1, 5, 2, -6 },
  { 176, 4, 4, 5, 0, -4 },
  { 178, 4, 6, 5, 0, -6 },
  { 181, 3, 4, 5, 1, -4 },
  { 183, 4, 6, 5, 1, -6 },
  { 186, 4, 4, 5, 0, -4 },
  { 188, 4, 6, 5, 1, -6 },
  { 191, 4, 6, 5, 0, -4 },
  { 194, 4, 6, 5, 0, -6 },
  { 197, 4, 6, 5, 0, -6 },
  { 200, 4, 8, 5, 0, -6 },
  { 204, 4, 6, 5, 0, -6 },
  { 207, 4, 6, 5, 0, -6 },
  { 210, 4, 4, 5, 0, -4 },
  { 212, 4, 4, 5, 0, -4 },
  { 214, 4, 4, 5, 0, -4 },
  { 216, 4, 6, 5, 0, -4 },
  { 219, 3, 6, 5, 1, -4 },
  { 222, 3, 4, 5, 1, -4 },
  { 224, 3, 4, 5, 1, -4 },
  { 226, 3, 5, 5, 1, -5 },
  { 228, 3, 4, 5, 1, -4 },
  { 230, 4, 4, 5, 1, -4 },
  { 232, 4, 4, 5, 1, -4 },
  { 234, 5, 4, 5, 0, -4 },
  { 237, 5, 6, 5, 0, -4 },
  { 241, 4, 4, 5, 0, -4 },
  { 243, 3, 8, 5, 1, -6 },
  { 246, 1, 7, 5, 2, -6 },
  { 247, 3, 8, 5, 1, -6 },
  { 250, 5, 1, 5, 0, -3 },
};

const GFXfont RobotoMono_LightItalic8pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic8pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _ROBOTOMONO_LIGHTITALIC8PT7B_H_
