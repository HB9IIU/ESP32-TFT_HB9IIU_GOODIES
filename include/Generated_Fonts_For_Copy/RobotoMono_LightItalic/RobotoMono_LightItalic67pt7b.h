#ifndef _ROBOTOMONO_LIGHTITALIC67PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0x00, 0x1C, 0x0F, 0x3C, 0x0E, 0x3C,
  0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x1E, 0x38, 0x1C, 0x78, 0x1C, 0x70,
  0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x38, 0x70, 0x38, 0xE0, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x07, 0x00, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x0F,
  0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x07,
  0x80, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F,
  0xF0, 0x7F, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x07,
  0x80, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x1C, 0x00,
  0x00, 0x1E, 0x0E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xE0, 0x3C,
  0x00, 0x01, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xF0, 0x03,
  0xF8, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x3C, 0x07, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x78, 0x03, 0x80,
  0x18, 0x70, 0x03, 0x80, 0x3C, 0x70, 0x03, 0x80, 0x38, 0x70, 0x03, 0x80,
  0x70, 0xF0, 0x03, 0x80, 0xF0, 0xE0, 0x07, 0x81, 0xE0, 0xE0, 0x07, 0x01,
  0xC0, 0xE0, 0x07, 0x03, 0xC0, 0xE0, 0x07, 0x07, 0x80, 0xF0, 0x0E, 0x07,
  0x00, 0x70, 0x1E, 0x0E, 0x00, 0x78, 0x3C, 0x1E, 0x00, 0x3F, 0xF8, 0x1C,
  0x00, 0x1F, 0xF0, 0x38, 0x00, 0x0F, 0xE0, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x01,
  0xF0, 0x00, 0x0E, 0x07, 0xF8, 0x00, 0x1C, 0x1F, 0xFC, 0x00, 0x3C, 0x3E,
  0x1E, 0x00, 0x78, 0x38, 0x0E, 0x00, 0x70, 0x78, 0x07, 0x00, 0xE0, 0x70,
  0x07, 0x01, 0xE0, 0xF0, 0x07, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0xE0,
  0x07, 0x07, 0x80, 0xE0, 0x07, 0x0F, 0x00, 0xE0, 0x07, 0x0E, 0x01, 0xE0,
  0x07, 0x1E, 0x01, 0xE0, 0x0E, 0x1C, 0x01, 0xE0, 0x0E, 0x08, 0x00, 0xE0,
  0x1E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x01, 0xE0,
  0x07, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00,
  0x3C, 0x3E, 0x00, 0x00, 0x0E, 0x3E, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x01, 0xF8, 0xF0, 0x00, 0x01, 0xF8, 0x3C, 0x00, 0x70, 0xF0, 0x1E, 0x00,
  0x78, 0xF0, 0x07, 0x80, 0x3C, 0xF8, 0x03, 0xE0, 0x1E, 0x78, 0x00, 0xF0,
  0x1E, 0x78, 0x00, 0x3C, 0x0F, 0x3C, 0x00, 0x1F, 0x07, 0xBC, 0x00, 0x07,
  0x87, 0x9E, 0x00, 0x03, 0xE3, 0xCF, 0x00, 0x00, 0xF3, 0xC7, 0x80, 0x00,
  0x3F, 0xC3, 0xC0, 0x00, 0x1F, 0xE1, 0xE0, 0x00, 0x07, 0xE0, 0xF0, 0x00,
  0x03, 0xE0, 0x3C, 0x00, 0x03, 0xF8, 0x1E, 0x00, 0x03, 0xFC, 0x07, 0x80,
  0x07, 0xFF, 0x03, 0xF0, 0x0F, 0xE7, 0x80, 0xFF, 0xFF, 0xC1, 0xE0, 0x1F,
  0xFF, 0xC0, 0xF8, 0x07, 0xFF, 0x80, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0xE3, 0x8E, 0x39, 0xE7, 0x9C, 0x71, 0xC7, 0x3C, 0xE3, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x01, 0x00, 0x1C, 0x00, 0xDE, 0x00, 0xE0,
  0x1E, 0xFE, 0x07, 0x07, 0xFF, 0xFC, 0x71, 0xFF, 0x8F, 0xFF, 0xBF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF8, 0x0F, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x38,
  0x00, 0x3C, 0x00, 0x80, 0x00, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3C, 0x0F, 0x07, 0x81,
  0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0x00, 0x80, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0xFF, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0xF8, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x1C, 0x0F, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x1F,
  0x9E, 0x00, 0x00, 0x7F, 0x3C, 0x00, 0x01, 0xFE, 0x78, 0x00, 0x07, 0xBC,
  0xF0, 0x00, 0x3E, 0x79, 0xC0, 0x00, 0xF8, 0xF7, 0x80, 0x03, 0xE1, 0xEF,
  0x00, 0x0F, 0x07, 0x9E, 0x00, 0x7C, 0x0F, 0x3C, 0x01, 0xF0, 0x1E, 0x78,
  0x07, 0xC0, 0x3C, 0xE0, 0x1E, 0x00, 0x7B, 0xC0, 0xF8, 0x00, 0xF7, 0x83,
  0xE0, 0x03, 0xCF, 0x0F, 0x80, 0x07, 0x9E, 0x3C, 0x00, 0x0F, 0x3D, 0xF0,
  0x00, 0x1E, 0x7F, 0xC0, 0x00, 0x3C, 0xFF, 0x00, 0x00, 0x71, 0xF8, 0x00,
  0x01, 0xE3, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x7C,
  0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0xFC, 0x00, 0xFF, 0x01, 0xFF, 0xC1,
  0xFF, 0xE3, 0xFE, 0x39, 0xFE, 0x1E, 0xFC, 0x07, 0xBC, 0x01, 0xE8, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x47, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1E, 0x03, 0xE0,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x0F, 0x80, 0x1F, 0x80, 0x7F, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x01, 0xF1, 0xC0, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x78, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x03, 0xC0, 0x0F, 0x00,
  0x01, 0xE0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x07, 0x80, 0x01,
  0xE0, 0x03, 0xC0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x01, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x10, 0x00, 0x00, 0x78, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x3F, 0xE0, 0x07, 0x87, 0xFF, 0xC0,
  0x38, 0xFF, 0xFF, 0x03, 0xCF, 0xC1, 0xFC, 0x1E, 0xF0, 0x03, 0xF0, 0xEE,
  0x00, 0x07, 0x87, 0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0xF3, 0xE0, 0x00,
  0x07, 0x9F, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07,
  0xB8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1D, 0xE0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x0F,
  0x80, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x1F, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x01, 0xF0, 0x78, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0xF8, 0x07, 0xC0,
  0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x03,
  0xF8, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF0, 0x1E, 0x00,
  0x07, 0xC1, 0xE0, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x07, 0x78, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x03, 0xEF,
  0x00, 0x00, 0x3E, 0x3C, 0x00, 0x03, 0xF1, 0xE0, 0x00, 0x3F, 0x8F, 0x80,
  0x03, 0xFC, 0x3E, 0x00, 0x7D, 0xE0, 0xFC, 0x0F, 0xCE, 0x03, 0xFF, 0xFC,
  0xF0, 0x0F, 0xFF, 0x87, 0x80, 0x1F, 0xF0, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x7E, 0x07, 0xF0, 0x7E,
  0x07, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x7C, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0x80, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x30, 0x1F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x0E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xC0,
  0x3F, 0xC1, 0xF8, 0x1F, 0x80, 0x1F, 0x0F, 0xC0, 0x03, 0xE3, 0xC0, 0x00,
  0x79, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0xF0, 0x07, 0xE0, 0x1C, 0x07, 0x00, 0xFF, 0xC0, 0x60, 0x78, 0x0F,
  0xFF, 0x03, 0x03, 0x80, 0xF0, 0x38, 0x1C, 0x38, 0x0F, 0x01, 0xC0, 0xE1,
  0xC0, 0xF0, 0x0C, 0x07, 0x1C, 0x07, 0x00, 0x60, 0x38, 0xE0, 0x70, 0x07,
  0x01, 0xCE, 0x03, 0x80, 0x38, 0x0E, 0x70, 0x38, 0x01, 0x80, 0x63, 0x81,
  0xC0, 0x0C, 0x03, 0x38, 0x0E, 0x00, 0xE0, 0x19, 0xC0, 0xE0, 0x07, 0x01,
  0xCE, 0x07, 0x00, 0x30, 0x0E, 0x70, 0x38, 0x03, 0x80, 0x77, 0x03, 0x80,
  0x1C, 0x03, 0x38, 0x1C, 0x00, 0xE0, 0x19, 0xC0, 0xE0, 0x06, 0x01, 0xCE,
  0x07, 0x00, 0x70, 0x0E, 0x70, 0x38, 0x03, 0x80, 0x63, 0x81, 0xC0, 0x3C,
  0x07, 0x1C, 0x0E, 0x03, 0xE0, 0x30, 0xE0, 0x70, 0x1F, 0x03, 0x87, 0x03,
  0x81, 0xB8, 0x18, 0x38, 0x1E, 0x3D, 0xC1, 0xC1, 0xC0, 0x7F, 0xCF, 0xFC,
  0x0E, 0x03, 0xFC, 0x3F, 0xC0, 0x70, 0x0F, 0x80, 0xFC, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x04,
  0x00, 0x00, 0xFC, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0E,
  0x78, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07,
  0x87, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0xF0, 0x0E, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00,
  0x3C, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x07, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x78, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x78, 0x00, 0x01,
  0xC0, 0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x03, 0x8F, 0x00, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0xFE, 0x00,
  0x78, 0x00, 0x0F, 0xC0, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x3E,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x01, 0xE0, 0x38, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3E, 0x07, 0x80,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x03, 0xE0, 0x1E,
  0x00, 0x01, 0xF0, 0x07, 0x00, 0x01, 0xF8, 0x03, 0xC0, 0x03, 0xF8, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x03, 0x80, 0x01, 0xFC, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x01,
  0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x81, 0xE0, 0x00,
  0x01, 0xE0, 0x70, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x7C,
  0x07, 0x80, 0x00, 0x3E, 0x01, 0xC0, 0x00, 0x3F, 0x00, 0xF0, 0x01, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x02, 0x3C, 0x00,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x07, 0x81, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xE0, 0x78,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x01, 0xE0, 0x03,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x1F, 0xC0, 0x01,
  0xC0, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x78,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0x7C, 0x1E, 0x00,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF8, 0x0F,
  0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x38, 0x00, 0x01, 0xF0,
  0x0F, 0x00, 0x00, 0xFC, 0x01, 0xE0, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0x1F,
  0x80, 0x07, 0x80, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xF0, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x0F, 0x83, 0xC0, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x00, 0xF1, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x1C, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x3F, 0xFF,
  0x3C, 0x00, 0x1F, 0xFF, 0x9E, 0x00, 0x1F, 0xFF, 0xCF, 0x00, 0x0F, 0xFF,
  0xE7, 0x80, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x01, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x7C, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x38, 0x00,
  0x00, 0x1C, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x07, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x1E,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x1E, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00,
  0x38, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x00, 0x38,
  0x07, 0x80, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0x3C, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0x3C, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x1C, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x0F,
  0x00, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x01, 0xF0, 0x1E, 0x00,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x03, 0xE0, 0x07,
  0x80, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x01, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x00, 0xE0,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00,
  0x00, 0x78, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x00, 0x07, 0x87,
  0xC0, 0x00, 0x00, 0x1C, 0x3E, 0x00, 0x00, 0x00, 0xF1, 0xF8, 0x00, 0x00,
  0x03, 0xCF, 0xF0, 0x00, 0x00, 0x0F, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE7,
  0x80, 0x00, 0x00, 0xFF, 0x1E, 0x00, 0x00, 0x03, 0xF8, 0x3C, 0x00, 0x00,
  0x1F, 0xC0, 0xF8, 0x00, 0x00, 0x7E, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x70, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3B, 0x80, 0x01, 0xEE,
  0x01, 0xDC, 0x00, 0x0F, 0xF0, 0x0E, 0xF0, 0x00, 0xF7, 0x80, 0xF7, 0x80,
  0x07, 0xBC, 0x07, 0x9C, 0x00, 0x79, 0xC0, 0x3C, 0xE0, 0x03, 0x8E, 0x01,
  0xC7, 0x00, 0x3C, 0xF0, 0x0E, 0x38, 0x03, 0xC7, 0x80, 0x71, 0xE0, 0x1E,
  0x3C, 0x07, 0x8F, 0x01, 0xE1, 0xE0, 0x3C, 0x38, 0x0F, 0x0E, 0x01, 0xE1,
  0xC0, 0xF0, 0xF0, 0x0F, 0x0E, 0x07, 0x87, 0x80, 0x70, 0x70, 0x78, 0x3C,
  0x07, 0x83, 0xC3, 0xC1, 0xE0, 0x3C, 0x1E, 0x3C, 0x0E, 0x01, 0xE0, 0x71,
  0xC0, 0x70, 0x0F, 0x03, 0x9E, 0x07, 0x80, 0x78, 0x1D, 0xE0, 0x3C, 0x03,
  0x80, 0xEF, 0x01, 0xE0, 0x3C, 0x07, 0xF0, 0x0F, 0x01, 0xE0, 0x3F, 0x80,
  0x70, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x01, 0xE0, 0x1C, 0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x0E, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x1C, 0x03, 0xF0, 0x00, 0x01, 0xE0,
  0x1F, 0x80, 0x00, 0x0F, 0x00, 0xFE, 0x00, 0x00, 0x78, 0x07, 0xF0, 0x00,
  0x03, 0xC0, 0x3F, 0x80, 0x00, 0x1E, 0x01, 0xDE, 0x00, 0x00, 0xE0, 0x1E,
  0xF0, 0x00, 0x0F, 0x00, 0xF7, 0x80, 0x00, 0x78, 0x07, 0x9E, 0x00, 0x03,
  0xC0, 0x3C, 0xF0, 0x00, 0x1E, 0x01, 0xE3, 0x80, 0x00, 0xF0, 0x0E, 0x1E,
  0x00, 0x0F, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x07, 0x83, 0x80, 0x03, 0xC0,
  0x3C, 0x1E, 0x00, 0x1E, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x0F, 0x03, 0x80,
  0x07, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07,
  0x80, 0x70, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x3C, 0x00,
  0x70, 0x1E, 0x01, 0xE0, 0x03, 0xC0, 0xF0, 0x0F, 0x00, 0x1E, 0x07, 0x80,
  0x78, 0x00, 0x70, 0x3C, 0x03, 0x80, 0x03, 0xC1, 0xC0, 0x3C, 0x00, 0x1E,
  0x1E, 0x01, 0xE0, 0x00, 0x70, 0xF0, 0x0F, 0x00, 0x03, 0xC7, 0x80, 0x78,
  0x00, 0x1E, 0x3C, 0x03, 0xC0, 0x00, 0x79, 0xE0, 0x1C, 0x00, 0x03, 0xDE,
  0x01, 0xE0, 0x00, 0x1E, 0xF0, 0x0F, 0x00, 0x00, 0x7F, 0x80, 0x78, 0x00,
  0x03, 0xFC, 0x03, 0xC0, 0x00, 0x0F, 0xE0, 0x1E, 0x00, 0x00, 0x7F, 0x00,
  0xE0, 0x00, 0x03, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x00,
  0x7C, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x07, 0xF8, 0x7F, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0,
  0x07, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0E,
  0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00,
  0x1E, 0x38, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0xE7, 0x80, 0x00,
  0x00, 0x73, 0xC0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x1E, 0x70, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x03, 0x9E, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0,
  0x00, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x3E, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x1E, 0x00, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00,
  0xF8, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x07, 0x00,
  0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0x87, 0xF0, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x0F, 0x80, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x00, 0x3C, 0x78, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x01, 0xCF, 0x00,
  0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x01, 0xE1, 0xC0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x1E, 0x00,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C,
  0x0E, 0x00, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x1E, 0x01, 0xC0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0x3C, 0x00,
  0x07, 0xE0, 0x0F, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xE0,
  0x7F, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x03, 0x81, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0F, 0x83, 0xC0,
  0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xFE, 0x01, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x00, 0xF0, 0x38, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x03, 0x81, 0xE0,
  0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0xE0, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x70, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x0F, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x0F, 0xE0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0xF8, 0xF0,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x38, 0x00, 0x07, 0x80,
  0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xE0,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x01, 0xE0, 0x0F,
  0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0x38,
  0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xF7, 0x80, 0x0F, 0x00, 0x0E, 0x78, 0x00, 0xF0,
  0x00, 0xE7, 0x80, 0x0F, 0x00, 0x1E, 0x78, 0x01, 0xF0, 0x01, 0xE7, 0x80,
  0x1F, 0x00, 0x1C, 0x78, 0x01, 0xF0, 0x03, 0xC7, 0x00, 0x3F, 0x00, 0x3C,
  0x70, 0x03, 0xF0, 0x03, 0x87, 0x00, 0x3F, 0x00, 0x38, 0x70, 0x07, 0xF0,
  0x07, 0x87, 0x00, 0x77, 0x00, 0x78, 0x70, 0x07, 0x70, 0x07, 0x07, 0x00,
  0xF7, 0x00, 0xF0, 0x70, 0x0E, 0x70, 0x0F, 0x07, 0x00, 0xE7, 0x80, 0xE0,
  0x70, 0x1E, 0x78, 0x0E, 0x07, 0x01, 0xC7, 0x81, 0xE0, 0x70, 0x1C, 0x78,
  0x1C, 0x07, 0x03, 0xC7, 0x81, 0xC0, 0x70, 0x38, 0x78, 0x3C, 0x07, 0x03,
  0x87, 0x83, 0xC0, 0x70, 0x78, 0x38, 0x38, 0x07, 0x07, 0x03, 0x83, 0x80,
  0x70, 0x70, 0x38, 0x78, 0x07, 0x0F, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x38,
  0x70, 0x07, 0x1E, 0x03, 0x8F, 0x00, 0x71, 0xE0, 0x38, 0xF0, 0x07, 0x1C,
  0x03, 0x8E, 0x00, 0xF3, 0xC0, 0x39, 0xE0, 0x0F, 0x3C, 0x03, 0x9E, 0x00,
  0xF3, 0x80, 0x39, 0xC0, 0x0F, 0x78, 0x03, 0x9C, 0x00, 0xF7, 0x80, 0x3B,
  0xC0, 0x0F, 0x70, 0x03, 0xBC, 0x00, 0xFF, 0x00, 0x3B, 0x80, 0x0F, 0xF0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0xF8, 0x00, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x00, 0x1F,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x00, 0x1E,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x07, 0xDE, 0x00,
  0x00, 0x03, 0xE7, 0x80, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x00, 0x7C, 0x3C,
  0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x7C, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C,
  0x07, 0xC0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x03, 0x8F, 0x00, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x38, 0xF0, 0x00, 0x78, 0x70, 0x00, 0xF0,
  0x70, 0x00, 0xF0, 0x70, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x03, 0xC0,
  0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x3C, 0x0F, 0x00,
  0x1C, 0x1E, 0x00, 0x1C, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x38, 0x00,
  0x1E, 0x78, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x3C, 0x0F, 0x07, 0x81, 0xE0,
  0x70, 0x3C, 0x0E, 0x03, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xF8, 0x3F, 0x80, 0x1F, 0x80, 0x0F,
  0x80, 0x7E, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xE0, 0x7F, 0x00, 0x03, 0xC1, 0xF8,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x3E, 0x00,
  0x00, 0x38, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x03, 0xC3, 0x80, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x3F, 0x0F, 0x00, 0x00,
  0xFC, 0x1E, 0x00, 0x03, 0xF8, 0x3E, 0x00, 0x1F, 0x70, 0x3F, 0x00, 0xFD,
  0xE0, 0x3F, 0xFF, 0xF3, 0xC0, 0x3F, 0xFF, 0x87, 0x80, 0x1F, 0xFC, 0x0F,
  0x80, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x3F, 0xC0, 0x01, 0xE1, 0xFF, 0xE0, 0x03, 0x8F, 0xFF, 0xE0, 0x07,
  0x3F, 0x9F, 0xE0, 0x1E, 0xF0, 0x07, 0xE0, 0x3F, 0xC0, 0x07, 0xC0, 0x7E,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x01, 0xE1,
  0xF0, 0x00, 0x07, 0x83, 0xF0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x7C, 0x0F,
  0xE0, 0x01, 0xF0, 0x1D, 0xF0, 0x0F, 0xC0, 0x79, 0xFF, 0xFF, 0x00, 0xF1,
  0xFF, 0xFC, 0x01, 0xE0, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xC3, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x3C, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x1C,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x78, 0x38, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x0F,
  0x80, 0x3F, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0x81, 0xE0, 0x00, 0x7F,
  0xF8, 0x78, 0x00, 0x7F, 0xFF, 0x1E, 0x00, 0x3F, 0xCF, 0xE7, 0x80, 0x1F,
  0x80, 0x3D, 0xE0, 0x0F, 0x80, 0x07, 0xF8, 0x07, 0xC0, 0x00, 0xFC, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xC0, 0x78, 0x00,
  0x00, 0xF0, 0x1C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x38, 0x0F,
  0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x07, 0x80, 0x0F, 0xF0, 0x01, 0xF8, 0x0F,
  0xFC, 0x00, 0x3F, 0xFF, 0xCF, 0x00, 0x07, 0xFF, 0xE3, 0xC0, 0x00, 0x7F,
  0xE0, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x1F,
  0x80, 0x1F, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x1C, 0x0F, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0x71, 0xE0, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x03, 0x9E, 0x00, 0x00, 0x07, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x18, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x60,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC1, 0xC0, 0x07,
  0xFF, 0xF1, 0xE0, 0x07, 0xF8, 0xFC, 0xF0, 0x07, 0xE0, 0x0F, 0x78, 0x07,
  0xC0, 0x03, 0xFC, 0x07, 0xC0, 0x00, 0xFC, 0x03, 0xC0, 0x00, 0x3E, 0x03,
  0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0xF0,
  0x38, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x78, 0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x0F, 0xC0, 0x0F, 0x00,
  0x1F, 0xE0, 0x07, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0xFE, 0x78, 0x00, 0x7F,
  0xFE, 0x3C, 0x00, 0x0F, 0xFC, 0x1C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x08, 0x00, 0x03, 0xE0, 0x0E,
  0x00, 0x01, 0xE0, 0x0F, 0x80, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xF0, 0x00,
  0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x1F, 0xE0, 0x01, 0xC0, 0xFF, 0xF0, 0x03, 0x87, 0xFF, 0xF0, 0x0F,
  0x1F, 0xCF, 0xF0, 0x1E, 0x78, 0x03, 0xF0, 0x3D, 0xC0, 0x03, 0xE0, 0x77,
  0x00, 0x03, 0xC0, 0xFC, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x07, 0x87, 0xC0,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x03, 0x87, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x3C, 0x38, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E,
  0x1C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xE1,
  0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x0E,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x70, 0xF0,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x7F, 0xFF, 0x80,
  0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x08, 0x07, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x04, 0x0F, 0x00, 0x00, 0x7E, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0x00, 0x0F,
  0xC0, 0x03, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x78, 0x01,
  0xF0, 0x00, 0x1E, 0x01, 0xF8, 0x00, 0x07, 0x80, 0xFC, 0x00, 0x01, 0xE0,
  0x7C, 0x00, 0x00, 0x70, 0x3E, 0x00, 0x00, 0x3C, 0x3F, 0x00, 0x00, 0x0F,
  0x1F, 0x80, 0x00, 0x03, 0xCF, 0xC0, 0x00, 0x00, 0xF7, 0xF0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xF7, 0x80, 0x00, 0x07, 0xF9, 0xF0, 0x00,
  0x01, 0xFC, 0x3E, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x3E, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0xF0, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x1E,
  0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x78, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0x9F, 0xF8,
  0x3F, 0xE0, 0x0F, 0x7F, 0xF9, 0xFF, 0xE0, 0x1D, 0xF7, 0xF7, 0xE7, 0xE0,
  0x3F, 0x01, 0xFE, 0x03, 0xC0, 0x7C, 0x01, 0xF8, 0x07, 0x80, 0xF0, 0x03,
  0xE0, 0x07, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x07, 0x80, 0x0F, 0x00, 0x1C,
  0x0F, 0x00, 0x1E, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x38, 0x00,
  0xF0, 0x01, 0xE0, 0x70, 0x01, 0xE0, 0x03, 0xC1, 0xE0, 0x03, 0xC0, 0x07,
  0x83, 0xC0, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0xF0, 0x01, 0xE0, 0x03, 0xC1, 0xE0, 0x03, 0xC0, 0x07, 0x03, 0xC0,
  0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x3C, 0x00,
  0x78, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0xF0,
  0x01, 0xE0, 0x03, 0x81, 0xE0, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x00,
  0x1E, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0xE0, 0x01, 0xC0,
  0x03, 0x81, 0xC0, 0x03, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x07, 0x03, 0xFF, 0xC0, 0x1E, 0x1F, 0xFF, 0xC0,
  0x3C, 0x7F, 0x3F, 0xC0, 0x79, 0xE0, 0x0F, 0xC0, 0xF7, 0x00, 0x0F, 0x81,
  0xDC, 0x00, 0x0F, 0x03, 0xF0, 0x00, 0x0F, 0x0F, 0xC0, 0x00, 0x1E, 0x1F,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x01, 0xE1, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x0E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x07, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x78, 0x70, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0x8F, 0xF0,
  0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0E,
  0x78, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x1E,
  0x70, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x07, 0xC0,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x08, 0x1F, 0xC0, 0x00, 0x1C, 0x3F, 0xFE, 0x00, 0x07, 0x1F, 0xFF,
  0xC0, 0x03, 0xCF, 0xC7, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0x00, 0x3F, 0x80,
  0x07, 0xC0, 0x0F, 0xC0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x7C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF0,
  0x1C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x1E, 0x03, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xC0,
  0x00, 0x07, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x3F, 0x80, 0x07, 0xC0, 0x1E, 0xF8, 0x07, 0xE0, 0x07, 0x9F, 0xFF, 0xF0,
  0x01, 0xE3, 0xFF, 0xF8, 0x00, 0x78, 0x3F, 0xF8, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x1C, 0x01, 0xFF, 0xFC, 0x78, 0x07, 0xF8, 0x7C,
  0xF0, 0x1F, 0x80, 0x3D, 0xE0, 0x7C, 0x00, 0x3F, 0xC1, 0xF0, 0x00, 0x3F,
  0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0x87,
  0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x3C, 0x78, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xE0, 0xE0, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x3E, 0x07, 0x80, 0x00, 0xF8, 0x0F, 0x00, 0x03, 0xF0, 0x0F, 0x00, 0x0F,
  0xE0, 0x1F, 0x80, 0x7F, 0xC0, 0x1F, 0xFF, 0xF7, 0x80, 0x1F, 0xFF, 0x8F,
  0x00, 0x0F, 0xFC, 0x1C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x1E, 0x07, 0xFF, 0xC0, 0xF0, 0xFF, 0xFC, 0x07, 0x0F,
  0xFF, 0xE0, 0x79, 0xFC, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xF8,
  0x7F, 0x80, 0x1F, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x03, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1F, 0x07, 0x80, 0x00,
  0x3E, 0x07, 0x80, 0x00, 0xFC, 0x0F, 0x00, 0x03, 0xF8, 0x1F, 0x00, 0x1E,
  0xE0, 0x1F, 0x00, 0xF9, 0xC0, 0x1F, 0xFF, 0xE7, 0x80, 0x1F, 0xFF, 0x8F,
  0x00, 0x1F, 0xFC, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03,
  0xC0, 0x1C, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x07,
  0x80, 0x1E, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x03, 0x81, 0xE0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xFC, 0x00, 0x3C,
  0x00, 0x3B, 0x80, 0x07, 0x80, 0x07, 0x70, 0x01, 0xF0, 0x01, 0xEE, 0x00,
  0x3E, 0x00, 0x39, 0xC0, 0x07, 0xC0, 0x0F, 0x38, 0x01, 0xF8, 0x01, 0xE7,
  0x00, 0x3F, 0x00, 0x38, 0xE0, 0x0E, 0xE0, 0x0F, 0x1E, 0x01, 0xDC, 0x01,
  0xC3, 0xC0, 0x7B, 0xC0, 0x38, 0x78, 0x0E, 0x38, 0x0F, 0x0F, 0x01, 0xC7,
  0x01, 0xC1, 0xE0, 0x70, 0xE0, 0x78, 0x3C, 0x0E, 0x1C, 0x0E, 0x07, 0x83,
  0xC3, 0x81, 0xC0, 0xF0, 0x70, 0x70, 0x78, 0x1E, 0x0E, 0x0E, 0x0E, 0x01,
  0xC3, 0x81, 0xC1, 0xC0, 0x38, 0x70, 0x38, 0x78, 0x07, 0x1E, 0x07, 0x0E,
  0x00, 0xE3, 0x80, 0xE1, 0xC0, 0x1C, 0xF0, 0x1C, 0x70, 0x03, 0x9C, 0x01,
  0x8E, 0x00, 0x73, 0x80, 0x33, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x01, 0xDC,
  0x00, 0xEE, 0x00, 0x3B, 0x80, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x0F,
  0x80, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x00,
  0x3C, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7D, 0xE0, 0x00, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x00, 0x7C, 0x3C,
  0x00, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x3E,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07,
  0x80, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0x83, 0xFF, 0xE0, 0x00,
  0x1E, 0x3F, 0xFF, 0x80, 0x00, 0xE1, 0xE0, 0x3E, 0x00, 0x07, 0x1E, 0x00,
  0xF8, 0x00, 0x79, 0xE0, 0x03, 0xE0, 0x07, 0x8F, 0x00, 0x0F, 0xC0, 0x7C,
  0x70, 0x00, 0x3F, 0xCF, 0xC7, 0x80, 0x00, 0x7F, 0xFC, 0x38, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
};

const GFXglyph RobotoMono_LightItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 39, 0, -1 },
  { 1, 13, 48, 39, 13, -48 },
  { 79, 16, 14, 39, 15, -50 },
  { 107, 39, 48, 39, 1, -48 },
  { 341, 33, 62, 39, 4, -55 },
  { 597, 32, 49, 39, 4, -48 },
  { 793, 33, 49, 39, 3, -48 },
  { 996, 6, 14, 39, 19, -50 },
  { 1007, 21, 68, 39, 11, -53 },
  { 1186, 21, 68, 39, 6, -53 },
  { 1365, 29, 29, 39, 8, -48 },
  { 1471, 32, 34, 39, 4, -39 },
  { 1607, 10, 16, 39, 7, -6 },
  { 1627, 24, 3, 39, 7, -23 },
  { 1636, 7, 6, 39, 14, -6 },
  { 1642, 32, 52, 39, 5, -48 },
  { 1850, 31, 49, 39, 5, -48 },
  { 2040, 18, 48, 39, 10, -48 },
  { 2148, 33, 48, 39, 1, -48 },
  { 2346, 32, 49, 39, 2, -48 },
  { 2542, 34, 48, 39, 1, -48 },
  { 2746, 34, 49, 39, 5, -48 },
  { 2955, 29, 49, 39, 4, -48 },
  { 3133, 32, 48, 39, 7, -48 },
  { 3325, 33, 49, 39, 4, -48 },
  { 3528, 29, 48, 39, 6, -48 },
  { 3702, 12, 35, 39, 16, -35 },
  { 3755, 15, 45, 39, 12, -35 },
  { 3840, 30, 28, 39, 5, -36 },
  { 3945, 32, 17, 39, 4, -30 },
  { 4013, 30, 28, 39, 4, -35 },
  { 4118, 26, 48, 39, 10, -48 },
  { 4274, 37, 48, 39, 2, -48 },
  { 4496, 33, 48, 39, 0, -48 },
  { 4694, 34, 48, 39, 3, -48 },
  { 4898, 33, 49, 39, 4, -48 },
  { 5101, 35, 48, 39, 2, -48 },
  { 5311, 35, 48, 39, 3, -48 },
  { 5521, 36, 48, 39, 3, -48 },
  { 5737, 33, 49, 39, 4, -48 },
  { 5940, 37, 48, 39, 2, -48 },
  { 6162, 35, 48, 39, 3, -48 },
  { 6372, 35, 49, 39, 2, -48 },
  { 6587, 38, 48, 39, 3, -48 },
  { 6815, 28, 48, 39, 4, -48 },
  { 6983, 37, 48, 39, 2, -48 },
  { 7205, 37, 48, 39, 2, -48 },
  { 7427, 33, 49, 39, 4, -48 },
  { 7630, 36, 48, 39, 3, -48 },
  { 7846, 34, 56, 39, 3, -48 },
  { 8084, 34, 48, 39, 3, -48 },
  { 8288, 35, 49, 39, 3, -48 },
  { 8503, 34, 48, 39, 7, -48 },
  { 8707, 35, 49, 39, 4, -48 },
  { 8922, 33, 48, 39, 7, -48 },
  { 9120, 36, 48, 39, 6, -48 },
  { 9336, 41, 48, 39, 0, -48 },
  { 9582, 34, 48, 39, 7, -48 },
  { 9786, 36, 48, 39, 1, -48 },
  { 10002, 21, 64, 39, 10, -54 },
  { 10170, 14, 52, 39, 13, -48 },
  { 10261, 21, 64, 39, 9, -54 },
  { 10429, 24, 26, 39, 8, -48 },
  { 10507, 28, 3, 39, 2, 0 },
  { 10518, 9, 9, 39, 19, -49 },
  { 10529, 31, 37, 39, 3, -36 },
  { 10673, 31, 51, 39, 3, -50 },
  { 10871, 30, 37, 39, 4, -36 },
  { 11010, 34, 51, 39, 4, -50 },
  { 11227, 31, 37, 39, 4, -36 },
  { 11371, 33, 51, 39, 8, -51 },
  { 11582, 33, 50, 39, 2, -36 },
  { 11789, 31, 50, 39, 3, -50 },
  { 11983, 28, 48, 39, 4, -48 },
  { 12151, 30, 62, 39, 1, -48 },
  { 12384, 34, 50, 39, 3, -50 },
  { 12597, 28, 50, 39, 4, -50 },
  { 12772, 39, 36, 39, -1, -36 },
  { 12948, 31, 36, 39, 3, -36 },
  { 13088, 32, 37, 39, 3, -36 },
  { 13236, 34, 50, 39, 0, -36 },
  { 13449, 31, 50, 39, 4, -36 },
  { 13643, 29, 36, 39, 8, -36 },
  { 13774, 31, 37, 39, 4, -36 },
  { 13918, 26, 45, 39, 8, -44 },
  { 14065, 31, 36, 39, 5, -35 },
  { 14205, 32, 35, 39, 6, -35 },
  { 14345, 35, 35, 39, 5, -35 },
  { 14499, 37, 35, 39, 1, -35 },
  { 14661, 40, 49, 39, -1, -35 },
  { 14906, 34, 35, 39, 2, -35 },
  { 15055, 26, 65, 39, 10, -52 },
  { 15267, 13, 59, 39, 13, -48 },
  { 15363, 26, 65, 39, 6, -52 },
  { 15575, 37, 12, 39, 1, -26 },
};

const GFXfont RobotoMono_LightItalic67pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic67pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic67pt7bGlyphs,
  0x20, 0x7E, 88
};

#endif // _ROBOTOMONO_LIGHTITALIC67PT7B_H_
