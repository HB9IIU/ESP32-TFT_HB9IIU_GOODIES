#ifndef _ROBOTOMONO_LIGHTITALIC17PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x22, 0x22, 0x44, 0x00, 0x0C, 0x99, 0xAA, 0x04, 0xC1, 0x20,
  0x88, 0xFF, 0x09, 0x04, 0x41, 0x20, 0x48, 0xFF, 0x89, 0x04, 0x41, 0x20,
  0x04, 0x04, 0x1E, 0x21, 0x21, 0x40, 0x20, 0x18, 0x04, 0x02, 0x02, 0x82,
  0x42, 0x7C, 0x10, 0x10, 0x70, 0x91, 0x92, 0x94, 0xE4, 0x08, 0x10, 0x17,
  0x29, 0x49, 0x49, 0x0E, 0x1C, 0x22, 0x22, 0x24, 0x28, 0x30, 0x70, 0x89,
  0x8D, 0x86, 0x86, 0x7B, 0xF0, 0x08, 0x44, 0x44, 0x21, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x41, 0x00, 0x10, 0x40, 0x82, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x82, 0x08, 0x41, 0x08, 0x42, 0x00, 0x08, 0x12, 0x4B, 0xE1, 0x05,
  0x11, 0x00, 0x08, 0x08, 0x08, 0x08, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x56,
  0xFC, 0xC0, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20,
  0x20, 0x40, 0x80, 0x1E, 0x21, 0x41, 0x41, 0x47, 0x49, 0x91, 0xA1, 0xC2,
  0x82, 0x44, 0x78, 0x3D, 0x91, 0x22, 0x22, 0x22, 0x44, 0x1F, 0x10, 0x88,
  0x48, 0x20, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x1F, 0xE0, 0x1F,
  0x10, 0x88, 0x20, 0x10, 0x10, 0xF0, 0x08, 0x02, 0x01, 0x40, 0x90, 0x87,
  0x80, 0x01, 0x01, 0x81, 0x41, 0x20, 0x90, 0x90, 0x88, 0x84, 0xFF, 0x81,
  0x00, 0x80, 0x80, 0x1F, 0x90, 0x08, 0x04, 0x03, 0xC3, 0x10, 0x08, 0x02,
  0x01, 0x41, 0x11, 0x87, 0x80, 0x0E, 0x20, 0x82, 0x05, 0xDC, 0x60, 0xC1,
  0x83, 0x05, 0x13, 0xC0, 0xFF, 0x02, 0x02, 0x04, 0x08, 0x08, 0x10, 0x10,
  0x20, 0x40, 0x40, 0x80, 0x1E, 0x21, 0x21, 0x41, 0x21, 0x3E, 0x66, 0x42,
  0x81, 0x82, 0x82, 0x7C, 0x3C, 0x86, 0x0C, 0x18, 0x30, 0x61, 0xBE, 0x04,
  0x10, 0x47, 0x00, 0x2C, 0x00, 0x04, 0xC0, 0x13, 0x00, 0x00, 0x04, 0x44,
  0x80, 0x01, 0x0E, 0x30, 0xC0, 0x30, 0x0C, 0x02, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x40, 0x30, 0x0C, 0x03, 0x0C, 0x70, 0x80, 0x7A, 0x18, 0x41, 0x08,
  0x42, 0x10, 0x40, 0x00, 0x30, 0x0F, 0x84, 0x22, 0x65, 0x25, 0x52, 0x54,
  0x99, 0x26, 0x4A, 0x96, 0x96, 0xC4, 0x00, 0xF8, 0x02, 0x06, 0x06, 0x0A,
  0x0A, 0x11, 0x11, 0x21, 0x3F, 0x41, 0x41, 0x81, 0x3E, 0x21, 0x41, 0x41,
  0x43, 0x7C, 0x42, 0x81, 0x81, 0x82, 0x86, 0xFC, 0x1E, 0x21, 0x41, 0x41,
  0x80, 0x80, 0x80, 0x80, 0x81, 0x82, 0x46, 0x78, 0x3C, 0x43, 0x41, 0x41,
  0x41, 0x41, 0x81, 0x81, 0x83, 0x82, 0x84, 0xF8, 0x3F, 0x90, 0x10, 0x08,
  0x04, 0x03, 0xF1, 0x00, 0x80, 0x80, 0x40, 0x20, 0x1F, 0xC0, 0x3F, 0x90,
  0x10, 0x08, 0x04, 0x03, 0xF1, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x00,
  0x1E, 0x21, 0x41, 0x40, 0x80, 0x80, 0x8F, 0x81, 0x81, 0x82, 0x42, 0x7C,
  0x20, 0x48, 0x12, 0x08, 0x82, 0x20, 0x8F, 0xE4, 0x09, 0x02, 0x41, 0x10,
  0x44, 0x12, 0x04, 0x3F, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20,
  0x10, 0x08, 0x04, 0x1F, 0xC0, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02,
  0x02, 0x02, 0x82, 0x84, 0x78, 0x20, 0x90, 0x90, 0x88, 0x84, 0x82, 0x81,
  0xA0, 0x90, 0x84, 0x42, 0x20, 0x90, 0x60, 0x20, 0x40, 0x82, 0x04, 0x08,
  0x10, 0x20, 0x81, 0x02, 0x07, 0xF0, 0x30, 0xCC, 0x33, 0x14, 0xC6, 0x2A,
  0x8A, 0xA4, 0xC9, 0x32, 0x41, 0x10, 0x44, 0x13, 0x04, 0x30, 0x4C, 0x13,
  0x08, 0xA2, 0x28, 0x8A, 0x24, 0x49, 0x12, 0x43, 0x10, 0xC4, 0x33, 0x04,
  0x1E, 0x21, 0x41, 0x41, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0x44, 0x78,
  0x3F, 0x10, 0x88, 0x28, 0x14, 0x12, 0x09, 0xF8, 0x80, 0x80, 0x40, 0x20,
  0x10, 0x00, 0x1E, 0x21, 0x41, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82,
  0xC4, 0x78, 0x04, 0x02, 0x3E, 0x21, 0x41, 0x41, 0x41, 0x42, 0x7C, 0x44,
  0x84, 0x84, 0x82, 0x82, 0x1E, 0x10, 0x90, 0x48, 0x16, 0x01, 0xC0, 0x18,
  0x04, 0x01, 0x40, 0xA0, 0x8F, 0x80, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0xA0, 0x50, 0x48, 0x24, 0x12,
  0x0A, 0x05, 0x02, 0x82, 0x41, 0x31, 0x0F, 0x00, 0x81, 0x83, 0x82, 0x82,
  0x44, 0x44, 0x48, 0x48, 0x50, 0x50, 0x60, 0x20, 0x89, 0xCC, 0xA6, 0x55,
  0x2A, 0xA5, 0x53, 0x29, 0x98, 0xCC, 0x46, 0x23, 0x11, 0x00, 0x20, 0x44,
  0x21, 0x10, 0x2C, 0x0A, 0x01, 0x00, 0xC0, 0x68, 0x12, 0x08, 0x84, 0x13,
  0x06, 0x81, 0x82, 0x46, 0x44, 0x48, 0x28, 0x30, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x3F, 0x80, 0x40, 0x40, 0x40, 0x40, 0x20, 0x20, 0x20, 0x30, 0x10,
  0x10, 0x1F, 0xE0, 0x1C, 0x41, 0x08, 0x20, 0x82, 0x08, 0x20, 0x84, 0x10,
  0x41, 0x04, 0x10, 0xE0, 0x84, 0x44, 0x44, 0x22, 0x22, 0x21, 0x10, 0x1C,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10, 0x42, 0x08, 0xE0,
  0x18, 0x62, 0x8A, 0x47, 0x10, 0xFF, 0x90, 0x3E, 0x42, 0x01, 0x02, 0x7E,
  0x82, 0x82, 0x86, 0x7A, 0x20, 0x20, 0x20, 0x40, 0x5E, 0x62, 0x41, 0x41,
  0x41, 0x82, 0x82, 0xC4, 0xB8, 0x3E, 0x62, 0x41, 0x80, 0x80, 0x80, 0x82,
  0x46, 0x7C, 0x00, 0x80, 0x80, 0x40, 0x23, 0xD3, 0x19, 0x05, 0x04, 0x82,
  0x41, 0x20, 0x98, 0xC7, 0xA0, 0x1E, 0x62, 0x41, 0x81, 0xFF, 0x80, 0x80,
  0x42, 0x7C, 0x0F, 0x18, 0x10, 0x10, 0xFE, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x40, 0x40, 0x40, 0x3D, 0x63, 0x41, 0x82, 0x82, 0x82, 0x82, 0xC6, 0x7A,
  0x04, 0x84, 0x98, 0x60, 0x20, 0x20, 0x40, 0x40, 0x5E, 0x62, 0x41, 0x41,
  0x82, 0x82, 0x82, 0x82, 0x82, 0x04, 0x00, 0x03, 0xE0, 0x81, 0x02, 0x04,
  0x08, 0x20, 0x47, 0xF0, 0x03, 0x00, 0x00, 0x1E, 0x02, 0x02, 0x02, 0x04,
  0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x18, 0xE0, 0x20, 0x20, 0x20, 0x20,
  0x43, 0x44, 0x48, 0x50, 0x70, 0xC8, 0x88, 0x84, 0x82, 0x3C, 0x08, 0x10,
  0x20, 0x81, 0x02, 0x04, 0x08, 0x10, 0x40, 0x8F, 0xE0, 0x7F, 0x91, 0x14,
  0x49, 0x12, 0x48, 0xA2, 0x28, 0x8A, 0x22, 0x89, 0x00, 0x5E, 0x62, 0x41,
  0x41, 0x82, 0x82, 0x82, 0x82, 0x82, 0x3E, 0x42, 0x41, 0x81, 0x81, 0x81,
  0x82, 0x86, 0x78, 0x2F, 0x18, 0x88, 0x24, 0x14, 0x0A, 0x09, 0x04, 0x84,
  0x7C, 0x20, 0x20, 0x10, 0x00, 0x3D, 0x63, 0x41, 0x82, 0x82, 0x82, 0x82,
  0xC6, 0x7A, 0x04, 0x04, 0x04, 0x6E, 0xE1, 0x02, 0x04, 0x08, 0x20, 0x40,
  0x80, 0x3E, 0x41, 0x41, 0x60, 0x1C, 0x02, 0x82, 0x82, 0x7C, 0x10, 0x23,
  0xF9, 0x02, 0x04, 0x08, 0x10, 0x40, 0x80, 0xF0, 0x41, 0x41, 0x41, 0x42,
  0x42, 0x82, 0x82, 0xC6, 0x7A, 0xC1, 0xA0, 0x90, 0x88, 0x42, 0x41, 0x20,
  0xA0, 0x60, 0x10, 0x00, 0x88, 0xC4, 0x66, 0x53, 0x2A, 0x95, 0x32, 0x98,
  0x88, 0x44, 0x00, 0x20, 0xC4, 0x41, 0x20, 0x30, 0x0C, 0x07, 0x01, 0x20,
  0x88, 0xC1, 0x00, 0x60, 0x48, 0x22, 0x10, 0x84, 0x12, 0x04, 0x81, 0x40,
  0x60, 0x08, 0x04, 0x01, 0x00, 0x80, 0xC0, 0x00, 0x3F, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x00, 0x0C, 0x41, 0x04, 0x20, 0x82,
  0x10, 0xC1, 0x04, 0x10, 0x41, 0x04, 0x0C, 0x24, 0x92, 0x4A, 0x49, 0x25,
  0x20, 0x18, 0x10, 0x20, 0x40, 0x81, 0x02, 0x02, 0x06, 0x10, 0x40, 0x81,
  0x02, 0x08, 0x60, 0x30, 0x52, 0x28, 0x58, 0x08,
};

const GFXglyph RobotoMono_LightItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 12, 10, 3, -12 },
  { 7, 4, 4, 10, 4, -13 },
  { 9, 10, 12, 10, 0, -12 },
  { 24, 8, 16, 10, 1, -14 },
  { 40, 8, 12, 10, 1, -12 },
  { 52, 8, 12, 10, 1, -12 },
  { 64, 1, 4, 10, 5, -13 },
  { 65, 5, 18, 10, 3, -14 },
  { 77, 6, 18, 10, 1, -14 },
  { 91, 7, 7, 10, 2, -12 },
  { 98, 8, 9, 10, 1, -10 },
  { 107, 2, 4, 10, 2, -2 },
  { 108, 6, 1, 10, 2, -6 },
  { 109, 1, 2, 10, 4, -2 },
  { 110, 8, 13, 10, 1, -12 },
  { 123, 8, 12, 10, 1, -12 },
  { 135, 4, 12, 10, 3, -12 },
  { 141, 9, 12, 10, 0, -12 },
  { 155, 9, 12, 10, 0, -12 },
  { 169, 9, 12, 10, 0, -12 },
  { 183, 9, 12, 10, 1, -12 },
  { 197, 7, 12, 10, 1, -12 },
  { 208, 8, 12, 10, 2, -12 },
  { 220, 8, 12, 10, 1, -12 },
  { 232, 7, 12, 10, 2, -12 },
  { 243, 3, 9, 10, 4, -9 },
  { 247, 4, 11, 10, 3, -9 },
  { 253, 8, 7, 10, 1, -9 },
  { 260, 8, 5, 10, 1, -8 },
  { 265, 8, 7, 10, 1, -9 },
  { 272, 6, 12, 10, 3, -12 },
  { 281, 10, 12, 10, 0, -12 },
  { 296, 8, 12, 10, 0, -12 },
  { 308, 8, 12, 10, 1, -12 },
  { 320, 8, 12, 10, 1, -12 },
  { 332, 8, 12, 10, 1, -12 },
  { 344, 9, 12, 10, 1, -12 },
  { 358, 9, 12, 10, 1, -12 },
  { 372, 8, 12, 10, 1, -12 },
  { 384, 10, 12, 10, 0, -12 },
  { 399, 9, 12, 10, 1, -12 },
  { 413, 8, 12, 10, 1, -12 },
  { 425, 9, 12, 10, 1, -12 },
  { 439, 7, 12, 10, 1, -12 },
  { 450, 10, 12, 10, 0, -12 },
  { 465, 10, 12, 10, 0, -12 },
  { 480, 8, 12, 10, 1, -12 },
  { 492, 9, 12, 10, 1, -12 },
  { 506, 8, 14, 10, 1, -12 },
  { 520, 8, 12, 10, 1, -12 },
  { 532, 9, 12, 10, 1, -12 },
  { 546, 8, 12, 10, 2, -12 },
  { 558, 9, 12, 10, 1, -12 },
  { 572, 8, 12, 10, 2, -12 },
  { 584, 9, 12, 10, 2, -12 },
  { 598, 10, 12, 10, 0, -12 },
  { 613, 8, 12, 10, 2, -12 },
  { 625, 9, 12, 10, 0, -12 },
  { 639, 6, 17, 10, 2, -14 },
  { 652, 4, 13, 10, 3, -12 },
  { 659, 6, 17, 10, 2, -14 },
  { 672, 6, 6, 10, 2, -12 },
  { 677, 8, 1, 10, 0, 0 },
  { 678, 2, 2, 10, 5, -12 },
  { 679, 8, 9, 10, 1, -9 },
  { 688, 8, 13, 10, 1, -13 },
  { 701, 8, 9, 10, 1, -9 },
  { 710, 9, 13, 10, 1, -13 },
  { 725, 8, 9, 10, 1, -9 },
  { 734, 8, 13, 10, 2, -13 },
  { 747, 8, 13, 10, 1, -9 },
  { 760, 8, 13, 10, 1, -13 },
  { 773, 7, 12, 10, 1, -12 },
  { 784, 8, 16, 10, 0, -12 },
  { 800, 8, 13, 10, 1, -13 },
  { 813, 7, 13, 10, 1, -13 },
  { 825, 10, 9, 10, 0, -9 },
  { 837, 8, 9, 10, 1, -9 },
  { 846, 8, 9, 10, 1, -9 },
  { 855, 9, 12, 10, 0, -9 },
  { 869, 8, 12, 10, 1, -9 },
  { 881, 7, 9, 10, 2, -9 },
  { 889, 8, 9, 10, 1, -9 },
  { 898, 7, 11, 10, 2, -11 },
  { 908, 8, 9, 10, 1, -9 },
  { 917, 9, 9, 10, 1, -9 },
  { 928, 9, 9, 10, 1, -9 },
  { 939, 10, 9, 10, 0, -9 },
  { 951, 10, 13, 10, 0, -9 },
  { 968, 9, 9, 10, 0, -9 },
  { 979, 6, 16, 10, 3, -13 },
  { 991, 3, 15, 10, 3, -12 },
  { 997, 7, 16, 10, 1, -13 },
  { 1011, 10, 4, 10, 0, -7 },
};

const GFXfont RobotoMono_LightItalic17pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic17pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic17pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _ROBOTOMONO_LIGHTITALIC17PT7B_H_
