#ifndef _ROBOTOMONO_LIGHTITALIC6PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0x70, 0x67, 0x6C, 0x2D, 0x1A, 0x80, 0xE9, 0xF0, 0x6B, 0xF0,
  0xC0, 0x6A, 0xA0, 0xFC, 0x70, 0x2B, 0xA0, 0xC0, 0xC0, 0x80, 0x25, 0x60,
  0x77, 0xF0, 0xDA, 0xE5, 0x70, 0xEC, 0xF0, 0x2F, 0x90, 0x6C, 0xF0, 0x6E,
  0xF0, 0xDA, 0x6E, 0xF0, 0xFE, 0x90, 0x98, 0x7C, 0x7C, 0x5C, 0xDA, 0x76,
  0xE0, 0x4F, 0xD0, 0x7E, 0xF0, 0x72, 0x70, 0xF6, 0xF0, 0x7E, 0x70, 0x7E,
  0x40, 0x72, 0xF0, 0xBE, 0xD0, 0x69, 0x70, 0x24, 0xF0, 0x74, 0xAA, 0x52,
  0x70, 0xB5, 0xEA, 0xBE, 0xD0, 0x76, 0xF0, 0x77, 0x40, 0x76, 0xF2, 0x77,
  0xD0, 0xE8, 0xF0, 0xF2, 0x40, 0xB6, 0xF0, 0xBA, 0x40, 0xB7, 0x60, 0x74,
  0x4A, 0xF2, 0x40, 0x69, 0x70, 0xEA, 0xA0, 0xF0, 0x56, 0xA0, 0xB0, 0xE0,
  0x00, 0xEF, 0x80, 0x4A, 0xDE, 0xF3, 0x80, 0x27, 0xDE, 0xFB, 0x80, 0x7A,
  0x48, 0xF6, 0xF0, 0x4A, 0xDA, 0x65, 0x70, 0x64, 0xAC, 0x4A, 0xAA, 0x64,
  0xAE, 0xFF, 0x80, 0xF6, 0x80, 0xF7, 0x80, 0xF7, 0xC0, 0xF7, 0x90, 0xE8,
  0xEF, 0x80, 0xEB, 0xB7, 0x80, 0xE8, 0xDA, 0xA0, 0x6A, 0x80, 0xB6, 0x4C,
  0x6B, 0x80, 0x56, 0xA0, 0xF8, 0x95, 0xA0, 0xE0,
};

const GFXglyph RobotoMono_LightItalic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 4, 4, 1, -4 },
  { 2, 2, 2, 4, 1, -5 },
  { 3, 4, 4, 4, 0, -4 },
  { 5, 3, 6, 4, 0, -5 },
  { 8, 3, 4, 4, 0, -4 },
  { 10, 3, 4, 4, 0, -4 },
  { 12, 1, 2, 4, 1, -5 },
  { 13, 2, 6, 4, 1, -5 },
  { 15, 1, 6, 4, 1, -5 },
  { 16, 2, 2, 4, 1, -4 },
  { 17, 3, 4, 4, 0, -4 },
  { 19, 1, 2, 4, 1, -1 },
  { 20, 2, 1, 4, 1, -2 },
  { 21, 1, 1, 4, 1, -1 },
  { 22, 3, 4, 4, 0, -4 },
  { 24, 3, 4, 4, 0, -4 },
  { 26, 2, 4, 4, 1, -4 },
  { 27, 3, 4, 4, 0, -4 },
  { 29, 3, 4, 4, 0, -4 },
  { 31, 3, 4, 4, 0, -4 },
  { 33, 3, 4, 4, 0, -4 },
  { 35, 3, 4, 4, 0, -4 },
  { 37, 2, 4, 4, 1, -4 },
  { 38, 3, 4, 4, 0, -4 },
  { 40, 2, 4, 4, 1, -4 },
  { 41, 1, 4, 4, 1, -4 },
  { 42, 1, 5, 4, 1, -4 },
  { 43, 3, 2, 4, 0, -3 },
  { 44, 3, 2, 4, 0, -3 },
  { 45, 3, 2, 4, 0, -3 },
  { 46, 2, 4, 4, 1, -4 },
  { 47, 3, 4, 4, 0, -4 },
  { 49, 3, 4, 4, 0, -4 },
  { 51, 3, 4, 4, 0, -4 },
  { 53, 3, 4, 4, 0, -4 },
  { 55, 3, 4, 4, 0, -4 },
  { 57, 3, 4, 4, 0, -4 },
  { 59, 3, 4, 4, 0, -4 },
  { 61, 3, 4, 4, 0, -4 },
  { 63, 3, 4, 4, 0, -4 },
  { 65, 3, 4, 4, 0, -4 },
  { 67, 3, 4, 4, 0, -4 },
  { 69, 4, 4, 4, 0, -4 },
  { 71, 3, 4, 4, 0, -4 },
  { 73, 4, 4, 4, 0, -4 },
  { 75, 3, 4, 4, 0, -4 },
  { 77, 3, 4, 4, 0, -4 },
  { 79, 3, 4, 4, 0, -4 },
  { 81, 3, 5, 4, 0, -4 },
  { 83, 3, 4, 4, 0, -4 },
  { 85, 3, 4, 4, 0, -4 },
  { 87, 3, 4, 4, 1, -4 },
  { 89, 3, 4, 4, 0, -4 },
  { 91, 3, 4, 4, 1, -4 },
  { 93, 3, 4, 4, 1, -4 },
  { 95, 4, 4, 4, 0, -4 },
  { 97, 3, 4, 4, 1, -4 },
  { 99, 3, 4, 4, 0, -4 },
  { 101, 2, 6, 4, 1, -5 },
  { 103, 1, 4, 4, 1, -4 },
  { 104, 2, 6, 4, 1, -5 },
  { 106, 2, 2, 4, 1, -4 },
  { 107, 3, 1, 4, 0, 0 },
  { 108, 1, 1, 4, 2, -5 },
  { 109, 3, 3, 4, 0, -3 },
  { 111, 3, 5, 4, 0, -5 },
  { 113, 3, 3, 4, 0, -3 },
  { 115, 3, 5, 4, 0, -5 },
  { 117, 3, 3, 4, 0, -3 },
  { 119, 3, 5, 4, 1, -5 },
  { 121, 3, 4, 4, 0, -3 },
  { 123, 3, 5, 4, 0, -5 },
  { 125, 3, 4, 4, 0, -4 },
  { 127, 3, 5, 4, 0, -4 },
  { 129, 3, 5, 4, 0, -5 },
  { 131, 3, 5, 4, 0, -5 },
  { 133, 3, 3, 4, 0, -3 },
  { 135, 3, 3, 4, 0, -3 },
  { 137, 3, 3, 4, 0, -3 },
  { 139, 3, 4, 4, 0, -3 },
  { 141, 3, 4, 4, 0, -3 },
  { 143, 2, 3, 4, 1, -3 },
  { 144, 3, 3, 4, 0, -3 },
  { 146, 2, 4, 4, 1, -4 },
  { 147, 3, 3, 4, 0, -3 },
  { 149, 2, 3, 4, 1, -3 },
  { 150, 4, 3, 4, 0, -3 },
  { 152, 3, 3, 4, 0, -3 },
  { 154, 4, 4, 4, 0, -3 },
  { 156, 3, 3, 4, 0, -3 },
  { 158, 2, 6, 4, 1, -5 },
  { 160, 1, 5, 4, 1, -4 },
  { 161, 2, 6, 4, 1, -5 },
  { 163, 3, 1, 4, 0, -2 },
};

const GFXfont RobotoMono_LightItalic6pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic6pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _ROBOTOMONO_LIGHTITALIC6PT7B_H_
