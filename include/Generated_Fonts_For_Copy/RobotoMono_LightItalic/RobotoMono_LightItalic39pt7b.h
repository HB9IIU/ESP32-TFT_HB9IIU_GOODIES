#ifndef _ROBOTOMONO_LIGHTITALIC39PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x1C, 0x38, 0x60, 0xC1, 0x83, 0x0E, 0x1C, 0x30, 0x60, 0xC1,
  0x87, 0x0C, 0x18, 0x30, 0x60, 0xC3, 0x80, 0x00, 0x00, 0x00, 0x01, 0xC3,
  0x87, 0x00, 0x61, 0xB0, 0xD8, 0xCC, 0x64, 0x36, 0x1B, 0x0D, 0x8C, 0x00,
  0x18, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30,
  0x60, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x18, 0x30, 0x1F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF0, 0x0C, 0x18, 0x00, 0x60, 0x60, 0x01, 0x81, 0x00, 0x04,
  0x0C, 0x00, 0x30, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x06, 0x00, 0x18, 0x18,
  0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x0C, 0x0C, 0x00, 0x30, 0x60, 0x01,
  0x81, 0x80, 0x06, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x02,
  0x00, 0x1C, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0x00, 0xF0, 0x70, 0x38, 0x06, 0x0E,
  0x00, 0xE1, 0x80, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x60, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x30, 0x01, 0xC7, 0x00,
  0x70, 0x70, 0x1C, 0x07, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0xC3,
  0x00, 0x30, 0x60, 0x46, 0x0C, 0x0C, 0xC1, 0x83, 0x10, 0x30, 0xC6, 0x06,
  0x38, 0x40, 0x86, 0x0C, 0x31, 0x81, 0xCC, 0x60, 0x1F, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x87, 0x80, 0x63,
  0xF8, 0x0C, 0x61, 0x83, 0x18, 0x30, 0xC3, 0x06, 0x18, 0x40, 0xC6, 0x18,
  0x19, 0x83, 0x03, 0x10, 0x60, 0xC0, 0x06, 0x18, 0x00, 0xEE, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x01, 0xC3, 0x00, 0x38, 0x18, 0x03,
  0x01, 0x80, 0x30, 0x18, 0x07, 0x03, 0x80, 0x70, 0x30, 0x03, 0x06, 0x00,
  0x30, 0xE0, 0x03, 0x38, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xE0, 0x00, 0xE6, 0x00, 0x1C, 0x30, 0x33, 0x83, 0x83, 0x30, 0x18,
  0x67, 0x01, 0xC6, 0x60, 0x0C, 0xE6, 0x00, 0x6C, 0x60, 0x07, 0x86, 0x00,
  0x38, 0x70, 0x07, 0x83, 0x81, 0xFC, 0x1F, 0xF8, 0xC0, 0xFF, 0x0E, 0x6D,
  0xB7, 0xB6, 0x00, 0x30, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x06,
  0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x40, 0x01, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x03, 0x80, 0x08, 0x00, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x04, 0x06, 0x07, 0xC2, 0x1F, 0xFB, 0x7F,
  0x1F, 0xFC, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xD8, 0x00, 0xC6, 0x00, 0xC3,
  0x80, 0xE0, 0xC0, 0xE0, 0x70, 0x20, 0x10, 0x00, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x71, 0x86, 0x18,
  0xE3, 0x1C, 0xE1, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x27, 0xF7, 0x00, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x70,
  0x70, 0x38, 0x06, 0x1C, 0x01, 0x86, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x03,
  0x70, 0x01, 0xD8, 0x01, 0xF6, 0x00, 0xED, 0x80, 0x77, 0x60, 0x31, 0xF8,
  0x38, 0x6E, 0x1C, 0x1B, 0x0E, 0x06, 0xC6, 0x01, 0xB7, 0x00, 0xEF, 0x80,
  0x3B, 0xC0, 0x0C, 0xC0, 0x03, 0x30, 0x01, 0xCC, 0x00, 0x63, 0x00, 0x38,
  0x60, 0x1C, 0x1C, 0x0E, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x40, 0x70,
  0xFC, 0xFB, 0xF8, 0xF0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01,
  0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x00, 0xFE, 0x00, 0x7F,
  0xE0, 0x1C, 0x0E, 0x07, 0x00, 0xE1, 0xC0, 0x0C, 0x30, 0x01, 0x86, 0x00,
  0x31, 0xC0, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xFE,
  0x7F, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x1E, 0x0F, 0x07, 0x00,
  0x60, 0xC0, 0x0E, 0x38, 0x01, 0xC6, 0x00, 0x18, 0xC0, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0xC7, 0x00, 0x18,
  0x60, 0x06, 0x0E, 0x03, 0xC0, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0x60, 0x00, 0xFC, 0x00, 0x3B,
  0x00, 0x06, 0x60, 0x01, 0x8C, 0x00, 0x61, 0x80, 0x1C, 0x70, 0x07, 0x0C,
  0x00, 0xC1, 0x80, 0x30, 0x30, 0x0C, 0x06, 0x03, 0x80, 0xC0, 0xE0, 0x38,
  0x18, 0x06, 0x06, 0x00, 0xC1, 0x80, 0x18, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x63, 0xC0, 0x0F, 0xFE, 0x01, 0xF1, 0xE0,
  0x70, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x31, 0x80, 0x06, 0x30, 0x01, 0xC3,
  0x00, 0x30, 0x60, 0x0E, 0x0E, 0x03, 0x80, 0xFF, 0xE0, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x7F, 0x06,
  0xFF, 0xC3, 0xE0, 0x73, 0xC0, 0x19, 0xC0, 0x0E, 0xE0, 0x03, 0x60, 0x01,
  0xB0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1B, 0x00, 0x19, 0x80,
  0x0C, 0xC0, 0x0E, 0x30, 0x0E, 0x1C, 0x0E, 0x07, 0xFE, 0x01, 0xFE, 0x00,
  0x7F, 0xFF, 0xEF, 0xFF, 0xF8, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8,
  0x03, 0xC1, 0xC0, 0x70, 0x0E, 0x0E, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00,
  0x60, 0xC0, 0x06, 0x1C, 0x00, 0x60, 0xC0, 0x0E, 0x0C, 0x00, 0xC0, 0xE0,
  0x38, 0x07, 0x8F, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0xE0, 0x70, 0x18,
  0x03, 0x83, 0x00, 0x18, 0x70, 0x01, 0xC6, 0x00, 0x0C, 0x60, 0x01, 0xCE,
  0x00, 0x1C, 0x60, 0x01, 0x86, 0x00, 0x38, 0x70, 0x07, 0x03, 0x80, 0xE0,
  0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0x83, 0x87,
  0x00, 0xC3, 0x00, 0x33, 0x80, 0x19, 0x80, 0x0D, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x3B, 0x80,
  0x3C, 0xE0, 0x36, 0x38, 0x76, 0x1F, 0xF3, 0x03, 0xE1, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0xE0,
  0x1F, 0xC0, 0x0F, 0x80, 0x00, 0x04, 0x3C, 0x78, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x41, 0xC7, 0x87, 0x00,
  0x01, 0x03, 0xC1, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x06, 0x03, 0x03, 0x81,
  0xC0, 0xC0, 0xE0, 0x60, 0x60, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x60,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0,
  0x00, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x7F, 0xFF,
  0xDF, 0xFF, 0xF7, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0xC0, 0x10, 0x00, 0x06,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x0F, 0xC0, 0x07, 0x80, 0x03, 0x80, 0x00, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x3F, 0xF0, 0xE0, 0xF3, 0x80, 0x66, 0x00, 0xD8, 0x01, 0xF0,
  0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x60, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x80, 0x1E,
  0x07, 0x00, 0xE0, 0x0C, 0x07, 0x00, 0x18, 0x38, 0x00, 0x60, 0xC1, 0xE0,
  0x86, 0x1F, 0xC2, 0x10, 0xE1, 0x08, 0xC3, 0x04, 0x22, 0x18, 0x30, 0x98,
  0x40, 0x82, 0x63, 0x02, 0x09, 0x0C, 0x18, 0x24, 0x20, 0x61, 0xB0, 0x81,
  0x06, 0xC6, 0x04, 0x13, 0x18, 0x30, 0x4C, 0x61, 0xC3, 0x31, 0x8F, 0x18,
  0xC3, 0x64, 0xC3, 0x0F, 0x1E, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x10, 0x01, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x36,
  0x00, 0x0E, 0xC0, 0x01, 0x98, 0x00, 0x71, 0x80, 0x0C, 0x30, 0x03, 0x86,
  0x00, 0x60, 0xC0, 0x1C, 0x18, 0x03, 0x03, 0x00, 0xE0, 0x60, 0x18, 0x0E,
  0x07, 0x00, 0xC0, 0xC0, 0x18, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xC0, 0x0C,
  0x30, 0x01, 0x86, 0x00, 0x39, 0x80, 0x03, 0x30, 0x00, 0x6C, 0x00, 0x0D,
  0x80, 0x01, 0xE0, 0x00, 0x30, 0x0F, 0xF8, 0x01, 0xFF, 0xE0, 0x30, 0x1F,
  0x06, 0x00, 0xE0, 0xC0, 0x0E, 0x18, 0x00, 0xC7, 0x00, 0x18, 0xC0, 0x03,
  0x18, 0x00, 0x63, 0x00, 0x1C, 0x60, 0x07, 0x1C, 0x01, 0xC3, 0x81, 0xF0,
  0x7F, 0xF8, 0x0F, 0xFF, 0xC1, 0x80, 0x1C, 0x30, 0x01, 0x8E, 0x00, 0x39,
  0x80, 0x03, 0x30, 0x00, 0x66, 0x00, 0x1C, 0xC0, 0x03, 0x98, 0x00, 0x67,
  0x00, 0x1C, 0xC0, 0x07, 0x18, 0x03, 0xC3, 0xFF, 0xF0, 0x7F, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0x81, 0xC0, 0x70, 0x0C, 0x0E, 0x00,
  0x61, 0xC0, 0x06, 0x18, 0x00, 0x63, 0x80, 0x07, 0x30, 0x00, 0x73, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x04, 0xE0, 0x01, 0x8E, 0x00, 0x18, 0x60, 0x03, 0x86, 0x00, 0x30,
  0x70, 0x06, 0x03, 0x81, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xF8, 0x01, 0x81, 0xE0, 0x0C, 0x03, 0x80, 0xE0, 0x0E, 0x06,
  0x00, 0x38, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x30, 0xE0, 0x01,
  0xC7, 0x00, 0x0E, 0x30, 0x00, 0x71, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60,
  0x00, 0xC7, 0x00, 0x06, 0x38, 0x00, 0x71, 0x80, 0x03, 0x8C, 0x00, 0x18,
  0x60, 0x01, 0xC3, 0x00, 0x0C, 0x38, 0x00, 0xE1, 0xC0, 0x0E, 0x0C, 0x00,
  0xE0, 0x60, 0x0E, 0x03, 0x01, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0xFF, 0xF0, 0x3F,
  0xFF, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x7F, 0xFF, 0x83, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0x81, 0xC0, 0x70, 0x0E, 0x0E, 0x00,
  0x61, 0xC0, 0x06, 0x18, 0x00, 0x73, 0x80, 0x07, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x2E, 0x03, 0xFC, 0xC0, 0x3F, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xCC,
  0x00, 0x0C, 0xE0, 0x01, 0xCE, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x18,
  0x30, 0x03, 0x83, 0x80, 0x70, 0x1F, 0xFE, 0x00, 0xFF, 0x80, 0x06, 0x00,
  0x1C, 0x18, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x18,
  0x30, 0x00, 0x60, 0xC0, 0x03, 0x83, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60,
  0x00, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x70, 0xFF, 0xFF,
  0x83, 0xFF, 0xFE, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x83,
  0x00, 0x0C, 0x1C, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x03, 0x06, 0x00,
  0x0C, 0x18, 0x00, 0x70, 0x60, 0x01, 0x83, 0x80, 0x06, 0x0C, 0x00, 0x18,
  0x30, 0x00, 0x60, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x0E, 0x00, 0x18, 0x70, 0x00, 0xC1, 0x80,
  0x0E, 0x0C, 0x00, 0xE0, 0x70, 0x0E, 0x01, 0xC0, 0xE0, 0x07, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0xE0, 0xC0, 0x07, 0x03,
  0x00, 0x38, 0x0C, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x70, 0x07, 0x03,
  0x80, 0x18, 0x1C, 0x00, 0x60, 0xE0, 0x01, 0x87, 0x00, 0x06, 0x38, 0x00,
  0x39, 0xC0, 0x00, 0xCF, 0x00, 0x03, 0x7E, 0x00, 0x0F, 0x98, 0x00, 0x3C,
  0x70, 0x00, 0xC0, 0xC0, 0x07, 0x03, 0x80, 0x18, 0x06, 0x00, 0x60, 0x1C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x18, 0x01, 0x80, 0xE0, 0x07, 0x03,
  0x00, 0x0C, 0x0C, 0x00, 0x38, 0x30, 0x00, 0x70, 0x06, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0xF0, 0x70, 0x03,
  0x83, 0xC0, 0x1E, 0x0D, 0x00, 0x78, 0x36, 0x03, 0x60, 0xD8, 0x1D, 0x83,
  0x60, 0x66, 0x1D, 0x83, 0xB0, 0x66, 0x0C, 0xC1, 0x88, 0x73, 0x06, 0x31,
  0x8C, 0x18, 0xCE, 0x30, 0x63, 0x31, 0xC3, 0x8D, 0x86, 0x0C, 0x36, 0x18,
  0x30, 0x70, 0x60, 0xC1, 0xC1, 0x83, 0x06, 0x06, 0x0C, 0x18, 0x38, 0x70,
  0x00, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x01,
  0xC1, 0x80, 0x07, 0x0E, 0x00, 0x18, 0x30, 0x00, 0x60, 0x06, 0x00, 0x1C,
  0x18, 0x00, 0x60, 0xF0, 0x01, 0x83, 0xC0, 0x06, 0x0F, 0x00, 0x18, 0x36,
  0x00, 0xE0, 0xD8, 0x03, 0x83, 0x70, 0x0C, 0x1C, 0xC0, 0x30, 0x63, 0x00,
  0xC1, 0x8E, 0x03, 0x06, 0x18, 0x1C, 0x18, 0x60, 0x60, 0x61, 0xC1, 0x83,
  0x83, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0x18, 0x60, 0xC0, 0x63, 0x83, 0x01,
  0x8C, 0x1C, 0x03, 0x30, 0x70, 0x0C, 0xC1, 0x80, 0x3B, 0x06, 0x00, 0x7C,
  0x18, 0x01, 0xF0, 0x60, 0x07, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x30,
  0x00, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x0E, 0x0E, 0x03, 0x80, 0xE0,
  0xE0, 0x0C, 0x38, 0x00, 0xC6, 0x00, 0x19, 0xC0, 0x03, 0x30, 0x00, 0x66,
  0x00, 0x0D, 0xC0, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xD8,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60,
  0x00, 0xEE, 0x00, 0x19, 0xC0, 0x07, 0x18, 0x00, 0xC3, 0x00, 0x38, 0x70,
  0x0E, 0x07, 0x03, 0x80, 0x7F, 0xE0, 0x07, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x3F, 0xFC, 0x03, 0x80, 0x78, 0x1C, 0x00, 0xC0, 0xC0, 0x07, 0x06, 0x00,
  0x18, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x1C, 0x00, 0x30, 0xC0, 0x01, 0x86,
  0x00, 0x1C, 0x30, 0x00, 0xC1, 0x80, 0x0E, 0x0C, 0x00, 0xE0, 0xE0, 0x7E,
  0x07, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x1F, 0xF8, 0x03, 0x83, 0xC0, 0x70, 0x0C, 0x0C, 0x00, 0xE1,
  0xC0, 0x06, 0x18, 0x00, 0x63, 0x80, 0x07, 0x30, 0x00, 0x77, 0x00, 0x03,
  0x60, 0x00, 0x36, 0x00, 0x07, 0x60, 0x00, 0x7E, 0x00, 0x06, 0xE0, 0x00,
  0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x0E, 0xC0, 0x00, 0xCC, 0x00,
  0x0C, 0xC0, 0x01, 0xCC, 0x00, 0x18, 0xE0, 0x03, 0x86, 0x00, 0x70, 0x70,
  0x0E, 0x03, 0x81, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x02, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0xF0, 0x0C, 0x03, 0xC0, 0xC0, 0x0C, 0x0C, 0x00, 0xE0, 0xC0,
  0x06, 0x0C, 0x00, 0x61, 0xC0, 0x06, 0x18, 0x00, 0x61, 0x80, 0x06, 0x18,
  0x00, 0xE1, 0x80, 0x0C, 0x38, 0x01, 0xC3, 0x80, 0x78, 0x3F, 0xFE, 0x03,
  0xFF, 0xC0, 0x30, 0x18, 0x03, 0x01, 0x80, 0x70, 0x1C, 0x06, 0x00, 0xC0,
  0x60, 0x0C, 0x06, 0x00, 0xE0, 0x60, 0x06, 0x06, 0x00, 0x60, 0xE0, 0x07,
  0x0C, 0x00, 0x30, 0xC0, 0x03, 0x8C, 0x00, 0x38, 0x00, 0x7E, 0x00, 0x1F,
  0xF8, 0x07, 0x81, 0xC0, 0xE0, 0x0E, 0x0C, 0x00, 0x61, 0xC0, 0x07, 0x18,
  0x00, 0x71, 0x80, 0x07, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0xCC, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x18, 0x70, 0x03, 0x83, 0x80,
  0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x38, 0x60, 0x01, 0x87, 0x00, 0x0C,
  0x30, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x01, 0xC7, 0x00,
  0x0C, 0x30, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC3,
  0x00, 0x0E, 0x38, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00,
  0xC3, 0x00, 0x0E, 0x18, 0x00, 0x71, 0xC0, 0x03, 0x0E, 0x00, 0x18, 0x70,
  0x01, 0xC1, 0x80, 0x0C, 0x0C, 0x00, 0xE0, 0x70, 0x0E, 0x01, 0xC0, 0xE0,
  0x07, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x06, 0x60,
  0x00, 0xC6, 0x00, 0x0C, 0x60, 0x01, 0xC6, 0x00, 0x18, 0x60, 0x03, 0x87,
  0x00, 0x30, 0x70, 0x07, 0x03, 0x00, 0x60, 0x30, 0x0E, 0x03, 0x00, 0xC0,
  0x30, 0x1C, 0x03, 0x01, 0x80, 0x38, 0x18, 0x01, 0x83, 0x00, 0x18, 0x30,
  0x01, 0x86, 0x00, 0x18, 0x60, 0x01, 0x8E, 0x00, 0x18, 0xC0, 0x01, 0xDC,
  0x00, 0x0D, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0, 0xE0, 0x3C,
  0x0E, 0x06, 0xC0, 0xE0, 0x6C, 0x1A, 0x06, 0xC1, 0xA0, 0xEC, 0x1A, 0x0C,
  0xC3, 0x20, 0xCC, 0x32, 0x0C, 0xC3, 0x21, 0x8C, 0x62, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x30, 0xCC, 0x33, 0x0C, 0xC3, 0x30, 0xCC, 0x33, 0x0D, 0x83,
  0x60, 0xD8, 0x36, 0x0D, 0x83, 0x60, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0E, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x38, 0x0C,
  0x03, 0x00, 0x06, 0x00, 0x06, 0x07, 0x00, 0x0E, 0x03, 0x00, 0x1C, 0x03,
  0x80, 0x18, 0x01, 0x80, 0x38, 0x01, 0xC0, 0x70, 0x00, 0xC0, 0xE0, 0x00,
  0xC0, 0xC0, 0x00, 0xE1, 0xC0, 0x00, 0x63, 0x80, 0x00, 0x77, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xE6, 0x00, 0x01, 0xC6, 0x00, 0x01,
  0x87, 0x00, 0x03, 0x03, 0x00, 0x07, 0x03, 0x80, 0x0E, 0x01, 0x80, 0x0C,
  0x01, 0xC0, 0x18, 0x00, 0xC0, 0x38, 0x00, 0xC0, 0x70, 0x00, 0xE0, 0xE0,
  0x00, 0x70, 0xE0, 0x00, 0x76, 0x00, 0x0E, 0x60, 0x00, 0xC7, 0x00, 0x1C,
  0x30, 0x03, 0x83, 0x00, 0x30, 0x38, 0x07, 0x01, 0x80, 0xE0, 0x18, 0x0C,
  0x01, 0xC1, 0xC0, 0x0C, 0x38, 0x00, 0xC3, 0x00, 0x0C, 0x60, 0x00, 0x6E,
  0x00, 0x06, 0xC0, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x00, 0x07, 0xF0, 0x7F, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFC, 0x0F, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x60, 0x60, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x18, 0x18, 0x18, 0x18, 0x18, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C,
  0x06, 0x06, 0x06, 0x06, 0x07, 0x03, 0xF8, 0x1F, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x70,
  0x07, 0xC0, 0x36, 0x03, 0xB0, 0x19, 0x81, 0x86, 0x0C, 0x30, 0xC1, 0x8E,
  0x0C, 0x60, 0x77, 0x01, 0xB0, 0x0F, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xE3, 0x1C, 0x61, 0x8C, 0x00, 0xFC, 0x01, 0xFF, 0xC0, 0xF0, 0x78,
  0x70, 0x06, 0x18, 0x01, 0x8E, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0xFF, 0xE0, 0xFF, 0xF8, 0xF0, 0x0E, 0x70, 0x03, 0x98, 0x00,
  0xCE, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x07, 0x38, 0x03, 0xC7, 0x03, 0xF1,
  0xFF, 0xDC, 0x1F, 0xC7, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x7C, 0x06, 0x7F, 0x81, 0xB0, 0x70, 0x78, 0x0E, 0x1C, 0x01, 0x8E, 0x00,
  0x73, 0x00, 0x1C, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x73, 0x00, 0x1D,
  0xC0, 0x06, 0x60, 0x01, 0x98, 0x00, 0x66, 0x00, 0x39, 0x80, 0x0C, 0xE0,
  0x07, 0x3C, 0x03, 0x8D, 0x81, 0xC3, 0x7F, 0xE0, 0xC7, 0xF0, 0x00, 0x01,
  0xF8, 0x03, 0xFF, 0x03, 0x83, 0xC3, 0x80, 0x63, 0x80, 0x3B, 0x80, 0x0D,
  0x80, 0x06, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x05, 0x80, 0x0C, 0xC0, 0x06, 0x30,
  0x06, 0x1C, 0x0F, 0x07, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0E, 0x03, 0xF1, 0xC0, 0xFF, 0x30, 0x78, 0x36, 0x0E, 0x03,
  0xC3, 0x80, 0x38, 0xE0, 0x07, 0x18, 0x00, 0xE7, 0x00, 0x18, 0xC0, 0x03,
  0x18, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x03, 0x8C, 0x00, 0x71, 0x80, 0x0C,
  0x30, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x0E, 0x1C, 0x03, 0xC1, 0xC0, 0xF0,
  0x1F, 0xF6, 0x01, 0xFC, 0xC0, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x70, 0x70,
  0x38, 0x06, 0x1C, 0x01, 0xCE, 0x00, 0x33, 0x00, 0x0D, 0xC0, 0x03, 0x60,
  0x00, 0xDF, 0xFF, 0xF7, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0xC3, 0x80, 0xE0,
  0x7F, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xFC, 0x03, 0xC0,
  0x80, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x1F, 0xFF, 0xE3, 0xFF, 0xF8, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFC, 0x70, 0x1F, 0xE6, 0x07, 0x83,
  0x60, 0x70, 0x1E, 0x0E, 0x00, 0xE1, 0xC0, 0x0E, 0x18, 0x00, 0xE1, 0x80,
  0x0C, 0x38, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x1C, 0x30,
  0x01, 0xC3, 0x00, 0x18, 0x30, 0x01, 0x83, 0x00, 0x18, 0x30, 0x03, 0x83,
  0x80, 0x78, 0x1C, 0x0F, 0x80, 0xFF, 0xB0, 0x07, 0xF3, 0x00, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x40, 0x0E, 0x0E, 0x01, 0xC0, 0x70, 0x38,
  0x03, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x7C, 0x06, 0x7F, 0xC1, 0xB8, 0x38, 0x78, 0x06, 0x3C, 0x01, 0xCE,
  0x00, 0x73, 0x00, 0x0C, 0xC0, 0x07, 0x30, 0x01, 0xCC, 0x00, 0x67, 0x00,
  0x19, 0x80, 0x06, 0x60, 0x01, 0x98, 0x00, 0xE6, 0x00, 0x39, 0x80, 0x0C,
  0xE0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x1C, 0xC0, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x78, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xE3, 0x80, 0x38, 0x60, 0x0E, 0x0C,
  0x07, 0x81, 0x81, 0xC0, 0x30, 0x70, 0x06, 0x1C, 0x01, 0xCF, 0x00, 0x33,
  0xC0, 0x06, 0xF0, 0x00, 0xFF, 0x00, 0x1E, 0x60, 0x07, 0x8E, 0x00, 0xE0,
  0xE0, 0x18, 0x1C, 0x03, 0x01, 0xC0, 0x60, 0x1C, 0x0C, 0x03, 0x83, 0x80,
  0x38, 0x70, 0x03, 0x0C, 0x00, 0x70, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x19, 0xF0, 0xF0, 0x6F,
  0xEF, 0xE1, 0xE3, 0xE1, 0xC7, 0x07, 0x07, 0x18, 0x18, 0x0C, 0xC0, 0x60,
  0x33, 0x01, 0x81, 0xCC, 0x06, 0x06, 0x30, 0x38, 0x18, 0xC0, 0xC0, 0x67,
  0x03, 0x01, 0x98, 0x0C, 0x06, 0x60, 0x30, 0x39, 0x80, 0xC0, 0xC6, 0x07,
  0x03, 0x18, 0x18, 0x0C, 0xE0, 0x60, 0x33, 0x01, 0x80, 0xCC, 0x06, 0x07,
  0x30, 0x18, 0x18, 0xC0, 0xE0, 0x60, 0x18, 0x7C, 0x06, 0x7F, 0xC1, 0xB8,
  0x38, 0x78, 0x06, 0x3C, 0x01, 0xCE, 0x00, 0x73, 0x00, 0x1C, 0xC0, 0x07,
  0x30, 0x01, 0xCC, 0x00, 0x67, 0x00, 0x19, 0x80, 0x06, 0x60, 0x01, 0x98,
  0x00, 0xE6, 0x00, 0x39, 0x80, 0x0C, 0xE0, 0x03, 0x30, 0x00, 0xCC, 0x00,
  0x33, 0x00, 0x1C, 0xC0, 0x06, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0xF0,
  0x70, 0x70, 0x0E, 0x18, 0x01, 0x8C, 0x00, 0x77, 0x00, 0x0D, 0x80, 0x03,
  0x60, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0x6C, 0x00, 0x1B, 0x80, 0x0E, 0x60, 0x07, 0x1C, 0x03, 0x83, 0x81,
  0xC0, 0x7F, 0xE0, 0x0F, 0xF0, 0x00, 0x06, 0x1F, 0x00, 0x67, 0xF8, 0x07,
  0xC1, 0xC0, 0x78, 0x0E, 0x07, 0x00, 0x60, 0xE0, 0x06, 0x0C, 0x00, 0x70,
  0xC0, 0x07, 0x0C, 0x00, 0x70, 0xC0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x06,
  0x18, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0xE1, 0x80, 0x0C, 0x38, 0x01,
  0xC3, 0xC0, 0x38, 0x3E, 0x07, 0x03, 0x7F, 0xE0, 0x31, 0xFC, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xF1, 0xC1, 0xFF, 0x61,
  0xE0, 0xD8, 0x70, 0x1E, 0x38, 0x03, 0x9C, 0x00, 0xE6, 0x00, 0x39, 0x80,
  0x0C, 0xE0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x1C, 0xC0, 0x07,
  0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x0E, 0x38, 0x07, 0x87,
  0x03, 0xC0, 0xFF, 0xB0, 0x1F, 0xCC, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x18, 0x3F, 0x18, 0xFF, 0x1B, 0xE1, 0x1F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x07,
  0x81, 0xC3, 0x00, 0x73, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x1D, 0x80, 0x06, 0xC0, 0x07, 0x70, 0x03, 0x1C, 0x07, 0x8F,
  0xFF, 0x81, 0xFF, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x30, 0x01, 0xCC, 0x00,
  0x73, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x9C, 0x00, 0x66, 0x00, 0x39,
  0x80, 0x0E, 0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x33, 0x80, 0x0C, 0xC0,
  0x07, 0x30, 0x01, 0xCC, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x0E, 0x38, 0x07,
  0x86, 0x03, 0x61, 0xFF, 0xB0, 0x3F, 0xCC, 0x00, 0xE0, 0x00, 0x6C, 0x00,
  0x1D, 0x80, 0x03, 0x30, 0x00, 0xC7, 0x00, 0x38, 0x60, 0x06, 0x0C, 0x01,
  0xC1, 0x80, 0x30, 0x38, 0x0E, 0x03, 0x01, 0x80, 0x60, 0x60, 0x0C, 0x0C,
  0x00, 0xC3, 0x00, 0x18, 0xE0, 0x03, 0x18, 0x00, 0x67, 0x00, 0x06, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0xC0, 0x60,
  0x3C, 0x06, 0x03, 0xC0, 0xE0, 0x3C, 0x0E, 0x06, 0xC0, 0xA0, 0x6C, 0x1A,
  0x0C, 0xC1, 0xA0, 0xCC, 0x32, 0x0C, 0xC3, 0x21, 0x8C, 0x62, 0x18, 0xC6,
  0x31, 0x0C, 0x43, 0x30, 0xCC, 0x33, 0x0C, 0xC3, 0x60, 0xD8, 0x36, 0x0D,
  0x83, 0x60, 0xD0, 0x3C, 0x0F, 0x03, 0xC0, 0x70, 0x38, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x00, 0x1C, 0x00, 0x38, 0x60, 0x03, 0x83, 0x80, 0x38, 0x0E,
  0x03, 0x80, 0x30, 0x38, 0x01, 0xC1, 0x80, 0x06, 0x18, 0x00, 0x39, 0x80,
  0x00, 0xDC, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x80, 0x01, 0xCC, 0x00, 0x1C, 0x30, 0x00, 0xC1, 0xC0, 0x0C, 0x06, 0x00,
  0xE0, 0x38, 0x0E, 0x00, 0xC0, 0xE0, 0x07, 0x0E, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x07, 0x0E, 0x00, 0x06, 0x06, 0x00, 0x0E, 0x06, 0x00, 0x1C, 0x07,
  0x00, 0x18, 0x07, 0x00, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x03,
  0x80, 0xE0, 0x01, 0x80, 0xC0, 0x01, 0x81, 0xC0, 0x01, 0x81, 0x80, 0x01,
  0xC3, 0x80, 0x00, 0xC3, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xCE, 0x00, 0x00,
  0xEC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x38, 0x01,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x00, 0x0E, 0x00, 0xF8, 0x03, 0xC0, 0x07, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x10, 0x00, 0x06, 0x0C, 0x18, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x10, 0x60, 0xC1, 0x83, 0x06, 0x08, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x04, 0x18, 0x30, 0x60, 0xC1,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x3C, 0x00,
  0x38, 0x01, 0xF0, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x10, 0x00,
  0x00, 0x1F, 0x00, 0x01, 0xFE, 0x00, 0xDC, 0x78, 0x06, 0xC0, 0xE0, 0x6C,
  0x03, 0x87, 0x60, 0x0F, 0xF0, 0x00, 0x1E, 0x00,
};

const GFXglyph RobotoMono_LightItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 7, 28, 23, 8, -28 },
  { 26, 9, 8, 23, 9, -29 },
  { 35, 22, 28, 23, 1, -28 },
  { 112, 19, 36, 23, 2, -32 },
  { 198, 19, 28, 23, 2, -28 },
  { 265, 20, 28, 23, 1, -28 },
  { 335, 3, 8, 23, 11, -29 },
  { 338, 12, 40, 23, 7, -31 },
  { 398, 13, 40, 23, 3, -31 },
  { 463, 17, 17, 23, 5, -28 },
  { 500, 19, 20, 23, 2, -23 },
  { 548, 6, 10, 23, 4, -4 },
  { 556, 14, 2, 23, 4, -13 },
  { 560, 4, 4, 23, 8, -4 },
  { 562, 18, 30, 23, 3, -28 },
  { 630, 18, 28, 23, 3, -28 },
  { 693, 10, 28, 23, 6, -28 },
  { 728, 19, 28, 23, 1, -28 },
  { 795, 19, 28, 23, 1, -28 },
  { 862, 19, 28, 23, 1, -28 },
  { 929, 19, 28, 23, 3, -28 },
  { 996, 17, 28, 23, 2, -28 },
  { 1056, 19, 28, 23, 4, -28 },
  { 1123, 20, 28, 23, 2, -28 },
  { 1193, 17, 28, 23, 4, -28 },
  { 1253, 7, 21, 23, 9, -21 },
  { 1272, 9, 27, 23, 7, -21 },
  { 1303, 18, 17, 23, 3, -21 },
  { 1342, 18, 10, 23, 3, -18 },
  { 1365, 18, 17, 23, 2, -21 },
  { 1404, 15, 28, 23, 6, -28 },
  { 1457, 22, 28, 23, 1, -28 },
  { 1534, 19, 28, 23, 0, -28 },
  { 1601, 19, 28, 23, 2, -28 },
  { 1668, 20, 28, 23, 2, -28 },
  { 1738, 21, 28, 23, 1, -28 },
  { 1812, 20, 28, 23, 2, -28 },
  { 1882, 21, 28, 23, 2, -28 },
  { 1956, 20, 28, 23, 2, -28 },
  { 2026, 22, 28, 23, 1, -28 },
  { 2103, 20, 28, 23, 2, -28 },
  { 2173, 21, 28, 23, 1, -28 },
  { 2247, 22, 28, 23, 2, -28 },
  { 2324, 16, 28, 23, 2, -28 },
  { 2380, 22, 28, 23, 1, -28 },
  { 2457, 22, 28, 23, 1, -28 },
  { 2534, 19, 28, 23, 2, -28 },
  { 2601, 21, 28, 23, 2, -28 },
  { 2675, 20, 33, 23, 2, -28 },
  { 2758, 20, 28, 23, 2, -28 },
  { 2828, 20, 28, 23, 2, -28 },
  { 2898, 20, 28, 23, 4, -28 },
  { 2968, 21, 28, 23, 2, -28 },
  { 3042, 20, 28, 23, 4, -28 },
  { 3112, 20, 28, 23, 4, -28 },
  { 3182, 24, 28, 23, 0, -28 },
  { 3266, 20, 28, 23, 4, -28 },
  { 3336, 21, 28, 23, 1, -28 },
  { 3410, 12, 38, 23, 6, -32 },
  { 3467, 8, 30, 23, 8, -28 },
  { 3497, 13, 38, 23, 5, -32 },
  { 3559, 13, 15, 23, 5, -28 },
  { 3584, 17, 2, 23, 1, 0 },
  { 3589, 5, 6, 23, 11, -29 },
  { 3593, 18, 21, 23, 2, -21 },
  { 3641, 18, 29, 23, 2, -29 },
  { 3707, 17, 21, 23, 3, -21 },
  { 3752, 19, 29, 23, 3, -29 },
  { 3821, 18, 21, 23, 2, -21 },
  { 3869, 19, 30, 23, 5, -30 },
  { 3941, 20, 29, 23, 1, -21 },
  { 4014, 18, 29, 23, 2, -29 },
  { 4080, 17, 28, 23, 2, -28 },
  { 4140, 18, 36, 23, 0, -28 },
  { 4221, 19, 29, 23, 2, -29 },
  { 4290, 17, 29, 23, 2, -29 },
  { 4352, 22, 21, 23, 0, -21 },
  { 4410, 18, 21, 23, 2, -21 },
  { 4458, 18, 21, 23, 2, -21 },
  { 4506, 20, 29, 23, 0, -21 },
  { 4579, 18, 29, 23, 3, -21 },
  { 4645, 16, 21, 23, 5, -21 },
  { 4687, 17, 21, 23, 3, -21 },
  { 4732, 16, 26, 23, 4, -26 },
  { 4784, 18, 21, 23, 3, -21 },
  { 4832, 19, 21, 23, 3, -21 },
  { 4882, 20, 21, 23, 3, -21 },
  { 4935, 21, 21, 23, 1, -21 },
  { 4991, 24, 29, 23, -1, -21 },
  { 5078, 20, 21, 23, 1, -21 },
  { 5131, 15, 38, 23, 6, -30 },
  { 5203, 7, 34, 23, 8, -28 },
  { 5233, 15, 38, 23, 3, -30 },
  { 5305, 21, 7, 23, 1, -15 },
};

const GFXfont RobotoMono_LightItalic39pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic39pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic39pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _ROBOTOMONO_LIGHTITALIC39PT7B_H_
