#ifndef _ROBOTOMONO_LIGHTITALIC55PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07,
  0x81, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0xF0, 0x3C,
  0x0F, 0x00, 0x70, 0x77, 0x07, 0x70, 0x77, 0x07, 0x60, 0x66, 0x06, 0xE0,
  0xEE, 0x0E, 0xE0, 0xEC, 0x0C, 0xC0, 0xCC, 0x1C, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x01, 0x80, 0x70, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0x60,
  0x00, 0x03, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xC0,
  0x00, 0x06, 0x01, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x30, 0x0E, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x60, 0x1C, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0xC0, 0x38, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0x80, 0x70, 0x00, 0x03, 0x00, 0x60, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x0E, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x1C, 0x03, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x7E, 0x1F, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x00,
  0xE0, 0x38, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x78, 0x38,
  0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xF0, 0x3C,
  0x00, 0x3C, 0x03, 0xC0, 0x1F, 0x00, 0x7E, 0x1F, 0xC0, 0x07, 0xFF, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0E,
  0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x60, 0x38, 0x02, 0x1C, 0x03, 0x00,
  0xE3, 0x80, 0x60, 0x38, 0x60, 0x1C, 0x07, 0x0C, 0x03, 0x81, 0xC1, 0x80,
  0x70, 0x70, 0x70, 0x0E, 0x0C, 0x06, 0x01, 0x83, 0x80, 0xC0, 0x70, 0xE0,
  0x1C, 0x1C, 0x38, 0x01, 0xC7, 0x07, 0x00, 0x3F, 0xE1, 0xC0, 0x01, 0xF0,
  0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC1, 0xF8, 0x00, 0x70,
  0x7F, 0x80, 0x0E, 0x1C, 0x78, 0x03, 0x87, 0x07, 0x00, 0xE1, 0xC0, 0x60,
  0x18, 0x38, 0x0E, 0x07, 0x06, 0x01, 0xC1, 0xC1, 0xC0, 0x38, 0x70, 0x38,
  0x07, 0x0E, 0x07, 0x00, 0xC3, 0x80, 0xE0, 0x18, 0xE0, 0x1C, 0x07, 0x04,
  0x03, 0x80, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78,
  0x1E, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0xE0,
  0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x1E, 0x00, 0x1C,
  0x03, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xE1, 0xE0,
  0x00, 0x0E, 0x3C, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x07, 0x8F, 0x00, 0x70, 0xF0, 0x70, 0x07, 0x1E, 0x07, 0x80, 0xE3,
  0xC0, 0x38, 0x0E, 0x38, 0x03, 0xC0, 0xE7, 0x80, 0x1E, 0x1E, 0x70, 0x00,
  0xE1, 0xC7, 0x00, 0x0F, 0x3C, 0x70, 0x00, 0x73, 0x8F, 0x00, 0x07, 0xF8,
  0xF0, 0x00, 0x3F, 0x07, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x3E, 0x07, 0x80,
  0x07, 0xF0, 0x3C, 0x01, 0xF7, 0x01, 0xF0, 0x7E, 0x78, 0x0F, 0xFF, 0x83,
  0x80, 0x7F, 0xE0, 0x3C, 0x00, 0x60, 0x00, 0x00, 0x39, 0xCE, 0x73, 0x99,
  0xCE, 0x73, 0x19, 0xC0, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0x80, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x40, 0x1C, 0x02, 0xF8, 0x18, 0x1E, 0xFE,
  0x18, 0xFF, 0x7F, 0xDB, 0xFE, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x8E, 0x00, 0x07,
  0x87, 0x00, 0x0F, 0x07, 0x00, 0x1E, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x78,
  0x01, 0xE0, 0x30, 0x01, 0xC0, 0x10, 0x00, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x07, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E,
  0x1E, 0x1C, 0x1C, 0x3C, 0x38, 0x70, 0xE0, 0x60, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x77, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x07,
  0xE0, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0xE0, 0x01, 0xC0, 0x78, 0x00, 0x78,
  0x3C, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x87, 0x80, 0x00, 0xE1, 0xC0, 0x00,
  0x38, 0x70, 0x00, 0x0F, 0x38, 0x00, 0x07, 0xCE, 0x00, 0x03, 0xF3, 0x80,
  0x03, 0xF8, 0xE0, 0x01, 0xEE, 0x78, 0x00, 0xF3, 0x9C, 0x00, 0x78, 0xE7,
  0x00, 0x78, 0x39, 0xC0, 0x3C, 0x0E, 0x70, 0x1E, 0x07, 0x9C, 0x0F, 0x01,
  0xCF, 0x0F, 0x00, 0x73, 0x87, 0x80, 0x1C, 0xE3, 0xC0, 0x07, 0x39, 0xE0,
  0x01, 0xCF, 0xE0, 0x00, 0xF3, 0xF0, 0x00, 0x38, 0xF8, 0x00, 0x0E, 0x38,
  0x00, 0x03, 0x8E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x38,
  0x3C, 0x00, 0x1E, 0x07, 0x00, 0x07, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x03,
  0xE0, 0x07, 0xC3, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x3C, 0x03, 0xF8, 0x1F, 0xF1, 0xFF,
  0xCF, 0xE3, 0x9F, 0x07, 0x70, 0x0E, 0x80, 0x1C, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x07, 0x80,
  0x07, 0x00, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE1, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x00,
  0x3C, 0x03, 0xC0, 0x03, 0x80, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x07,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x0E, 0x3C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x0F, 0x0E,
  0x00, 0x01, 0xC1, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x03, 0xE0, 0x0F,
  0x80, 0x3F, 0x07, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x7B, 0x80, 0x00, 0x0F, 0x38, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x1C, 0x78, 0x00, 0x03, 0x87, 0x00, 0x00, 0x78, 0x70, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x70, 0x0E, 0x00, 0x0F, 0x00, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x1C, 0x00,
  0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x1C, 0x01,
  0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x3F, 0xC0,
  0x00, 0xEF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x1F,
  0x00, 0x3C, 0x00, 0x40, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x3C, 0x07, 0x80, 0x03, 0x80, 0x38, 0x00, 0x78, 0x03, 0xC0,
  0x1F, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x1C, 0x7F,
  0xE0, 0x1C, 0xFF, 0xF8, 0x3B, 0xE0, 0xFC, 0x3F, 0x80, 0x3C, 0x3E, 0x00,
  0x1E, 0x7C, 0x00, 0x0E, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x07, 0x70, 0x00,
  0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x1C, 0x78, 0x00, 0x3C, 0x38, 0x00, 0x38, 0x3C, 0x00,
  0x78, 0x1E, 0x01, 0xF0, 0x0F, 0x87, 0xE0, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x00, 0x10, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0x0F,
  0xC0, 0x0F, 0x00, 0x7C, 0x03, 0xC0, 0x03, 0x80, 0xF0, 0x00, 0x78, 0x1C,
  0x00, 0x07, 0x07, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x70, 0x70, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0xF0, 0x3C, 0x00, 0x1C, 0x03, 0xC0, 0x07, 0x00, 0x3C, 0x03, 0xC0,
  0x03, 0xF7, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xE1,
  0xF8, 0x01, 0xE0, 0x0F, 0x80, 0x78, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x07,
  0x80, 0x00, 0xE0, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x38, 0x70,
  0x00, 0x07, 0x0E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x1C, 0x00, 0x1E,
  0x03, 0xE0, 0x07, 0x80, 0x3F, 0x07, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0xF0, 0x03, 0xE0, 0xF8, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x1C,
  0x1E, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x3C, 0x00, 0x0F, 0x38, 0x00, 0x07,
  0x78, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07,
  0x70, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x0F,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x1E, 0x70, 0x00, 0x3E, 0x78, 0x00, 0x7E,
  0x3C, 0x00, 0xEE, 0x1E, 0x03, 0xDC, 0x1F, 0xFF, 0x9C, 0x07, 0xFF, 0x1C,
  0x03, 0xFC, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x81, 0xE0, 0xFC, 0x3E, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x3E, 0x0F, 0xC3, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38,
  0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x04, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x20, 0x3F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF0, 0x08, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF0,
  0x1F, 0x87, 0xC1, 0xE0, 0x0F, 0x1E, 0x00, 0x39, 0xE0, 0x01, 0xEE, 0x00,
  0x07, 0x70, 0x00, 0x3F, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7E, 0x07,
  0xC0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x06, 0x03, 0x80, 0xFC, 0x0C,
  0x0E, 0x07, 0xFC, 0x1C, 0x18, 0x1E, 0x3C, 0x38, 0x70, 0x70, 0x30, 0x70,
  0xC0, 0xC0, 0x60, 0xE3, 0x83, 0x80, 0xC0, 0xC6, 0x0E, 0x03, 0x83, 0x9C,
  0x18, 0x06, 0x07, 0x30, 0x30, 0x0C, 0x0C, 0x60, 0xE0, 0x18, 0x19, 0xC1,
  0x80, 0x70, 0x33, 0x83, 0x00, 0xC0, 0x66, 0x0E, 0x01, 0x80, 0xCC, 0x1C,
  0x03, 0x03, 0x18, 0x30, 0x0E, 0x06, 0x30, 0x60, 0x18, 0x0C, 0x60, 0xC0,
  0x70, 0x38, 0xC1, 0x81, 0xE0, 0x63, 0x83, 0x03, 0xC1, 0xC3, 0x07, 0x0D,
  0x83, 0x06, 0x0F, 0xF3, 0x9C, 0x0C, 0x0F, 0xC3, 0xF0, 0x18, 0x0F, 0x03,
  0xC0, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x01, 0x80, 0x00, 0xFC, 0x1F, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0x70,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x03,
  0x83, 0x00, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0xE0, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xE0,
  0x1C, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00,
  0x38, 0x00, 0xE0, 0x0F, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x70, 0x00, 0x1C, 0x1E,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0xF0, 0x00, 0x0E, 0x1C, 0x00, 0x01,
  0xC7, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x38, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x3C, 0x00, 0x7C, 0x03,
  0x80, 0x01, 0xE0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xF0, 0x38, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x70, 0x78, 0x00, 0x07, 0x07, 0x00, 0x00, 0xF0,
  0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x1E, 0x07, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0x78, 0x0E, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x3E, 0x01, 0xC0,
  0x00, 0xF0, 0x1C, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03,
  0xC1, 0xC0, 0x00, 0x1C, 0x3C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x38,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x3C, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x78, 0x78, 0x00, 0x07, 0x07, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x3E, 0x07,
  0x00, 0x0F, 0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xC1, 0xF0, 0x01, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0x3C, 0x03,
  0x80, 0x01, 0xC0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x0E, 0x1E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x70, 0xF0,
  0x00, 0x07, 0x07, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x01,
  0xE0, 0x38, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x00,
  0xF8, 0x7E, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE,
  0x00, 0x38, 0x01, 0xF0, 0x03, 0x80, 0x07, 0x80, 0x38, 0x00, 0x3C, 0x07,
  0x80, 0x01, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x0F, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x0E, 0x3C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x3C, 0x38, 0x00, 0x03, 0x87, 0x80, 0x00, 0x78, 0x70,
  0x00, 0x0F, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x1E, 0x07, 0x00, 0x07,
  0xC0, 0x70, 0x00, 0xF8, 0x0F, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xE1, 0xF8, 0x01, 0xF0,
  0x07, 0x80, 0x3E, 0x00, 0x3C, 0x03, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x0E,
  0x0F, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0xF1, 0xC0,
  0x00, 0x07, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x3F,
  0xFC, 0xE0, 0x03, 0xFF, 0xCE, 0x00, 0x3F, 0xFC, 0xE0, 0x00, 0x03, 0xCE,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x07, 0x07, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0xC0,
  0x01, 0xF0, 0x1E, 0x00, 0x3E, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xFF, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x70, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x00, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xF0, 0x70,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x3C, 0x03, 0x80, 0x01, 0xC0, 0x1E, 0x00, 0x3E, 0x00, 0x78, 0x03, 0xE0,
  0x01, 0xF0, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x01, 0xC0, 0x00, 0x3C, 0x01,
  0xC0, 0x00, 0x78, 0x01, 0xC0, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x03,
  0x80, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x03, 0x80, 0x0F, 0x00, 0x03,
  0x80, 0x1E, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x07,
  0x07, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x0E,
  0x3C, 0x00, 0x00, 0x0E, 0x7E, 0x00, 0x00, 0x0E, 0xFE, 0x00, 0x00, 0x0F,
  0xEF, 0x00, 0x00, 0x1F, 0xC7, 0x80, 0x00, 0x1F, 0x87, 0x80, 0x00, 0x1F,
  0x03, 0xC0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x70, 0x00, 0x07, 0x80, 0x70, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3F, 0x03,
  0xE0, 0x00, 0xF8, 0x1D, 0x80, 0x07, 0xE0, 0x76, 0x00, 0x3F, 0x81, 0xDC,
  0x00, 0xEE, 0x07, 0x70, 0x07, 0xB8, 0x1D, 0xC0, 0x1C, 0xE0, 0xE7, 0x00,
  0xE7, 0x03, 0x8C, 0x03, 0x9C, 0x0E, 0x30, 0x1C, 0x70, 0x38, 0xE0, 0x71,
  0xC0, 0xE3, 0x83, 0x87, 0x03, 0x8E, 0x0E, 0x1C, 0x1C, 0x38, 0x70, 0xE0,
  0x70, 0x63, 0xC3, 0x81, 0xC1, 0xCE, 0x0E, 0x07, 0x07, 0x78, 0x38, 0x1C,
  0x1D, 0xC0, 0xE0, 0x70, 0x7E, 0x07, 0x83, 0x81, 0xF8, 0x1C, 0x0E, 0x03,
  0xC0, 0x70, 0x38, 0x0F, 0x01, 0xC0, 0xE0, 0x38, 0x07, 0x03, 0x80, 0xE0,
  0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x70, 0x0F,
  0x80, 0x00, 0xE0, 0x3F, 0x00, 0x01, 0xC0, 0x7E, 0x00, 0x03, 0x80, 0xFE,
  0x00, 0x07, 0x01, 0xDC, 0x00, 0x1E, 0x03, 0xB8, 0x00, 0x38, 0x07, 0x38,
  0x00, 0x70, 0x1C, 0x70, 0x00, 0xE0, 0x38, 0xE0, 0x01, 0xC0, 0x70, 0xE0,
  0x07, 0x80, 0xE1, 0xC0, 0x0E, 0x01, 0xC3, 0x80, 0x1C, 0x07, 0x83, 0x80,
  0x38, 0x0E, 0x07, 0x00, 0x70, 0x1C, 0x0F, 0x00, 0xE0, 0x38, 0x0E, 0x03,
  0xC0, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x3C, 0x0E, 0x03, 0xC0, 0x38, 0x1C,
  0x07, 0x00, 0x70, 0x38, 0x0E, 0x00, 0x70, 0x70, 0x1C, 0x00, 0xE1, 0xE0,
  0x38, 0x01, 0xC3, 0x80, 0x70, 0x01, 0xC7, 0x01, 0xE0, 0x03, 0x8E, 0x03,
  0x80, 0x07, 0x1C, 0x07, 0x00, 0x07, 0x38, 0x0E, 0x00, 0x0E, 0xF0, 0x1C,
  0x00, 0x1D, 0xC0, 0x38, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0x3F, 0x01, 0xC0,
  0x00, 0x7E, 0x03, 0x80, 0x00, 0x7C, 0x07, 0x00, 0x00, 0xF8, 0x0E, 0x00,
  0x00, 0xE0, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0x00, 0xF8,
  0x03, 0xC0, 0x07, 0x00, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x0E, 0x0F, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x78, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x0E, 0x78, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x07, 0x38, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0xBC, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x0E, 0x70, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E,
  0x3C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x70, 0x70, 0x00, 0x1E, 0x0E, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0xE0, 0x1E, 0x00, 0x3C, 0x01, 0xE0, 0x1F, 0x00,
  0x1F, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0x00, 0x07, 0x80, 0x38, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x78,
  0x1E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x78, 0x38,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x1C,
  0x0E, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x38,
  0x00, 0x3E, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xE1, 0xF0, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x01,
  0xC0, 0x70, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0xF3, 0x80, 0x00,
  0x07, 0x38, 0x00, 0x00, 0x77, 0x80, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0x78,
  0x00, 0x3C, 0x03, 0xC0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x01, 0xF8, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x21, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0xF8, 0x07,
  0x80, 0x03, 0xC0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1E, 0x0E, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x81, 0xC0, 0x00, 0xF0,
  0x1C, 0x00, 0x1E, 0x01, 0xC0, 0x07, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x01, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x70,
  0x00, 0x70, 0x07, 0x00, 0x07, 0x80, 0x70, 0x00, 0x78, 0x07, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1C, 0x0E,
  0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xC1, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x3C, 0x00, 0x3C, 0x07,
  0x80, 0x01, 0xE0, 0x70, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x0F, 0x0E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x70, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0x3E, 0x00, 0x7C, 0x01,
  0xFC, 0x3F, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xF0, 0x70, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x83, 0x80, 0x00, 0x38, 0x38,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x3C, 0x1C, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x70, 0x78, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x38, 0x0E,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x1C, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x03, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3B, 0xC0, 0x00, 0x07, 0x78, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x0F, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x78, 0x70,
  0x00, 0x0E, 0x0F, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x1E,
  0x03, 0x80, 0x03, 0x80, 0x70, 0x00, 0xF0, 0x0E, 0x00, 0x1C, 0x01, 0xC0,
  0x03, 0x80, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x07, 0x80,
  0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x3C, 0x00, 0x38, 0x07, 0x00, 0x07, 0x01,
  0xE0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x38, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x70,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x07, 0x00, 0x3B,
  0x80, 0x38, 0x01, 0xDC, 0x01, 0xC0, 0x0E, 0xE0, 0x1F, 0x00, 0xE7, 0x00,
  0xF8, 0x07, 0x38, 0x07, 0xC0, 0x39, 0xC0, 0x7E, 0x03, 0x8E, 0x03, 0xF0,
  0x1C, 0x70, 0x1B, 0x80, 0xE3, 0x81, 0xDC, 0x07, 0x1C, 0x0E, 0xE0, 0x70,
  0xC0, 0x67, 0x03, 0x86, 0x07, 0x38, 0x1C, 0x30, 0x39, 0xC1, 0xC1, 0x81,
  0x8E, 0x0E, 0x1C, 0x1C, 0x70, 0x70, 0xE0, 0xE3, 0x83, 0x07, 0x06, 0x1C,
  0x38, 0x38, 0x70, 0xE1, 0xC1, 0xC3, 0x87, 0x0E, 0x0E, 0x18, 0x38, 0xE0,
  0x71, 0xC1, 0xC7, 0x03, 0x8E, 0x0E, 0x38, 0x1C, 0x60, 0x71, 0x80, 0xE7,
  0x03, 0x9C, 0x07, 0x38, 0x1C, 0xE0, 0x39, 0x80, 0xE7, 0x01, 0xDC, 0x07,
  0x70, 0x0E, 0xE0, 0x1B, 0x80, 0x76, 0x00, 0xDC, 0x03, 0xF0, 0x06, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3E,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x70,
  0x00, 0x07, 0x80, 0x38, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x03, 0xC0, 0x07,
  0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0xE0, 0x01, 0xC0, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x0E, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x07, 0x78, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x1E, 0x38,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0F, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0x1C, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x01, 0xEE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0x70, 0x70, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0xE0, 0x1C, 0x00, 0x3C, 0x03, 0x80, 0x0F, 0x00, 0x78, 0x01, 0xC0,
  0x07, 0x00, 0x78, 0x00, 0xE0, 0x1E, 0x00, 0x1E, 0x03, 0x80, 0x01, 0xC0,
  0xF0, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x07, 0x00, 0x00, 0x71, 0xE0, 0x00,
  0x0E, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1F, 0xF0, 0x0F,
  0xF8, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x06, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x06, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x06,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x06, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x1C,
  0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xEC, 0x00, 0x39, 0xC0, 0x0F, 0x38, 0x01, 0xC7, 0x00, 0x70, 0xE0,
  0x0E, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x1C, 0x07, 0x07, 0x80, 0x60,
  0xE0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0x7E,
  0x00, 0x0E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xF0,
  0xE1, 0xE1, 0xC1, 0xC3, 0x83, 0x80, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x7E, 0x0F, 0xC0, 0x7C, 0x01, 0xF0, 0x78, 0x00,
  0x78, 0x38, 0x00, 0x1C, 0x3C, 0x00, 0x0F, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F, 0x80, 0x0E, 0x1E,
  0x00, 0x07, 0x1E, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xCF, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0xF3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x78, 0xE0, 0x00, 0x7C,
  0x78, 0x00, 0x7E, 0x1E, 0x00, 0xF7, 0x0F, 0xE3, 0xF3, 0x83, 0xFF, 0xF1,
  0xC0, 0x7F, 0xE0, 0xE0, 0x02, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x0F,
  0xF8, 0x01, 0xCF, 0xFF, 0x80, 0x77, 0xC3, 0xF0, 0x1F, 0xC0, 0x3C, 0x07,
  0xC0, 0x07, 0x83, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0x38, 0x38, 0x00, 0x0F,
  0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x78, 0x00,
  0x07, 0x1C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x3C, 0x70,
  0x00, 0x0E, 0x1C, 0x00, 0x03, 0x8F, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x78,
  0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x03, 0xC3, 0x80, 0x01,
  0xE1, 0xF0, 0x00, 0x70, 0x7E, 0x00, 0x3C, 0x1F, 0xC0, 0x3E, 0x07, 0x7E,
  0x7F, 0x01, 0xCF, 0xFF, 0x80, 0xE0, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xF0, 0xFC,
  0x07, 0x80, 0x1E, 0x0F, 0x00, 0x0E, 0x1E, 0x00, 0x0F, 0x1C, 0x00, 0x07,
  0x3C, 0x00, 0x07, 0x38, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xF0, 0x00, 0x38,
  0x70, 0x00, 0x78, 0x78, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x1F, 0x0F, 0xC0,
  0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x06,
  0x01, 0xC0, 0x0F, 0xFC, 0x38, 0x03, 0xFF, 0xC7, 0x01, 0xF8, 0x7D, 0xE0,
  0x3C, 0x01, 0xF8, 0x0F, 0x00, 0x1F, 0x03, 0xC0, 0x01, 0xE0, 0xF0, 0x00,
  0x3C, 0x1C, 0x00, 0x03, 0x87, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x1C, 0x1C,
  0x00, 0x03, 0x87, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x78, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x38, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x3C,
  0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x3C, 0x07, 0x80,
  0x0F, 0x80, 0xF8, 0x07, 0xF0, 0x0F, 0xC7, 0xEC, 0x00, 0xFF, 0xF3, 0x80,
  0x0F, 0xFC, 0x70, 0x00, 0x10, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xE1, 0xF8, 0x03, 0xE0, 0x1E, 0x01,
  0xE0, 0x03, 0xC0, 0xF0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x03,
  0x8F, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x70, 0x00,
  0x03, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x08, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x07, 0xC0, 0x3E,
  0x0F, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xFE, 0x1C, 0x01, 0xFF,
  0xE3, 0x80, 0xFE, 0x3E, 0x70, 0x3E, 0x00, 0xFE, 0x07, 0x80, 0x0F, 0x81,
  0xE0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x78, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x38, 0x70,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x3C, 0x38, 0x00, 0x07,
  0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x70, 0x70, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0x81, 0xE0, 0x00, 0xF0,
  0x1C, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0xC0, 0x7C, 0x03, 0xF8, 0x07, 0xE3,
  0xFF, 0x00, 0x7F, 0xF9, 0xC0, 0x03, 0xFE, 0x38, 0x00, 0x08, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x20, 0x00, 0x78, 0x0E, 0x00, 0x1E, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x83, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x03, 0x80, 0x07, 0x07, 0xFC, 0x01, 0xC7, 0xFF, 0x80, 0x73,
  0xE1, 0xF0, 0x1D, 0xC0, 0x1E, 0x07, 0xE0, 0x03, 0x83, 0xE0, 0x00, 0xF0,
  0xF8, 0x00, 0x1C, 0x3C, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x71, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0F, 0x1C, 0x00, 0x03, 0x87, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x3C, 0x00, 0x03, 0x8E,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07,
  0x0E, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x3C, 0x70, 0x00,
  0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0xF0,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x17, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x3E, 0x0E, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0x70, 0x01, 0xF0, 0x0E,
  0x00, 0x7C, 0x01, 0xC0, 0x1E, 0x00, 0x38, 0x07, 0x80, 0x07, 0x03, 0xE0,
  0x01, 0xE0, 0xF8, 0x00, 0x38, 0x3E, 0x00, 0x07, 0x0F, 0x00, 0x00, 0xE3,
  0xC0, 0x00, 0x1D, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0x9E, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x78, 0x1C, 0x00, 0x0E, 0x03,
  0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01,
  0xC0, 0x07, 0x80, 0x38, 0x00, 0x70, 0x07, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0xF0, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x06,
  0x00, 0x40, 0x1C, 0xFF, 0x0F, 0xF0, 0x3B, 0xFF, 0x3F, 0xF0, 0x7F, 0x1E,
  0xF1, 0xE0, 0xF8, 0x1F, 0x81, 0xE1, 0xE0, 0x3E, 0x01, 0xC3, 0x80, 0x38,
  0x03, 0x8F, 0x00, 0x70, 0x07, 0x1C, 0x01, 0xC0, 0x0E, 0x38, 0x03, 0x80,
  0x38, 0x70, 0x07, 0x00, 0x70, 0xE0, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x01,
  0xC7, 0x00, 0x38, 0x03, 0x8E, 0x00, 0xE0, 0x07, 0x1C, 0x01, 0xC0, 0x1C,
  0x38, 0x03, 0x80, 0x38, 0x70, 0x07, 0x00, 0x70, 0xE0, 0x0E, 0x00, 0xE3,
  0x80, 0x1C, 0x01, 0xC7, 0x00, 0x70, 0x03, 0x8E, 0x00, 0xE0, 0x0E, 0x1C,
  0x01, 0xC0, 0x1C, 0x38, 0x03, 0x80, 0x38, 0xE0, 0x07, 0x00, 0x71, 0xC0,
  0x1E, 0x00, 0xE3, 0x80, 0x38, 0x01, 0xC7, 0x00, 0x70, 0x07, 0x0E, 0x00,
  0xE0, 0x0E, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xC1,
  0xFF, 0x00, 0x71, 0xFF, 0xE0, 0x1C, 0xF8, 0x7C, 0x07, 0x70, 0x07, 0x83,
  0xB8, 0x00, 0xE0, 0xF8, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x0F, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x78, 0x00, 0x07, 0x1C, 0x00,
  0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C,
  0x00, 0x03, 0x8F, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C,
  0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x71, 0xE0, 0x00,
  0x3C, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x38, 0xF0, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xC1, 0xF0, 0x07, 0xC0,
  0x1E, 0x03, 0xE0, 0x03, 0xC0, 0xF0, 0x00, 0x70, 0x78, 0x00, 0x1E, 0x3C,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x0F,
  0x70, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x0E, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x7B, 0x80,
  0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x70, 0x78, 0x00, 0x3C, 0x0E, 0x00, 0x1E, 0x03, 0xC0, 0x1F,
  0x00, 0x7C, 0x1F, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x3F, 0xE0, 0x01, 0xCF, 0xFF,
  0x00, 0x1D, 0xF0, 0xF8, 0x01, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x1E, 0x03,
  0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00,
  0x0F, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07, 0x07, 0x80, 0x00, 0x70,
  0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x0F, 0x07, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1E,
  0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0xE0,
  0x00, 0x78, 0x1E, 0x00, 0x07, 0x01, 0xF0, 0x00, 0xF0, 0x1F, 0x80, 0x3E,
  0x01, 0xDF, 0x1F, 0xC0, 0x1C, 0xFF, 0xF8, 0x03, 0xC3, 0xFE, 0x00, 0x38,
  0x02, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xE1, 0xC0, 0x7F, 0xF8, 0xE0,
  0xFC, 0x1E, 0x70, 0xF8, 0x03, 0xF0, 0x78, 0x00, 0xF8, 0x78, 0x00, 0x3C,
  0x78, 0x00, 0x1E, 0x38, 0x00, 0x07, 0x3C, 0x00, 0x07, 0x9C, 0x00, 0x03,
  0x8E, 0x00, 0x01, 0xCF, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x39, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00,
  0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xE3, 0x80,
  0x00, 0xE1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x78, 0x3C, 0x00, 0x7C, 0x1F,
  0x00, 0xFE, 0x07, 0xE1, 0xFE, 0x01, 0xFF, 0xE7, 0x00, 0x3F, 0xE3, 0x80,
  0x02, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x0E, 0x0F, 0xFC, 0x38, 0x7F, 0xF8, 0x71, 0xFF, 0xF0, 0xE7,
  0x80, 0x01, 0xDC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0xFC, 0x0F, 0x80, 0xF8, 0x01, 0xE0, 0x70, 0x00, 0x78, 0x78, 0x00, 0x1C,
  0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x1C, 0x1E,
  0x00, 0x3E, 0x07, 0xE0, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x3F, 0x0C, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0xF1, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70, 0x00,
  0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x8E, 0x00, 0x03, 0x8F, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0,
  0x00, 0x3C, 0x70, 0x00, 0x1C, 0x78, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C,
  0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xE3, 0xC0, 0x01, 0xE0,
  0xE0, 0x00, 0xF0, 0x70, 0x01, 0xF8, 0x3C, 0x01, 0xDC, 0x0F, 0x87, 0xCE,
  0x03, 0xFF, 0xC7, 0x00, 0xFF, 0x87, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x1C, 0x70,
  0x00, 0x0F, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x70,
  0x38, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x03,
  0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x00, 0xE0, 0x1C, 0x00, 0x38,
  0x0E, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x00, 0x60, 0x70, 0x00,
  0x1C, 0x38, 0x00, 0x07, 0x1E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x33, 0xC0,
  0x00, 0x0E, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x3F, 0x00, 0x38, 0x03, 0xB8, 0x03, 0xC0, 0x1D, 0xC0, 0x1E, 0x00, 0xEE,
  0x01, 0xF0, 0x0E, 0x70, 0x0D, 0x80, 0x73, 0x80, 0x6C, 0x03, 0x1C, 0x07,
  0x60, 0x38, 0xE0, 0x33, 0x01, 0xC7, 0x03, 0x98, 0x0C, 0x38, 0x1C, 0xC0,
  0xE1, 0xC1, 0xC6, 0x07, 0x0E, 0x0E, 0x30, 0x70, 0x70, 0x61, 0x83, 0x81,
  0x87, 0x0E, 0x18, 0x0C, 0x30, 0x71, 0xC0, 0x63, 0x83, 0x8E, 0x03, 0x1C,
  0x1C, 0x60, 0x18, 0xC0, 0xE7, 0x00, 0xCE, 0x07, 0x30, 0x06, 0x60, 0x1B,
  0x80, 0x37, 0x00, 0xDC, 0x01, 0xB0, 0x06, 0xC0, 0x0D, 0x80, 0x3E, 0x00,
  0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x0E,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xE0,
  0x78, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x07,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x70,
  0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x07,
  0x81, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03,
  0xC0, 0x1C, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00,
  0xE0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x70,
  0x1E, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x0F,
  0x07, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x70,
  0x1C, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x18, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x00, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x71, 0xFF, 0xE0, 0x01, 0xCF, 0x07, 0xC0, 0x06, 0x70, 0x07,
  0x80, 0x39, 0xC0, 0x0F, 0x01, 0xCE, 0x00, 0x1F, 0x1F, 0x38, 0x00, 0x3F,
  0xF8, 0x60, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x38, 0x00,
};

const GFXglyph RobotoMono_LightItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 10, 39, 32, 11, -39 },
  { 50, 12, 12, 32, 13, -41 },
  { 68, 32, 39, 32, 1, -39 },
  { 224, 27, 51, 32, 3, -45 },
  { 397, 27, 41, 32, 3, -40 },
  { 536, 28, 41, 32, 2, -40 },
  { 680, 5, 12, 32, 15, -41 },
  { 688, 17, 57, 32, 9, -44 },
  { 810, 17, 57, 32, 5, -44 },
  { 932, 24, 24, 32, 7, -39 },
  { 1004, 27, 28, 32, 3, -32 },
  { 1099, 8, 13, 32, 6, -5 },
  { 1112, 20, 3, 32, 6, -19 },
  { 1120, 5, 5, 32, 12, -5 },
  { 1124, 26, 42, 32, 4, -39 },
  { 1261, 26, 41, 32, 4, -40 },
  { 1395, 15, 39, 32, 8, -39 },
  { 1469, 27, 40, 32, 1, -40 },
  { 1604, 27, 41, 32, 1, -40 },
  { 1743, 28, 39, 32, 1, -39 },
  { 1880, 28, 40, 32, 4, -39 },
  { 2020, 24, 40, 32, 3, -39 },
  { 2140, 26, 39, 32, 6, -39 },
  { 2267, 27, 41, 32, 3, -40 },
  { 2406, 24, 40, 32, 5, -40 },
  { 2526, 10, 29, 32, 13, -29 },
  { 2563, 13, 37, 32, 10, -29 },
  { 2624, 25, 23, 32, 4, -29 },
  { 2696, 25, 14, 32, 4, -25 },
  { 2740, 25, 23, 32, 3, -29 },
  { 2812, 21, 40, 32, 8, -40 },
  { 2917, 31, 39, 32, 1, -39 },
  { 3069, 27, 39, 32, 0, -39 },
  { 3201, 28, 39, 32, 2, -39 },
  { 3338, 28, 41, 32, 3, -40 },
  { 3482, 28, 39, 32, 2, -39 },
  { 3619, 30, 39, 32, 2, -39 },
  { 3766, 29, 39, 32, 3, -39 },
  { 3908, 28, 41, 32, 3, -40 },
  { 4052, 31, 39, 32, 1, -39 },
  { 4204, 29, 39, 32, 2, -39 },
  { 4346, 29, 40, 32, 2, -39 },
  { 4491, 32, 39, 32, 2, -39 },
  { 4647, 23, 39, 32, 3, -39 },
  { 4760, 30, 39, 32, 2, -39 },
  { 4907, 31, 39, 32, 1, -39 },
  { 5059, 27, 41, 32, 3, -40 },
  { 5198, 29, 39, 32, 3, -39 },
  { 5340, 28, 47, 32, 3, -40 },
  { 5505, 28, 39, 32, 3, -39 },
  { 5642, 28, 41, 32, 3, -40 },
  { 5786, 28, 39, 32, 6, -39 },
  { 5923, 29, 40, 32, 3, -39 },
  { 6068, 27, 39, 32, 6, -39 },
  { 6200, 29, 39, 32, 5, -39 },
  { 6342, 33, 39, 32, 0, -39 },
  { 6503, 27, 39, 32, 6, -39 },
  { 6635, 29, 39, 32, 1, -39 },
  { 6777, 17, 53, 32, 8, -45 },
  { 6890, 11, 42, 32, 11, -39 },
  { 6948, 18, 53, 32, 7, -45 },
  { 7068, 19, 21, 32, 7, -39 },
  { 7118, 24, 3, 32, 1, 0 },
  { 7127, 7, 7, 32, 16, -40 },
  { 7134, 25, 31, 32, 3, -30 },
  { 7231, 26, 42, 32, 2, -41 },
  { 7368, 24, 31, 32, 4, -30 },
  { 7461, 27, 42, 32, 4, -41 },
  { 7603, 26, 31, 32, 3, -30 },
  { 7704, 28, 42, 32, 6, -42 },
  { 7851, 27, 42, 32, 2, -30 },
  { 7993, 26, 41, 32, 2, -41 },
  { 8127, 23, 40, 32, 3, -40 },
  { 8242, 25, 52, 32, 0, -40 },
  { 8405, 27, 41, 32, 3, -41 },
  { 8544, 23, 41, 32, 3, -41 },
  { 8662, 31, 30, 32, 0, -30 },
  { 8779, 26, 30, 32, 2, -30 },
  { 8877, 26, 31, 32, 3, -30 },
  { 8978, 28, 41, 32, 0, -30 },
  { 9122, 25, 41, 32, 4, -30 },
  { 9251, 23, 30, 32, 7, -30 },
  { 9338, 25, 31, 32, 4, -30 },
  { 9435, 22, 38, 32, 6, -37 },
  { 9540, 25, 30, 32, 4, -29 },
  { 9634, 26, 29, 32, 5, -29 },
  { 9729, 29, 29, 32, 4, -29 },
  { 9835, 30, 29, 32, 1, -29 },
  { 9944, 33, 41, 32, -1, -29 },
  { 10114, 28, 29, 32, 1, -29 },
  { 10216, 22, 54, 32, 8, -43 },
  { 10365, 10, 48, 32, 11, -39 },
  { 10425, 21, 54, 32, 5, -43 },
  { 10567, 30, 10, 32, 1, -21 },
};

const GFXfont RobotoMono_LightItalic55pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic55pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic55pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _ROBOTOMONO_LIGHTITALIC55PT7B_H_
