#ifndef _ROBOTOMONO_LIGHTITALIC22PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x11, 0x33, 0x22, 0x22, 0x60, 0x00, 0x4C, 0x4A, 0x73, 0x39,
  0x00, 0x01, 0x10, 0x08, 0x80, 0x8C, 0x04, 0x40, 0x62, 0x1F, 0xFC, 0x11,
  0x01, 0x08, 0x08, 0x80, 0x44, 0x04, 0x21, 0xFF, 0xC1, 0x10, 0x10, 0x80,
  0x88, 0x0C, 0x40, 0x01, 0x00, 0x20, 0x1E, 0x06, 0x61, 0x06, 0x60, 0x48,
  0x09, 0x80, 0x10, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x80, 0x90, 0x12,
  0x06, 0x61, 0x87, 0xE0, 0x20, 0x04, 0x00, 0x38, 0x09, 0x81, 0x11, 0x62,
  0x68, 0x48, 0x92, 0x1E, 0x80, 0x10, 0x04, 0x01, 0x38, 0x69, 0x89, 0x12,
  0x62, 0x88, 0x40, 0x90, 0x1E, 0x07, 0x01, 0x30, 0x42, 0x08, 0x41, 0x18,
  0x26, 0x07, 0x80, 0x40, 0x3C, 0x0C, 0x85, 0x09, 0xC1, 0xA8, 0x1D, 0x03,
  0x30, 0xE3, 0xE2, 0x55, 0x80, 0x02, 0x08, 0x20, 0x83, 0x04, 0x18, 0x20,
  0x41, 0x82, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x06, 0x04, 0x0C,
  0x08, 0x00, 0x10, 0x30, 0x20, 0x20, 0x40, 0x81, 0x81, 0x02, 0x04, 0x18,
  0x30, 0x40, 0x81, 0x06, 0x08, 0x10, 0x41, 0x82, 0x08, 0x20, 0x00, 0x04,
  0x06, 0x02, 0x11, 0x1E, 0xB8, 0xE0, 0x70, 0x48, 0x46, 0x61, 0x00, 0x02,
  0x00, 0x40, 0x18, 0x03, 0x00, 0x41, 0xFF, 0xC1, 0x00, 0x20, 0x0C, 0x01,
  0x80, 0x20, 0x00, 0x32, 0x26, 0xC0, 0x7F, 0xFF, 0xF0, 0x00, 0x40, 0x20,
  0x08, 0x04, 0x01, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x40,
  0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x00, 0x0F, 0x04, 0x62, 0x09, 0x01,
  0x40, 0x70, 0x78, 0x3E, 0x13, 0x88, 0xAC, 0x2E, 0x0A, 0x02, 0x81, 0x20,
  0x4C, 0x21, 0xF0, 0x04, 0x77, 0x61, 0x0C, 0x20, 0x82, 0x08, 0x61, 0x84,
  0x10, 0x41, 0x0C, 0x07, 0x81, 0x98, 0x41, 0x90, 0x12, 0x02, 0x00, 0xC0,
  0x10, 0x04, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07,
  0xFE, 0x0F, 0x06, 0x22, 0x05, 0x81, 0x00, 0x40, 0x10, 0x08, 0x3C, 0x1F,
  0x00, 0x60, 0x08, 0x02, 0x80, 0xA0, 0x6C, 0x31, 0xF8, 0x00, 0x60, 0x0C,
  0x03, 0x00, 0xA0, 0x24, 0x0C, 0x83, 0x10, 0x46, 0x10, 0x84, 0x11, 0x82,
  0x7F, 0xF0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x1F, 0xE3, 0xF8, 0xC0, 0x10,
  0x02, 0x00, 0x40, 0x1F, 0x83, 0x18, 0x01, 0x80, 0x10, 0x02, 0x00, 0x48,
  0x19, 0x02, 0x30, 0xC3, 0xE0, 0x01, 0x81, 0xC0, 0x80, 0x40, 0x30, 0x08,
  0x05, 0xF1, 0xC2, 0x40, 0xD0, 0x1C, 0x07, 0x03, 0xC0, 0x90, 0x66, 0x30,
  0xF8, 0x7F, 0xEF, 0xF8, 0x01, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x10,
  0x04, 0x01, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x18, 0x06, 0x00, 0x07,
  0x81, 0x98, 0x41, 0x98, 0x12, 0x02, 0x40, 0xC4, 0x10, 0xFC, 0x1F, 0x84,
  0x19, 0x01, 0x20, 0x2C, 0x04, 0x81, 0x98, 0x61, 0xF8, 0x0E, 0x0C, 0x66,
  0x09, 0x02, 0xC0, 0xF0, 0x38, 0x0F, 0x02, 0x41, 0x99, 0xA3, 0xD8, 0x04,
  0x03, 0x01, 0x80, 0xC1, 0xC0, 0x33, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x18,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0x18, 0xC4, 0x40, 0x00, 0x40, 0x60, 0xE0,
  0xE0, 0xC0, 0x30, 0x03, 0x80, 0x38, 0x03, 0x00, 0x40, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x40, 0x0C, 0x01, 0xC0, 0x0C, 0x00,
  0xC0, 0x70, 0x70, 0xE0, 0xE0, 0x20, 0x00, 0x1E, 0x19, 0x90, 0x78, 0x30,
  0x18, 0x08, 0x0C, 0x0C, 0x0C, 0x0C, 0x04, 0x06, 0x00, 0x00, 0x00, 0x80,
  0xC0, 0x03, 0x80, 0xC6, 0x10, 0x22, 0x01, 0x47, 0x94, 0x89, 0x91, 0x19,
  0x11, 0x91, 0x29, 0x12, 0x92, 0x29, 0x54, 0x99, 0x88, 0x00, 0x41, 0x03,
  0xE0, 0x01, 0x80, 0x30, 0x06, 0x01, 0x40, 0x28, 0x09, 0x01, 0x30, 0x42,
  0x08, 0x42, 0x08, 0x7F, 0x1F, 0xE2, 0x04, 0x80, 0xD0, 0x1C, 0x01, 0x1F,
  0x07, 0xF8, 0xC1, 0x90, 0x12, 0x02, 0x40, 0xC8, 0x33, 0xFC, 0x43, 0x88,
  0x19, 0x01, 0x20, 0x24, 0x05, 0x81, 0xA0, 0x67, 0xF0, 0x07, 0x83, 0x98,
  0x41, 0x90, 0x16, 0x02, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x2C, 0x0C, 0x81, 0x18, 0x41, 0xF0, 0x3E, 0x06, 0x70, 0x81, 0x10,
  0x32, 0x02, 0x40, 0x58, 0x0A, 0x01, 0x40, 0x28, 0x0D, 0x01, 0x20, 0x2C,
  0x09, 0x03, 0x21, 0xC7, 0xE0, 0x1F, 0xF3, 0xFE, 0x30, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x07, 0xF8, 0x7F, 0x84, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x0C, 0x00, 0x80, 0x0F, 0xF8, 0x1F, 0xF1, 0xFF, 0x30, 0x03, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x04, 0x7F, 0x84, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0xC0, 0x08, 0x00, 0x07, 0x83, 0x98, 0x41, 0x90, 0x16, 0x02,
  0x80, 0x10, 0x02, 0x00, 0xC0, 0x38, 0x7A, 0x01, 0x60, 0x2C, 0x04, 0x80,
  0x98, 0x61, 0xF8, 0x20, 0x12, 0x03, 0x20, 0x22, 0x02, 0x20, 0x26, 0x02,
  0x40, 0x67, 0xFE, 0x7F, 0xC4, 0x04, 0xC0, 0x4C, 0x04, 0x80, 0xC8, 0x08,
  0x80, 0x88, 0x08, 0x1F, 0xE7, 0xFC, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01,
  0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x10, 0x02, 0x07,
  0xFC, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x18, 0x03, 0x00, 0x48, 0x09, 0x03, 0x10, 0xC3, 0xF0, 0x10,
  0x19, 0x81, 0x0C, 0x10, 0x41, 0x02, 0x10, 0x11, 0x00, 0x90, 0x0D, 0x80,
  0x74, 0x03, 0x30, 0x10, 0x80, 0x86, 0x04, 0x10, 0x60, 0xC3, 0x02, 0x10,
  0x18, 0x10, 0x08, 0x04, 0x06, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x30,
  0x10, 0x08, 0x04, 0x02, 0x03, 0x01, 0xFF, 0x30, 0x33, 0x03, 0x30, 0x73,
  0x06, 0x28, 0xA6, 0x9A, 0x49, 0x24, 0xB6, 0x4A, 0x44, 0xE4, 0x44, 0x4C,
  0x04, 0x80, 0x48, 0x0C, 0x80, 0x88, 0x08, 0x30, 0x33, 0x03, 0x30, 0x23,
  0x82, 0x28, 0x26, 0x82, 0x4C, 0x64, 0x46, 0x44, 0x44, 0x64, 0x42, 0x4C,
  0x24, 0x81, 0xC8, 0x18, 0x81, 0x88, 0x08, 0x07, 0x83, 0x98, 0x41, 0x10,
  0x16, 0x02, 0x80, 0x50, 0x0A, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0x60, 0x2C,
  0x0C, 0x81, 0x18, 0xC1, 0xF0, 0x1F, 0x81, 0x0C, 0x30, 0x23, 0x03, 0x20,
  0x32, 0x03, 0x20, 0x22, 0x06, 0x7F, 0xC7, 0xE0, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0xC0, 0x08, 0x00, 0x07, 0x83, 0x98, 0xC1, 0x90, 0x16, 0x02,
  0x80, 0x50, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x2C, 0x0C, 0x81,
  0x18, 0x41, 0xF0, 0x03, 0x00, 0x30, 0x02, 0x00, 0x1F, 0x02, 0x38, 0xC1,
  0x90, 0x12, 0x02, 0x40, 0x48, 0x1B, 0x06, 0x7F, 0x88, 0x41, 0x04, 0x20,
  0x84, 0x19, 0x81, 0x30, 0x24, 0x06, 0x07, 0x83, 0x98, 0xC1, 0x90, 0x12,
  0x02, 0x40, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x10, 0x01, 0x00, 0x28, 0x05,
  0x81, 0x98, 0x61, 0xF8, 0x7F, 0xFF, 0xFC, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x04,
  0x00, 0x80, 0x20, 0x12, 0x03, 0x20, 0x22, 0x02, 0x20, 0x26, 0x02, 0x40,
  0x64, 0x06, 0x40, 0x44, 0x04, 0x40, 0x4C, 0x04, 0xC0, 0xC4, 0x08, 0x63,
  0x03, 0xE0, 0xC0, 0x28, 0x0D, 0x01, 0x20, 0x64, 0x08, 0x81, 0x18, 0x43,
  0x08, 0x22, 0x04, 0x40, 0x98, 0x12, 0x02, 0xC0, 0x70, 0x06, 0x00, 0x80,
  0xC6, 0x38, 0x62, 0x86, 0x28, 0xA2, 0x8A, 0x68, 0xA4, 0x92, 0x49, 0x2C,
  0x92, 0x8A, 0x28, 0xA2, 0x8A, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x08, 0x20,
  0x10, 0x08, 0xC0, 0xC2, 0x0C, 0x10, 0xC0, 0x44, 0x02, 0x60, 0x1E, 0x00,
  0x60, 0x03, 0x00, 0x28, 0x03, 0x60, 0x31, 0x01, 0x08, 0x10, 0x21, 0x81,
  0x18, 0x0C, 0xC0, 0x28, 0x0D, 0x03, 0x30, 0x42, 0x18, 0x42, 0x0C, 0x80,
  0xB0, 0x14, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x1F, 0xF0, 0x03, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20,
  0x06, 0x00, 0x40, 0x08, 0x01, 0x80, 0x30, 0x02, 0x00, 0x40, 0x0F, 0xFC,
  0x1E, 0x20, 0x40, 0x81, 0x02, 0x0C, 0x18, 0x20, 0x40, 0x81, 0x02, 0x0C,
  0x10, 0x20, 0x40, 0x81, 0x06, 0x0F, 0x00, 0x82, 0x10, 0x84, 0x20, 0x84,
  0x21, 0x08, 0x21, 0x08, 0x42, 0x08, 0x1E, 0x0C, 0x18, 0x20, 0x40, 0x81,
  0x02, 0x0C, 0x10, 0x20, 0x40, 0x81, 0x06, 0x08, 0x10, 0x20, 0x40, 0x8F,
  0x00, 0x08, 0x18, 0x50, 0xA2, 0x44, 0xD0, 0xE1, 0x82, 0xFF, 0xC0, 0xC8,
  0x80, 0x0F, 0x06, 0x62, 0x05, 0x81, 0x00, 0x43, 0xF3, 0x0D, 0x02, 0xC0,
  0xA0, 0x6C, 0x39, 0xF2, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x09, 0xC3,
  0x98, 0x83, 0x60, 0x58, 0x14, 0x05, 0x01, 0x40, 0xD0, 0x2C, 0x0A, 0x8C,
  0xBE, 0x00, 0x0F, 0x06, 0x22, 0x05, 0x81, 0x40, 0x10, 0x04, 0x03, 0x00,
  0x40, 0xD0, 0x26, 0x10, 0xF8, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x06,
  0x1E, 0xC6, 0x71, 0x06, 0x60, 0x48, 0x09, 0x03, 0x60, 0x6C, 0x08, 0x81,
  0x10, 0x23, 0x1C, 0x3F, 0x80, 0x07, 0x06, 0x63, 0x05, 0x81, 0x40, 0x5F,
  0xFC, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x18, 0xFC, 0x03, 0xC3, 0x90, 0x80,
  0x60, 0x10, 0x3F, 0xE1, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x18, 0x06, 0x01, 0x00, 0x40, 0x00, 0x0F, 0x63, 0x38, 0x83, 0x30, 0x24,
  0x04, 0x81, 0x90, 0x36, 0x04, 0x40, 0x88, 0x11, 0x8E, 0x1F, 0xC0, 0x18,
  0x02, 0x20, 0xC7, 0x70, 0x38, 0x00, 0x10, 0x04, 0x03, 0x00, 0x80, 0x20,
  0x09, 0xE2, 0x8C, 0xC1, 0x60, 0x50, 0x14, 0x05, 0x01, 0x40, 0xD0, 0x2C,
  0x0A, 0x02, 0x80, 0x80, 0x01, 0x01, 0x80, 0x00, 0x03, 0xE1, 0xF0, 0x08,
  0x04, 0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x31, 0xFF, 0x00, 0x40,
  0x30, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x00, 0x80, 0x42, 0x70, 0xF0,
  0x00, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0xC8, 0x31, 0x08,
  0x26, 0x0D, 0x81, 0xE0, 0x3E, 0x04, 0x40, 0x84, 0x10, 0xC6, 0x08, 0x80,
  0x80, 0x1F, 0x0F, 0x80, 0x40, 0x20, 0x30, 0x10, 0x08, 0x04, 0x02, 0x03,
  0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x18, 0xFF, 0x80, 0x2E, 0x63, 0x29,
  0x63, 0x14, 0x21, 0x42, 0x14, 0x21, 0x42, 0x14, 0x63, 0xC4, 0x28, 0x42,
  0x84, 0x28, 0x42, 0x27, 0x0A, 0x33, 0x05, 0x81, 0x40, 0x50, 0x14, 0x0D,
  0x03, 0xC0, 0xB0, 0x28, 0x0A, 0x02, 0x0F, 0x06, 0x62, 0x0D, 0x81, 0x40,
  0x70, 0x18, 0x06, 0x01, 0xC0, 0xD0, 0x26, 0x10, 0xF8, 0x13, 0x83, 0x98,
  0x41, 0x98, 0x12, 0x02, 0x40, 0x48, 0x09, 0x03, 0x20, 0x4C, 0x19, 0xC6,
  0x2F, 0x84, 0x00, 0x80, 0x30, 0x06, 0x00, 0x0F, 0x63, 0x38, 0x83, 0x30,
  0x24, 0x04, 0x81, 0x90, 0x36, 0x04, 0x40, 0x88, 0x11, 0x8E, 0x1F, 0xC0,
  0x18, 0x02, 0x00, 0x40, 0x08, 0x27, 0xB6, 0x54, 0x0C, 0x04, 0x02, 0x01,
  0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x00, 0x0F, 0x06, 0x32, 0x04, 0x81,
  0x20, 0x07, 0x00, 0x70, 0x02, 0x00, 0xF0, 0x26, 0x18, 0xFC, 0x0C, 0x04,
  0x02, 0x0F, 0xF8, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x04, 0x06, 0x03,
  0x00, 0x80, 0x7C, 0x40, 0xD0, 0x34, 0x0B, 0x02, 0xC0, 0xA0, 0x28, 0x1A,
  0x04, 0x81, 0x20, 0xCC, 0x71, 0xE4, 0x80, 0x60, 0x1C, 0x09, 0x06, 0x41,
  0x10, 0xC2, 0x20, 0x90, 0x24, 0x0A, 0x01, 0x80, 0x40, 0x84, 0x31, 0x86,
  0x31, 0x46, 0x29, 0x4D, 0x29, 0x29, 0x25, 0x28, 0xA5, 0x18, 0xA3, 0x08,
  0x41, 0x00, 0x30, 0x11, 0x02, 0x08, 0x40, 0xCC, 0x05, 0x80, 0x70, 0x06,
  0x00, 0xD0, 0x19, 0x81, 0x08, 0x20, 0xCC, 0x06, 0x20, 0x19, 0x00, 0x8C,
  0x0C, 0x20, 0x41, 0x04, 0x08, 0x60, 0x62, 0x01, 0x30, 0x09, 0x00, 0x50,
  0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x1E, 0x00, 0xC0, 0x00,
  0x3F, 0xEF, 0xF8, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0x7F, 0xE0, 0x01, 0x81, 0x01, 0x00, 0x80, 0xC0, 0x40,
  0x20, 0x10, 0x18, 0x18, 0x30, 0x04, 0x01, 0x00, 0x80, 0x40, 0x20, 0x30,
  0x18, 0x04, 0x02, 0x00, 0xC0, 0x11, 0x11, 0x11, 0x22, 0x22, 0x22, 0x44,
  0x44, 0x44, 0xC8, 0x18, 0x0C, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04,
  0x06, 0x01, 0x06, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x20, 0xC0,
  0x3C, 0x14, 0x21, 0xC1, 0xE0,
};

const GFXglyph RobotoMono_LightItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 4, 16, 13, 4, -16 },
  { 9, 5, 5, 13, 5, -17 },
  { 13, 13, 16, 13, 0, -16 },
  { 39, 11, 20, 13, 1, -18 },
  { 67, 11, 16, 13, 1, -16 },
  { 89, 11, 16, 13, 1, -16 },
  { 111, 2, 5, 13, 6, -17 },
  { 113, 7, 23, 13, 4, -18 },
  { 134, 7, 23, 13, 2, -18 },
  { 155, 9, 10, 13, 3, -16 },
  { 167, 11, 11, 13, 1, -13 },
  { 183, 4, 5, 13, 2, -2 },
  { 186, 8, 2, 13, 2, -8 },
  { 188, 2, 2, 13, 5, -2 },
  { 189, 10, 17, 13, 2, -16 },
  { 211, 10, 16, 13, 2, -16 },
  { 231, 6, 16, 13, 3, -16 },
  { 243, 11, 16, 13, 0, -16 },
  { 265, 10, 16, 13, 1, -16 },
  { 285, 11, 16, 13, 0, -16 },
  { 307, 11, 16, 13, 2, -16 },
  { 329, 10, 16, 13, 1, -16 },
  { 349, 11, 16, 13, 2, -16 },
  { 371, 11, 16, 13, 1, -16 },
  { 393, 10, 16, 13, 2, -16 },
  { 413, 4, 11, 13, 5, -11 },
  { 419, 5, 14, 13, 4, -11 },
  { 428, 10, 10, 13, 2, -12 },
  { 441, 11, 6, 13, 1, -10 },
  { 450, 10, 10, 13, 1, -12 },
  { 463, 9, 16, 13, 3, -16 },
  { 481, 12, 16, 13, 1, -16 },
  { 505, 11, 16, 13, 0, -16 },
  { 527, 11, 16, 13, 1, -16 },
  { 549, 11, 16, 13, 1, -16 },
  { 571, 11, 16, 13, 1, -16 },
  { 593, 12, 16, 13, 1, -16 },
  { 617, 12, 16, 13, 1, -16 },
  { 641, 11, 16, 13, 1, -16 },
  { 663, 12, 16, 13, 1, -16 },
  { 687, 11, 16, 13, 1, -16 },
  { 709, 11, 16, 13, 1, -16 },
  { 731, 13, 16, 13, 1, -16 },
  { 757, 9, 16, 13, 1, -16 },
  { 775, 12, 16, 13, 1, -16 },
  { 799, 12, 16, 13, 1, -16 },
  { 823, 11, 16, 13, 1, -16 },
  { 845, 12, 16, 13, 1, -16 },
  { 869, 11, 19, 13, 1, -16 },
  { 896, 11, 16, 13, 1, -16 },
  { 918, 11, 16, 13, 1, -16 },
  { 940, 11, 16, 13, 2, -16 },
  { 962, 12, 16, 13, 1, -16 },
  { 986, 11, 16, 13, 2, -16 },
  { 1008, 12, 16, 13, 2, -16 },
  { 1032, 13, 16, 13, 0, -16 },
  { 1058, 11, 16, 13, 2, -16 },
  { 1080, 12, 16, 13, 0, -16 },
  { 1104, 7, 21, 13, 3, -18 },
  { 1123, 5, 17, 13, 4, -16 },
  { 1134, 7, 21, 13, 3, -18 },
  { 1153, 7, 9, 13, 3, -16 },
  { 1161, 10, 1, 13, 0, 0 },
  { 1163, 3, 3, 13, 6, -16 },
  { 1165, 10, 12, 13, 1, -12 },
  { 1180, 10, 17, 13, 1, -17 },
  { 1202, 10, 12, 13, 1, -12 },
  { 1217, 11, 17, 13, 1, -17 },
  { 1241, 10, 12, 13, 1, -12 },
  { 1256, 10, 17, 13, 3, -17 },
  { 1278, 11, 17, 13, 1, -12 },
  { 1302, 10, 17, 13, 1, -17 },
  { 1324, 9, 16, 13, 1, -16 },
  { 1342, 10, 21, 13, 0, -16 },
  { 1369, 11, 17, 13, 1, -17 },
  { 1393, 9, 17, 13, 1, -17 },
  { 1413, 12, 12, 13, 0, -12 },
  { 1431, 10, 12, 13, 1, -12 },
  { 1446, 10, 12, 13, 1, -12 },
  { 1461, 11, 16, 13, 0, -12 },
  { 1483, 11, 16, 13, 1, -12 },
  { 1505, 9, 12, 13, 3, -12 },
  { 1519, 10, 12, 13, 1, -12 },
  { 1534, 9, 15, 13, 2, -15 },
  { 1551, 10, 12, 13, 2, -12 },
  { 1566, 10, 12, 13, 2, -12 },
  { 1581, 11, 12, 13, 2, -12 },
  { 1598, 12, 12, 13, 0, -12 },
  { 1616, 13, 17, 13, 0, -12 },
  { 1644, 11, 12, 13, 1, -12 },
  { 1661, 9, 21, 13, 3, -17 },
  { 1685, 4, 20, 13, 4, -16 },
  { 1695, 8, 21, 13, 2, -17 },
  { 1716, 12, 3, 13, 0, -8 },
};

const GFXfont RobotoMono_LightItalic22pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic22pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic22pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _ROBOTOMONO_LIGHTITALIC22PT7B_H_
