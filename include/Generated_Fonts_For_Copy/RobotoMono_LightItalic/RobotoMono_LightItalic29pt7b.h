#ifndef _ROBOTOMONO_LIGHTITALIC29PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC6, 0x31, 0x08, 0xC6, 0x31, 0x88, 0x46, 0x31, 0x80, 0x00,
  0x01, 0x8C, 0x00, 0x47, 0x1C, 0xF3, 0x8A, 0x28, 0x80, 0x00, 0x61, 0x00,
  0x21, 0x80, 0x30, 0x80, 0x10, 0x40, 0x08, 0x60, 0x0C, 0x20, 0x7F, 0xFE,
  0x3F, 0xFF, 0x03, 0x08, 0x01, 0x04, 0x00, 0x86, 0x00, 0xC2, 0x00, 0x43,
  0x00, 0x61, 0x83, 0xFF, 0xF8, 0x10, 0xC0, 0x18, 0x40, 0x08, 0x20, 0x04,
  0x30, 0x06, 0x10, 0x02, 0x18, 0x00, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00,
  0xF8, 0x0F, 0xF0, 0x70, 0x61, 0x80, 0x8C, 0x03, 0x30, 0x0C, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x4C, 0x01, 0x30, 0x04, 0xC0, 0x31, 0x81, 0x87, 0x1E, 0x0F, 0xE0,
  0x04, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x3C, 0x01, 0x98, 0x04, 0x20, 0x30,
  0x86, 0x82, 0x32, 0x18, 0x88, 0x66, 0x33, 0x30, 0x78, 0x80, 0x04, 0x00,
  0x30, 0x01, 0x80, 0x04, 0x70, 0x33, 0x21, 0x98, 0xC4, 0x43, 0x21, 0x0D,
  0x8C, 0x24, 0x30, 0x80, 0x46, 0x01, 0xF0, 0x01, 0xE0, 0x0F, 0xE0, 0x18,
  0xC0, 0x60, 0x80, 0xC1, 0x01, 0x06, 0x03, 0x18, 0x06, 0x60, 0x05, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xD8, 0x03, 0x18, 0x6C, 0x30, 0x90, 0x33, 0x60,
  0x36, 0xC0, 0x79, 0x80, 0x61, 0x81, 0xC3, 0x8E, 0xC3, 0xF8, 0xC0, 0x6D,
  0x25, 0xB0, 0x00, 0x81, 0x81, 0x80, 0x80, 0xC0, 0xC0, 0x40, 0x60, 0x30,
  0x30, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x01, 0x80, 0x40,
  0x04, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x60, 0x08, 0x02, 0x00, 0x80,
  0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x80, 0x60, 0x10,
  0x04, 0x03, 0x00, 0x80, 0x60, 0x18, 0x0C, 0x02, 0x01, 0x80, 0xC0, 0x60,
  0x20, 0x00, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x86, 0x1F, 0x6F, 0x3F,
  0xC0, 0xE0, 0x1A, 0x01, 0x30, 0x31, 0x8E, 0x1C, 0x40, 0x80, 0x01, 0x80,
  0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x0F, 0xFF, 0xFF, 0xFF,
  0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0,
  0x00, 0x33, 0x33, 0x66, 0xC0, 0xFF, 0xFF, 0xF8, 0x5F, 0x80, 0x00, 0x0C,
  0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40,
  0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0xC1, 0x81, 0x84, 0x06, 0x30, 0x08,
  0x80, 0x36, 0x01, 0xD8, 0x0F, 0x60, 0x69, 0x06, 0x24, 0x31, 0xB1, 0x86,
  0xCC, 0x1B, 0xC0, 0x6E, 0x01, 0x30, 0x0C, 0xC0, 0x33, 0x01, 0x84, 0x06,
  0x1C, 0x70, 0x3F, 0x00, 0x01, 0x07, 0x1F, 0x73, 0xC3, 0x02, 0x02, 0x06,
  0x06, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x18,
  0x18, 0x01, 0xE0, 0x0F, 0xF0, 0x30, 0x30, 0xC0, 0x61, 0x80, 0x46, 0x00,
  0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xE0, 0x3F, 0xC1, 0xC1, 0x86, 0x03,
  0x30, 0x0C, 0xC0, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x78,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x40, 0x01, 0x20, 0x04, 0x80, 0x33, 0x00,
  0xCC, 0x06, 0x1C, 0x70, 0x3F, 0x80, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80,
  0x1E, 0x00, 0xD8, 0x06, 0x40, 0x31, 0x00, 0x8C, 0x06, 0x30, 0x30, 0xC1,
  0x83, 0x0C, 0x08, 0x20, 0x21, 0x81, 0x8F, 0xFF, 0xFF, 0xFF, 0x00, 0x60,
  0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x07, 0xFE, 0x1F, 0xF8, 0x30,
  0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x37, 0xC0,
  0x79, 0xC0, 0xC0, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x08, 0xC0, 0x30, 0x80, 0x61, 0x81, 0x81, 0x8E, 0x01, 0xF8, 0x00, 0x00,
  0x30, 0x3F, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x06, 0x10, 0x6F,
  0xC5, 0x86, 0xE0, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0x80, 0x3C, 0x03, 0xC0,
  0x3C, 0x06, 0x60, 0xE7, 0x1C, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01,
  0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x30, 0x00, 0x80, 0x06,
  0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18,
  0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0x3F, 0xC1,
  0xC1, 0x86, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0xCC, 0x06, 0x18, 0x18,
  0x73, 0x80, 0xFC, 0x0E, 0x18, 0x60, 0x31, 0x00, 0x4C, 0x01, 0xB0, 0x06,
  0xC0, 0x13, 0x00, 0xCC, 0x06, 0x1C, 0x30, 0x3F, 0x80, 0x07, 0x81, 0xFE,
  0x30, 0x66, 0x03, 0x60, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03,
  0xC0, 0x34, 0x0F, 0x71, 0xA3, 0xF6, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18,
  0x07, 0x03, 0xE0, 0x78, 0x00, 0x11, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x73, 0x00, 0x04, 0x1C, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x06, 0x0C, 0x18, 0x60, 0xC3, 0x00, 0x00, 0x18, 0x03, 0xC0,
  0xF0, 0x1E, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x40, 0x7F, 0xFB, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x20, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x0C, 0x01, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x38, 0x01, 0x00, 0x00,
  0x0F, 0x87, 0xF9, 0xC1, 0xB0, 0x3C, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0xE0, 0x03, 0xFC, 0x06, 0x06, 0x08,
  0x02, 0x10, 0x02, 0x31, 0xF3, 0x23, 0x11, 0x66, 0x31, 0x44, 0x23, 0xCC,
  0x23, 0x88, 0x22, 0x88, 0x62, 0x88, 0x42, 0x88, 0xC6, 0x88, 0xC4, 0x8F,
  0x68, 0x86, 0x30, 0xC0, 0x00, 0x60, 0x00, 0x30, 0xC0, 0x1F, 0x80, 0x00,
  0x30, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xD0, 0x06, 0x40, 0x19, 0x00,
  0xC4, 0x03, 0x18, 0x18, 0x60, 0x61, 0x81, 0x06, 0x0C, 0x08, 0x20, 0x21,
  0xFF, 0x84, 0x03, 0x30, 0x0C, 0x80, 0x36, 0x00, 0xD0, 0x01, 0xC0, 0x04,
  0x0F, 0xC0, 0x1F, 0xF0, 0x60, 0x30, 0xC0, 0x21, 0x80, 0x63, 0x00, 0xC4,
  0x01, 0x88, 0x06, 0x30, 0x18, 0x60, 0xE0, 0xFF, 0x81, 0x81, 0xC2, 0x01,
  0x8C, 0x01, 0x98, 0x03, 0x30, 0x06, 0x60, 0x08, 0x80, 0x31, 0x00, 0xC6,
  0x0F, 0x0F, 0xF8, 0x00, 0x03, 0xE0, 0x3F, 0xC1, 0xC1, 0x8C, 0x03, 0x30,
  0x0D, 0x80, 0x36, 0x00, 0xD0, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0xA0, 0x04, 0xC0, 0x33, 0x00, 0xC4,
  0x06, 0x1C, 0x70, 0x3F, 0x80, 0x0F, 0xC0, 0x3F, 0xE0, 0x60, 0x60, 0xC0,
  0x61, 0x80, 0x42, 0x00, 0xCC, 0x01, 0x98, 0x03, 0x30, 0x06, 0x60, 0x0C,
  0x80, 0x19, 0x00, 0x36, 0x00, 0x4C, 0x01, 0x98, 0x03, 0x30, 0x04, 0x40,
  0x18, 0x80, 0x63, 0x01, 0x86, 0x3E, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x0F,
  0xFE, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x3F, 0xF8, 0x30, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x7F,
  0xF0, 0xFF, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0x08, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x3F,
  0xF8, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0x3F,
  0xC1, 0xC1, 0x8C, 0x03, 0x30, 0x0D, 0x80, 0x36, 0x00, 0x10, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x20, 0x7E, 0x81, 0xFA, 0x00, 0x68, 0x01, 0xA0,
  0x06, 0xC0, 0x13, 0x00, 0x46, 0x03, 0x1C, 0x38, 0x1F, 0x80, 0x18, 0x03,
  0x18, 0x03, 0x10, 0x02, 0x10, 0x02, 0x10, 0x02, 0x30, 0x06, 0x30, 0x06,
  0x30, 0x06, 0x20, 0x04, 0x20, 0x04, 0x3F, 0xFC, 0x60, 0x0C, 0x60, 0x0C,
  0x60, 0x0C, 0x40, 0x08, 0x40, 0x08, 0x40, 0x18, 0xC0, 0x18, 0xC0, 0x18,
  0xC0, 0x18, 0x80, 0x10, 0x0F, 0xFE, 0x3F, 0xFC, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x18, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x60, 0x0C, 0xC0, 0x31, 0x80, 0x61, 0x81, 0x83, 0x8E, 0x01, 0xF8, 0x00,
  0x0C, 0x01, 0x84, 0x03, 0x86, 0x03, 0x83, 0x03, 0x81, 0x83, 0x80, 0xC3,
  0x80, 0x43, 0x80, 0x23, 0x80, 0x33, 0x80, 0x1B, 0x80, 0x0F, 0xC0, 0x07,
  0xB0, 0x03, 0x98, 0x01, 0x06, 0x01, 0x83, 0x00, 0xC0, 0xC0, 0x60, 0x60,
  0x30, 0x18, 0x10, 0x0C, 0x08, 0x03, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80,
  0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1C, 0x03, 0x1C, 0x07, 0x1C, 0x07, 0x14,
  0x0E, 0x14, 0x0A, 0x14, 0x1A, 0x36, 0x36, 0x36, 0x36, 0x36, 0x66, 0x22,
  0x44, 0x22, 0xC4, 0x62, 0x8C, 0x63, 0x8C, 0x63, 0x0C, 0x63, 0x0C, 0x40,
  0x08, 0x40, 0x08, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0x18,
  0x03, 0x18, 0x03, 0x1C, 0x02, 0x1C, 0x02, 0x14, 0x06, 0x36, 0x06, 0x36,
  0x06, 0x32, 0x06, 0x33, 0x04, 0x21, 0x04, 0x21, 0x8C, 0x61, 0x8C, 0x60,
  0x8C, 0x60, 0xCC, 0x60, 0xC8, 0x40, 0x48, 0x40, 0x78, 0xC0, 0x78, 0xC0,
  0x38, 0xC0, 0x30, 0xC0, 0x30, 0x03, 0xC0, 0x3F, 0xC1, 0xC1, 0x8C, 0x06,
  0x30, 0x09, 0x80, 0x36, 0x00, 0xD0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x02, 0x80, 0x0A, 0x00, 0x68, 0x01, 0xA0, 0x04, 0xC0, 0x33, 0x01,
  0x86, 0x0E, 0x1C, 0x70, 0x3F, 0x00, 0x0F, 0xE0, 0x0F, 0xFC, 0x08, 0x0E,
  0x08, 0x06, 0x18, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x02, 0x10, 0x06,
  0x30, 0x0C, 0x30, 0x1C, 0x3F, 0xF0, 0x3F, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0x01, 0xF0, 0x0F, 0xF0, 0x38, 0x30, 0xC0, 0x21, 0x80, 0x66, 0x00, 0xC8,
  0x01, 0xB0, 0x01, 0x60, 0x06, 0xC0, 0x0D, 0x00, 0x1A, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xB0, 0x03, 0x20, 0x06, 0x40, 0x18, 0xC0, 0x21, 0x80, 0xC1,
  0xC7, 0x01, 0xFC, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x10, 0x0F,
  0xC0, 0x1F, 0xF0, 0x20, 0x30, 0xC0, 0x31, 0x80, 0x63, 0x00, 0xC4, 0x01,
  0x88, 0x03, 0x10, 0x0C, 0x60, 0x18, 0xC0, 0xE1, 0xFF, 0x02, 0x0C, 0x04,
  0x0C, 0x18, 0x18, 0x30, 0x30, 0x60, 0x30, 0xC0, 0x61, 0x00, 0xC2, 0x00,
  0xCC, 0x01, 0x80, 0x01, 0xF0, 0x0F, 0xF0, 0x30, 0x30, 0xC0, 0x31, 0x80,
  0x62, 0x00, 0xC4, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x60, 0x06, 0xC0, 0x0C, 0xC0,
  0x31, 0x80, 0x61, 0xC3, 0x81, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x30,
  0x06, 0x60, 0x0C, 0xC0, 0x11, 0x00, 0x22, 0x00, 0xCC, 0x01, 0x98, 0x03,
  0x30, 0x06, 0x40, 0x08, 0x80, 0x11, 0x00, 0x66, 0x00, 0xCC, 0x01, 0x98,
  0x03, 0x20, 0x04, 0x40, 0x18, 0xC0, 0x31, 0x80, 0xC1, 0x01, 0x83, 0x8E,
  0x03, 0xF0, 0x00, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xD0, 0x06, 0x40, 0x19,
  0x80, 0xC6, 0x03, 0x18, 0x18, 0x60, 0x60, 0x83, 0x02, 0x0C, 0x08, 0x20,
  0x31, 0x80, 0xC4, 0x03, 0x30, 0x0C, 0x80, 0x16, 0x00, 0x58, 0x01, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0xC1, 0x07, 0x86, 0x0F, 0x0C, 0x16, 0x18, 0x2C,
  0x70, 0xD0, 0xE1, 0xA1, 0x42, 0x46, 0x8C, 0x8D, 0x99, 0x13, 0x22, 0x66,
  0x44, 0xCD, 0x89, 0x1B, 0x16, 0x34, 0x2C, 0x78, 0x50, 0xF0, 0xE1, 0xC1,
  0xC3, 0x83, 0x07, 0x06, 0x0E, 0x0C, 0x18, 0x00, 0x0C, 0x01, 0xC3, 0x00,
  0x60, 0x40, 0x30, 0x18, 0x18, 0x06, 0x06, 0x00, 0xC3, 0x00, 0x31, 0x80,
  0x04, 0xC0, 0x01, 0xB0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03,
  0x60, 0x00, 0xD8, 0x00, 0x63, 0x00, 0x30, 0xC0, 0x18, 0x18, 0x06, 0x06,
  0x03, 0x00, 0x81, 0x80, 0x30, 0xE0, 0x0E, 0x00, 0xC0, 0x06, 0x80, 0x19,
  0x80, 0x63, 0x00, 0xC2, 0x03, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x60, 0x11,
  0x80, 0x32, 0x00, 0x6C, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x00,
  0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0x07, 0x87, 0xC3, 0x01, 0x80, 0xC0,
  0x40, 0x20, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x10, 0x08, 0x04, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x30,
  0x1F, 0x00, 0x82, 0x0C, 0x30, 0xC1, 0x04, 0x18, 0x61, 0x82, 0x08, 0x30,
  0xC3, 0x04, 0x10, 0x61, 0x86, 0x08, 0x20, 0xC0, 0x0F, 0x87, 0xC0, 0x60,
  0x30, 0x10, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30,
  0x18, 0x0C, 0x06, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08,
  0x04, 0x06, 0x1F, 0x00, 0x01, 0x00, 0x60, 0x0E, 0x03, 0xC0, 0x48, 0x19,
  0x06, 0x30, 0x86, 0x30, 0xC4, 0x09, 0x81, 0x60, 0x30, 0xFF, 0xF0, 0xE6,
  0x31, 0x00, 0x80, 0x1F, 0xC1, 0xC1, 0x86, 0x02, 0x30, 0x0C, 0x00, 0x20,
  0x00, 0x81, 0xFE, 0x1E, 0x18, 0xC0, 0x66, 0x01, 0x90, 0x04, 0x40, 0x31,
  0x81, 0xC7, 0x1F, 0x0F, 0xCC, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x8C, 0x05, 0xFC, 0x1C, 0x18, 0xE0, 0x63, 0x00,
  0xCC, 0x03, 0x30, 0x0C, 0x80, 0x32, 0x00, 0xD8, 0x02, 0x60, 0x19, 0x80,
  0x66, 0x03, 0x18, 0x1C, 0x58, 0xE3, 0x3F, 0x00, 0x03, 0x00, 0x7F, 0x06,
  0x0C, 0x60, 0x26, 0x01, 0xB0, 0x0F, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x6C, 0x02, 0x30, 0x31, 0xC7, 0x07, 0xF0, 0x00, 0x04,
  0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x30, 0x83, 0xF6,
  0x18, 0x78, 0xC0, 0xE6, 0x01, 0x98, 0x04, 0xC0, 0x13, 0x00, 0xCC, 0x03,
  0x30, 0x0C, 0xC0, 0x33, 0x00, 0x8C, 0x06, 0x10, 0x38, 0x71, 0xE0, 0xFD,
  0x80, 0x03, 0x80, 0x7F, 0x06, 0x0C, 0x60, 0x26, 0x01, 0xA0, 0x0F, 0x00,
  0x7F, 0xFF, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x11,
  0xC3, 0x83, 0xF0, 0x00, 0xFE, 0x03, 0x84, 0x0C, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x00, 0x7F, 0xF8, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x1F,
  0x90, 0xC3, 0xC6, 0x07, 0x30, 0x0C, 0xC0, 0x36, 0x00, 0x98, 0x06, 0x60,
  0x19, 0x80, 0x66, 0x01, 0x98, 0x04, 0x60, 0x30, 0x81, 0xC3, 0x8F, 0x07,
  0xEC, 0x00, 0x30, 0x00, 0x88, 0x06, 0x30, 0x30, 0x73, 0x80, 0xFC, 0x00,
  0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x0C,
  0x04, 0xFC, 0x16, 0x18, 0xE0, 0x33, 0x00, 0xCC, 0x03, 0x30, 0x0C, 0x80,
  0x26, 0x00, 0x98, 0x06, 0x60, 0x19, 0x80, 0x64, 0x01, 0x90, 0x04, 0xC0,
  0x13, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x03, 0x00, 0x78, 0x3F, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x8C, 0x06, 0x18, 0x38,
  0x20, 0xC0, 0xC3, 0x01, 0x8C, 0x03, 0x70, 0x07, 0xC0, 0x0E, 0xC0, 0x19,
  0x80, 0x61, 0x80, 0xC1, 0x81, 0x83, 0x03, 0x03, 0x04, 0x03, 0x18, 0x07,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0x03, 0x04,
  0x3F, 0x9F, 0x38, 0xE3, 0x30, 0xC1, 0x20, 0xC1, 0x20, 0xC3, 0x60, 0x83,
  0x60, 0x83, 0x61, 0x82, 0x41, 0x82, 0x41, 0x82, 0x41, 0x86, 0xC1, 0x06,
  0xC1, 0x06, 0xC3, 0x04, 0x83, 0x04, 0x00, 0xC0, 0x4F, 0xC1, 0x61, 0x8E,
  0x02, 0x30, 0x0C, 0xC0, 0x32, 0x00, 0xC8, 0x02, 0x60, 0x09, 0x80, 0x66,
  0x01, 0x98, 0x06, 0x40, 0x19, 0x00, 0x4C, 0x01, 0x30, 0x0C, 0x01, 0xC0,
  0x1F, 0xC1, 0xC1, 0x86, 0x06, 0x30, 0x0D, 0x80, 0x36, 0x00, 0xD8, 0x03,
  0x40, 0x0D, 0x00, 0x34, 0x00, 0x90, 0x06, 0x60, 0x11, 0x80, 0xC3, 0x8E,
  0x07, 0xE0, 0x00, 0x40, 0x17, 0xF0, 0x38, 0x70, 0xE0, 0x61, 0x80, 0x43,
  0x00, 0xC6, 0x01, 0x88, 0x03, 0x10, 0x06, 0x60, 0x08, 0xC0, 0x31, 0x80,
  0x63, 0x01, 0x86, 0x07, 0x1B, 0x1C, 0x33, 0xE0, 0x60, 0x00, 0xC0, 0x01,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x7E, 0x46,
  0x1E, 0x60, 0x76, 0x01, 0xB0, 0x0B, 0x00, 0x58, 0x06, 0xC0, 0x36, 0x01,
  0xB0, 0x0D, 0x80, 0x4C, 0x06, 0x20, 0x31, 0xC7, 0x87, 0xEC, 0x00, 0x60,
  0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x30, 0xCF, 0xC5,
  0xC0, 0x38, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x7F, 0x0E, 0x0C, 0x60, 0x32, 0x01, 0x90, 0x00, 0xC0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0x00, 0x0C, 0x00, 0x6C, 0x03, 0x60, 0x19, 0xC3, 0x87, 0xF0,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0xFF, 0xF0, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00,
  0x18, 0x01, 0xC4, 0x0F, 0xC0, 0x30, 0x09, 0x00, 0xD8, 0x06, 0xC0, 0x36,
  0x01, 0xB0, 0x09, 0x00, 0x48, 0x06, 0xC0, 0x36, 0x01, 0xB0, 0x0D, 0x80,
  0xC4, 0x0E, 0x38, 0xD0, 0xFD, 0x80, 0x80, 0x1E, 0x00, 0xB0, 0x0C, 0x80,
  0x44, 0x06, 0x30, 0x61, 0x83, 0x04, 0x30, 0x21, 0x01, 0x98, 0x0C, 0x80,
  0x2C, 0x01, 0x40, 0x0E, 0x00, 0x60, 0x00, 0xC1, 0x03, 0x86, 0x0F, 0x0C,
  0x16, 0x1C, 0x6C, 0x58, 0xD8, 0xB1, 0x33, 0x66, 0x64, 0x48, 0xD8, 0x91,
  0xA1, 0x63, 0x42, 0x83, 0x87, 0x06, 0x0C, 0x0C, 0x18, 0x10, 0x30, 0x00,
  0x18, 0x07, 0x0C, 0x06, 0x06, 0x0C, 0x06, 0x18, 0x03, 0x30, 0x01, 0x60,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x06, 0x60, 0x0E, 0x20, 0x0C, 0x30,
  0x18, 0x18, 0x30, 0x18, 0xE0, 0x0C, 0x30, 0x01, 0x8C, 0x01, 0x86, 0x01,
  0x83, 0x00, 0xC0, 0x80, 0xC0, 0x60, 0x40, 0x30, 0x60, 0x18, 0x60, 0x04,
  0x30, 0x03, 0x30, 0x01, 0x90, 0x00, 0x58, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x10, 0x07, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x0C, 0x03, 0x80, 0x60, 0x0F, 0x00, 0x18, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x01, 0x00, 0x08, 0xC6, 0x31, 0x08, 0x42, 0x31, 0x88, 0x42, 0x11, 0x8C,
  0x62, 0x10, 0x8C, 0x63, 0x10, 0x84, 0x00, 0x04, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x0C, 0x03, 0x00, 0x30, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x0F,
  0x00, 0x40, 0x00, 0x3C, 0x02, 0xCE, 0x07, 0x0E, 0x1C, 0x0F, 0xE0, 0x07,
  0x80,
};

const GFXglyph RobotoMono_LightItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 5, 21, 17, 6, -21 },
  { 15, 6, 7, 17, 7, -22 },
  { 21, 17, 21, 17, 0, -21 },
  { 66, 14, 27, 17, 2, -24 },
  { 114, 14, 21, 17, 2, -21 },
  { 151, 15, 21, 17, 1, -21 },
  { 191, 3, 7, 17, 8, -22 },
  { 194, 9, 30, 17, 5, -23 },
  { 228, 10, 30, 17, 2, -23 },
  { 266, 12, 13, 17, 4, -21 },
  { 286, 14, 15, 17, 2, -17 },
  { 313, 4, 7, 17, 3, -3 },
  { 317, 11, 2, 17, 3, -10 },
  { 320, 3, 3, 17, 6, -3 },
  { 322, 14, 23, 17, 2, -21 },
  { 363, 14, 21, 17, 2, -21 },
  { 400, 8, 21, 17, 4, -21 },
  { 421, 15, 21, 17, 0, -21 },
  { 461, 14, 21, 17, 1, -21 },
  { 498, 14, 21, 17, 1, -21 },
  { 535, 15, 21, 17, 2, -21 },
  { 575, 12, 21, 17, 2, -21 },
  { 607, 14, 21, 17, 3, -21 },
  { 644, 14, 21, 17, 2, -21 },
  { 681, 12, 21, 17, 3, -21 },
  { 713, 5, 15, 17, 7, -15 },
  { 723, 7, 19, 17, 5, -15 },
  { 740, 13, 12, 17, 2, -15 },
  { 760, 13, 7, 17, 2, -13 },
  { 772, 13, 12, 17, 2, -15 },
  { 792, 11, 21, 17, 4, -21 },
  { 821, 16, 21, 17, 1, -21 },
  { 863, 14, 21, 17, 0, -21 },
  { 900, 15, 21, 17, 1, -21 },
  { 940, 14, 21, 17, 2, -21 },
  { 977, 15, 21, 17, 1, -21 },
  { 1017, 16, 21, 17, 1, -21 },
  { 1059, 16, 21, 17, 1, -21 },
  { 1101, 14, 21, 17, 2, -21 },
  { 1138, 16, 21, 17, 1, -21 },
  { 1180, 15, 21, 17, 1, -21 },
  { 1220, 15, 21, 17, 1, -21 },
  { 1260, 17, 21, 17, 1, -21 },
  { 1305, 12, 21, 17, 2, -21 },
  { 1337, 16, 21, 17, 1, -21 },
  { 1379, 16, 21, 17, 1, -21 },
  { 1421, 14, 21, 17, 2, -21 },
  { 1458, 16, 21, 17, 1, -21 },
  { 1500, 15, 25, 17, 1, -21 },
  { 1547, 15, 21, 17, 1, -21 },
  { 1587, 15, 21, 17, 1, -21 },
  { 1627, 15, 21, 17, 3, -21 },
  { 1667, 15, 21, 17, 2, -21 },
  { 1707, 14, 21, 17, 3, -21 },
  { 1744, 15, 21, 17, 3, -21 },
  { 1784, 18, 21, 17, 0, -21 },
  { 1832, 15, 21, 17, 3, -21 },
  { 1872, 16, 21, 17, 0, -21 },
  { 1914, 9, 28, 17, 4, -24 },
  { 1946, 6, 23, 17, 6, -21 },
  { 1964, 9, 28, 17, 4, -24 },
  { 1996, 11, 12, 17, 3, -21 },
  { 2013, 12, 1, 17, 1, 0 },
  { 2015, 4, 4, 17, 8, -21 },
  { 2017, 14, 16, 17, 1, -16 },
  { 2045, 14, 22, 17, 1, -22 },
  { 2084, 13, 16, 17, 2, -16 },
  { 2110, 14, 22, 17, 2, -22 },
  { 2149, 13, 16, 17, 2, -16 },
  { 2175, 15, 22, 17, 3, -22 },
  { 2217, 14, 22, 17, 1, -16 },
  { 2256, 14, 22, 17, 1, -22 },
  { 2295, 12, 21, 17, 2, -21 },
  { 2327, 13, 27, 17, 0, -21 },
  { 2371, 15, 22, 17, 1, -22 },
  { 2413, 12, 22, 17, 2, -22 },
  { 2446, 16, 16, 17, 0, -16 },
  { 2478, 14, 16, 17, 1, -16 },
  { 2506, 14, 16, 17, 1, -16 },
  { 2534, 15, 22, 17, 0, -16 },
  { 2576, 13, 22, 17, 2, -16 },
  { 2612, 13, 16, 17, 3, -16 },
  { 2638, 13, 16, 17, 2, -16 },
  { 2664, 12, 19, 17, 3, -19 },
  { 2693, 13, 15, 17, 2, -15 },
  { 2718, 13, 15, 17, 3, -15 },
  { 2743, 15, 15, 17, 2, -15 },
  { 2772, 16, 15, 17, 0, -15 },
  { 2802, 17, 21, 17, 0, -15 },
  { 2847, 14, 15, 17, 1, -15 },
  { 2874, 12, 29, 17, 4, -23 },
  { 2918, 5, 26, 17, 6, -21 },
  { 2935, 12, 29, 17, 2, -23 },
  { 2979, 15, 5, 17, 1, -11 },
};

const GFXfont RobotoMono_LightItalic29pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic29pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic29pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _ROBOTOMONO_LIGHTITALIC29PT7B_H_
