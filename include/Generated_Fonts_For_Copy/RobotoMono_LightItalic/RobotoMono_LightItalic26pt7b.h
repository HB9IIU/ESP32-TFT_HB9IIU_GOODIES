#ifndef _ROBOTOMONO_LIGHTITALIC26PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC4, 0x21, 0x18, 0xC6, 0x21, 0x08, 0xC0, 0x00, 0x00, 0xC6,
  0x00, 0x45, 0x34, 0xF2, 0x8A, 0x20, 0x00, 0x86, 0x03, 0x08, 0x04, 0x20,
  0x08, 0x40, 0x31, 0x87, 0xFF, 0xC0, 0x84, 0x03, 0x18, 0x04, 0x20, 0x08,
  0x40, 0x31, 0x80, 0x42, 0x0F, 0xFF, 0x82, 0x18, 0x04, 0x20, 0x18, 0x40,
  0x21, 0x00, 0x42, 0x00, 0x01, 0x80, 0x10, 0x03, 0x80, 0xFE, 0x18, 0x23,
  0x03, 0x20, 0x32, 0x01, 0x20, 0x03, 0x00, 0x18, 0x00, 0xF0, 0x03, 0x80,
  0x0C, 0x00, 0x60, 0x06, 0x80, 0x68, 0x06, 0xC0, 0xC6, 0x18, 0x3F, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x30, 0x06, 0xC0, 0xC4, 0x08, 0x42, 0x84, 0x48,
  0x4C, 0x89, 0x8F, 0x90, 0x22, 0x00, 0x60, 0x04, 0x00, 0x9E, 0x1B, 0x31,
  0x21, 0x22, 0x16, 0x21, 0x42, 0x30, 0x22, 0x03, 0xC0, 0x03, 0x80, 0x3E,
  0x03, 0x18, 0x10, 0xC1, 0x86, 0x0C, 0x20, 0x63, 0x01, 0x60, 0x0E, 0x00,
  0x70, 0x0E, 0x80, 0xC6, 0x16, 0x11, 0xE0, 0xCB, 0x03, 0xD8, 0x0C, 0xC0,
  0xE3, 0x0D, 0x0F, 0xCC, 0x69, 0x25, 0x80, 0x00, 0x81, 0x81, 0x80, 0x80,
  0x80, 0xC0, 0x40, 0x60, 0x20, 0x10, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08,
  0x02, 0x00, 0x08, 0x0C, 0x06, 0x02, 0x03, 0x03, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x03, 0x03, 0x03, 0x02, 0x06, 0x06, 0x04, 0x0C,
  0x18, 0x10, 0x30, 0x60, 0x80, 0x02, 0x00, 0x40, 0x08, 0x23, 0x1F, 0xDE,
  0x1E, 0x03, 0x80, 0xD8, 0x31, 0x0C, 0x31, 0x02, 0x00, 0x03, 0x00, 0x20,
  0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xF0, 0x40, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x08, 0x00, 0x32, 0x66, 0xC8, 0xFF, 0x80, 0xF0, 0x00,
  0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x30, 0x02,
  0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x60,
  0x04, 0x00, 0xC0, 0x08, 0x00, 0x03, 0x80, 0xFE, 0x18, 0x23, 0x03, 0x20,
  0x36, 0x03, 0x40, 0x74, 0x0F, 0xC1, 0x3C, 0x63, 0xCC, 0x29, 0x82, 0xA0,
  0x2C, 0x06, 0x80, 0x48, 0x0C, 0xC0, 0x86, 0x38, 0x3E, 0x00, 0x0E, 0x7F,
  0x94, 0x20, 0x40, 0x83, 0x06, 0x08, 0x10, 0x20, 0xC1, 0x83, 0x04, 0x08,
  0x10, 0x60, 0x01, 0xC0, 0x3F, 0x82, 0x04, 0x30, 0x33, 0x01, 0x98, 0x0C,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x3F, 0xFC, 0x03, 0x80, 0xFE,
  0x18, 0x33, 0x01, 0x20, 0x10, 0x01, 0x00, 0x30, 0x06, 0x00, 0xC0, 0xF8,
  0x01, 0xC0, 0x06, 0x00, 0x60, 0x02, 0x80, 0x68, 0x06, 0xC0, 0xC6, 0x18,
  0x3F, 0x00, 0x00, 0x70, 0x06, 0x00, 0xA0, 0x1A, 0x03, 0x20, 0x66, 0x0C,
  0x60, 0x84, 0x10, 0x43, 0x04, 0x60, 0xCC, 0x0C, 0xFF, 0xF0, 0x08, 0x00,
  0x80, 0x08, 0x01, 0x80, 0x18, 0x0F, 0xF8, 0xC0, 0x06, 0x00, 0x20, 0x01,
  0x00, 0x18, 0x00, 0x9C, 0x07, 0xF8, 0x20, 0x60, 0x03, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x60, 0x33, 0x01, 0x08, 0x18, 0x61, 0x81, 0xF8, 0x00, 0x00,
  0xC0, 0x78, 0x38, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x02, 0x7C, 0xF1, 0xDC,
  0x0B, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x14, 0x06, 0xC0, 0x8C, 0x70,
  0xF8, 0x00, 0xFF, 0xF0, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x01,
  0x00, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30,
  0x06, 0x00, 0x40, 0x0C, 0x00, 0x03, 0x80, 0xFE, 0x18, 0x33, 0x01, 0x20,
  0x12, 0x01, 0x20, 0x33, 0x02, 0x18, 0xC0, 0xF8, 0x30, 0xC6, 0x06, 0xC0,
  0x28, 0x02, 0x80, 0x28, 0x06, 0xC0, 0xC6, 0x18, 0x3F, 0x00, 0x0E, 0x07,
  0xF1, 0x83, 0x20, 0x2C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1B,
  0x07, 0x3B, 0xE3, 0xCC, 0x01, 0x00, 0x60, 0x18, 0x06, 0x03, 0x83, 0xC0,
  0x00, 0x39, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x1C, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x61, 0x84, 0x30, 0x80, 0x00,
  0x10, 0x06, 0x03, 0xC0, 0xE0, 0x78, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x40, 0x7F, 0xF7, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x20, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x00, 0xF0, 0x38, 0x1E, 0x07, 0x00, 0xC0, 0x00, 0x0E, 0x0F, 0xE6, 0x0B,
  0x03, 0x80, 0xC0, 0x30, 0x08, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x10,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x40, 0x1F, 0xC0,
  0xC0, 0x86, 0x03, 0x31, 0x84, 0x8D, 0x94, 0x44, 0x53, 0x11, 0xC8, 0x46,
  0x21, 0x19, 0x88, 0xA4, 0x22, 0x91, 0x8A, 0x6E, 0x48, 0xEE, 0x20, 0x00,
  0x40, 0x01, 0x82, 0x01, 0xF0, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x78, 0x02,
  0xC0, 0x32, 0x01, 0x90, 0x18, 0x80, 0xC4, 0x04, 0x30, 0x61, 0x82, 0x0C,
  0x3F, 0xE1, 0xFF, 0x18, 0x08, 0x80, 0x4C, 0x03, 0x40, 0x1E, 0x00, 0xC0,
  0x1F, 0xE0, 0x81, 0x84, 0x06, 0x20, 0x13, 0x00, 0x98, 0x0C, 0xC0, 0xC4,
  0x0C, 0x3F, 0xC1, 0x03, 0x18, 0x0C, 0xC0, 0x26, 0x01, 0x20, 0x09, 0x00,
  0xD8, 0x0C, 0xC1, 0xC7, 0xF8, 0x00, 0x01, 0xC0, 0x3F, 0x83, 0x06, 0x30,
  0x33, 0x00, 0x90, 0x05, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x09, 0x00, 0xC8, 0x04, 0x60, 0x61, 0x86, 0x07,
  0xE0, 0x1F, 0xE0, 0x81, 0x84, 0x04, 0x60, 0x33, 0x00, 0x98, 0x04, 0x80,
  0x24, 0x01, 0x20, 0x0B, 0x00, 0x58, 0x06, 0x80, 0x34, 0x01, 0x20, 0x1B,
  0x01, 0x98, 0x18, 0xC3, 0x87, 0xF0, 0x00, 0x1F, 0xFC, 0x60, 0x01, 0x00,
  0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x3F, 0xE0, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3F, 0xE0, 0x80, 0x02, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x00, 0x01,
  0xC0, 0x1F, 0xC0, 0xC1, 0x86, 0x06, 0x30, 0x08, 0x80, 0x36, 0x00, 0x18,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x1F, 0xB0, 0x7E, 0xC0, 0x13, 0x00, 0x44,
  0x01, 0x10, 0x0C, 0x60, 0x30, 0xC3, 0x81, 0xF8, 0x00, 0x10, 0x0C, 0xC0,
  0x33, 0x00, 0xCC, 0x02, 0x20, 0x08, 0x80, 0x22, 0x01, 0x98, 0x06, 0x7F,
  0xF9, 0x80, 0x44, 0x01, 0x10, 0x04, 0x40, 0x33, 0x00, 0xCC, 0x02, 0x20,
  0x08, 0x80, 0x22, 0x01, 0x80, 0x1F, 0xFC, 0x06, 0x00, 0x18, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x03, 0xFF,
  0x80, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x22,
  0x01, 0x8C, 0x06, 0x30, 0x30, 0x61, 0x80, 0xFC, 0x00, 0x18, 0x0E, 0x30,
  0x30, 0x40, 0xC0, 0x83, 0x03, 0x0C, 0x06, 0x30, 0x0C, 0xC0, 0x13, 0x00,
  0x2E, 0x00, 0x76, 0x01, 0xCC, 0x03, 0x0C, 0x06, 0x08, 0x08, 0x18, 0x10,
  0x10, 0x20, 0x30, 0xC0, 0x21, 0x80, 0x60, 0x18, 0x03, 0x00, 0x60, 0x08,
  0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x06,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x1F, 0xFC, 0x18, 0x0C, 0x60, 0x73,
  0x81, 0xCF, 0x0F, 0x2C, 0x28, 0x91, 0xA2, 0x4C, 0x89, 0x26, 0x65, 0x99,
  0x9C, 0x64, 0x71, 0x10, 0x84, 0x40, 0x11, 0x00, 0xCC, 0x03, 0x30, 0x08,
  0x80, 0x22, 0x00, 0x80, 0x18, 0x0C, 0x60, 0x33, 0x80, 0xCF, 0x02, 0x24,
  0x08, 0x90, 0x22, 0x61, 0x98, 0x86, 0x63, 0x19, 0x8C, 0x44, 0x11, 0x10,
  0x6C, 0x41, 0xB3, 0x02, 0xCC, 0x0E, 0x30, 0x18, 0x80, 0x62, 0x01, 0x80,
  0x01, 0x80, 0x3F, 0x03, 0x0C, 0x30, 0x33, 0x01, 0x90, 0x04, 0x80, 0x2C,
  0x01, 0x60, 0x0A, 0x00, 0xD0, 0x06, 0x80, 0x3C, 0x01, 0x60, 0x09, 0x00,
  0xC8, 0x0C, 0x60, 0x41, 0x8E, 0x07, 0xC0, 0x1F, 0xF0, 0x60, 0x61, 0x80,
  0xC4, 0x03, 0x10, 0x0C, 0x40, 0x33, 0x00, 0xCC, 0x06, 0x20, 0x30, 0xFF,
  0x82, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x1F, 0xC0, 0xC1, 0x06, 0x06, 0x30, 0x08,
  0x80, 0x26, 0x00, 0x98, 0x02, 0x40, 0x09, 0x00, 0x2C, 0x00, 0xB0, 0x06,
  0xC0, 0x1B, 0x00, 0x4C, 0x03, 0x10, 0x08, 0x60, 0x60, 0xC7, 0x01, 0xF8,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x1F, 0xE0, 0xC1, 0x84, 0x06, 0x20,
  0x11, 0x00, 0x98, 0x04, 0xC0, 0x64, 0x06, 0x20, 0x61, 0xFE, 0x18, 0x20,
  0xC1, 0x06, 0x0C, 0x20, 0x21, 0x01, 0x08, 0x0C, 0xC0, 0x26, 0x01, 0x80,
  0x01, 0xC0, 0x3F, 0xC1, 0x81, 0x84, 0x02, 0x30, 0x08, 0xC0, 0x33, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x4C, 0x01, 0x30, 0x0C, 0x60, 0x30, 0xC3, 0x81, 0xF8, 0x00, 0xFF, 0xF8,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x00, 0x20, 0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x24, 0x01,
  0x20, 0x09, 0x00, 0xD8, 0x06, 0xC0, 0x36, 0x01, 0x20, 0x09, 0x00, 0x48,
  0x06, 0x40, 0x32, 0x03, 0x18, 0x18, 0x63, 0x81, 0xF0, 0x00, 0x80, 0x0E,
  0x00, 0xB0, 0x0D, 0x80, 0x4C, 0x06, 0x20, 0x21, 0x03, 0x08, 0x10, 0x61,
  0x83, 0x08, 0x18, 0xC0, 0xC6, 0x02, 0x20, 0x13, 0x00, 0x90, 0x07, 0x80,
  0x38, 0x01, 0xC0, 0x04, 0x00, 0x43, 0x05, 0x0C, 0x34, 0x30, 0x91, 0xC2,
  0x45, 0x19, 0x14, 0x44, 0xD1, 0x12, 0x44, 0x49, 0x31, 0x64, 0x85, 0x12,
  0x14, 0x58, 0x71, 0x43, 0x85, 0x0E, 0x1C, 0x38, 0x70, 0xC1, 0x83, 0x06,
  0x00, 0x18, 0x01, 0x08, 0x06, 0x0C, 0x0C, 0x04, 0x0C, 0x06, 0x18, 0x06,
  0x30, 0x02, 0x20, 0x03, 0x60, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x02,
  0xC0, 0x06, 0x40, 0x0C, 0x60, 0x18, 0x60, 0x10, 0x20, 0x30, 0x30, 0x60,
  0x10, 0xC0, 0x18, 0xC0, 0x0E, 0x01, 0xB0, 0x08, 0x80, 0xC6, 0x0C, 0x30,
  0x40, 0x86, 0x06, 0x60, 0x32, 0x00, 0xB0, 0x05, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x1F, 0xFC,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x01, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0x60, 0x03, 0xFF, 0xC0, 0x0F, 0x18, 0x18, 0x18, 0x10, 0x10,
  0x10, 0x30, 0x30, 0x30, 0x20, 0x20, 0x20, 0x20, 0x60, 0x60, 0x60, 0x40,
  0x40, 0x40, 0xC0, 0xC0, 0xC0, 0x80, 0xF0, 0x86, 0x30, 0x84, 0x21, 0x8C,
  0x21, 0x08, 0x63, 0x08, 0x42, 0x18, 0xC2, 0x10, 0x80, 0x0F, 0x80, 0x80,
  0x40, 0x20, 0x10, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60,
  0x30, 0x10, 0x08, 0x04, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10,
  0xF8, 0x00, 0x06, 0x03, 0x03, 0xC1, 0x21, 0x11, 0x88, 0x86, 0xC3, 0x40,
  0xE0, 0x40, 0xFF, 0xE0, 0xC6, 0x30, 0x07, 0xC1, 0xC6, 0x30, 0x33, 0x01,
  0x00, 0x10, 0x03, 0x0F, 0xF3, 0x83, 0x60, 0x24, 0x02, 0xC0, 0x6C, 0x0E,
  0x61, 0xE3, 0xE6, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x33, 0xC3, 0xEE, 0x38, 0x33, 0x03, 0x20, 0x12, 0x01, 0x60, 0x16, 0x03,
  0x60, 0x34, 0x02, 0x40, 0x66, 0x04, 0xF1, 0xCD, 0xF0, 0x0F, 0x83, 0x18,
  0xC1, 0xB0, 0x14, 0x03, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x01,
  0x60, 0x66, 0x18, 0x7E, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x18, 0x3C, 0xC7, 0x36, 0x30, 0x63, 0x03, 0x10, 0x09, 0x80,
  0xC8, 0x06, 0x40, 0x22, 0x01, 0x10, 0x08, 0x80, 0xC6, 0x06, 0x18, 0xF0,
  0x7D, 0x00, 0x0F, 0x83, 0x38, 0xC1, 0xB0, 0x1C, 0x03, 0x80, 0x7F, 0xFC,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x60, 0x26, 0x18, 0x7E, 0x00, 0x00, 0xF8,
  0x1E, 0xC1, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x03, 0xFF, 0x9F, 0xFC, 0x08,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x00, 0x07, 0x98, 0xE6, 0xC6, 0x0C,
  0x60, 0x62, 0x01, 0x30, 0x19, 0x00, 0xC8, 0x06, 0x40, 0x22, 0x01, 0x10,
  0x18, 0xC0, 0xC3, 0x1E, 0x0F, 0xB0, 0x01, 0x00, 0x18, 0x80, 0x86, 0x0C,
  0x1F, 0xC0, 0x00, 0x00, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x33, 0xC3, 0x66, 0x28, 0x33, 0x01, 0x20, 0x12, 0x01, 0x60, 0x36,
  0x03, 0x60, 0x34, 0x02, 0x40, 0x2C, 0x02, 0xC0, 0x6C, 0x06, 0x00, 0x80,
  0x18, 0x02, 0x00, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x0C, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC3, 0xFF,
  0x80, 0x00, 0x10, 0x03, 0x00, 0x20, 0x00, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x06, 0x0F,
  0xC0, 0x60, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08,
  0x00, 0x40, 0x62, 0x06, 0x30, 0xE1, 0x8C, 0x0C, 0xC0, 0x4C, 0x02, 0xC0,
  0x3B, 0x01, 0x8C, 0x0C, 0x20, 0x41, 0x82, 0x06, 0x10, 0x11, 0x80, 0xC0,
  0x0F, 0xC1, 0xF8, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x20, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00,
  0x40, 0x18, 0x7F, 0xF0, 0x27, 0x3C, 0x73, 0xD8, 0xC6, 0x19, 0x0C, 0x36,
  0x18, 0x4C, 0x20, 0x98, 0x41, 0x20, 0x86, 0x43, 0x0C, 0x86, 0x1B, 0x0C,
  0x26, 0x10, 0x48, 0x20, 0x90, 0x43, 0x00, 0x33, 0xC3, 0x66, 0x28, 0x33,
  0x01, 0x20, 0x12, 0x01, 0x60, 0x36, 0x03, 0x60, 0x34, 0x02, 0x40, 0x2C,
  0x02, 0xC0, 0x6C, 0x06, 0x07, 0xC0, 0xE7, 0x0C, 0x0C, 0x40, 0x26, 0x01,
  0x20, 0x09, 0x00, 0x58, 0x02, 0xC0, 0x16, 0x01, 0x90, 0x08, 0xC0, 0xC3,
  0x1C, 0x0F, 0x80, 0x19, 0xE0, 0xFB, 0x87, 0x06, 0x30, 0x31, 0x00, 0x88,
  0x04, 0xC0, 0x26, 0x03, 0x30, 0x19, 0x00, 0x88, 0x0C, 0x60, 0x47, 0x8E,
  0x37, 0xC1, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x00, 0x0F, 0x33,
  0x9F, 0x30, 0x66, 0x02, 0x40, 0x2C, 0x06, 0x80, 0x68, 0x06, 0x80, 0x48,
  0x04, 0x80, 0xCC, 0x0C, 0x63, 0xC3, 0xE8, 0x00, 0x80, 0x08, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x31, 0xE6, 0xFC, 0xE0, 0x18, 0x02, 0x00, 0x40, 0x18,
  0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x00, 0x0F,
  0x87, 0x1C, 0x81, 0xB0, 0x16, 0x00, 0x60, 0x07, 0x00, 0x3C, 0x00, 0xC0,
  0x0E, 0x01, 0x60, 0x2E, 0x1C, 0x7E, 0x00, 0x0C, 0x03, 0x00, 0x83, 0xFF,
  0xFF, 0xC6, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0x60, 0x1F, 0x80, 0x60, 0x36, 0x03, 0x60, 0x24, 0x02, 0x40,
  0x24, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x48, 0x04, 0x80, 0xCC, 0x0C, 0x63,
  0xC7, 0xEC, 0xC0, 0x1A, 0x01, 0x90, 0x0C, 0xC0, 0xC6, 0x04, 0x10, 0x60,
  0x82, 0x06, 0x30, 0x31, 0x00, 0x98, 0x04, 0x80, 0x28, 0x01, 0xC0, 0x04,
  0x00, 0x82, 0x0E, 0x08, 0x28, 0x61, 0xA1, 0x84, 0x8F, 0x12, 0x2C, 0xC8,
  0xB2, 0x24, 0x48, 0x91, 0x42, 0xC5, 0x0A, 0x1C, 0x28, 0x60, 0xC1, 0x83,
  0x04, 0x00, 0x18, 0x06, 0x10, 0x18, 0x30, 0x60, 0x21, 0x80, 0x66, 0x00,
  0x78, 0x00, 0x60, 0x01, 0xC0, 0x06, 0x80, 0x19, 0x80, 0x21, 0x80, 0xC3,
  0x03, 0x03, 0x1C, 0x03, 0x00, 0x30, 0x06, 0x60, 0x0C, 0x40, 0x30, 0xC0,
  0x41, 0x81, 0x83, 0x06, 0x02, 0x08, 0x06, 0x30, 0x0C, 0x40, 0x09, 0x80,
  0x16, 0x00, 0x38, 0x00, 0x70, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x08,
  0x00, 0x30, 0x03, 0xC0, 0x04, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x01, 0x7F, 0xF0, 0x00, 0xC0, 0xC0, 0x20, 0x18, 0x04,
  0x01, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0xC0, 0xC0, 0x0C, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x00, 0x60,
  0x04, 0x00, 0x18, 0xC4, 0x21, 0x08, 0x46, 0x21, 0x08, 0x42, 0x31, 0x88,
  0x42, 0x10, 0x8C, 0x40, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x02, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0xC0, 0x60, 0x18,
  0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0xC0, 0xC0, 0x00,
  0x1C, 0x06, 0xEE, 0x09, 0x06, 0x32, 0x07, 0xC8, 0x02, 0x00,
};

const GFXglyph RobotoMono_LightItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 5, 18, 15, 5, -18 },
  { 13, 6, 6, 15, 6, -20 },
  { 18, 15, 18, 15, 0, -18 },
  { 52, 12, 24, 15, 2, -21 },
  { 88, 12, 19, 15, 2, -19 },
  { 117, 13, 19, 15, 1, -19 },
  { 148, 3, 6, 15, 7, -20 },
  { 151, 9, 27, 15, 4, -21 },
  { 182, 8, 27, 15, 2, -21 },
  { 209, 11, 11, 15, 3, -18 },
  { 225, 12, 13, 15, 2, -15 },
  { 245, 4, 6, 15, 3, -2 },
  { 248, 9, 1, 15, 3, -9 },
  { 250, 2, 2, 15, 6, -2 },
  { 251, 12, 20, 15, 2, -18 },
  { 281, 12, 19, 15, 2, -19 },
  { 310, 7, 18, 15, 4, -18 },
  { 326, 13, 19, 15, 0, -19 },
  { 357, 12, 19, 15, 1, -19 },
  { 386, 12, 18, 15, 1, -18 },
  { 413, 13, 18, 15, 2, -18 },
  { 443, 11, 19, 15, 2, -19 },
  { 470, 12, 18, 15, 3, -18 },
  { 497, 12, 19, 15, 2, -19 },
  { 526, 11, 19, 15, 3, -19 },
  { 553, 5, 13, 15, 6, -13 },
  { 562, 6, 17, 15, 5, -13 },
  { 575, 12, 11, 15, 2, -14 },
  { 592, 12, 7, 15, 2, -12 },
  { 603, 12, 11, 15, 1, -14 },
  { 620, 10, 19, 15, 4, -19 },
  { 644, 14, 19, 15, 1, -19 },
  { 678, 13, 18, 15, 0, -18 },
  { 708, 13, 18, 15, 1, -18 },
  { 738, 13, 19, 15, 1, -19 },
  { 769, 13, 18, 15, 1, -18 },
  { 799, 14, 18, 15, 1, -18 },
  { 831, 14, 18, 15, 1, -18 },
  { 863, 14, 19, 15, 1, -19 },
  { 897, 14, 18, 15, 1, -18 },
  { 929, 14, 18, 15, 1, -18 },
  { 961, 14, 18, 15, 1, -18 },
  { 993, 15, 18, 15, 1, -18 },
  { 1027, 11, 18, 15, 1, -18 },
  { 1052, 14, 18, 15, 1, -18 },
  { 1084, 14, 18, 15, 1, -18 },
  { 1116, 13, 19, 15, 1, -19 },
  { 1147, 14, 18, 15, 1, -18 },
  { 1179, 14, 22, 15, 1, -19 },
  { 1218, 13, 18, 15, 1, -18 },
  { 1248, 14, 19, 15, 1, -19 },
  { 1282, 13, 18, 15, 3, -18 },
  { 1312, 13, 18, 15, 2, -18 },
  { 1342, 13, 19, 15, 3, -19 },
  { 1373, 14, 18, 15, 2, -18 },
  { 1405, 16, 19, 15, 0, -19 },
  { 1443, 13, 19, 15, 3, -19 },
  { 1474, 14, 18, 15, 0, -18 },
  { 1506, 8, 25, 15, 4, -21 },
  { 1531, 5, 21, 15, 5, -19 },
  { 1545, 9, 25, 15, 3, -21 },
  { 1574, 9, 10, 15, 3, -18 },
  { 1586, 11, 1, 15, 1, 0 },
  { 1588, 4, 3, 15, 7, -19 },
  { 1590, 12, 14, 15, 1, -14 },
  { 1611, 12, 20, 15, 1, -20 },
  { 1641, 11, 14, 15, 2, -14 },
  { 1661, 13, 20, 15, 2, -20 },
  { 1694, 11, 14, 15, 2, -14 },
  { 1714, 13, 20, 15, 3, -20 },
  { 1747, 13, 20, 15, 1, -14 },
  { 1780, 12, 20, 15, 1, -20 },
  { 1810, 11, 19, 15, 1, -19 },
  { 1837, 12, 25, 15, 0, -19 },
  { 1875, 13, 20, 15, 1, -20 },
  { 1908, 11, 20, 15, 1, -20 },
  { 1936, 15, 14, 15, 0, -14 },
  { 1963, 12, 14, 15, 1, -14 },
  { 1984, 13, 14, 15, 1, -14 },
  { 2007, 13, 19, 15, 0, -14 },
  { 2038, 12, 19, 15, 2, -14 },
  { 2067, 11, 14, 15, 3, -14 },
  { 2087, 11, 14, 15, 2, -14 },
  { 2107, 10, 17, 15, 3, -17 },
  { 2129, 12, 14, 15, 2, -14 },
  { 2150, 13, 14, 15, 2, -14 },
  { 2173, 14, 14, 15, 2, -14 },
  { 2198, 15, 14, 15, 0, -14 },
  { 2225, 15, 20, 15, 0, -14 },
  { 2263, 13, 14, 15, 1, -14 },
  { 2286, 10, 25, 15, 4, -20 },
  { 2318, 5, 22, 15, 5, -18 },
  { 2332, 10, 25, 15, 2, -20 },
  { 2364, 15, 5, 15, 0, -10 },
};

const GFXfont RobotoMono_LightItalic26pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic26pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic26pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _ROBOTOMONO_LIGHTITALIC26PT7B_H_
