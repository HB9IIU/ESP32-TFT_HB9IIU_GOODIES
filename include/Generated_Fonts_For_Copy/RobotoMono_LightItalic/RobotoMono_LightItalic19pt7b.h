#ifndef _ROBOTOMONO_LIGHTITALIC19PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x96, 0x92, 0x48, 0x01, 0x00, 0x4A, 0xA5, 0x20, 0x02, 0x20,
  0x48, 0x11, 0x02, 0x23, 0xFE, 0x11, 0x02, 0x20, 0x88, 0x11, 0x1F, 0xF8,
  0x88, 0x11, 0x02, 0x40, 0x88, 0x00, 0x02, 0x01, 0x01, 0x83, 0x32, 0x09,
  0x04, 0x80, 0x40, 0x18, 0x07, 0x00, 0xC0, 0x28, 0x16, 0x09, 0x0C, 0x7C,
  0x10, 0x08, 0x00, 0x30, 0x24, 0x22, 0x31, 0x28, 0xA3, 0xA0, 0x10, 0x10,
  0x13, 0x0A, 0x49, 0x29, 0x14, 0x48, 0x38, 0x0C, 0x09, 0x0C, 0x44, 0x62,
  0x21, 0xA0, 0x60, 0x50, 0x48, 0xC2, 0x61, 0xD0, 0x68, 0x73, 0xEC, 0x56,
  0x04, 0x21, 0x0C, 0x21, 0x84, 0x10, 0x43, 0x08, 0x20, 0x82, 0x08, 0x10,
  0x41, 0x02, 0x00, 0x30, 0x40, 0x82, 0x08, 0x10, 0x41, 0x0C, 0x20, 0x82,
  0x08, 0x41, 0x08, 0x21, 0x08, 0x00, 0x04, 0x04, 0x02, 0x19, 0x33, 0xE0,
  0xC0, 0x90, 0xC8, 0x42, 0x00, 0x04, 0x02, 0x03, 0x01, 0x0F, 0xF8, 0x40,
  0x20, 0x10, 0x18, 0x08, 0x00, 0x2D, 0x28, 0xFE, 0xF0, 0x00, 0x80, 0x40,
  0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02,
  0x03, 0x00, 0x0E, 0x0C, 0x88, 0x24, 0x14, 0x0A, 0x1D, 0x12, 0x91, 0xD0,
  0xF0, 0xA0, 0x58, 0x24, 0x21, 0xE0, 0x09, 0xF3, 0x31, 0x08, 0x42, 0x11,
  0x08, 0x42, 0x10, 0x06, 0x06, 0x62, 0x08, 0x82, 0x00, 0x80, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x3F, 0xE0, 0x07, 0x06, 0x63,
  0x0C, 0x81, 0x00, 0xC0, 0x20, 0x30, 0x3C, 0x01, 0x00, 0x24, 0x09, 0x04,
  0x43, 0x0F, 0x80, 0x00, 0x80, 0x60, 0x18, 0x0A, 0x04, 0x82, 0x61, 0x10,
  0xC4, 0x21, 0x10, 0x4F, 0xFC, 0x08, 0x02, 0x00, 0x80, 0x3F, 0x9F, 0xC8,
  0x04, 0x04, 0x02, 0xC1, 0x98, 0x04, 0x03, 0x00, 0xA0, 0x90, 0x48, 0x43,
  0xC0, 0x01, 0x0E, 0x10, 0x20, 0x60, 0x5E, 0x63, 0xC1, 0x81, 0x81, 0x81,
  0xC1, 0x42, 0x3C, 0xFF, 0xFF, 0xC0, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10,
  0x18, 0x08, 0x08, 0x04, 0x04, 0x06, 0x00, 0x06, 0x0C, 0xC8, 0x24, 0x12,
  0x09, 0x04, 0x4C, 0x7C, 0x41, 0x20, 0xE0, 0x70, 0x24, 0x31, 0xF0, 0x1C,
  0x22, 0x41, 0x81, 0x81, 0x81, 0x81, 0x83, 0x6E, 0x32, 0x06, 0x04, 0x18,
  0xE0, 0x6C, 0x00, 0x00, 0x90, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x21, 0x18,
  0x8C, 0x00, 0x01, 0x0E, 0x30, 0xC0, 0xC0, 0x30, 0x0C, 0x02, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x60, 0x1C, 0x03, 0x80, 0x30, 0x30, 0xE1, 0x81,
  0x00, 0x18, 0xCE, 0x0C, 0x10, 0x20, 0x83, 0x08, 0x20, 0x40, 0x00, 0x00,
  0x08, 0x00, 0x03, 0x01, 0x98, 0x40, 0x91, 0x92, 0x4A, 0x92, 0x54, 0x4A,
  0x89, 0x92, 0x52, 0x4A, 0x76, 0x20, 0x04, 0x00, 0x7C, 0x00, 0x01, 0x01,
  0x80, 0xC0, 0xA0, 0x50, 0x48, 0x24, 0x22, 0x10, 0x9F, 0xC8, 0x28, 0x14,
  0x0C, 0x04, 0x3C, 0x11, 0x88, 0x24, 0x16, 0x0A, 0x0D, 0x1C, 0xFE, 0x41,
  0x20, 0x60, 0x70, 0x28, 0x37, 0xE0, 0x06, 0x06, 0x62, 0x09, 0x82, 0x40,
  0xD0, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x1A, 0x04, 0x42, 0x0F, 0x00,
  0x38, 0x09, 0xC2, 0x19, 0x82, 0x40, 0x90, 0x34, 0x09, 0x02, 0x40, 0xB0,
  0x28, 0x12, 0x0C, 0x86, 0x3E, 0x00, 0x3F, 0xC8, 0x02, 0x00, 0x80, 0x60,
  0x10, 0x04, 0x01, 0xFC, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x3F, 0xC0,
  0x3F, 0xC8, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0xFC, 0x40, 0x10,
  0x04, 0x02, 0x00, 0x80, 0x20, 0x00, 0x06, 0x06, 0x62, 0x09, 0x83, 0x40,
  0x10, 0x08, 0x02, 0x00, 0x87, 0xA0, 0x28, 0x1B, 0x04, 0x41, 0x0F, 0x80,
  0x10, 0x22, 0x04, 0x80, 0x90, 0x22, 0x04, 0x40, 0x88, 0x11, 0xFE, 0x40,
  0x48, 0x11, 0x02, 0x20, 0x44, 0x09, 0x81, 0x00, 0x3F, 0xCF, 0xF0, 0x40,
  0x10, 0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10,
  0x3F, 0xC0, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x18, 0x04,
  0x01, 0x00, 0x48, 0x12, 0x08, 0x86, 0x1F, 0x00, 0x20, 0x64, 0x18, 0x86,
  0x11, 0x86, 0x60, 0x98, 0x16, 0x03, 0xC0, 0x6C, 0x08, 0x83, 0x08, 0x41,
  0x08, 0x11, 0x03, 0x00, 0x20, 0x20, 0x20, 0x20, 0x20, 0x60, 0x40, 0x40,
  0x40, 0x40, 0x40, 0xC0, 0x80, 0xFF, 0x20, 0x48, 0x33, 0x0D, 0x45, 0x51,
  0x94, 0xA5, 0x69, 0x52, 0xC8, 0xA2, 0x28, 0x12, 0x04, 0x81, 0x20, 0x40,
  0x10, 0x22, 0x04, 0xE0, 0x94, 0x22, 0x84, 0x48, 0x89, 0x11, 0x22, 0x62,
  0x48, 0x51, 0x0A, 0x20, 0xC4, 0x19, 0x83, 0x00, 0x0E, 0x0C, 0x88, 0x2C,
  0x14, 0x0A, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x50, 0x24, 0x21, 0xE0,
  0x3E, 0x08, 0x62, 0x0C, 0x81, 0x20, 0x58, 0x34, 0x09, 0xFC, 0x40, 0x10,
  0x04, 0x02, 0x00, 0x80, 0x20, 0x00, 0x06, 0x06, 0x42, 0x09, 0x02, 0x40,
  0xD0, 0x18, 0x0A, 0x02, 0x80, 0xA0, 0x28, 0x12, 0x04, 0x42, 0x0F, 0x00,
  0x60, 0x0C, 0x3C, 0x08, 0xC2, 0x08, 0x82, 0x20, 0x90, 0x24, 0x19, 0xF8,
  0x44, 0x10, 0x8C, 0x22, 0x08, 0x81, 0x20, 0x40, 0x0E, 0x06, 0x62, 0x09,
  0x83, 0x40, 0x08, 0x01, 0x80, 0x38, 0x01, 0x00, 0x68, 0x0A, 0x04, 0x43,
  0x0F, 0x80, 0xFF, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x00, 0x20, 0x48, 0x16, 0x05,
  0x03, 0x40, 0x90, 0x24, 0x09, 0x02, 0x80, 0xA0, 0x48, 0x12, 0x04, 0x42,
  0x0F, 0x00, 0x80, 0xC0, 0x60, 0x68, 0x24, 0x32, 0x11, 0x08, 0x88, 0x44,
  0x24, 0x0A, 0x06, 0x03, 0x01, 0x00, 0x88, 0x62, 0x18, 0x8A, 0x52, 0x94,
  0xA5, 0x4A, 0x52, 0x94, 0xA5, 0x31, 0x8C, 0x63, 0x18, 0x84, 0x21, 0x00,
  0x30, 0x31, 0x06, 0x10, 0x40, 0x88, 0x09, 0x80, 0x50, 0x06, 0x00, 0x60,
  0x0A, 0x01, 0xB0, 0x11, 0x02, 0x10, 0x60, 0x8C, 0x0C, 0x80, 0xF0, 0x24,
  0x11, 0x0C, 0x42, 0x09, 0x02, 0x80, 0xA0, 0x10, 0x04, 0x01, 0x00, 0x80,
  0x20, 0x08, 0x00, 0x1F, 0xE4, 0x08, 0x03, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x80, 0x20, 0x08, 0x02, 0x00, 0xC0, 0x10, 0x04, 0x01, 0xFF, 0x00, 0x3C,
  0x82, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10, 0x42, 0x08, 0x20, 0x83,
  0x80, 0x88, 0x88, 0x84, 0x44, 0x44, 0x22, 0x22, 0x30, 0x3C, 0x20, 0x82,
  0x08, 0x21, 0x04, 0x10, 0x41, 0x04, 0x30, 0x82, 0x08, 0x23, 0x80, 0x08,
  0x18, 0x50, 0xA2, 0x44, 0x90, 0xE1, 0xFF, 0x80, 0xC8, 0x80, 0x1F, 0x10,
  0x90, 0x60, 0x21, 0xF3, 0x0A, 0x05, 0x06, 0x87, 0x3D, 0x80, 0x20, 0x10,
  0x08, 0x04, 0x07, 0xE3, 0x09, 0x06, 0x81, 0x40, 0xA0, 0xB0, 0x50, 0x2C,
  0x25, 0xE0, 0x1F, 0x10, 0x90, 0x28, 0x0C, 0x04, 0x02, 0x01, 0x82, 0x42,
  0x1E, 0x00, 0x00, 0x40, 0x20, 0x08, 0x02, 0x1E, 0x88, 0x64, 0x19, 0x04,
  0xC1, 0x20, 0x48, 0x13, 0x04, 0x43, 0x1F, 0x80, 0x1F, 0x10, 0x90, 0x28,
  0x1F, 0xFC, 0x02, 0x01, 0x80, 0x43, 0x1F, 0x00, 0x01, 0x01, 0xB0, 0x80,
  0x40, 0x10, 0x3F, 0xC1, 0x00, 0x40, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x06, 0x00, 0x1E, 0x90, 0xD0, 0x68, 0x2C, 0x14, 0x0A, 0x05, 0x82,
  0x43, 0x3F, 0x00, 0x80, 0x48, 0x43, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x04,
  0xF3, 0x89, 0x02, 0x81, 0x41, 0x20, 0xA0, 0x50, 0x28, 0x14, 0x18, 0x02,
  0x06, 0x00, 0x00, 0x3C, 0x04, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x08,
  0xFF, 0x01, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x08, 0x04, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x08, 0x78, 0x00, 0x30, 0x10,
  0x08, 0x04, 0x02, 0x1B, 0x19, 0x10, 0x90, 0x70, 0x34, 0x13, 0x18, 0x88,
  0x24, 0x18, 0x3E, 0x02, 0x06, 0x04, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x08,
  0x08, 0x08, 0x08, 0xFF, 0x7D, 0xCC, 0xC5, 0x10, 0xA2, 0x24, 0x44, 0x88,
  0xA1, 0x14, 0x62, 0x88, 0x51, 0x10, 0x7F, 0x30, 0x90, 0x68, 0x34, 0x12,
  0x0A, 0x05, 0x02, 0x81, 0x41, 0x80, 0x1E, 0x10, 0x90, 0x38, 0x18, 0x0C,
  0x06, 0x05, 0x02, 0x42, 0x1E, 0x00, 0x3F, 0x0C, 0x22, 0x08, 0x81, 0x20,
  0xC8, 0x24, 0x09, 0x02, 0x61, 0x17, 0x84, 0x01, 0x00, 0x80, 0x20, 0x00,
  0x1E, 0x90, 0xD0, 0x68, 0x2C, 0x14, 0x0A, 0x05, 0x82, 0x43, 0x3F, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x2F, 0x30, 0x20, 0x60, 0x40, 0x40, 0x40, 0x40,
  0x40, 0x80, 0x1F, 0x10, 0xD0, 0x2C, 0x03, 0x80, 0x30, 0x05, 0x02, 0x43,
  0x3F, 0x00, 0x18, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x3C, 0x60, 0xA0, 0x50, 0x28, 0x34, 0x12, 0x0B, 0x05, 0x82,
  0x43, 0x3F, 0x00, 0x81, 0xC0, 0xA0, 0x88, 0x44, 0x42, 0x21, 0x20, 0x70,
  0x30, 0x10, 0x00, 0x84, 0x63, 0x18, 0xCA, 0x52, 0x94, 0x95, 0x46, 0x51,
  0x94, 0x42, 0x10, 0x80, 0x30, 0x62, 0x10, 0x24, 0x05, 0x00, 0x60, 0x18,
  0x06, 0x80, 0x88, 0x21, 0x18, 0x10, 0x60, 0x24, 0x08, 0x83, 0x18, 0x41,
  0x10, 0x22, 0x04, 0x80, 0x70, 0x0C, 0x01, 0x00, 0x20, 0x08, 0x03, 0x01,
  0x80, 0x00, 0x3F, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x80, 0xC0,
  0x60, 0x3F, 0xE0, 0x02, 0x08, 0x20, 0xC1, 0x02, 0x04, 0x08, 0x21, 0x81,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x60, 0x20, 0x24, 0x92, 0x92, 0x49,
  0x29, 0x24, 0x80, 0x20, 0x30, 0x20, 0x40, 0x81, 0x02, 0x04, 0x0C, 0x0C,
  0x20, 0x81, 0x02, 0x04, 0x10, 0x20, 0x82, 0x00, 0x78, 0x28, 0x8A, 0x0E,
  0x00,
};

const GFXglyph RobotoMono_LightItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 14, 11, 4, -14 },
  { 7, 5, 4, 11, 4, -14 },
  { 10, 11, 14, 11, 0, -14 },
  { 30, 9, 18, 11, 1, -16 },
  { 51, 9, 14, 11, 1, -14 },
  { 67, 9, 14, 11, 1, -14 },
  { 83, 2, 4, 11, 5, -14 },
  { 84, 6, 19, 11, 3, -15 },
  { 99, 6, 19, 11, 2, -15 },
  { 114, 9, 9, 11, 2, -14 },
  { 125, 9, 10, 11, 1, -11 },
  { 137, 3, 5, 11, 2, -2 },
  { 139, 7, 1, 11, 2, -7 },
  { 140, 2, 2, 11, 4, -2 },
  { 141, 9, 15, 11, 1, -14 },
  { 158, 9, 14, 11, 1, -14 },
  { 174, 5, 14, 11, 3, -14 },
  { 183, 10, 14, 11, 0, -14 },
  { 201, 10, 14, 11, 0, -14 },
  { 219, 10, 14, 11, 0, -14 },
  { 237, 9, 14, 11, 2, -14 },
  { 253, 8, 14, 11, 1, -14 },
  { 267, 9, 14, 11, 2, -14 },
  { 283, 9, 14, 11, 1, -14 },
  { 299, 8, 14, 11, 2, -14 },
  { 313, 3, 10, 11, 5, -10 },
  { 317, 5, 13, 11, 3, -10 },
  { 326, 8, 8, 11, 2, -10 },
  { 334, 9, 5, 11, 1, -9 },
  { 340, 9, 8, 11, 1, -10 },
  { 349, 7, 14, 11, 3, -14 },
  { 362, 11, 14, 11, 0, -14 },
  { 382, 9, 14, 11, 0, -14 },
  { 398, 9, 14, 11, 1, -14 },
  { 414, 10, 14, 11, 1, -14 },
  { 432, 10, 14, 11, 1, -14 },
  { 450, 10, 14, 11, 1, -14 },
  { 468, 10, 14, 11, 1, -14 },
  { 486, 10, 14, 11, 1, -14 },
  { 504, 11, 14, 11, 0, -14 },
  { 524, 10, 14, 11, 1, -14 },
  { 542, 10, 14, 11, 1, -14 },
  { 560, 11, 14, 11, 1, -14 },
  { 580, 8, 14, 11, 1, -14 },
  { 594, 10, 14, 11, 1, -14 },
  { 612, 11, 14, 11, 0, -14 },
  { 632, 9, 14, 11, 1, -14 },
  { 648, 10, 14, 11, 1, -14 },
  { 666, 10, 16, 11, 1, -14 },
  { 686, 10, 14, 11, 1, -14 },
  { 704, 10, 14, 11, 1, -14 },
  { 722, 10, 14, 11, 2, -14 },
  { 740, 10, 14, 11, 1, -14 },
  { 758, 9, 14, 11, 2, -14 },
  { 774, 10, 14, 11, 2, -14 },
  { 792, 12, 14, 11, 0, -14 },
  { 813, 10, 14, 11, 2, -14 },
  { 831, 11, 14, 11, 0, -14 },
  { 851, 6, 18, 11, 3, -15 },
  { 865, 4, 15, 11, 4, -14 },
  { 873, 6, 18, 11, 3, -15 },
  { 887, 7, 8, 11, 2, -14 },
  { 894, 9, 1, 11, 0, 0 },
  { 896, 3, 3, 11, 5, -14 },
  { 898, 9, 10, 11, 1, -10 },
  { 910, 9, 14, 11, 1, -14 },
  { 926, 9, 10, 11, 1, -10 },
  { 938, 10, 14, 11, 1, -14 },
  { 956, 9, 10, 11, 1, -10 },
  { 968, 10, 15, 11, 2, -15 },
  { 987, 9, 14, 11, 1, -10 },
  { 1003, 9, 14, 11, 1, -14 },
  { 1019, 8, 14, 11, 1, -14 },
  { 1033, 9, 18, 11, 0, -14 },
  { 1054, 9, 14, 11, 1, -14 },
  { 1070, 8, 14, 11, 1, -14 },
  { 1084, 11, 10, 11, 0, -10 },
  { 1098, 9, 10, 11, 1, -10 },
  { 1110, 9, 10, 11, 1, -10 },
  { 1122, 10, 14, 11, 0, -10 },
  { 1140, 9, 14, 11, 1, -10 },
  { 1156, 8, 10, 11, 2, -10 },
  { 1166, 9, 10, 11, 1, -10 },
  { 1178, 8, 13, 11, 2, -13 },
  { 1191, 9, 10, 11, 1, -10 },
  { 1203, 9, 10, 11, 2, -10 },
  { 1215, 10, 10, 11, 1, -10 },
  { 1228, 11, 10, 11, 0, -10 },
  { 1242, 11, 14, 11, 0, -10 },
  { 1262, 10, 10, 11, 0, -10 },
  { 1275, 7, 19, 11, 3, -15 },
  { 1292, 3, 17, 11, 4, -14 },
  { 1299, 7, 19, 11, 2, -15 },
  { 1316, 11, 3, 11, 0, -7 },
};

const GFXfont RobotoMono_LightItalic19pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic19pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic19pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _ROBOTOMONO_LIGHTITALIC19PT7B_H_
