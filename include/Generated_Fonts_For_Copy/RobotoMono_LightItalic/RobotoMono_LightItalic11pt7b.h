#ifndef _ROBOTOMONO_LIGHTITALIC11PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x62, 0x74, 0x14, 0x29, 0xF9, 0x42, 0x9F, 0x94, 0x28, 0x11,
  0x93, 0x04, 0x18, 0x31, 0xF2, 0x00, 0xC5, 0x75, 0x43, 0x36, 0xA7, 0x18,
  0xA2, 0x8C, 0x56, 0x58, 0x9F, 0xC0, 0x25, 0x49, 0x24, 0x92, 0x20, 0x44,
  0x92, 0x49, 0x2A, 0x40, 0x11, 0x3E, 0xA5, 0x00, 0x21, 0x3E, 0x44, 0x00,
  0x58, 0xF0, 0x80, 0x08, 0x84, 0x42, 0x21, 0x10, 0x80, 0x32, 0x63, 0x7C,
  0xC6, 0x5C, 0x75, 0x24, 0x92, 0x39, 0x10, 0x42, 0x10, 0x84, 0x3E, 0x39,
  0x10, 0x42, 0x38, 0x28, 0x9C, 0x08, 0x61, 0x8A, 0x4B, 0xF0, 0x84, 0x7A,
  0x11, 0xE0, 0x86, 0x5E, 0x34, 0x8F, 0x99, 0x9E, 0xF8, 0x44, 0x22, 0x11,
  0x10, 0x32, 0x62, 0xAB, 0x46, 0x3E, 0x74, 0x63, 0x19, 0xB8, 0x5C, 0xC0,
  0x20, 0x60, 0x00, 0xA4, 0x0B, 0xA0, 0xC1, 0x00, 0xF8, 0x3C, 0x83, 0x06,
  0xC8, 0x00, 0x69, 0x12, 0x44, 0x08, 0x39, 0x17, 0xEB, 0xAE, 0xD8, 0x9C,
  0x10, 0xCA, 0x54, 0xBD, 0x31, 0x39, 0x14, 0x5E, 0x49, 0x14, 0x7E, 0x74,
  0x63, 0x08, 0x46, 0x5C, 0x39, 0x14, 0x51, 0x45, 0x18, 0xBC, 0x3D, 0x04,
  0x1E, 0x41, 0x04, 0x3E, 0x7C, 0x21, 0x0F, 0x42, 0x10, 0x74, 0x61, 0x0B,
  0xC6, 0x3E, 0x45, 0x14, 0x5F, 0x46, 0x18, 0xA2, 0x3C, 0x41, 0x04, 0x10,
  0x42, 0x3E, 0x04, 0x10, 0x41, 0x04, 0x28, 0x9C, 0x22, 0x89, 0x22, 0x87,
  0x0A, 0x12, 0x46, 0x44, 0x88, 0x88, 0x8F, 0x25, 0x96, 0xDB, 0x55, 0x58,
  0x62, 0x45, 0x96, 0x55, 0x55, 0x58, 0xA2, 0x74, 0x63, 0x18, 0xC6, 0x5C,
  0x74, 0x63, 0x1F, 0x42, 0x10, 0x74, 0x63, 0x18, 0xC6, 0x5C, 0x10, 0x39,
  0x14, 0x51, 0x79, 0x24, 0xA2, 0x74, 0x60, 0x83, 0x06, 0x3E, 0xFC, 0x82,
  0x08, 0x20, 0x84, 0x10, 0x8C, 0x63, 0x18, 0xC6, 0x5C, 0x86, 0x28, 0x94,
  0x51, 0x86, 0x10, 0xA6, 0x9A, 0xB6, 0xDA, 0x49, 0x24, 0x42, 0x48, 0xA0,
  0x81, 0x05, 0x12, 0x46, 0x86, 0x25, 0x14, 0x21, 0x04, 0x10, 0x7C, 0x10,
  0x84, 0x20, 0x84, 0x3E, 0x69, 0x29, 0x24, 0x92, 0x00, 0xA9, 0x55, 0x40,
  0x31, 0x11, 0x22, 0x22, 0x22, 0xC0, 0x23, 0x5D, 0xF8, 0xC0, 0x74, 0x5B,
  0x29, 0x78, 0x21, 0x07, 0x91, 0x45, 0x14, 0xBC, 0x74, 0x61, 0x09, 0x70,
  0x08, 0x5F, 0x18, 0xCA, 0x5E, 0x74, 0x7F, 0x08, 0x78, 0x3C, 0x8F, 0x88,
  0x41, 0x04, 0x10, 0x3D, 0x14, 0x52, 0x49, 0xE0, 0xBC, 0x21, 0x07, 0x91,
  0x45, 0x14, 0xA2, 0x10, 0xE2, 0x22, 0x2F, 0x08, 0x0E, 0x11, 0x08, 0x42,
  0x17, 0x00, 0x42, 0x23, 0x6C, 0x52, 0x92, 0x71, 0x22, 0x22, 0x2F, 0x7E,
  0x59, 0x65, 0xA6, 0x90, 0x79, 0x14, 0x51, 0x4A, 0x20, 0x74, 0x63, 0x19,
  0x70, 0x79, 0x14, 0x51, 0x49, 0xC8, 0x20, 0x7C, 0x63, 0x29, 0x78, 0x42,
  0x7A, 0x10, 0x88, 0x40, 0x74, 0x50, 0x69, 0x78, 0x27, 0xD0, 0x84, 0x21,
  0xC0, 0x8C, 0x63, 0x29, 0x78, 0x8C, 0x64, 0xA6, 0x20, 0xA6, 0xAE, 0xBA,
  0x92, 0x40, 0x44, 0xA1, 0x0C, 0x4A, 0x20, 0x45, 0x14, 0x8A, 0x30, 0x82,
  0x30, 0x7C, 0x21, 0x08, 0x43, 0xE0, 0x12, 0x24, 0x48, 0x44, 0x44, 0x40,
  0x55, 0x5A, 0xA0, 0x42, 0x22, 0x21, 0x22, 0x44, 0x80, 0xE6, 0x60,
};

const GFXglyph RobotoMono_LightItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 8, 6, 2, -8 },
  { 3, 3, 2, 6, 2, -8 },
  { 4, 7, 8, 6, 0, -8 },
  { 11, 5, 10, 6, 1, -9 },
  { 18, 5, 8, 6, 1, -8 },
  { 23, 6, 8, 6, 0, -8 },
  { 29, 1, 2, 6, 3, -8 },
  { 30, 3, 12, 6, 2, -9 },
  { 35, 3, 12, 6, 1, -9 },
  { 40, 5, 5, 6, 1, -8 },
  { 44, 5, 5, 6, 1, -6 },
  { 48, 2, 3, 6, 1, -1 },
  { 49, 4, 1, 6, 1, -4 },
  { 50, 1, 1, 6, 2, -1 },
  { 51, 5, 9, 6, 1, -8 },
  { 57, 5, 8, 6, 1, -8 },
  { 62, 3, 8, 6, 2, -8 },
  { 65, 6, 8, 6, 0, -8 },
  { 71, 6, 8, 6, 0, -8 },
  { 77, 6, 8, 6, 0, -8 },
  { 83, 5, 8, 6, 1, -8 },
  { 88, 4, 8, 6, 1, -8 },
  { 92, 5, 8, 6, 1, -8 },
  { 97, 5, 8, 6, 1, -8 },
  { 102, 5, 8, 6, 1, -8 },
  { 107, 2, 6, 6, 3, -6 },
  { 109, 3, 8, 6, 2, -6 },
  { 112, 5, 5, 6, 1, -6 },
  { 116, 5, 3, 6, 1, -5 },
  { 118, 5, 5, 6, 1, -6 },
  { 122, 4, 8, 6, 2, -8 },
  { 126, 6, 8, 6, 0, -8 },
  { 132, 5, 8, 6, 0, -8 },
  { 137, 6, 8, 6, 0, -8 },
  { 143, 5, 8, 6, 1, -8 },
  { 148, 6, 8, 6, 0, -8 },
  { 154, 6, 8, 6, 0, -8 },
  { 160, 5, 8, 6, 1, -8 },
  { 165, 5, 8, 6, 1, -8 },
  { 170, 6, 8, 6, 0, -8 },
  { 176, 6, 8, 6, 0, -8 },
  { 182, 6, 8, 6, 0, -8 },
  { 188, 7, 8, 6, 0, -8 },
  { 195, 4, 8, 6, 1, -8 },
  { 199, 6, 8, 6, 0, -8 },
  { 205, 6, 8, 6, 0, -8 },
  { 211, 5, 8, 6, 1, -8 },
  { 216, 5, 8, 6, 1, -8 },
  { 221, 5, 9, 6, 1, -8 },
  { 227, 6, 8, 6, 0, -8 },
  { 233, 5, 8, 6, 1, -8 },
  { 238, 6, 8, 6, 1, -8 },
  { 244, 5, 8, 6, 1, -8 },
  { 249, 6, 8, 6, 1, -8 },
  { 255, 6, 8, 6, 1, -8 },
  { 261, 7, 8, 6, 0, -8 },
  { 268, 6, 8, 6, 1, -8 },
  { 274, 6, 8, 6, 0, -8 },
  { 280, 3, 11, 6, 2, -9 },
  { 285, 2, 9, 6, 2, -8 },
  { 288, 4, 11, 6, 1, -9 },
  { 294, 4, 4, 6, 1, -8 },
  { 296, 5, 1, 6, 0, 0 },
  { 297, 2, 1, 6, 3, -8 },
  { 298, 5, 6, 6, 1, -6 },
  { 302, 6, 8, 6, 0, -8 },
  { 308, 5, 6, 6, 1, -6 },
  { 312, 5, 8, 6, 1, -8 },
  { 317, 5, 6, 6, 1, -6 },
  { 321, 6, 8, 6, 1, -8 },
  { 327, 6, 8, 6, 0, -6 },
  { 333, 6, 8, 6, 0, -8 },
  { 339, 4, 8, 6, 1, -8 },
  { 343, 5, 10, 6, 0, -8 },
  { 350, 5, 8, 6, 1, -8 },
  { 355, 4, 8, 6, 1, -8 },
  { 359, 6, 6, 6, 0, -6 },
  { 364, 6, 6, 6, 0, -6 },
  { 369, 5, 6, 6, 1, -6 },
  { 373, 6, 8, 6, 0, -6 },
  { 379, 5, 8, 6, 1, -6 },
  { 384, 5, 6, 6, 1, -6 },
  { 388, 5, 6, 6, 1, -6 },
  { 392, 5, 7, 6, 1, -7 },
  { 397, 5, 6, 6, 1, -6 },
  { 401, 5, 6, 6, 1, -6 },
  { 405, 6, 6, 6, 1, -6 },
  { 410, 6, 6, 6, 0, -6 },
  { 415, 6, 8, 6, 0, -6 },
  { 421, 6, 6, 6, 0, -6 },
  { 426, 4, 11, 6, 2, -9 },
  { 432, 2, 10, 6, 2, -8 },
  { 435, 4, 11, 6, 1, -9 },
  { 441, 6, 2, 6, 0, -4 },
};

const GFXfont RobotoMono_LightItalic11pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic11pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _ROBOTOMONO_LIGHTITALIC11PT7B_H_
