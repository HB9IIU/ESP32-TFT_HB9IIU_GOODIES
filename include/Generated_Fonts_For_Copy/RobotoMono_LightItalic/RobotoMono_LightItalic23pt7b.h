#ifndef _ROBOTOMONO_LIGHTITALIC23PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x22, 0x26, 0x64, 0x44, 0x48, 0x00, 0x88, 0x4D, 0x24, 0xB2,
  0x88, 0x01, 0x18, 0x04, 0x40, 0x21, 0x00, 0x88, 0x3F, 0xFC, 0x10, 0x80,
  0x44, 0x03, 0x10, 0x08, 0x40, 0x22, 0x0F, 0xFF, 0x04, 0x20, 0x11, 0x00,
  0x84, 0x02, 0x30, 0x18, 0x80, 0x01, 0x80, 0x10, 0x01, 0x00, 0xFC, 0x18,
  0x61, 0x02, 0x30, 0x23, 0x00, 0x10, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xC0, 0x04, 0x40, 0x44, 0x04, 0x40, 0xC6, 0x18, 0x3F, 0x00, 0xC0, 0x08,
  0x00, 0x18, 0x05, 0x81, 0x11, 0x22, 0x3C, 0x4D, 0x89, 0x12, 0x41, 0x90,
  0x02, 0x00, 0x80, 0x27, 0x8D, 0x91, 0x22, 0x44, 0x58, 0x88, 0x11, 0x03,
  0xC0, 0x03, 0x01, 0xF0, 0x62, 0x08, 0x61, 0x08, 0x23, 0x06, 0xC0, 0x60,
  0x1C, 0x06, 0x81, 0x98, 0xE1, 0x18, 0x17, 0x03, 0xB0, 0x22, 0x1E, 0x3E,
  0x60, 0x55, 0xC0, 0x02, 0x18, 0x20, 0x83, 0x04, 0x18, 0x20, 0x40, 0x83,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x02, 0x04, 0x04, 0x0C, 0x00,
  0x18, 0x10, 0x10, 0x20, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x60,
  0xC1, 0x02, 0x0C, 0x10, 0x60, 0x82, 0x0C, 0x20, 0x00, 0x04, 0x01, 0x00,
  0x43, 0xA7, 0x3F, 0x07, 0x01, 0x40, 0x98, 0xC3, 0x10, 0x80, 0x03, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x3F, 0xF8, 0x20, 0x04, 0x00, 0x80,
  0x30, 0x06, 0x00, 0x69, 0x68, 0xFF, 0x80, 0xF0, 0x00, 0x60, 0x18, 0x02,
  0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08,
  0x03, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x00, 0x06, 0x07, 0xE3, 0x0D,
  0x81, 0x40, 0x50, 0x3C, 0x1F, 0x0D, 0x84, 0x66, 0x1B, 0x0F, 0x82, 0x80,
  0xA0, 0x68, 0x13, 0x0C, 0x7C, 0x00, 0x0E, 0x79, 0x14, 0x20, 0x41, 0x83,
  0x04, 0x08, 0x10, 0x20, 0xC1, 0x82, 0x04, 0x08, 0x03, 0x00, 0xFC, 0x18,
  0x63, 0x02, 0x20, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x02, 0xFF, 0xC0, 0x03, 0x03,
  0xF8, 0xC1, 0x10, 0x36, 0x06, 0x00, 0xC0, 0x10, 0x0C, 0x0F, 0x00, 0x70,
  0x02, 0x00, 0x60, 0x0D, 0x01, 0x20, 0x66, 0x18, 0x7E, 0x00, 0x00, 0x60,
  0x0E, 0x00, 0xA0, 0x16, 0x02, 0x60, 0x64, 0x0C, 0x41, 0x84, 0x10, 0x42,
  0x0C, 0x40, 0x8F, 0xFF, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x1F, 0xE2,
  0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x1F, 0xC3, 0x0C, 0x00, 0x80, 0x18,
  0x03, 0x00, 0x48, 0x09, 0x03, 0x10, 0xC1, 0xF0, 0x03, 0xC3, 0x01, 0x80,
  0x40, 0x20, 0x09, 0xC5, 0x99, 0x83, 0x40, 0x50, 0x1C, 0x07, 0x01, 0x40,
  0xD0, 0x26, 0x18, 0xF8, 0xFF, 0xC0, 0x30, 0x08, 0x04, 0x03, 0x00, 0x80,
  0x60, 0x10, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x10, 0x0C, 0x02, 0x00,
  0x01, 0x00, 0xFC, 0x18, 0x21, 0x03, 0x30, 0x33, 0x02, 0x30, 0x21, 0x8C,
  0x0F, 0x83, 0x0C, 0x60, 0x44, 0x06, 0x40, 0x6C, 0x04, 0x40, 0xC6, 0x18,
  0x3F, 0x00, 0x06, 0x07, 0xE3, 0x09, 0x83, 0x40, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0xD0, 0x73, 0xE8, 0x62, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x70, 0x00,
  0x33, 0x00, 0x00, 0x00, 0x00, 0x6E, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x46, 0x23, 0x00, 0x00, 0xC0, 0xE0, 0xE1, 0xC0, 0xC0, 0x18, 0x01,
  0x80, 0x1C, 0x01, 0x80, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFD, 0xFF,
  0x80, 0x20, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x06, 0x03, 0x83, 0x81, 0xC0,
  0xC0, 0x00, 0x0C, 0x1F, 0x98, 0x68, 0x18, 0x08, 0x04, 0x04, 0x06, 0x06,
  0x06, 0x06, 0x02, 0x00, 0x00, 0x00, 0x00, 0x40, 0x30, 0x00, 0x07, 0xE1,
  0x83, 0x30, 0x12, 0x39, 0x44, 0x94, 0x89, 0x90, 0x99, 0x11, 0x91, 0x19,
  0x11, 0x93, 0x29, 0x54, 0x88, 0x88, 0x00, 0x41, 0x03, 0xE0, 0x01, 0x80,
  0x30, 0x0E, 0x01, 0x60, 0x24, 0x08, 0x81, 0x10, 0x42, 0x08, 0x42, 0x08,
  0x7F, 0x90, 0x32, 0x02, 0xC0, 0x50, 0x0E, 0x01, 0x1F, 0xC3, 0x06, 0x30,
  0x22, 0x02, 0x20, 0x22, 0x06, 0x20, 0xC7, 0xF0, 0x60, 0xC4, 0x04, 0x40,
  0x64, 0x06, 0x40, 0x4C, 0x0C, 0xC1, 0x8F, 0xE0, 0x03, 0x00, 0xFC, 0x18,
  0x63, 0x02, 0x20, 0x36, 0x03, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x64, 0x04, 0x40, 0xC6, 0x18, 0x3E, 0x00, 0x3F, 0x83,
  0x04, 0x20, 0x22, 0x02, 0x20, 0x32, 0x03, 0x60, 0x36, 0x03, 0x40, 0x24,
  0x02, 0x40, 0x64, 0x04, 0xC0, 0xCC, 0x18, 0x83, 0x0F, 0xC0, 0x1F, 0xF1,
  0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x07, 0xFC, 0x60, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0F, 0xFC, 0x1F, 0xF1,
  0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x03, 0xFC, 0x60, 0x06,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00,
  0xFC, 0x18, 0x23, 0x03, 0x20, 0x36, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C,
  0x3E, 0xC0, 0x2C, 0x06, 0xC0, 0x64, 0x04, 0x40, 0x46, 0x0C, 0x1F, 0x00,
  0x30, 0x12, 0x01, 0x20, 0x12, 0x03, 0x20, 0x26, 0x02, 0x40, 0x27, 0xFE,
  0x40, 0x24, 0x06, 0x40, 0x4C, 0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x0C,
  0x1F, 0xF0, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x0F, 0xF8,
  0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x48, 0x0C, 0x80, 0x8C, 0x18, 0x43, 0x03, 0xE0,
  0x10, 0x18, 0x81, 0x0C, 0x10, 0x41, 0x02, 0x10, 0x11, 0x00, 0xB0, 0x0F,
  0x80, 0x76, 0x03, 0x10, 0x10, 0xC0, 0x82, 0x04, 0x18, 0x60, 0x43, 0x03,
  0x10, 0x0C, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0xFF, 0x30, 0x33,
  0x03, 0x38, 0x72, 0x85, 0x28, 0xB6, 0x8A, 0x69, 0x24, 0xF2, 0x46, 0x24,
  0x66, 0x44, 0x6C, 0x04, 0xC0, 0x48, 0x04, 0x80, 0x48, 0x0C, 0x30, 0x13,
  0x01, 0x38, 0x12, 0x83, 0x28, 0x26, 0xC2, 0x64, 0x24, 0x42, 0x42, 0x64,
  0x26, 0x43, 0x4C, 0x14, 0xC1, 0x48, 0x1C, 0x80, 0xC8, 0x0C, 0x03, 0x00,
  0xFC, 0x18, 0x63, 0x02, 0x20, 0x26, 0x03, 0x40, 0x34, 0x02, 0x40, 0x2C,
  0x02, 0xC0, 0x2C, 0x06, 0xC0, 0x44, 0x04, 0x40, 0x86, 0x18, 0x3E, 0x00,
  0x1F, 0xE1, 0x03, 0x10, 0x13, 0x01, 0x30, 0x12, 0x01, 0x20, 0x32, 0x06,
  0x7F, 0x86, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0x03, 0x00, 0xFC, 0x18, 0x63, 0x02, 0x20, 0x36, 0x03, 0x40, 0x14, 0x03,
  0xC0, 0x3C, 0x02, 0x80, 0x28, 0x02, 0xC0, 0x6C, 0x04, 0x40, 0x86, 0x18,
  0x3F, 0x00, 0x10, 0x00, 0xC0, 0x08, 0x1F, 0xC1, 0x06, 0x30, 0x23, 0x03,
  0x20, 0x32, 0x02, 0x20, 0x62, 0x0C, 0x7F, 0x84, 0x10, 0x41, 0x04, 0x18,
  0x40, 0x8C, 0x08, 0xC0, 0xC8, 0x04, 0x03, 0x00, 0xFC, 0x18, 0x23, 0x03,
  0x20, 0x32, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x80, 0x6C, 0x06, 0xC0, 0x46, 0x18, 0x3F, 0x00, 0xFF, 0xF0, 0x60, 0x06,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x12, 0x01, 0x20,
  0x12, 0x03, 0x20, 0x36, 0x02, 0x40, 0x24, 0x02, 0x40, 0x24, 0x06, 0x40,
  0x4C, 0x04, 0x40, 0x44, 0x08, 0x61, 0x83, 0xE0, 0xC0, 0x34, 0x02, 0x40,
  0x64, 0x04, 0x60, 0xC6, 0x08, 0x21, 0x82, 0x10, 0x23, 0x02, 0x20, 0x26,
  0x03, 0x40, 0x34, 0x01, 0x80, 0x18, 0x01, 0x00, 0xC2, 0x1C, 0x61, 0xC6,
  0x3C, 0xE2, 0xCA, 0x2C, 0xA6, 0x9A, 0x49, 0x24, 0x92, 0x4B, 0x28, 0xA2,
  0x8A, 0x28, 0xE3, 0x8C, 0x30, 0xC3, 0x0C, 0x30, 0x18, 0x0C, 0x20, 0x60,
  0xC3, 0x01, 0x08, 0x04, 0x40, 0x1B, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00,
  0x16, 0x00, 0xC8, 0x06, 0x30, 0x10, 0x40, 0xC1, 0x06, 0x06, 0x30, 0x0C,
  0x80, 0x78, 0x1B, 0x02, 0x20, 0x84, 0x30, 0xC4, 0x09, 0x01, 0x60, 0x38,
  0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x1F, 0xF8,
  0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x60, 0x06,
  0x00, 0x20, 0x02, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x00, 0x1F, 0xFC,
  0x0F, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0x40, 0x40, 0xF0, 0xF0, 0xC2,
  0x10, 0x86, 0x10, 0x84, 0x21, 0x84, 0x21, 0x08, 0x61, 0x08, 0x0E, 0x24,
  0x08, 0x10, 0x60, 0xC1, 0x02, 0x04, 0x08, 0x30, 0x60, 0x81, 0x02, 0x04,
  0x08, 0x30, 0x40, 0x81, 0x1E, 0x3C, 0x00, 0x0C, 0x0C, 0x1C, 0x12, 0x22,
  0x62, 0x42, 0xC3, 0x01, 0xFF, 0x80, 0x99, 0x80, 0x1F, 0x86, 0x08, 0x81,
  0x80, 0x30, 0x04, 0x3F, 0x98, 0x12, 0x02, 0xC0, 0xD8, 0x19, 0x0E, 0x3F,
  0x40, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x5F, 0x0C, 0x31, 0x02,
  0x60, 0x6C, 0x0D, 0x01, 0xA0, 0x24, 0x04, 0x81, 0xB0, 0x27, 0x0C, 0x9F,
  0x00, 0x1F, 0x08, 0x24, 0x0F, 0x01, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0xA0, 0x6C, 0x31, 0xF8, 0x00, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x21,
  0xFA, 0x30, 0xE2, 0x06, 0x60, 0x64, 0x04, 0x40, 0x44, 0x04, 0x40, 0x44,
  0x0C, 0x40, 0x86, 0x18, 0x3E, 0x80, 0x0F, 0x82, 0x08, 0x81, 0xB0, 0x14,
  0x02, 0xFF, 0xF0, 0x06, 0x00, 0x40, 0x08, 0x10, 0x87, 0x0F, 0x80, 0x01,
  0xC0, 0xFC, 0x30, 0x04, 0x01, 0x80, 0x30, 0x3F, 0xE0, 0x80, 0x10, 0x06,
  0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x08, 0x00,
  0x1F, 0xA6, 0x1C, 0x81, 0xB0, 0x34, 0x04, 0x80, 0x90, 0x12, 0x02, 0x40,
  0xC8, 0x19, 0x86, 0x1F, 0x40, 0x08, 0x03, 0x20, 0xC6, 0x30, 0x3C, 0x00,
  0x10, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x4F, 0x8E, 0x11, 0x03, 0x60,
  0x6C, 0x0D, 0x01, 0x20, 0x24, 0x04, 0x80, 0xB0, 0x36, 0x06, 0x80, 0x80,
  0x01, 0x00, 0x60, 0x10, 0x00, 0x00, 0x0F, 0xC0, 0x30, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0xFF, 0xC0, 0x00, 0x40,
  0x0C, 0x01, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10,
  0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x08,
  0x03, 0x00, 0xC1, 0xF0, 0x00, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30,
  0x13, 0x06, 0x20, 0xC2, 0x30, 0x26, 0x06, 0xC0, 0x7C, 0x07, 0x40, 0x46,
  0x04, 0x30, 0x41, 0x0C, 0x18, 0xC0, 0xC0, 0x1F, 0x80, 0x40, 0x10, 0x04,
  0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01,
  0x00, 0x40, 0x10, 0xFF, 0xC0, 0x3E, 0xF1, 0x1C, 0xD8, 0x42, 0xC6, 0x34,
  0x21, 0xA1, 0x09, 0x08, 0x48, 0x42, 0xC2, 0x14, 0x31, 0xA1, 0x0D, 0x08,
  0x40, 0x27, 0xC7, 0x08, 0x81, 0xB0, 0x36, 0x06, 0x80, 0x90, 0x12, 0x02,
  0x40, 0x58, 0x1B, 0x03, 0x40, 0x40, 0x0F, 0x86, 0x18, 0x81, 0xA0, 0x34,
  0x03, 0x80, 0x70, 0x1E, 0x02, 0xC0, 0x48, 0x19, 0x86, 0x1F, 0x00, 0x17,
  0xC1, 0x86, 0x10, 0x23, 0x03, 0x30, 0x32, 0x03, 0x20, 0x22, 0x02, 0x20,
  0x66, 0x04, 0x70, 0xC4, 0xF0, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0,
  0x00, 0x1F, 0xA6, 0x1C, 0x81, 0xB0, 0x34, 0x04, 0x80, 0x90, 0x12, 0x02,
  0x40, 0xC8, 0x11, 0x86, 0x1F, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01,
  0x00, 0x27, 0xCE, 0x07, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0xC0,
  0x30, 0x08, 0x02, 0x00, 0x1F, 0xC6, 0x08, 0x80, 0x90, 0x03, 0x00, 0x3C,
  0x00, 0xE0, 0x06, 0x00, 0x48, 0x09, 0x86, 0x1F, 0x80, 0x18, 0x0C, 0x04,
  0x1F, 0xF1, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x78, 0x40, 0x50, 0x14, 0x0F, 0x03, 0xC0, 0xA0, 0x28, 0x0A, 0x02,
  0x81, 0xA0, 0x6C, 0x31, 0xF4, 0x80, 0x78, 0x09, 0x03, 0x20, 0x44, 0x10,
  0xC2, 0x08, 0x81, 0x30, 0x24, 0x07, 0x80, 0x60, 0x08, 0x00, 0x84, 0x38,
  0x42, 0x8C, 0x28, 0xC4, 0x94, 0x49, 0x2C, 0xB2, 0x8A, 0x28, 0xA3, 0x0C,
  0x30, 0xC3, 0x08, 0x20, 0x30, 0x18, 0xC1, 0x03, 0x18, 0x09, 0x80, 0x78,
  0x01, 0x80, 0x1C, 0x01, 0xA0, 0x08, 0x80, 0x86, 0x08, 0x11, 0x80, 0xC0,
  0x20, 0x0C, 0xC0, 0x61, 0x03, 0x04, 0x08, 0x10, 0x60, 0x61, 0x00, 0x88,
  0x02, 0x60, 0x0D, 0x00, 0x3C, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20,
  0x01, 0x80, 0x0C, 0x00, 0xE0, 0x00, 0x3F, 0xE0, 0x08, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x7F, 0xE0, 0x01,
  0x06, 0x04, 0x08, 0x08, 0x08, 0x18, 0x18, 0x10, 0x30, 0x60, 0xC0, 0x60,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x30, 0x18, 0x08, 0x08, 0x84,
  0x21, 0x08, 0x46, 0x21, 0x08, 0x42, 0x31, 0x08, 0x42, 0x11, 0x80, 0x18,
  0x06, 0x01, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x04, 0x03, 0x00, 0xC0,
  0x30, 0x60, 0x60, 0x20, 0x10, 0x08, 0x04, 0x06, 0x02, 0x03, 0x07, 0x02,
  0x00, 0x38, 0x03, 0x30, 0x50, 0xC5, 0x83, 0xC0,
};

const GFXglyph RobotoMono_LightItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 16, 14, 5, -16 },
  { 9, 6, 5, 14, 5, -17 },
  { 13, 14, 16, 14, 0, -16 },
  { 41, 12, 21, 14, 1, -19 },
  { 73, 11, 17, 14, 1, -17 },
  { 97, 11, 17, 14, 1, -17 },
  { 121, 2, 5, 14, 6, -17 },
  { 123, 7, 23, 14, 4, -18 },
  { 144, 7, 23, 14, 2, -18 },
  { 165, 10, 10, 14, 3, -16 },
  { 178, 11, 12, 14, 1, -14 },
  { 195, 3, 5, 14, 3, -2 },
  { 197, 9, 1, 14, 2, -8 },
  { 199, 2, 2, 14, 5, -2 },
  { 200, 11, 17, 14, 2, -16 },
  { 224, 10, 17, 14, 2, -17 },
  { 246, 7, 16, 14, 3, -16 },
  { 260, 12, 17, 14, 0, -17 },
  { 286, 11, 17, 14, 1, -17 },
  { 310, 12, 16, 14, 0, -16 },
  { 334, 11, 16, 14, 2, -16 },
  { 356, 10, 16, 14, 1, -16 },
  { 376, 10, 16, 14, 3, -16 },
  { 396, 12, 17, 14, 1, -17 },
  { 422, 10, 17, 14, 2, -17 },
  { 444, 4, 12, 14, 5, -12 },
  { 450, 5, 15, 14, 4, -12 },
  { 460, 10, 9, 14, 2, -12 },
  { 472, 11, 6, 14, 1, -10 },
  { 481, 11, 9, 14, 1, -12 },
  { 494, 9, 17, 14, 3, -17 },
  { 514, 12, 16, 14, 1, -16 },
  { 538, 11, 16, 14, 0, -16 },
  { 560, 12, 16, 14, 1, -16 },
  { 584, 12, 17, 14, 1, -17 },
  { 610, 12, 16, 14, 1, -16 },
  { 634, 12, 16, 14, 1, -16 },
  { 658, 12, 16, 14, 1, -16 },
  { 682, 12, 17, 14, 1, -17 },
  { 708, 12, 16, 14, 1, -16 },
  { 732, 12, 16, 14, 1, -16 },
  { 756, 12, 16, 14, 1, -16 },
  { 780, 13, 16, 14, 1, -16 },
  { 806, 10, 16, 14, 1, -16 },
  { 826, 12, 16, 14, 1, -16 },
  { 850, 12, 16, 14, 1, -16 },
  { 874, 12, 17, 14, 1, -17 },
  { 900, 12, 16, 14, 1, -16 },
  { 924, 12, 20, 14, 1, -17 },
  { 954, 12, 16, 14, 1, -16 },
  { 978, 12, 17, 14, 1, -17 },
  { 1004, 12, 16, 14, 2, -16 },
  { 1028, 12, 16, 14, 1, -16 },
  { 1052, 12, 16, 14, 2, -16 },
  { 1076, 12, 16, 14, 2, -16 },
  { 1100, 14, 16, 14, 0, -16 },
  { 1128, 11, 16, 14, 3, -16 },
  { 1150, 13, 16, 14, 0, -16 },
  { 1176, 8, 23, 14, 3, -19 },
  { 1199, 5, 17, 14, 4, -16 },
  { 1210, 7, 23, 14, 3, -19 },
  { 1231, 8, 9, 14, 3, -16 },
  { 1240, 9, 1, 14, 1, 0 },
  { 1242, 3, 3, 14, 7, -17 },
  { 1244, 11, 12, 14, 1, -12 },
  { 1261, 11, 17, 14, 1, -17 },
  { 1285, 10, 12, 14, 2, -12 },
  { 1300, 12, 17, 14, 1, -17 },
  { 1326, 11, 12, 14, 1, -12 },
  { 1343, 11, 18, 14, 3, -18 },
  { 1368, 11, 17, 14, 1, -12 },
  { 1392, 11, 17, 14, 1, -17 },
  { 1416, 10, 17, 14, 1, -17 },
  { 1438, 11, 22, 14, 0, -17 },
  { 1469, 12, 17, 14, 1, -17 },
  { 1495, 10, 17, 14, 1, -17 },
  { 1517, 13, 12, 14, 0, -12 },
  { 1537, 11, 12, 14, 1, -12 },
  { 1554, 11, 12, 14, 1, -12 },
  { 1571, 12, 17, 14, 0, -12 },
  { 1597, 11, 17, 14, 1, -12 },
  { 1621, 10, 12, 14, 3, -12 },
  { 1636, 11, 12, 14, 1, -12 },
  { 1653, 9, 15, 14, 3, -15 },
  { 1670, 10, 12, 14, 2, -12 },
  { 1685, 11, 12, 14, 2, -12 },
  { 1702, 12, 12, 14, 2, -12 },
  { 1720, 13, 12, 14, 0, -12 },
  { 1740, 14, 17, 14, 0, -12 },
  { 1770, 11, 12, 14, 1, -12 },
  { 1787, 8, 23, 14, 4, -18 },
  { 1810, 5, 20, 14, 4, -16 },
  { 1823, 9, 23, 14, 2, -18 },
  { 1849, 13, 4, 14, 0, -9 },
};

const GFXfont RobotoMono_LightItalic23pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic23pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic23pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _ROBOTOMONO_LIGHTITALIC23PT7B_H_
