#ifndef _ROBOTOMONO_LIGHTITALIC63PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x1E, 0x03, 0xE0,
  0x7C, 0x0F, 0x00, 0x3C, 0x0E, 0x70, 0x3C, 0xE0, 0x71, 0xC0, 0xE3, 0x81,
  0xC7, 0x03, 0x8E, 0x07, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0xE3,
  0x81, 0xCE, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x00, 0x3C, 0x01, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x07, 0x80, 0x38, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x3C,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xE0, 0x3F, 0x00, 0x3E, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x78, 0x07, 0x80,
  0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0x80, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x3C,
  0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x1E, 0x1C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x1F, 0x03, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x00, 0x7F,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x0F, 0x03,
  0x80, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x18, 0x01, 0x07, 0x00, 0x70,
  0x07, 0x1C, 0x01, 0xC0, 0x38, 0xE0, 0x07, 0x01, 0xE3, 0x80, 0x38, 0x07,
  0x0E, 0x00, 0xE0, 0x38, 0x38, 0x03, 0x81, 0xE0, 0xE0, 0x0E, 0x07, 0x03,
  0x80, 0x38, 0x38, 0x0E, 0x01, 0xC1, 0xC0, 0x1C, 0x0F, 0x0F, 0x00, 0x78,
  0x78, 0x38, 0x00, 0xFF, 0xC1, 0xC0, 0x01, 0xFE, 0x0F, 0x00, 0x03, 0xE0,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x0E,
  0x00, 0x01, 0xC1, 0xFE, 0x00, 0x0E, 0x0F, 0xFC, 0x00, 0x78, 0x78, 0x78,
  0x01, 0xC3, 0xC0, 0xE0, 0x0E, 0x0E, 0x01, 0xC0, 0x70, 0x78, 0x07, 0x03,
  0xC1, 0xC0, 0x1C, 0x0E, 0x07, 0x00, 0x70, 0x70, 0x1C, 0x01, 0xC3, 0xC0,
  0x60, 0x07, 0x0E, 0x03, 0x80, 0x1C, 0x70, 0x0E, 0x00, 0xE3, 0xC0, 0x38,
  0x03, 0x82, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x03,
  0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0x03, 0xC0,
  0x00, 0x3E, 0x01, 0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x78, 0x01, 0xE0,
  0x00, 0x78, 0x01, 0xE0, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x70, 0x01, 0xE0,
  0x00, 0xF0, 0x01, 0xC0, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0x80,
  0x00, 0x70, 0x0F, 0x80, 0x00, 0x70, 0x1F, 0x00, 0x00, 0x78, 0x3E, 0x00,
  0x00, 0x78, 0x7C, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x03, 0xE3, 0xC0, 0x00,
  0x07, 0xC3, 0xC0, 0x07, 0x0F, 0x81, 0xE0, 0x0F, 0x0F, 0x00, 0xF0, 0x0F,
  0x1E, 0x00, 0xF0, 0x0E, 0x3C, 0x00, 0x78, 0x0E, 0x3C, 0x00, 0x78, 0x1E,
  0x78, 0x00, 0x3C, 0x1C, 0x78, 0x00, 0x1E, 0x3C, 0x78, 0x00, 0x1E, 0x38,
  0x70, 0x00, 0x0F, 0x78, 0x70, 0x00, 0x0F, 0xF0, 0x78, 0x00, 0x07, 0xF0,
  0x78, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x0F, 0xE0,
  0x3E, 0x00, 0x1F, 0xF0, 0x1F, 0x00, 0x7E, 0xF0, 0x0F, 0xFF, 0xF8, 0x78,
  0x07, 0xFF, 0xF0, 0x7C, 0x01, 0xFF, 0xC0, 0x3C, 0x00, 0x1C, 0x00, 0x00,
  0x39, 0xCE, 0xF7, 0xB9, 0xCE, 0x77, 0x39, 0xCE, 0x40, 0x00, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x40, 0x07, 0x00, 0x2E, 0x01, 0xC0, 0x3F, 0xF0, 0x38, 0x1F, 0xFF, 0xC7,
  0x1F, 0xF3, 0xFE, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0x9E,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x0F, 0x03, 0xC0, 0x03,
  0xC0, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x0F, 0x80, 0x0F,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x83, 0xC1, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x3C, 0x1E, 0x0F, 0x0F,
  0x0F, 0x07, 0x87, 0x81, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x38, 0xF9, 0xFF, 0xF7, 0xCF, 0x80, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x07, 0x80,
  0x01, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0E, 0x07, 0x80, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xF1, 0xE0, 0x00, 0x1F, 0xC7,
  0x00, 0x00, 0xFF, 0x3C, 0x00, 0x07, 0xBC, 0xF0, 0x00, 0x7C, 0xF3, 0xC0,
  0x03, 0xE3, 0x8F, 0x00, 0x1E, 0x0E, 0x38, 0x00, 0xF0, 0x38, 0xE0, 0x0F,
  0x81, 0xE7, 0x80, 0x7C, 0x07, 0x9E, 0x03, 0xC0, 0x1E, 0x78, 0x1E, 0x00,
  0x71, 0xE1, 0xF0, 0x01, 0xC7, 0x0F, 0x80, 0x07, 0x1C, 0x78, 0x00, 0x3C,
  0xF3, 0xC0, 0x00, 0xF3, 0xFE, 0x00, 0x03, 0xCF, 0xF0, 0x00, 0x0E, 0x3F,
  0x00, 0x00, 0x78, 0xF8, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x3C, 0x1C, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x3C,
  0x00, 0x7C, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0xE0, 0x01, 0xF8, 0x01, 0xFE, 0x03, 0xFF, 0x83, 0xFD, 0xE7, 0xFC, 0x79,
  0xF8, 0x1C, 0x78, 0x07, 0x30, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x03, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00,
  0xE0, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0xF8, 0x00, 0xF8, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0x80,
  0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xE3, 0x80, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x70,
  0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x1F, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00,
  0x78, 0x70, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x0F,
  0x00, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x38,
  0x01, 0xE0, 0x00, 0x78, 0x01, 0xC0, 0x00, 0xF0, 0x01, 0xC0, 0x01, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x03, 0xC0, 0x07, 0x80,
  0x03, 0xC0, 0x0F, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x03, 0x80, 0x3C, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x07, 0x81, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x07, 0xC0, 0x00, 0x0E, 0x7F, 0xF0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFE, 0x01, 0xF8, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC1, 0xE0, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x78, 0x0E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x1F, 0xF8, 0x03, 0x8F,
  0xFF, 0x80, 0xF3, 0xFF, 0xFC, 0x1D, 0xF8, 0x0F, 0x83, 0xF8, 0x00, 0xF8,
  0xFE, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0xF3, 0xE0, 0x00, 0x0E, 0x78, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x78,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0xF0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x1F, 0x80, 0x3F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x78, 0x07, 0x80, 0x01, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x3E, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x0E, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x1F, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x00,
  0xF8, 0x1F, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x0E, 0x3C,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x77, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3E, 0xE0, 0x00, 0x07, 0x9E, 0x00,
  0x01, 0xF3, 0xC0, 0x00, 0x7E, 0x3C, 0x00, 0x1F, 0xC7, 0xC0, 0x0F, 0x78,
  0x7E, 0x07, 0xCE, 0x07, 0xFF, 0xF1, 0xC0, 0x7F, 0xFC, 0x78, 0x03, 0xFE,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0x80, 0xF8, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0x78, 0x00, 0x00, 0x38, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x10, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xF8, 0x06, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x01, 0xF8, 0x0F, 0xC1, 0xF0, 0x01, 0xE1, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0x3C, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x38, 0x00, 0x03, 0xBC, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x70, 0x03, 0xC0, 0x38, 0x1E, 0x03, 0xFE, 0x07,
  0x03, 0x80, 0xFF, 0xE0, 0x60, 0xE0, 0x3C, 0x1C, 0x0C, 0x1C, 0x0F, 0x03,
  0x81, 0x87, 0x03, 0xC0, 0x70, 0x30, 0xE0, 0x70, 0x0C, 0x06, 0x38, 0x1C,
  0x01, 0x80, 0xC7, 0x03, 0x80, 0x70, 0x18, 0xE0, 0xE0, 0x0E, 0x03, 0x38,
  0x1C, 0x01, 0x80, 0x67, 0x03, 0x00, 0x30, 0x1C, 0xE0, 0xE0, 0x0E, 0x03,
  0x98, 0x1C, 0x01, 0xC0, 0x67, 0x03, 0x80, 0x30, 0x0C, 0xE0, 0x60, 0x06,
  0x01, 0x9C, 0x1C, 0x01, 0xC0, 0x73, 0x83, 0x80, 0x38, 0x0C, 0x60, 0x70,
  0x0E, 0x01, 0x8C, 0x0E, 0x01, 0xC0, 0x71, 0x81, 0xC0, 0x78, 0x0C, 0x30,
  0x38, 0x1F, 0x03, 0x86, 0x07, 0x07, 0x60, 0x60, 0xE0, 0x71, 0xCE, 0x3C,
  0x1C, 0x0F, 0xF1, 0xFF, 0x03, 0x80, 0xFC, 0x1F, 0xC0, 0x70, 0x0E, 0x01,
  0xE0, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x04, 0x00, 0x03,
  0xE0, 0x03, 0x80, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x1E, 0xE0,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x0F, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x00,
  0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0,
  0x01, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x0E, 0x00, 0x07, 0x80, 0x3F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF8, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x07,
  0x1E, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x0E, 0x00, 0xFF, 0x80, 0x1C, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x0F, 0x80,
  0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x07,
  0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x1E, 0x07, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xF0, 0x3C, 0x00,
  0x07, 0xC0, 0x78, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x1F, 0xE0, 0x1E, 0x00, 0x03,
  0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x03,
  0x83, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0xF8, 0x38, 0x00, 0x03, 0xE0, 0xF0,
  0x00, 0x1F, 0x81, 0xE0, 0x01, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0xE0,
  0x00, 0x00, 0xF1, 0xC0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x0E, 0x0F, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x03, 0xE0, 0x1E, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x01,
  0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3C, 0x03, 0xFC, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x07, 0x00, 0x00, 0xF0, 0x03,
  0x80, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x01,
  0xE0, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00,
  0x38, 0x3C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x01, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0xF0, 0x70, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x3E, 0x03, 0x80,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x38, 0x01, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x00,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x07, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xFC, 0x70, 0x00,
  0xFF, 0xFC, 0x70, 0x00, 0xFF, 0xFC, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x38, 0xF0, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x38, 0xF0, 0x00,
  0x00, 0x78, 0x70, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0x70, 0x78, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x70, 0x3C, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x38, 0x07, 0x00,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x3C,
  0x03, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x3C, 0x07, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x3E, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x7E, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x1E, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00,
  0xF8, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x07, 0x80, 0x00, 0x38, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x3C, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0xF1, 0xF0, 0x00,
  0x00, 0x0F, 0x3F, 0x00, 0x00, 0x00, 0xE7, 0xF0, 0x00, 0x00, 0x0E, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x78, 0x00, 0x00, 0x1F, 0xE3, 0xC0, 0x00, 0x01,
  0xFC, 0x3E, 0x00, 0x00, 0x1F, 0x81, 0xE0, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFC, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0x70, 0x1F, 0xC0, 0x01,
  0xFE, 0x03, 0xBC, 0x00, 0x3B, 0xC0, 0x73, 0x80, 0x0F, 0x70, 0x0E, 0x70,
  0x01, 0xCE, 0x01, 0xCE, 0x00, 0x79, 0xC0, 0x79, 0xC0, 0x1E, 0x78, 0x0F,
  0x38, 0x03, 0xCF, 0x01, 0xC7, 0x80, 0xF1, 0xC0, 0x38, 0x70, 0x1C, 0x38,
  0x07, 0x0E, 0x07, 0x87, 0x00, 0xE1, 0xC0, 0xE1, 0xE0, 0x3C, 0x38, 0x3C,
  0x3C, 0x07, 0x87, 0x07, 0x07, 0x80, 0xF0, 0xF1, 0xE0, 0xE0, 0x1C, 0x0E,
  0x38, 0x1C, 0x03, 0x81, 0xCF, 0x03, 0x80, 0xF0, 0x3B, 0xC0, 0xF0, 0x1E,
  0x07, 0x78, 0x1E, 0x03, 0xC0, 0xFE, 0x03, 0xC0, 0x78, 0x1F, 0x80, 0x70,
  0x0E, 0x01, 0xF0, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80,
  0x78, 0x0F, 0x00, 0xE0, 0x0F, 0x01, 0xE0, 0x1C, 0x01, 0xE0, 0x38, 0x00,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x78, 0x00, 0x00, 0x70, 0x1F, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x0F,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0xFE, 0x00, 0x00, 0xF0, 0x3F, 0x80, 0x00,
  0x38, 0x0F, 0xE0, 0x00, 0x0E, 0x03, 0xFC, 0x00, 0x07, 0x80, 0xE7, 0x00,
  0x01, 0xE0, 0x39, 0xE0, 0x00, 0x78, 0x1E, 0x78, 0x00, 0x1E, 0x07, 0x8E,
  0x00, 0x07, 0x01, 0xE3, 0xC0, 0x01, 0xC0, 0x78, 0xF0, 0x00, 0xF0, 0x1C,
  0x1C, 0x00, 0x3C, 0x07, 0x07, 0x80, 0x0F, 0x03, 0xC1, 0xE0, 0x03, 0x80,
  0xF0, 0x38, 0x00, 0xE0, 0x3C, 0x0F, 0x00, 0x38, 0x0E, 0x01, 0xC0, 0x1E,
  0x03, 0x80, 0x70, 0x07, 0x80, 0xE0, 0x1E, 0x01, 0xE0, 0x78, 0x03, 0x80,
  0x70, 0x1E, 0x00, 0xF0, 0x1C, 0x07, 0x80, 0x3C, 0x0F, 0x01, 0xC0, 0x07,
  0x03, 0xC0, 0x70, 0x01, 0xE0, 0xF0, 0x3C, 0x00, 0x78, 0x3C, 0x0F, 0x00,
  0x0E, 0x0E, 0x03, 0xC0, 0x03, 0xC3, 0x80, 0xF0, 0x00, 0xF1, 0xE0, 0x38,
  0x00, 0x1C, 0x78, 0x0E, 0x00, 0x07, 0x9E, 0x07, 0x80, 0x00, 0xE7, 0x81,
  0xE0, 0x00, 0x39, 0xC0, 0x78, 0x00, 0x0F, 0x70, 0x1E, 0x00, 0x01, 0xFC,
  0x07, 0x00, 0x00, 0x7F, 0x01, 0xC0, 0x00, 0x1F, 0xC0, 0xF0, 0x00, 0x03,
  0xF0, 0x3C, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x81, 0xF0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x38, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x73,
  0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1D, 0xE0,
  0x00, 0x00, 0x77, 0x80, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0E, 0xF0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07,
  0xB8, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xF0, 0x70, 0x00,
  0x07, 0x81, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x07,
  0x80, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x3C, 0x00, 0x7F, 0x80, 0x1E, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00,
  0xF8, 0x07, 0x80, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x0F, 0x01, 0xC0, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xE0, 0x78, 0x00,
  0x00, 0x70, 0x3C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x03, 0xC0,
  0x00, 0x07, 0x81, 0xC0, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0x03, 0xC0, 0x70,
  0x00, 0x07, 0xC0, 0x78, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x0F, 0xC0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0E, 0x0F, 0x00,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x0F, 0x1C, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x07, 0x3C, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x70, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1C, 0xF0, 0x00,
  0x00, 0x1C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x38, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0xF0, 0x70, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x08, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xE0, 0x01, 0xE0, 0x07, 0xF0, 0x01, 0xC0, 0x00, 0xF8, 0x01, 0xC0,
  0x00, 0x7C, 0x01, 0xC0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x0E, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0F, 0x03, 0x80,
  0x00, 0x0F, 0x03, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x0E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x1E, 0x07, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x03, 0xE0, 0x0E, 0x00, 0x0F, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1F, 0x07, 0x80,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x00,
  0x00, 0x0F, 0x07, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x01, 0xF0, 0x3C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x80,
  0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x01, 0xE0, 0x70,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0F, 0x03,
  0x80, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x78, 0x03, 0x80, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x07, 0x8E,
  0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x01, 0xC0,
  0x00, 0x1E, 0x03, 0x80, 0x00, 0x78, 0x07, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x03, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x0E, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0xF0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x38, 0x07, 0x80,
  0x00, 0x78, 0x0E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x0F, 0x00, 0x00,
  0x0E, 0x1C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x01, 0xE0, 0x03, 0xB8, 0x00, 0xF0, 0x01, 0xDC, 0x00, 0x78, 0x01, 0xEE,
  0x00, 0x7C, 0x00, 0xE7, 0x00, 0x3E, 0x00, 0x73, 0x80, 0x1F, 0x00, 0x79,
  0xC0, 0x1F, 0x80, 0x38, 0xE0, 0x0F, 0xC0, 0x1C, 0xF0, 0x07, 0xE0, 0x0E,
  0x78, 0x07, 0x70, 0x0F, 0x3C, 0x03, 0xB8, 0x07, 0x1E, 0x01, 0xDC, 0x03,
  0x8F, 0x01, 0xCE, 0x03, 0xC7, 0x80, 0xE7, 0x01, 0xC3, 0xC0, 0xF3, 0x80,
  0xE1, 0xE0, 0x71, 0xC0, 0xF0, 0xF0, 0x38, 0xE0, 0x78, 0x78, 0x3C, 0x70,
  0x38, 0x3C, 0x1C, 0x38, 0x1C, 0x1E, 0x0E, 0x1C, 0x1E, 0x0F, 0x0F, 0x0E,
  0x0E, 0x07, 0x87, 0x07, 0x07, 0x03, 0x83, 0x83, 0x87, 0x81, 0xC3, 0xC1,
  0xC3, 0x80, 0xE1, 0xC0, 0xE1, 0xC0, 0x70, 0xE0, 0x70, 0xE0, 0x38, 0xF0,
  0x38, 0xF0, 0x1C, 0x70, 0x1C, 0x70, 0x0E, 0x38, 0x0E, 0x38, 0x07, 0x3C,
  0x07, 0x3C, 0x03, 0x9C, 0x03, 0x9C, 0x01, 0xCE, 0x01, 0xCE, 0x00, 0xEF,
  0x00, 0xE7, 0x00, 0x77, 0x00, 0x77, 0x80, 0x3B, 0x80, 0x3B, 0x80, 0x1F,
  0xC0, 0x1D, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x1F, 0x00, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x0E, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0xE0,
  0x00, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x00, 0x07, 0x87, 0x00, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x0F, 0x80, 0xF0,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x07, 0x80, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x01, 0xF3, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x07, 0x00,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x1C, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xC0, 0x0F,
  0x00, 0x03, 0x80, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x01, 0xE0,
  0x00, 0x0E, 0x07, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1C, 0x3C, 0x00,
  0x00, 0x38, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x77, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xBC, 0x00, 0x1E, 0x70, 0x00, 0x71,
  0xC0, 0x03, 0xC7, 0x00, 0x0E, 0x1E, 0x00, 0x78, 0x78, 0x03, 0xC0, 0xE0,
  0x0E, 0x03, 0x80, 0x78, 0x0E, 0x01, 0xC0, 0x3C, 0x0F, 0x00, 0x70, 0x38,
  0x01, 0xC1, 0xE0, 0x07, 0x0F, 0x00, 0x1E, 0x3C, 0x00, 0x79, 0xE0, 0x00,
  0xE7, 0x00, 0x03, 0xBC, 0x00, 0x0F, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x78, 0x38, 0x3C, 0x1C, 0x0E, 0x0E,
  0x07, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0,
  0x01, 0xFC, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0xF8, 0x1E,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0x03, 0xF0, 0x00, 0x38, 0x3E, 0x00,
  0x01, 0xC3, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07,
  0x8E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x1E, 0x3C,
  0x00, 0x01, 0xF1, 0xE0, 0x00, 0x1F, 0x87, 0x80, 0x01, 0xFC, 0x3C, 0x00,
  0x3F, 0xE0, 0xF8, 0x07, 0xEF, 0x07, 0xFF, 0xFC, 0x78, 0x1F, 0xFF, 0xC3,
  0xC0, 0x3F, 0xF8, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0xFE, 0x00, 0x1E,
  0x1F, 0xFC, 0x00, 0xF3, 0xFF, 0xF0, 0x07, 0x3F, 0x1F, 0xC0, 0x3B, 0xC0,
  0x1F, 0x01, 0xF8, 0x00, 0x78, 0x0F, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x38, 0x3C, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x0F, 0x0E,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x3C, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x07,
  0x83, 0xE0, 0x00, 0x78, 0x1F, 0x80, 0x07, 0xC1, 0xEF, 0x00, 0xFC, 0x0F,
  0x3F, 0xFF, 0xC0, 0x70, 0xFF, 0xFC, 0x03, 0x83, 0xFF, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xE1, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x3C, 0x00, 0x1E, 0x07,
  0x80, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x07, 0x3C, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x03, 0xE0, 0x01, 0xE0, 0x1F,
  0x00, 0x7C, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xE0,
  0x38, 0x00, 0x3F, 0xF8, 0x78, 0x00, 0xFF, 0xFE, 0x78, 0x01, 0xFC, 0x7F,
  0x78, 0x03, 0xF0, 0x07, 0x78, 0x07, 0xC0, 0x03, 0xF0, 0x0F, 0x80, 0x01,
  0xF0, 0x0F, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00,
  0xE0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F,
  0x80, 0x3C, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0xF7,
  0x00, 0x1F, 0xFF, 0xE7, 0x00, 0x0F, 0xFF, 0xCF, 0x00, 0x03, 0xFF, 0x0F,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0x00, 0x7C, 0x01,
  0xE0, 0x01, 0xF0, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00,
  0xE7, 0x80, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x39, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBC, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x02, 0x03, 0xC0,
  0x00, 0x78, 0x0F, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xC0, 0x10, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x1C, 0x00, 0xFF, 0xFE, 0x38, 0x03, 0xF8, 0x7E, 0xF0, 0x0F, 0xC0,
  0x1D, 0xE0, 0x3E, 0x00, 0x1F, 0xC0, 0xF8, 0x00, 0x1F, 0x01, 0xE0, 0x00,
  0x3E, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x7E, 0x01, 0xE0,
  0x03, 0xF8, 0x01, 0xF0, 0x0F, 0x70, 0x03, 0xFF, 0xFC, 0xE0, 0x03, 0xFF,
  0xF3, 0xC0, 0x01, 0xFF, 0x87, 0x80, 0x00, 0x60, 0x0F, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x10, 0x00, 0x07, 0x80, 0x60, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78,
  0x01, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x1F, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x7F, 0x00,
  0x1E, 0x0F, 0xFE, 0x00, 0xE1, 0xFF, 0xF8, 0x07, 0x1F, 0x8F, 0xE0, 0x39,
  0xE0, 0x0F, 0x81, 0xDC, 0x00, 0x3C, 0x1F, 0xC0, 0x00, 0xE0, 0xFC, 0x00,
  0x07, 0x87, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0xF1, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0xF0, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x81, 0xC0, 0x00, 0x7C, 0x03, 0x80, 0x01, 0xF0, 0x0F, 0x00, 0x07,
  0xC0, 0x1E, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x70, 0x03, 0xE0,
  0x00, 0xE0, 0x0F, 0x80, 0x01, 0xC0, 0x3E, 0x00, 0x07, 0x81, 0xF8, 0x00,
  0x0F, 0x07, 0xC0, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x38, 0x7C, 0x00, 0x00,
  0x71, 0xF0, 0x00, 0x01, 0xEF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFB, 0xC0, 0x00, 0x0F, 0xE7, 0xC0, 0x00, 0x1F, 0x87, 0x80, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0xF0, 0x0F, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0xC0,
  0x0F, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x7C, 0x03, 0xC0, 0x00, 0x7C, 0x07, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00,
  0xF8, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x07, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x38, 0xFF, 0x87, 0xFC, 0x03, 0xBF, 0xF8, 0xFF, 0xE0, 0x3F,
  0xCF, 0xDF, 0x3F, 0x03, 0xE0, 0x3F, 0x80, 0xF0, 0x7C, 0x01, 0xF0, 0x0F,
  0x07, 0x80, 0x1E, 0x00, 0x70, 0x78, 0x01, 0xE0, 0x07, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x70, 0x01, 0xC0, 0x07, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0xF0,
  0x03, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0xE0, 0x03, 0x80, 0x0E,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x80, 0x0E, 0x0E, 0x00, 0x78,
  0x01, 0xE1, 0xE0, 0x07, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x01, 0xE1, 0xC0,
  0x07, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x00, 0x1C,
  0x3C, 0x00, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0,
  0x03, 0x83, 0x80, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0x03, 0x83, 0x80,
  0x0E, 0x00, 0x38, 0x78, 0x01, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x00, 0x78,
  0x70, 0x01, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC0,
  0x07, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x3C, 0x1F,
  0xFC, 0x01, 0xC3, 0xFF, 0xF0, 0x0E, 0x3F, 0x1F, 0xC0, 0x73, 0xC0, 0x1F,
  0x07, 0xB8, 0x00, 0x78, 0x3F, 0x80, 0x03, 0xC1, 0xF8, 0x00, 0x0F, 0x0F,
  0x80, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x8F,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x78, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0x87,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0x80, 0x7C, 0x00, 0x0F,
  0x03, 0xE0, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0x70, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F,
  0x1C, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x80, 0x78,
  0x00, 0x7C, 0x00, 0xF8, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0xF0, 0xFF, 0xE0, 0x00, 0xE3, 0xFF, 0xF0, 0x00, 0xE7,
  0xE3, 0xF8, 0x00, 0xEF, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x3C, 0x01, 0xF8,
  0x00, 0x1E, 0x01, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0x80,
  0x00, 0x0F, 0x03, 0x80, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x0E, 0x07, 0x80, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x00,
  0x00, 0x1E, 0x07, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF8, 0x0F, 0x00,
  0x00, 0xF0, 0x0F, 0x80, 0x01, 0xE0, 0x1F, 0xC0, 0x03, 0xE0, 0x1F, 0xE0,
  0x0F, 0xC0, 0x1E, 0xFF, 0xFF, 0x80, 0x1E, 0x7F, 0xFE, 0x00, 0x1C, 0x1F,
  0xFC, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF,
  0xC1, 0xC0, 0x3F, 0xFF, 0x8E, 0x03, 0xF8, 0x7E, 0xF0, 0x3F, 0x00, 0x77,
  0x83, 0xE0, 0x01, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x3E, 0x1E,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07,
  0x8E, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0E, 0x3C,
  0x00, 0x00, 0x71, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1F, 0x03,
  0xC0, 0x01, 0xF8, 0x1E, 0x00, 0x1F, 0x80, 0x7C, 0x03, 0xDC, 0x03, 0xFF,
  0xFC, 0xE0, 0x0F, 0xFF, 0xCF, 0x00, 0x1F, 0xF8, 0x78, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0xF0, 0x3F, 0xF8, 0x1C, 0x1F, 0xFF, 0x03, 0x8F, 0xFF, 0xE0, 0x73,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x3E, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0xF8, 0x3E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0E, 0x0F, 0x00, 0x00,
  0x78, 0x70, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC7, 0x80,
  0x00, 0x0E, 0x3C, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x78, 0x3E, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0x87, 0x80, 0x00,
  0x3C, 0x38, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x01, 0xE1, 0xC0,
  0x00, 0x0F, 0x0E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x1C, 0x3C, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x78,
  0x70, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xE1, 0xE0,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0x70, 0x00, 0x03, 0xC3, 0x80, 0x00,
  0x1E, 0x1C, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78,
  0x3C, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x7E, 0x07, 0x80, 0x0F, 0xF0, 0x3E,
  0x01, 0xF7, 0x00, 0xFF, 0xFF, 0x38, 0x03, 0xFF, 0xE1, 0xC0, 0x0F, 0xFE,
  0x1E, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x07,
  0x00, 0x07, 0x80, 0x1C, 0x00, 0x1E, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0x80, 0x03, 0x80, 0x1E, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x03,
  0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x07, 0x03, 0xC0,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x03, 0x8F, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x01,
  0xC0, 0x03, 0xDC, 0x00, 0x70, 0x00, 0xE7, 0x00, 0x1E, 0x00, 0x79, 0xC0,
  0x0F, 0x80, 0x1C, 0x70, 0x03, 0xE0, 0x07, 0x1C, 0x01, 0xF8, 0x03, 0xC7,
  0x00, 0x7E, 0x00, 0xE1, 0xC0, 0x1B, 0x80, 0x38, 0x70, 0x0E, 0xE0, 0x1C,
  0x1C, 0x03, 0xB8, 0x07, 0x07, 0x01, 0xCE, 0x03, 0xC1, 0xC0, 0x73, 0x80,
  0xE0, 0x70, 0x38, 0xE0, 0x38, 0x1C, 0x0E, 0x38, 0x1C, 0x07, 0x03, 0x86,
  0x07, 0x01, 0xC1, 0xC1, 0x81, 0xC0, 0x70, 0x70, 0x70, 0xE0, 0x1C, 0x38,
  0x1C, 0x38, 0x07, 0x0E, 0x07, 0x1E, 0x01, 0xC3, 0x81, 0xC7, 0x00, 0x71,
  0xC0, 0x71, 0xC0, 0x1C, 0x70, 0x1C, 0xE0, 0x07, 0x38, 0x07, 0x38, 0x01,
  0xCE, 0x01, 0xCE, 0x00, 0x73, 0x00, 0x77, 0x00, 0x0D, 0xC0, 0x1D, 0xC0,
  0x03, 0x70, 0x07, 0x60, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x0F,
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xC1,
  0xF0, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x07,
  0xBE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3E, 0xE0, 0x00, 0x00, 0x1F, 0x3C, 0x00,
  0x00, 0x0F, 0x87, 0x80, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x03, 0xE0, 0x3C,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x07, 0xC0,
  0x00, 0x78, 0x03, 0xE0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x07,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03,
  0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x31, 0xFF, 0xF8, 0x00, 0x1C, 0x7C, 0x3F, 0x00,
  0x07, 0x3C, 0x03, 0xE0, 0x03, 0xDE, 0x00, 0x7C, 0x00, 0xE7, 0x00, 0x0F,
  0x80, 0xF9, 0xC0, 0x01, 0xFC, 0xFC, 0xE0, 0x00, 0x3F, 0xFE, 0x38, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00,
};

const GFXglyph RobotoMono_LightItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 11, 45, 37, 13, -45 },
  { 63, 15, 13, 37, 14, -47 },
  { 88, 37, 45, 37, 1, -45 },
  { 297, 30, 58, 37, 4, -52 },
  { 515, 30, 46, 37, 4, -45 },
  { 688, 32, 47, 37, 2, -46 },
  { 876, 5, 14, 37, 18, -47 },
  { 885, 19, 64, 37, 11, -50 },
  { 1037, 20, 64, 37, 5, -50 },
  { 1197, 27, 28, 37, 8, -45 },
  { 1292, 30, 33, 37, 4, -37 },
  { 1416, 9, 15, 37, 7, -6 },
  { 1433, 23, 4, 37, 7, -22 },
  { 1445, 7, 6, 37, 13, -6 },
  { 1451, 30, 49, 37, 4, -45 },
  { 1635, 30, 46, 37, 4, -45 },
  { 1808, 18, 45, 37, 9, -45 },
  { 1910, 31, 45, 37, 1, -45 },
  { 2085, 30, 46, 37, 2, -45 },
  { 2258, 32, 45, 37, 1, -45 },
  { 2438, 31, 46, 37, 5, -45 },
  { 2617, 27, 46, 37, 4, -45 },
  { 2773, 29, 45, 37, 7, -45 },
  { 2937, 31, 46, 37, 4, -45 },
  { 3116, 27, 45, 37, 6, -45 },
  { 3268, 11, 33, 37, 15, -33 },
  { 3314, 15, 42, 37, 11, -33 },
  { 3393, 28, 26, 37, 5, -33 },
  { 3484, 30, 16, 37, 4, -28 },
  { 3544, 29, 26, 37, 3, -33 },
  { 3639, 25, 45, 37, 9, -45 },
  { 3780, 35, 45, 37, 2, -45 },
  { 3977, 31, 45, 37, 0, -45 },
  { 4152, 31, 45, 37, 3, -45 },
  { 4327, 31, 46, 37, 4, -45 },
  { 4506, 33, 45, 37, 2, -45 },
  { 4692, 33, 45, 37, 3, -45 },
  { 4878, 34, 45, 37, 3, -45 },
  { 5070, 32, 46, 37, 3, -45 },
  { 5254, 35, 45, 37, 2, -45 },
  { 5451, 33, 45, 37, 3, -45 },
  { 5637, 33, 46, 37, 2, -45 },
  { 5827, 36, 45, 37, 3, -45 },
  { 6030, 27, 45, 37, 3, -45 },
  { 6182, 35, 45, 37, 2, -45 },
  { 6379, 34, 45, 37, 2, -45 },
  { 6571, 30, 46, 37, 4, -45 },
  { 6744, 33, 45, 37, 3, -45 },
  { 6930, 32, 53, 37, 3, -45 },
  { 7142, 32, 45, 37, 3, -45 },
  { 7322, 32, 46, 37, 3, -45 },
  { 7506, 32, 45, 37, 7, -45 },
  { 7686, 33, 46, 37, 4, -45 },
  { 7876, 31, 45, 37, 7, -45 },
  { 8051, 33, 45, 37, 6, -45 },
  { 8237, 38, 45, 37, 0, -45 },
  { 8451, 31, 45, 37, 7, -45 },
  { 8626, 34, 45, 37, 1, -45 },
  { 8818, 20, 61, 37, 9, -51 },
  { 8971, 13, 49, 37, 12, -45 },
  { 9051, 20, 61, 37, 8, -51 },
  { 9204, 22, 24, 37, 8, -45 },
  { 9270, 27, 3, 37, 1, 0 },
  { 9281, 8, 8, 37, 18, -46 },
  { 9289, 29, 35, 37, 3, -34 },
  { 9416, 29, 48, 37, 3, -47 },
  { 9590, 28, 35, 37, 4, -34 },
  { 9713, 32, 48, 37, 4, -47 },
  { 9905, 29, 35, 37, 4, -34 },
  { 10032, 31, 48, 37, 7, -48 },
  { 10218, 31, 47, 37, 2, -34 },
  { 10401, 29, 47, 37, 3, -47 },
  { 10572, 27, 45, 37, 3, -45 },
  { 10724, 29, 58, 37, 0, -45 },
  { 10935, 31, 47, 37, 3, -47 },
  { 11118, 27, 47, 37, 3, -47 },
  { 11277, 36, 34, 37, -1, -34 },
  { 11430, 29, 34, 37, 3, -34 },
  { 11554, 30, 35, 37, 3, -34 },
  { 11686, 32, 47, 37, 0, -34 },
  { 11874, 29, 47, 37, 4, -34 },
  { 12045, 27, 34, 37, 8, -34 },
  { 12160, 29, 35, 37, 4, -34 },
  { 12287, 25, 43, 37, 7, -42 },
  { 12422, 29, 34, 37, 5, -33 },
  { 12546, 30, 33, 37, 6, -33 },
  { 12670, 34, 33, 37, 4, -33 },
  { 12811, 34, 33, 37, 1, -33 },
  { 12952, 38, 46, 37, -1, -33 },
  { 13171, 32, 33, 37, 2, -33 },
  { 13303, 24, 61, 37, 10, -49 },
  { 13486, 12, 55, 37, 12, -45 },
  { 13569, 25, 61, 37, 5, -49 },
  { 13760, 34, 11, 37, 1, -24 },
};

const GFXfont RobotoMono_LightItalic63pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic63pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic63pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _ROBOTOMONO_LIGHTITALIC63PT7B_H_
