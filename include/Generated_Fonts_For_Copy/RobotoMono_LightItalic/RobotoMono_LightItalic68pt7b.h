#ifndef _ROBOTOMONO_LIGHTITALIC68PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x00, 0x1C, 0x07, 0x1C, 0x0F, 0x1C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0E, 0x38,
  0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x1E, 0x78, 0x1C, 0x70, 0x1C, 0x70,
  0x1C, 0x70, 0x1C, 0x70, 0x3C, 0xF0, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x70, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x00,
  0x00, 0x70, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07,
  0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0xF8, 0x03,
  0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0xFC, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xE1, 0xE0,
  0x00, 0x01, 0xC0, 0x78, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0x20, 0xE0, 0x07, 0x00, 0x38, 0x70, 0x03, 0x80, 0x3C, 0x38, 0x01,
  0xC0, 0x1C, 0x1C, 0x00, 0xE0, 0x1C, 0x1E, 0x00, 0x70, 0x1E, 0x0F, 0x00,
  0x38, 0x0E, 0x07, 0x00, 0x3C, 0x0E, 0x03, 0xC0, 0x1C, 0x0F, 0x01, 0xE0,
  0x1E, 0x0F, 0x00, 0x70, 0x0E, 0x07, 0x00, 0x3C, 0x0F, 0x07, 0x80, 0x0F,
  0x0F, 0x07, 0x80, 0x07, 0xFF, 0x03, 0x80, 0x01, 0xFF, 0x03, 0x80, 0x00,
  0x3E, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x3F, 0x80, 0x00, 0x70, 0x3F,
  0xE0, 0x00, 0x70, 0x7F, 0xF8, 0x00, 0x78, 0x3C, 0x1E, 0x00, 0x78, 0x3C,
  0x07, 0x00, 0x38, 0x3C, 0x03, 0x80, 0x3C, 0x1C, 0x01, 0xE0, 0x3C, 0x0E,
  0x00, 0xF0, 0x1C, 0x0F, 0x00, 0x78, 0x1C, 0x07, 0x00, 0x3C, 0x1E, 0x03,
  0x80, 0x1C, 0x1E, 0x01, 0xC0, 0x0E, 0x0E, 0x00, 0xE0, 0x07, 0x0F, 0x00,
  0x70, 0x03, 0x87, 0x00, 0x38, 0x03, 0xC0, 0x80, 0x1C, 0x01, 0xC0, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x3C, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x78, 0x1F, 0x00,
  0x00, 0x1E, 0x0F, 0x80, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x00, 0xF7, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0x3C, 0x00, 0x00, 0x1F, 0x8F, 0x80, 0x0F, 0x0F,
  0x81, 0xE0, 0x03, 0xC7, 0xC0, 0x3C, 0x00, 0xE1, 0xE0, 0x0F, 0x80, 0x78,
  0xF8, 0x01, 0xE0, 0x1E, 0x7C, 0x00, 0x7C, 0x07, 0x9E, 0x00, 0x0F, 0x03,
  0xC7, 0x80, 0x01, 0xE0, 0xF3, 0xC0, 0x00, 0x7C, 0x78, 0xF0, 0x00, 0x0F,
  0x1E, 0x3C, 0x00, 0x03, 0xEF, 0x0F, 0x00, 0x00, 0x7B, 0xC3, 0xC0, 0x00,
  0x0F, 0xE0, 0xF0, 0x00, 0x03, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3F, 0xE0, 0x3E, 0x00, 0x1F, 0xF8, 0x0F,
  0xC0, 0x1F, 0x9F, 0x01, 0xFF, 0xFF, 0xC3, 0xC0, 0x1F, 0xFF, 0xC0, 0x78,
  0x03, 0xFF, 0xC0, 0x1F, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0xF3, 0xCF,
  0x38, 0xE3, 0x9E, 0x79, 0xC7, 0x1C, 0x73, 0xCE, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x04,
  0xC0, 0x0E, 0x00, 0xE7, 0xE0, 0x38, 0x0F, 0xDF, 0xE0, 0xE1, 0xFF, 0xFF,
  0xF3, 0xBF, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xDC,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x3C, 0x07, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0x3C, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0x00, 0x03, 0x80, 0x08,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x83, 0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x3C,
  0x3C, 0x1E, 0x1F, 0x0F, 0x0F, 0x87, 0x87, 0x83, 0x80, 0x80, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0xFD, 0xFF, 0xF7,
  0xEF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xE0,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x00,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x0E, 0x1E, 0x00,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3F, 0x1E, 0x00, 0x00, 0x7F, 0x3C, 0x00,
  0x00, 0xFF, 0x3C, 0x00, 0x01, 0xEE, 0x3C, 0x00, 0x07, 0xDE, 0x3C, 0x00,
  0x0F, 0x9E, 0x38, 0x00, 0x1F, 0x1E, 0x78, 0x00, 0x3C, 0x1E, 0x78, 0x00,
  0xF8, 0x1E, 0x78, 0x01, 0xF0, 0x1E, 0x78, 0x03, 0xE0, 0x1C, 0x78, 0x07,
  0x80, 0x3C, 0x70, 0x1F, 0x00, 0x3C, 0xF0, 0x3E, 0x00, 0x3C, 0xF0, 0x7C,
  0x00, 0x3C, 0xF0, 0xF0, 0x00, 0x3C, 0xF3, 0xE0, 0x00, 0x38, 0xF7, 0xC0,
  0x00, 0x78, 0xFF, 0x80, 0x00, 0x78, 0xFE, 0x00, 0x00, 0x78, 0xFC, 0x00,
  0x00, 0x78, 0xF8, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x80, 0x3C, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0xE0,
  0x3F, 0xFC, 0x3F, 0xF7, 0x9F, 0xF0, 0xF3, 0xF8, 0x1C, 0xF8, 0x07, 0x9C,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x7F,
  0x80, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x03, 0xE0, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0F, 0x81, 0xE0, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x7F, 0x80,
  0x07, 0xE0, 0x07, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x7C,
  0x03, 0xC0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x04, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x0F,
  0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xF8,
  0x1E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00,
  0xF0, 0x0E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x03, 0xC0, 0x07, 0x80,
  0x01, 0xE0, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0xFE, 0x00, 0x00, 0x79, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1C, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0xF0, 0x1C,
  0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x01, 0xE0,
  0xFF, 0xE0, 0x07, 0x8F, 0xFF, 0xE0, 0x1C, 0x7F, 0xFF, 0xC0, 0xF7, 0xE0,
  0x1F, 0x83, 0xFE, 0x00, 0x3E, 0x0F, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x00,
  0xF1, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xBC,
  0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01,
  0xE1, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0,
  0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x03, 0xF0,
  0x07, 0xE0, 0x03, 0xE0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x1F, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1F, 0x03,
  0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0x7C, 0x07, 0x80, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFC,
  0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0x00, 0x3F,
  0x00, 0xFC, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0x83, 0xE0, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x03, 0xF3, 0xC0, 0x00, 0x3F, 0x9F, 0x00, 0x03, 0xF8, 0x7C, 0x00,
  0x3D, 0xC3, 0xF0, 0x07, 0xDE, 0x0F, 0xE1, 0xFC, 0xF0, 0x3F, 0xFF, 0xC7,
  0x00, 0xFF, 0xF8, 0x78, 0x01, 0xFF, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x3F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x06, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x04, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x0F, 0xC0, 0x1F, 0x07,
  0xC0, 0x03, 0xE3, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x1F, 0x78, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x70, 0x03, 0x80, 0xF0, 0x0F, 0xF0, 0x0E, 0x03, 0x80, 0x7F, 0xF0,
  0x38, 0x1C, 0x03, 0xE3, 0xC0, 0xE0, 0xF0, 0x1E, 0x03, 0x03, 0x83, 0x80,
  0xF0, 0x1C, 0x0E, 0x1E, 0x07, 0x80, 0x70, 0x38, 0x70, 0x1C, 0x01, 0x80,
  0xE1, 0xC0, 0xE0, 0x06, 0x03, 0x8E, 0x03, 0x80, 0x38, 0x0E, 0x38, 0x1C,
  0x00, 0xE0, 0x38, 0xE0, 0x70, 0x03, 0x00, 0xE7, 0x01, 0xC0, 0x0C, 0x03,
  0x9C, 0x0E, 0x00, 0x70, 0x0E, 0x70, 0x38, 0x01, 0xC0, 0x31, 0xC0, 0xE0,
  0x06, 0x01, 0xCE, 0x03, 0x80, 0x38, 0x07, 0x38, 0x1C, 0x00, 0xE0, 0x1C,
  0xE0, 0x70, 0x03, 0x80, 0x63, 0x81, 0xC0, 0x1C, 0x03, 0x8E, 0x07, 0x00,
  0x70, 0x0E, 0x38, 0x1C, 0x03, 0xC0, 0x30, 0xE0, 0x70, 0x1F, 0x01, 0xC3,
  0x81, 0xC0, 0x7C, 0x06, 0x0E, 0x07, 0x03, 0xF0, 0x38, 0x38, 0x1E, 0x3D,
  0xC1, 0xC0, 0xE0, 0x3F, 0xE3, 0xFE, 0x03, 0x80, 0xFF, 0x0F, 0xF0, 0x0F,
  0x01, 0xF0, 0x1F, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0x00, 0x00, 0x3F, 0x00, 0x3C,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3B, 0xC0, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x03, 0xC7, 0x00, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0x1C, 0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x01, 0xE0,
  0x0F, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0x00, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x00, 0x70, 0x3C, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x1E, 0x7C,
  0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0xEF, 0x80, 0x00, 0x00, 0x3B,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0x80, 0x07, 0xF8, 0x01, 0xE0, 0x00,
  0x3F, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x03,
  0xE0, 0x1E, 0x00, 0x03, 0xF0, 0x07, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0xF8, 0x1E, 0x00,
  0x00, 0x7E, 0x07, 0x80, 0x00, 0x3F, 0x01, 0xC0, 0x00, 0x3F, 0x80, 0xFF,
  0xC1, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x01, 0xF0, 0x07, 0x80,
  0x00, 0x3C, 0x03, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x1F, 0xC0, 0x00, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00,
  0x0E, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x78, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x3E, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x38, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x7E, 0x00, 0x78, 0x00,
  0x0F, 0xC0, 0x07, 0x80, 0x03, 0xF8, 0x00, 0x78, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x78,
  0x3E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0xF3, 0xC0, 0x01, 0xFF, 0xFC,
  0xF0, 0x00, 0x7F, 0xFE, 0x3C, 0x00, 0x3F, 0xFF, 0x8F, 0x00, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x03, 0xF0,
  0x03, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x00, 0x38, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x1E, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x0E, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x3C, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x1C, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x1C, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7E, 0x01, 0xE0, 0x00, 0x01,
  0xF0, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x0E,
  0x00, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x7C,
  0x00, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x00,
  0x3C, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0x00, 0xE1, 0xF0,
  0x00, 0x00, 0x03, 0xC7, 0xF0, 0x00, 0x00, 0x07, 0x9F, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF3, 0xC0, 0x00, 0x00, 0x3F, 0xC3,
  0xC0, 0x00, 0x00, 0x7F, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03, 0xDE, 0x01,
  0xDE, 0x00, 0x0F, 0x70, 0x07, 0x78, 0x00, 0x79, 0xC0, 0x3C, 0xE0, 0x01,
  0xEF, 0x00, 0xF3, 0x80, 0x0F, 0x3C, 0x03, 0xCE, 0x00, 0x3C, 0xF0, 0x0F,
  0x3C, 0x01, 0xE3, 0x80, 0x38, 0xF0, 0x07, 0x8E, 0x00, 0xE1, 0xC0, 0x3C,
  0x78, 0x07, 0x87, 0x00, 0xE1, 0xE0, 0x1E, 0x1C, 0x07, 0x87, 0x80, 0x78,
  0x70, 0x3C, 0x1E, 0x01, 0xE1, 0xE0, 0xF0, 0x70, 0x07, 0x07, 0x87, 0x81,
  0xC0, 0x1C, 0x0E, 0x1E, 0x0F, 0x00, 0xF0, 0x38, 0xF0, 0x3C, 0x03, 0xC0,
  0xE3, 0xC0, 0xF0, 0x0F, 0x03, 0x9E, 0x03, 0xC0, 0x3C, 0x0F, 0x78, 0x0E,
  0x00, 0xE0, 0x3F, 0xC0, 0x78, 0x07, 0x80, 0x7E, 0x01, 0xE0, 0x1E, 0x01,
  0xF8, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x1E, 0x01, 0xE0, 0x1F, 0x00, 0x78,
  0x07, 0x80, 0x78, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x1E, 0x03,
  0xF0, 0x00, 0x00, 0xF0, 0x1F, 0xC0, 0x00, 0x07, 0x80, 0xFE, 0x00, 0x00,
  0x78, 0x07, 0xF0, 0x00, 0x03, 0xC0, 0x3F, 0xC0, 0x00, 0x1E, 0x01, 0xDE,
  0x00, 0x00, 0xF0, 0x1E, 0x70, 0x00, 0x07, 0x80, 0xF3, 0xC0, 0x00, 0x3C,
  0x07, 0x9E, 0x00, 0x03, 0xC0, 0x3C, 0x70, 0x00, 0x1E, 0x01, 0xE3, 0xC0,
  0x00, 0xF0, 0x0E, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x78, 0x00, 0x3C, 0x07,
  0x83, 0xC0, 0x01, 0xC0, 0x3C, 0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x78, 0x00,
  0xF0, 0x0F, 0x03, 0xC0, 0x07, 0x80, 0x70, 0x1E, 0x00, 0x3C, 0x07, 0x80,
  0x78, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xF0,
  0x0F, 0x00, 0x78, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x0E,
  0x01, 0xE0, 0x3C, 0x00, 0x78, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0xF0, 0x0F,
  0x00, 0x0F, 0x07, 0x80, 0x78, 0x00, 0x78, 0x3C, 0x03, 0xC0, 0x03, 0xC1,
  0xE0, 0x3C, 0x00, 0x0F, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x78, 0x0F, 0x00,
  0x03, 0xC7, 0x80, 0x78, 0x00, 0x0F, 0x3C, 0x03, 0xC0, 0x00, 0x79, 0xE0,
  0x1C, 0x00, 0x01, 0xCF, 0x01, 0xE0, 0x00, 0x0F, 0x78, 0x0F, 0x00, 0x00,
  0x7B, 0x80, 0x78, 0x00, 0x01, 0xFC, 0x03, 0xC0, 0x00, 0x0F, 0xE0, 0x1E,
  0x00, 0x00, 0x7F, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0x00, 0x00, 0x0F,
  0xC0, 0x78, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x0F, 0xC0,
  0x07, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x3C,
  0x03, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x38, 0x00,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x01, 0xF0,
  0x07, 0xC0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x00, 0x3F, 0x80,
  0x1E, 0x00, 0x01, 0xF8, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x0E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x00, 0xF8, 0x1E, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x78,
  0x00, 0x07, 0xE0, 0x0E, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x03,
  0xCE, 0x00, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x01, 0xE7, 0x00, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF8, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xC3, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x78, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x7C, 0x01, 0xC0,
  0x00, 0x3F, 0x00, 0x78, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0xE0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x78,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x7C, 0x07, 0x80,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1F, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xF0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x0F,
  0x80, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x7C,
  0x0F, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x00, 0x3E, 0x1E, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x01, 0xF0,
  0x1F, 0x80, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x1F,
  0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x3C, 0x0E, 0x00,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x1E,
  0x07, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x1C, 0x00,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0x3C,
  0x0E, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x70, 0x3C, 0x00,
  0x00, 0x1E, 0x07, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00,
  0xF9, 0xE0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x7C, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x03, 0xC0,
  0x07, 0x80, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x0F, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x00, 0x38, 0x3C, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x07, 0x78,
  0x00, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x80, 0x0F, 0x78, 0x00, 0xF8,
  0x00, 0xF7, 0x80, 0x0F, 0x80, 0x0E, 0x78, 0x01, 0xF8, 0x01, 0xE7, 0x80,
  0x1F, 0x80, 0x1E, 0x78, 0x01, 0xF8, 0x01, 0xC7, 0x80, 0x3F, 0x80, 0x3C,
  0x78, 0x03, 0xB8, 0x03, 0xC7, 0x80, 0x3B, 0x80, 0x3C, 0x78, 0x07, 0xB8,
  0x03, 0x87, 0x80, 0x73, 0x80, 0x78, 0x78, 0x07, 0x38, 0x07, 0x87, 0x00,
  0xF3, 0x80, 0x70, 0x70, 0x0E, 0x38, 0x0F, 0x07, 0x00, 0xE3, 0x80, 0xF0,
  0x70, 0x1E, 0x38, 0x0F, 0x07, 0x01, 0xC3, 0x80, 0xE0, 0x70, 0x1C, 0x38,
  0x1E, 0x07, 0x03, 0xC3, 0x81, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x07, 0x03,
  0x83, 0x83, 0xC0, 0x70, 0x78, 0x38, 0x3C, 0x07, 0x07, 0x03, 0x83, 0x80,
  0x70, 0x70, 0x38, 0x38, 0x07, 0x0F, 0x03, 0x87, 0x80, 0x70, 0xE0, 0x38,
  0x78, 0x07, 0x0E, 0x03, 0x87, 0x00, 0x71, 0xE0, 0x38, 0xF0, 0x07, 0x1C,
  0x03, 0x8F, 0x00, 0x71, 0xC0, 0x38, 0xE0, 0x07, 0x3C, 0x03, 0x8E, 0x00,
  0x73, 0x80, 0x39, 0xE0, 0x07, 0x38, 0x03, 0x9E, 0x00, 0x77, 0x80, 0x39,
  0xC0, 0x0F, 0x70, 0x03, 0xBC, 0x00, 0xF7, 0x00, 0x3B, 0xC0, 0x0F, 0xF0,
  0x03, 0xB8, 0x00, 0xFE, 0x00, 0x3B, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0xF8, 0x00, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x00, 0x1F,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x00, 0x1E,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x07, 0xDE, 0x00,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x7C, 0x3C,
  0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1C,
  0x07, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00,
  0x38, 0x7C, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x00, 0x73, 0xC0, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3C, 0x70,
  0x00, 0x38, 0x70, 0x00, 0x78, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78,
  0x01, 0xE0, 0x38, 0x01, 0xE0, 0x38, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x3C,
  0x07, 0x80, 0x1C, 0x0F, 0x00, 0x1C, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x1E,
  0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x0E, 0x38, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFC, 0xF8, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0E, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x01, 0xE0, 0xFE, 0x00, 0x03, 0xC3, 0xF0,
  0x00, 0x07, 0x0F, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x7C, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x7E, 0x1E, 0x00, 0x01,
  0xFC, 0x3E, 0x00, 0x07, 0xF8, 0x3E, 0x00, 0x3E, 0xF0, 0x7E, 0x01, 0xF9,
  0xE0, 0x7F, 0xFF, 0xE3, 0xC0, 0x7F, 0xFF, 0x07, 0x80, 0x3F, 0xF8, 0x0F,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x38, 0x00, 0x03, 0xC1, 0xFF, 0x80, 0x03, 0xC7, 0xFF,
  0xE0, 0x03, 0x8F, 0xFF, 0xF0, 0x03, 0xBF, 0x01, 0xF8, 0x07, 0xFC, 0x00,
  0xF8, 0x07, 0xF0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x3C, 0x07, 0xC0, 0x00,
  0x3E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x01,
  0xF0, 0x7E, 0x00, 0x03, 0xE0, 0x7F, 0x00, 0x07, 0xC0, 0x7F, 0x80, 0x0F,
  0xC0, 0x73, 0xE0, 0x3F, 0x80, 0xF3, 0xFF, 0xFF, 0x00, 0xF0, 0xFF, 0xFC,
  0x00, 0xF0, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x01, 0xFC, 0x07, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF3, 0xE0,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x7C, 0x0F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x1F,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x30,
  0x03, 0xC0, 0x00, 0x7F, 0xE0, 0x78, 0x00, 0x3F, 0xFF, 0x0F, 0x00, 0x0F,
  0xFF, 0xF3, 0xE0, 0x07, 0xF0, 0x1F, 0x78, 0x01, 0xF8, 0x00, 0xFF, 0x00,
  0x3E, 0x00, 0x0F, 0xE0, 0x0F, 0x80, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x78, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0xF8, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x03, 0x80,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x07, 0xC0, 0x07, 0xF8, 0x00, 0xFC, 0x07,
  0xEE, 0x00, 0x0F, 0xFF, 0xF9, 0xC0, 0x00, 0xFF, 0xFC, 0x78, 0x00, 0x07,
  0xFE, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1E, 0x03,
  0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x38, 0x7C,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x03, 0xCE, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F, 0x7F, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x08, 0x0F, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0xF8,
  0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x80, 0x1F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x40, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x03, 0xFE, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0xF0, 0x00, 0xFF, 0xFC, 0x3C, 0x00, 0x7F, 0xFF, 0x8F, 0x00, 0x7F,
  0x01, 0xF3, 0x80, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0x80, 0x03, 0xF8, 0x07,
  0xC0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x00,
  0x00, 0x07, 0x81, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x1C,
  0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0xF0, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x0F, 0xE0, 0x07, 0xC0, 0x07,
  0xF8, 0x01, 0xF8, 0x07, 0xDC, 0x00, 0x3F, 0xFF, 0xEF, 0x00, 0x07, 0xFF,
  0xE3, 0xC0, 0x00, 0x7F, 0xE0, 0xF0, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x80, 0x00, 0x1E, 0x00,
  0x70, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x0C, 0x00, 0x03, 0xC0, 0xFF, 0xC0, 0x03, 0xC3,
  0xFF, 0xF0, 0x03, 0x87, 0xFF, 0xF8, 0x07, 0x8F, 0x80, 0xFC, 0x07, 0x9E,
  0x00, 0x7C, 0x07, 0xB8, 0x00, 0x3E, 0x07, 0xF0, 0x00, 0x1E, 0x07, 0xE0,
  0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x0E, 0x0F, 0x00,
  0x00, 0x0E, 0x0F, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x0E, 0x0F, 0x00,
  0x00, 0x1E, 0x0E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1C, 0x1E, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0x70, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x3F, 0x07, 0x80, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x3E,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x78, 0x00, 0x7E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0xFC,
  0x00, 0x0F, 0x00, 0xFC, 0x00, 0x07, 0x80, 0xFC, 0x00, 0x03, 0xC0, 0xF8,
  0x00, 0x01, 0xE1, 0xF8, 0x00, 0x01, 0xE1, 0xF8, 0x00, 0x00, 0xF1, 0xF8,
  0x00, 0x00, 0x79, 0xF8, 0x00, 0x00, 0x3D, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x0F, 0xF7, 0xC0, 0x00, 0x0F, 0xF1, 0xE0, 0x00, 0x07, 0xE0,
  0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0xF0,
  0x07, 0xC0, 0x00, 0x70, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x03, 0xC0, 0x07,
  0x80, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x01, 0xF0,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x8F, 0xF8,
  0x1F, 0xE0, 0x0F, 0x3F, 0xF8, 0xFF, 0xE0, 0x1E, 0xFF, 0xF3, 0xFF, 0xE0,
  0x3B, 0x81, 0xFF, 0x03, 0xC0, 0x7E, 0x01, 0xFC, 0x03, 0xC0, 0xF8, 0x03,
  0xF0, 0x07, 0x81, 0xE0, 0x07, 0xC0, 0x0F, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x70, 0x00, 0xE0, 0x01, 0xE1, 0xE0, 0x01, 0xC0, 0x03,
  0x83, 0xC0, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0xF0, 0x00, 0xE0, 0x01, 0xC1, 0xE0, 0x03, 0xC0, 0x07, 0x83, 0xC0,
  0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x00,
  0x3C, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0xF0,
  0x01, 0xE0, 0x03, 0xC1, 0xE0, 0x03, 0xC0, 0x07, 0x83, 0xC0, 0x07, 0x80,
  0x0F, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x3C,
  0x00, 0x78, 0x00, 0x70, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0,
  0x03, 0xC1, 0xE0, 0x03, 0xC0, 0x07, 0x83, 0x80, 0x07, 0x00, 0x0F, 0x0F,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x03, 0xC0, 0xFF,
  0xC0, 0x03, 0x83, 0xFF, 0xF0, 0x03, 0x87, 0xFF, 0xF8, 0x07, 0x9F, 0x80,
  0xFC, 0x07, 0xBC, 0x00, 0x7C, 0x07, 0xB8, 0x00, 0x3E, 0x07, 0x70, 0x00,
  0x1E, 0x07, 0xE0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1E, 0x0F, 0x80, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00,
  0x78, 0x38, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00,
  0xF0, 0x70, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x3E,
  0x03, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x1F, 0x0F, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0xFC, 0x00, 0x07, 0x0F,
  0xFF, 0xC0, 0x01, 0xCF, 0xFF, 0xF8, 0x00, 0xF7, 0xE0, 0x7F, 0x00, 0x3F,
  0xC0, 0x07, 0xC0, 0x0F, 0xE0, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x1E, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x7C,
  0x0F, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07,
  0xC0, 0x3F, 0x00, 0x03, 0xE0, 0x0F, 0xE0, 0x01, 0xF0, 0x07, 0xFE, 0x01,
  0xFC, 0x01, 0xE7, 0xFF, 0xFC, 0x00, 0x78, 0xFF, 0xFE, 0x00, 0x1E, 0x0F,
  0xFE, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x0F, 0x00, 0x3F,
  0xFF, 0x0F, 0x00, 0x7F, 0xFF, 0x8F, 0x01, 0xFC, 0x07, 0xDE, 0x03, 0xF0,
  0x01, 0xFE, 0x03, 0xE0, 0x00, 0xFE, 0x07, 0xC0, 0x00, 0x7E, 0x0F, 0x80,
  0x00, 0x3E, 0x0F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x3C, 0x3E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0x78, 0x70, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0xF0, 0x70, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x03, 0xE0, 0x3C, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0xE0, 0x1F, 0x00,
  0x1F, 0xE0, 0x1F, 0x80, 0x7D, 0xC0, 0x0F, 0xFF, 0xFB, 0xC0, 0x07, 0xFF,
  0xE3, 0xC0, 0x01, 0xFF, 0x83, 0xC0, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x1E, 0x03, 0xFF, 0xC0, 0xF0, 0x7F,
  0xFE, 0x07, 0x87, 0xFF, 0xF0, 0x3C, 0xFF, 0x83, 0x81, 0xCF, 0xC0, 0x00,
  0x1E, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x1F,
  0x80, 0x7E, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1F,
  0x07, 0x80, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x7C, 0x0F, 0x00, 0x01, 0xF8, 0x1E, 0x00, 0x07, 0xF0, 0x3E, 0x00, 0x3D,
  0xE0, 0x3F, 0x01, 0xF3, 0xC0, 0x3F, 0xFF, 0xC7, 0x00, 0x3F, 0xFF, 0x0E,
  0x00, 0x3F, 0xF8, 0x3C, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x07, 0xC7, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x03, 0xE0, 0xE0, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0xF0, 0x07, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x78, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x01,
  0xC0, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x70, 0xF0, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFE, 0x00, 0x0E, 0x00, 0x0E, 0xE0,
  0x01, 0xE0, 0x01, 0xEE, 0x00, 0x1E, 0x00, 0x1E, 0xE0, 0x03, 0xE0, 0x01,
  0xCE, 0x00, 0x3F, 0x00, 0x3C, 0xF0, 0x03, 0xF0, 0x03, 0x8F, 0x00, 0x77,
  0x00, 0x78, 0xF0, 0x07, 0x70, 0x07, 0x8F, 0x00, 0xF7, 0x00, 0x70, 0xF0,
  0x0E, 0x70, 0x0F, 0x0F, 0x00, 0xE7, 0x00, 0xE0, 0xF0, 0x1C, 0x70, 0x0E,
  0x0F, 0x01, 0xC7, 0x01, 0xE0, 0xF0, 0x3C, 0x70, 0x1C, 0x0F, 0x03, 0x87,
  0x03, 0xC0, 0xF0, 0x78, 0x70, 0x38, 0x07, 0x07, 0x07, 0x03, 0x80, 0x70,
  0x70, 0x70, 0x78, 0x07, 0x0E, 0x07, 0x07, 0x00, 0x70, 0xE0, 0x38, 0x70,
  0x07, 0x1E, 0x03, 0x8F, 0x00, 0x71, 0xC0, 0x38, 0xE0, 0x07, 0x1C, 0x03,
  0x9E, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x07, 0x38, 0x03, 0x9C, 0x00, 0x77,
  0x80, 0x3B, 0xC0, 0x07, 0x70, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x3B, 0x80,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0xF8, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00,
  0x0F, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xEF,
  0x00, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x00,
  0x3E, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00,
  0x07, 0x81, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x03,
  0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xC3, 0xFF, 0xF0, 0x00, 0x0E, 0x3F, 0xBF,
  0xC0, 0x00, 0xF3, 0xE0, 0x3F, 0x00, 0x07, 0x1E, 0x00, 0x7C, 0x00, 0x79,
  0xE0, 0x01, 0xF0, 0x07, 0xCE, 0x00, 0x07, 0xE0, 0x7C, 0x70, 0x00, 0x1F,
  0xFF, 0xC7, 0x80, 0x00, 0x7F, 0xFC, 0x18, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00,
};

const GFXglyph RobotoMono_LightItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 12, 48, 40, 14, -48 },
  { 73, 16, 15, 40, 15, -51 },
  { 103, 39, 48, 40, 1, -48 },
  { 337, 33, 63, 40, 4, -56 },
  { 597, 33, 50, 40, 4, -49 },
  { 804, 34, 50, 40, 3, -49 },
  { 1017, 6, 15, 40, 19, -51 },
  { 1029, 22, 70, 40, 11, -54 },
  { 1222, 21, 70, 40, 6, -54 },
  { 1406, 30, 29, 40, 8, -48 },
  { 1515, 33, 35, 40, 4, -40 },
  { 1660, 9, 16, 40, 8, -6 },
  { 1678, 25, 3, 40, 7, -23 },
  { 1688, 7, 6, 40, 14, -6 },
  { 1694, 32, 52, 40, 5, -48 },
  { 1902, 32, 50, 40, 5, -49 },
  { 2102, 19, 48, 40, 10, -48 },
  { 2216, 33, 49, 40, 1, -49 },
  { 2419, 33, 50, 40, 2, -49 },
  { 2626, 34, 48, 40, 1, -48 },
  { 2830, 34, 49, 40, 5, -48 },
  { 3039, 30, 50, 40, 4, -49 },
  { 3227, 31, 48, 40, 8, -48 },
  { 3413, 33, 50, 40, 4, -49 },
  { 3620, 29, 49, 40, 7, -49 },
  { 3798, 12, 35, 40, 16, -35 },
  { 3851, 16, 45, 40, 12, -35 },
  { 3941, 31, 28, 40, 5, -36 },
  { 4050, 32, 18, 40, 4, -31 },
  { 4122, 31, 28, 40, 4, -36 },
  { 4231, 26, 49, 40, 10, -49 },
  { 4391, 38, 49, 40, 2, -49 },
  { 4624, 34, 48, 40, 0, -48 },
  { 4828, 34, 48, 40, 3, -48 },
  { 5032, 34, 50, 40, 4, -49 },
  { 5245, 36, 48, 40, 2, -48 },
  { 5461, 36, 48, 40, 3, -48 },
  { 5677, 36, 48, 40, 3, -48 },
  { 5893, 34, 50, 40, 4, -49 },
  { 6106, 37, 48, 40, 2, -48 },
  { 6328, 35, 48, 40, 3, -48 },
  { 6538, 36, 49, 40, 2, -48 },
  { 6759, 39, 48, 40, 3, -48 },
  { 6993, 28, 48, 40, 4, -48 },
  { 7161, 38, 48, 40, 2, -48 },
  { 7389, 37, 48, 40, 2, -48 },
  { 7611, 33, 50, 40, 4, -49 },
  { 7818, 35, 48, 40, 4, -48 },
  { 8028, 35, 57, 40, 3, -49 },
  { 8278, 35, 48, 40, 3, -48 },
  { 8488, 35, 50, 40, 3, -49 },
  { 8707, 35, 48, 40, 7, -48 },
  { 8917, 35, 49, 40, 4, -48 },
  { 9132, 34, 48, 40, 7, -48 },
  { 9336, 36, 48, 40, 6, -48 },
  { 9552, 41, 48, 40, 0, -48 },
  { 9798, 34, 48, 40, 7, -48 },
  { 10002, 37, 48, 40, 1, -48 },
  { 10224, 21, 65, 40, 10, -55 },
  { 10395, 14, 52, 40, 13, -48 },
  { 10486, 22, 65, 40, 9, -55 },
  { 10665, 24, 26, 40, 8, -48 },
  { 10743, 29, 3, 40, 2, 0 },
  { 10754, 9, 9, 40, 19, -50 },
  { 10765, 31, 38, 40, 3, -37 },
  { 10913, 32, 52, 40, 3, -51 },
  { 11121, 30, 38, 40, 5, -37 },
  { 11264, 35, 52, 40, 4, -51 },
  { 11492, 31, 38, 40, 4, -37 },
  { 11640, 34, 52, 40, 8, -52 },
  { 11861, 34, 51, 40, 2, -37 },
  { 12078, 32, 51, 40, 3, -51 },
  { 12282, 28, 49, 40, 4, -49 },
  { 12454, 30, 64, 40, 1, -49 },
  { 12694, 33, 51, 40, 4, -51 },
  { 12905, 28, 51, 40, 4, -51 },
  { 13084, 39, 37, 40, -1, -37 },
  { 13265, 32, 37, 40, 3, -37 },
  { 13413, 31, 38, 40, 4, -37 },
  { 13561, 34, 51, 40, 0, -37 },
  { 13778, 32, 51, 40, 4, -37 },
  { 13982, 29, 37, 40, 8, -37 },
  { 14117, 31, 38, 40, 4, -37 },
  { 14265, 27, 46, 40, 8, -45 },
  { 14421, 31, 37, 40, 5, -36 },
  { 14565, 33, 36, 40, 6, -36 },
  { 14714, 36, 36, 40, 5, -36 },
  { 14876, 37, 36, 40, 1, -36 },
  { 15043, 41, 51, 40, -1, -36 },
  { 15305, 34, 36, 40, 2, -36 },
  { 15458, 27, 66, 40, 10, -53 },
  { 15681, 13, 59, 40, 13, -48 },
  { 15777, 26, 66, 40, 6, -53 },
  { 15992, 37, 12, 40, 1, -26 },
};

const GFXfont RobotoMono_LightItalic68pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic68pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic68pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _ROBOTOMONO_LIGHTITALIC68PT7B_H_
