#ifndef _ROBOTOMONO_LIGHTITALIC43PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x0C, 0x18, 0x70, 0xE1, 0xC3, 0x06, 0x0C, 0x38, 0x70, 0xE1,
  0x83, 0x06, 0x1C, 0x38, 0x70, 0xC1, 0x83, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x1C, 0x38, 0x00, 0x61, 0xD8, 0x66, 0x19, 0x86, 0x61, 0xB0,
  0x6C, 0x33, 0x0C, 0xC3, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x06, 0x03, 0x00,
  0x03, 0x03, 0x00, 0x03, 0x81, 0x80, 0x01, 0x81, 0xC0, 0x00, 0xC0, 0xC0,
  0x00, 0xC0, 0x60, 0x00, 0x60, 0x70, 0x00, 0x30, 0x30, 0x0F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xC0, 0x0C, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x06,
  0x00, 0x07, 0x03, 0x00, 0x03, 0x01, 0x80, 0x01, 0x81, 0x80, 0x01, 0xC0,
  0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x60, 0x60, 0x0F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xC0, 0x18, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x06,
  0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80, 0x01,
  0x80, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0x8F,
  0x80, 0xF0, 0x1C, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x83, 0x00, 0x0C, 0x38,
  0x00, 0x61, 0xC0, 0x03, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x01, 0x8E, 0x00, 0x1C, 0x70, 0x00,
  0xE3, 0x80, 0x0E, 0x0E, 0x00, 0xF0, 0x38, 0x0F, 0x01, 0xFF, 0xF0, 0x03,
  0xFE, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x0F, 0x00, 0x03, 0xF8, 0x00, 0x70, 0xC0, 0x06, 0x0C, 0x00, 0xC0,
  0xC0, 0x6C, 0x0C, 0x0C, 0xC0, 0xC1, 0xCC, 0x0C, 0x18, 0xC0, 0xC3, 0x0C,
  0x0C, 0x70, 0xC1, 0x86, 0x0E, 0x38, 0xC0, 0x7F, 0x18, 0x03, 0xC3, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x87,
  0xC0, 0x30, 0xEE, 0x03, 0x18, 0x30, 0x63, 0x83, 0x0C, 0x30, 0x31, 0xC3,
  0x03, 0x18, 0x30, 0x33, 0x03, 0x03, 0x70, 0x70, 0x32, 0x03, 0x06, 0x00,
  0x30, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x07, 0xF8,
  0x00, 0x78, 0xE0, 0x07, 0x03, 0x00, 0x38, 0x1C, 0x03, 0x80, 0xE0, 0x1C,
  0x07, 0x00, 0xE0, 0x30, 0x07, 0x03, 0x80, 0x38, 0x38, 0x01, 0xC3, 0x80,
  0x06, 0x38, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0xE3, 0x80, 0xCE, 0x0C, 0x06, 0xE0, 0x70, 0x77,
  0x01, 0xC3, 0xF0, 0x0E, 0x1B, 0x80, 0x39, 0xD8, 0x00, 0xCC, 0xC0, 0x07,
  0xE6, 0x00, 0x1E, 0x38, 0x00, 0xE0, 0xC0, 0x0F, 0x87, 0x81, 0xEE, 0x1F,
  0xFE, 0x70, 0x3F, 0xC1, 0xC0, 0x37, 0x66, 0x66, 0x6C, 0xC0, 0x00, 0x08,
  0x00, 0x70, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xC0,
  0x07, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80,
  0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x60, 0x00, 0x80, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00,
  0x30, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00,
  0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0,
  0x06, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0x00, 0x38, 0x03, 0x80, 0x30,
  0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x18, 0x1B, 0xC3, 0x1F, 0xFE, 0x6F,
  0xE1, 0xFF, 0xC0, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x0E, 0x60,
  0x03, 0x86, 0x00, 0xE0, 0xE0, 0x38, 0x0C, 0x0E, 0x01, 0xC0, 0x40, 0x10,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x03, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x1C,
  0x71, 0x86, 0x38, 0xE3, 0x1C, 0xE3, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xF7, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8,
  0x03, 0xC3, 0xC0, 0x70, 0x0E, 0x0E, 0x00, 0x60, 0xC0, 0x07, 0x1C, 0x00,
  0x71, 0x80, 0x03, 0x38, 0x00, 0x33, 0x00, 0x0F, 0x30, 0x01, 0xF7, 0x00,
  0x3B, 0x70, 0x07, 0x77, 0x01, 0xE7, 0x60, 0x38, 0x76, 0x07, 0x06, 0x60,
  0xE0, 0x6E, 0x3C, 0x06, 0xE7, 0x00, 0xEE, 0xE0, 0x0E, 0xFC, 0x00, 0xEF,
  0x00, 0x0C, 0xE0, 0x00, 0xCC, 0x00, 0x1C, 0xE0, 0x01, 0x8E, 0x00, 0x38,
  0x60, 0x07, 0x07, 0x00, 0xE0, 0x38, 0x1E, 0x01, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0x00, 0x10, 0x07, 0x01, 0xF0, 0xFF, 0x3E, 0x67, 0x86, 0xC0, 0x60,
  0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0,
  0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00, 0xF0, 0x78, 0x0E, 0x01, 0xC0, 0xE0,
  0x07, 0x06, 0x00, 0x18, 0x70, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x31,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0x00, 0x07, 0xFE, 0x00, 0xF8, 0x78, 0x0F, 0x00, 0xE0, 0x70, 0x03, 0x07,
  0x00, 0x1C, 0x30, 0x00, 0xE3, 0x80, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x9C, 0x00,
  0x1C, 0xE0, 0x00, 0xC7, 0x00, 0x0E, 0x18, 0x00, 0x70, 0xE0, 0x07, 0x03,
  0x80, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xB0,
  0x00, 0x39, 0x80, 0x01, 0x8C, 0x00, 0x1C, 0xE0, 0x01, 0xC7, 0x00, 0x1C,
  0x30, 0x01, 0xC1, 0x80, 0x0C, 0x0C, 0x00, 0xE0, 0x60, 0x0E, 0x07, 0x00,
  0xE0, 0x38, 0x0E, 0x01, 0x80, 0x60, 0x0C, 0x06, 0x00, 0x60, 0x70, 0x07,
  0x07, 0x00, 0x38, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0x80, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x0E, 0x00, 0x0D, 0xFE, 0x00, 0x7F, 0xFE, 0x01, 0xE0, 0x38, 0x02,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x38, 0x00, 0x30,
  0x60, 0x01, 0xC1, 0x80, 0x06, 0x07, 0x00, 0x38, 0x1C, 0x01, 0xC0, 0x38,
  0x0E, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0x80, 0x07,
  0xE0, 0x07, 0xF8, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC3, 0xF0, 0x73,
  0xFE, 0x1B, 0xC3, 0xC7, 0xC0, 0x39, 0xE0, 0x06, 0xF0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x06, 0xC0, 0x01, 0xB8, 0x00, 0xE6, 0x00, 0x71, 0xC0, 0x38, 0x38,
  0x1E, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00, 0xF8, 0xF8, 0x0F, 0x01, 0xE0, 0xE0,
  0x07, 0x07, 0x00, 0x18, 0x30, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x30,
  0xE0, 0x01, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xC0, 0xE0, 0x0E, 0x03, 0x81,
  0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0x8F, 0x00, 0xE0, 0x1C, 0x0E,
  0x00, 0x70, 0xE0, 0x01, 0x86, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x00, 0x03,
  0x98, 0x00, 0x1C, 0xC0, 0x00, 0xC6, 0x00, 0x0E, 0x38, 0x00, 0x60, 0xE0,
  0x0F, 0x07, 0x80, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x7F, 0xC0, 0x3E, 0x3C, 0x0F, 0x01, 0xC1, 0xC0, 0x1C, 0x70, 0x01,
  0x8C, 0x00, 0x33, 0x80, 0x07, 0x60, 0x00, 0xEC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0D, 0xC0, 0x01, 0xB8, 0x00, 0x73, 0x00, 0x0E,
  0x70, 0x03, 0xC7, 0x01, 0xF8, 0xF0, 0xF6, 0x0F, 0xFC, 0xC0, 0x7E, 0x38,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x00,
  0x0E, 0x0F, 0x1F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0xF0, 0xF0, 0x70, 0x03, 0x80,
  0xF0, 0x7C, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x60, 0x18,
  0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x0E, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x18, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x10, 0x00,
  0x01, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x00, 0x70, 0x00, 0x04, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x07,
  0xC7, 0x87, 0x80, 0xE3, 0x00, 0x33, 0x80, 0x1D, 0x80, 0x0F, 0xC0, 0x07,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x78, 0x38, 0x01, 0xE0,
  0x0C, 0x03, 0x80, 0x06, 0x07, 0x00, 0x06, 0x06, 0x00, 0x02, 0x0C, 0x1F,
  0x83, 0x1C, 0x3D, 0xC3, 0x18, 0x70, 0xC3, 0x38, 0x60, 0xC3, 0x30, 0xC0,
  0xC3, 0x30, 0xC0, 0x83, 0x61, 0x81, 0x83, 0x61, 0x81, 0x82, 0x61, 0x81,
  0x82, 0x43, 0x01, 0x06, 0xC3, 0x03, 0x06, 0xC3, 0x03, 0x04, 0xC3, 0x07,
  0x0C, 0xC3, 0x06, 0x0C, 0xC3, 0x0E, 0x18, 0xC3, 0xBB, 0x38, 0xC1, 0xF3,
  0xF0, 0x60, 0xC1, 0xC0, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1C, 0x06, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x33, 0x00, 0x03, 0x98, 0x00, 0x18, 0xC0, 0x01, 0xC6,
  0x00, 0x0C, 0x30, 0x00, 0xE1, 0xC0, 0x06, 0x0E, 0x00, 0x70, 0x30, 0x03,
  0x01, 0x80, 0x38, 0x0C, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xC0, 0x1C,
  0x0E, 0x00, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x38, 0x00, 0xC3, 0x80,
  0x06, 0x1C, 0x00, 0x30, 0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x60, 0x00, 0x77,
  0x00, 0x01, 0xB0, 0x00, 0x0F, 0x80, 0x00, 0x60, 0x07, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x7F, 0xFE, 0x01, 0x80, 0x3C, 0x0E, 0x00, 0x38, 0x38, 0x00,
  0xE0, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x70, 0x00, 0xE1,
  0xC0, 0x03, 0x87, 0x00, 0x1C, 0x18, 0x00, 0xE0, 0x60, 0x0F, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x38, 0x07, 0xC0, 0xE0, 0x03, 0x83, 0x00, 0x06,
  0x0C, 0x00, 0x1C, 0x30, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x1C,
  0x00, 0x1C, 0x60, 0x00, 0x61, 0x80, 0x03, 0x86, 0x00, 0x1C, 0x38, 0x00,
  0xF0, 0xE0, 0x1F, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x03, 0xFF, 0x00, 0x1E, 0x0F, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0x38,
  0x38, 0x00, 0x60, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x18, 0x00, 0x1C, 0xE0,
  0x00, 0x73, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x07, 0x18, 0x00, 0x18, 0x60, 0x00, 0xE1, 0xC0, 0x03, 0x07, 0x00, 0x1C,
  0x0E, 0x00, 0xE0, 0x1C, 0x0F, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x38, 0x07, 0x80,
  0x70, 0x03, 0x80, 0xC0, 0x07, 0x01, 0x80, 0x07, 0x07, 0x00, 0x06, 0x0E,
  0x00, 0x0C, 0x1C, 0x00, 0x1C, 0x30, 0x00, 0x38, 0x60, 0x00, 0x70, 0xC0,
  0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x06, 0x18, 0x00,
  0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80, 0x01,
  0x87, 0x00, 0x07, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x38, 0x30, 0x00, 0xE0,
  0xE0, 0x01, 0xC1, 0xC0, 0x0F, 0x03, 0x80, 0x3C, 0x06, 0x03, 0xE0, 0x0F,
  0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x00,
  0x1F, 0x1F, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0x38, 0x38, 0x00, 0x60, 0xC0,
  0x01, 0xC7, 0x00, 0x07, 0x18, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x1F, 0xF9, 0x80, 0x7F, 0xEE, 0x01, 0xFF, 0x38, 0x00,
  0x0C, 0xE0, 0x00, 0x33, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x18, 0x00, 0x1C,
  0x60, 0x00, 0x61, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x0E, 0x00, 0x78, 0x1C,
  0x07, 0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0x00, 0x03, 0x06,
  0x00, 0x07, 0x06, 0x00, 0x07, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0E,
  0x00, 0x06, 0x0E, 0x00, 0x06, 0x0C, 0x00, 0x0E, 0x0C, 0x00, 0x0E, 0x0C,
  0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x1C, 0x00, 0x0C, 0x1C, 0x00, 0x0C, 0x18,
  0x00, 0x1C, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x18, 0x00, 0x18, 0x38,
  0x00, 0x18, 0x38, 0x00, 0x38, 0x30, 0x00, 0x38, 0x30, 0x00, 0x30, 0x30,
  0x00, 0x30, 0x30, 0x00, 0x30, 0x70, 0x00, 0x30, 0x70, 0x00, 0x70, 0x60,
  0x00, 0x70, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0xE0,
  0x00, 0x60, 0xC0, 0x00, 0xE0, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00,
  0x70, 0xC0, 0x01, 0xC3, 0x00, 0x0E, 0x0E, 0x00, 0x70, 0x1C, 0x03, 0xC0,
  0x78, 0x1E, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x07,
  0x06, 0x00, 0x0E, 0x06, 0x00, 0x1C, 0x06, 0x00, 0x38, 0x0E, 0x00, 0x70,
  0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x0C, 0x03, 0x80, 0x0C, 0x07, 0x00,
  0x0C, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x70, 0x00,
  0x18, 0xE0, 0x00, 0x19, 0xE0, 0x00, 0x1B, 0xF0, 0x00, 0x3F, 0x70, 0x00,
  0x3E, 0x38, 0x00, 0x3C, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x30, 0x1C, 0x00,
  0x30, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x60, 0x03, 0x00,
  0x60, 0x03, 0x80, 0x60, 0x01, 0x80, 0x60, 0x01, 0xC0, 0xE0, 0x00, 0xE0,
  0xE0, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x07, 0x07, 0x80, 0x0F, 0x07, 0x80,
  0x0F, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x1F, 0x07, 0xC0, 0x3E, 0x0E, 0xC0,
  0x36, 0x0E, 0xC0, 0x76, 0x0C, 0xC0, 0x66, 0x0C, 0xC0, 0xCE, 0x0C, 0xC1,
  0xCC, 0x0C, 0xE1, 0x8C, 0x1C, 0x63, 0x8C, 0x1C, 0x63, 0x0C, 0x18, 0x67,
  0x1C, 0x18, 0x66, 0x1C, 0x18, 0x6E, 0x18, 0x18, 0x7C, 0x18, 0x38, 0x3C,
  0x18, 0x38, 0x38, 0x38, 0x30, 0x30, 0x38, 0x30, 0x30, 0x38, 0x30, 0x00,
  0x30, 0x30, 0x00, 0x30, 0x70, 0x00, 0x30, 0x70, 0x00, 0x70, 0x60, 0x00,
  0x70, 0x60, 0x00, 0x70, 0x60, 0x00, 0x60, 0xE0, 0x00, 0x60, 0xE0, 0x00,
  0x60, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07, 0x80, 0x07, 0x07, 0x80,
  0x06, 0x07, 0x80, 0x06, 0x07, 0xC0, 0x06, 0x0E, 0xC0, 0x0E, 0x0E, 0xC0,
  0x0E, 0x0C, 0xE0, 0x0E, 0x0C, 0x60, 0x0C, 0x0C, 0x60, 0x0C, 0x1C, 0x70,
  0x0C, 0x1C, 0x30, 0x1C, 0x1C, 0x30, 0x1C, 0x18, 0x38, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x1C, 0x18, 0x38, 0x1C, 0x38, 0x38, 0x0C, 0x38, 0x38, 0x0E,
  0x38, 0x30, 0x0E, 0x30, 0x30, 0x06, 0x30, 0x30, 0x07, 0x30, 0x70, 0x03,
  0x70, 0x70, 0x03, 0x70, 0x70, 0x03, 0xF0, 0x60, 0x01, 0xE0, 0x60, 0x01,
  0xE0, 0x60, 0x01, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xFF, 0x00, 0x1F, 0x1E, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0x30,
  0x38, 0x00, 0xE0, 0xC0, 0x01, 0x87, 0x00, 0x06, 0x18, 0x00, 0x18, 0xE0,
  0x00, 0x63, 0x80, 0x01, 0xCC, 0x00, 0x06, 0x30, 0x00, 0x19, 0xC0, 0x00,
  0x67, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x39, 0x80, 0x00, 0xE6,
  0x00, 0x03, 0x38, 0x00, 0x0C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xC6, 0x00,
  0x06, 0x18, 0x00, 0x38, 0x60, 0x00, 0xC1, 0xC0, 0x07, 0x03, 0x00, 0x38,
  0x0E, 0x01, 0xC0, 0x1C, 0x0F, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x30, 0x01, 0xC0,
  0x60, 0x01, 0xC0, 0xC0, 0x01, 0x83, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0E,
  0x00, 0x0E, 0x18, 0x00, 0x1C, 0x30, 0x00, 0x30, 0x60, 0x00, 0x61, 0xC0,
  0x01, 0xC3, 0x80, 0x07, 0x07, 0x00, 0x1E, 0x0C, 0x00, 0xF8, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0x00,
  0x1F, 0x1E, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xC0,
  0x01, 0x87, 0x00, 0x07, 0x18, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x00, 0x00,
  0xDC, 0x00, 0x03, 0x70, 0x00, 0x1D, 0x80, 0x00, 0x76, 0x00, 0x01, 0xD8,
  0x00, 0x06, 0x60, 0x00, 0x1B, 0x80, 0x00, 0x6E, 0x00, 0x03, 0xB8, 0x00,
  0x0E, 0xE0, 0x00, 0x33, 0x80, 0x00, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x18,
  0x60, 0x00, 0xE1, 0x80, 0x07, 0x07, 0x00, 0x18, 0x0E, 0x00, 0xE0, 0x3C,
  0x0F, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x20, 0x07, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0x80, 0x1C, 0x06, 0x00, 0x38, 0x38,
  0x00, 0x60, 0xE0, 0x01, 0xC3, 0x00, 0x07, 0x0C, 0x00, 0x1C, 0x30, 0x00,
  0x70, 0xC0, 0x01, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x60, 0x01, 0xC1,
  0x80, 0x0E, 0x06, 0x00, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0x80,
  0xE0, 0x0C, 0x03, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1C, 0x07, 0x00, 0x70,
  0x1C, 0x00, 0xC0, 0x70, 0x03, 0x81, 0x80, 0x0E, 0x06, 0x00, 0x18, 0x18,
  0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x03, 0x0E, 0x00, 0x0E, 0x00, 0x00,
  0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3E, 0x1F, 0x01, 0xE0, 0x1E, 0x07, 0x00,
  0x38, 0x38, 0x00, 0x70, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x0C,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xCE,
  0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0x87, 0x00,
  0x0E, 0x1E, 0x00, 0x70, 0x3C, 0x07, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x06, 0x1C, 0x00, 0x1C, 0x30, 0x00, 0x38, 0x60, 0x00, 0x60, 0xC0,
  0x00, 0xC3, 0x80, 0x01, 0x87, 0x00, 0x03, 0x0C, 0x00, 0x0E, 0x18, 0x00,
  0x1C, 0x30, 0x00, 0x30, 0x60, 0x00, 0x61, 0xC0, 0x00, 0xC3, 0x80, 0x03,
  0x86, 0x00, 0x07, 0x0C, 0x00, 0x0E, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30,
  0xE0, 0x00, 0x61, 0xC0, 0x01, 0xC3, 0x00, 0x03, 0x86, 0x00, 0x07, 0x0C,
  0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x70, 0x60, 0x00, 0xC0, 0xE0,
  0x03, 0x81, 0xC0, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0xF0, 0x03, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xB0, 0x00,
  0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x0E, 0x70, 0x00, 0x71, 0x80, 0x07, 0x0C,
  0x00, 0x38, 0x60, 0x01, 0x83, 0x80, 0x1C, 0x1C, 0x00, 0xC0, 0xE0, 0x0E,
  0x07, 0x00, 0x60, 0x18, 0x07, 0x00, 0xC0, 0x30, 0x06, 0x03, 0x80, 0x38,
  0x18, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x30, 0xE0, 0x01, 0x87, 0x00,
  0x0C, 0x30, 0x00, 0x63, 0x80, 0x03, 0x98, 0x00, 0x1D, 0xC0, 0x00, 0x6C,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x18, 0x0E, 0xC0, 0x70, 0x1F, 0x80, 0xE0, 0x37,
  0x01, 0xC0, 0x6E, 0x07, 0x81, 0xDC, 0x0F, 0x03, 0x38, 0x1E, 0x06, 0x70,
  0x6C, 0x1C, 0xE0, 0xD8, 0x31, 0xC3, 0xB0, 0x63, 0x86, 0x60, 0xC7, 0x0C,
  0xC3, 0x8E, 0x39, 0x86, 0x1C, 0x63, 0x0C, 0x30, 0xC6, 0x38, 0x63, 0x8C,
  0x60, 0xC6, 0x18, 0xC1, 0x8C, 0x31, 0x83, 0x38, 0x67, 0x06, 0x60, 0xCC,
  0x0C, 0xC1, 0x98, 0x1B, 0x83, 0x70, 0x36, 0x06, 0xC0, 0x6C, 0x0D, 0x80,
  0xF8, 0x1B, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0E,
  0x01, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x06, 0x00, 0x1C, 0x01, 0xC0,
  0x0E, 0x00, 0x30, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x00,
  0x60, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0x70, 0x00, 0x01,
  0xCC, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x70, 0x60, 0x00, 0x18, 0x1C, 0x00,
  0x0E, 0x03, 0x00, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x01, 0xC0, 0x38, 0x00, 0x30, 0x1C, 0x00, 0x0E, 0x0F, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xB8, 0x00, 0x1C, 0xC0, 0x01,
  0xC7, 0x00, 0x0C, 0x38, 0x00, 0xE0, 0xC0, 0x0E, 0x07, 0x00, 0x60, 0x38,
  0x07, 0x00, 0xC0, 0x70, 0x06, 0x03, 0x00, 0x38, 0x38, 0x00, 0xC3, 0x80,
  0x06, 0x18, 0x00, 0x39, 0xC0, 0x00, 0xDC, 0x00, 0x06, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x38, 0x00,
  0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x00, 0xE0, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0E, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x38, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0E, 0x03, 0x01, 0x80, 0xC0, 0x03,
  0xF8, 0x1F, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07,
  0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x00, 0x18, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x30, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x37, 0x00, 0xE6, 0x01, 0x8C, 0x06,
  0x18, 0x1C, 0x38, 0x30, 0x30, 0xE0, 0x61, 0x80, 0xC7, 0x01, 0x8C, 0x03,
  0xB8, 0x03, 0xE0, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF1, 0xC3, 0x86,
  0x1C, 0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0x81, 0xC0, 0xE0, 0x0E, 0x1C,
  0x00, 0x61, 0xC0, 0x07, 0x18, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x1E, 0x00, 0xE3, 0x80, 0x0C,
  0x70, 0x00, 0xC6, 0x00, 0x0C, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x03,
  0xC6, 0x00, 0x7C, 0x78, 0x1D, 0x83, 0xFF, 0x9C, 0x1F, 0xE1, 0xC0, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC7, 0xF0,
  0x0C, 0xFF, 0x81, 0xFC, 0x3C, 0x1F, 0x00, 0xE1, 0xE0, 0x0E, 0x1C, 0x00,
  0x61, 0x80, 0x07, 0x18, 0x00, 0x73, 0x80, 0x07, 0x38, 0x00, 0x73, 0x80,
  0x07, 0x30, 0x00, 0x73, 0x00, 0x06, 0x30, 0x00, 0x67, 0x00, 0x0E, 0x70,
  0x00, 0xE6, 0x00, 0x0C, 0x60, 0x01, 0xC7, 0x00, 0x38, 0xF8, 0x07, 0x8F,
  0xC0, 0xF0, 0xEF, 0xFE, 0x0C, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0xE0,
  0x1E, 0x0E, 0x07, 0x00, 0xE1, 0xC0, 0x0C, 0x70, 0x01, 0xCC, 0x00, 0x1B,
  0x80, 0x03, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x01, 0xDC,
  0x00, 0x31, 0x80, 0x0E, 0x38, 0x03, 0x83, 0x81, 0xE0, 0x3F, 0xF8, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x0F, 0xE3, 0x81, 0xFF, 0x9C, 0x1E, 0x0E, 0xC1, 0xE0, 0x1E,
  0x0E, 0x00, 0xF0, 0xE0, 0x03, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0xC3, 0x00,
  0x06, 0x38, 0x00, 0x31, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x60, 0x00, 0xE3,
  0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x87, 0x00, 0x1C, 0x38, 0x00,
  0xE1, 0xC0, 0x0F, 0x07, 0x00, 0xF0, 0x3C, 0x0F, 0x80, 0xFF, 0xEC, 0x03,
  0xFC, 0xE0, 0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x03, 0xC1, 0xC0, 0x70, 0x0E,
  0x0E, 0x00, 0x61, 0xC0, 0x07, 0x38, 0x00, 0x33, 0x80, 0x03, 0x30, 0x00,
  0x37, 0x00, 0x03, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x83, 0x80, 0x1C, 0x1C, 0x07, 0x80, 0xFF, 0xF0, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0x86, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x80, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x7F, 0x1C, 0x07, 0xFE, 0x70, 0x3C, 0x1D, 0x81,
  0xE0, 0x1E, 0x07, 0x00, 0x78, 0x38, 0x00, 0xE0, 0xC0, 0x03, 0x87, 0x00,
  0x0E, 0x18, 0x00, 0x30, 0xE0, 0x00, 0xC3, 0x80, 0x03, 0x0E, 0x00, 0x1C,
  0x30, 0x00, 0x70, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x30,
  0x00, 0xE0, 0xE0, 0x03, 0x81, 0x80, 0x1E, 0x07, 0x00, 0xF0, 0x1E, 0x07,
  0xC0, 0x3F, 0xFB, 0x00, 0x7F, 0x8C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x18, 0x01, 0xC0, 0xF0, 0x0E, 0x01, 0xE0,
  0xF0, 0x01, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC3, 0xF0, 0x1C, 0xFF, 0xC1, 0xDC,
  0x1E, 0x1B, 0x00, 0xE1, 0xE0, 0x07, 0x1C, 0x00, 0x71, 0x80, 0x07, 0x38,
  0x00, 0x73, 0x80, 0x07, 0x38, 0x00, 0x73, 0x00, 0x06, 0x30, 0x00, 0x63,
  0x00, 0x06, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE6, 0x00, 0x0C,
  0x60, 0x00, 0xC6, 0x00, 0x0C, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x01,
  0x8C, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x60, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x01, 0xC3, 0x00, 0x1C, 0x18, 0x03,
  0xC0, 0xC0, 0x3C, 0x0E, 0x03, 0x80, 0x70, 0x38, 0x03, 0x87, 0x80, 0x18,
  0x78, 0x00, 0xC7, 0x80, 0x06, 0x70, 0x00, 0x77, 0x80, 0x03, 0xFE, 0x00,
  0x1F, 0x30, 0x00, 0xE1, 0xC0, 0x06, 0x07, 0x00, 0x30, 0x38, 0x03, 0x80,
  0xE0, 0x1C, 0x03, 0x80, 0xC0, 0x1C, 0x06, 0x00, 0x70, 0x30, 0x01, 0xC3,
  0x80, 0x0E, 0x1C, 0x00, 0x38, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x0C, 0xF8, 0x7C, 0x1F, 0xFC, 0xFE, 0x1F,
  0x1D, 0x87, 0x1C, 0x0F, 0x07, 0x1C, 0x0E, 0x03, 0x18, 0x0E, 0x03, 0x38,
  0x0C, 0x03, 0x38, 0x0C, 0x07, 0x30, 0x0C, 0x07, 0x30, 0x1C, 0x06, 0x30,
  0x1C, 0x06, 0x30, 0x18, 0x06, 0x70, 0x18, 0x06, 0x70, 0x18, 0x0E, 0x60,
  0x18, 0x0E, 0x60, 0x38, 0x0C, 0x60, 0x38, 0x0C, 0x60, 0x30, 0x0C, 0xE0,
  0x30, 0x0C, 0xE0, 0x30, 0x1C, 0xC0, 0x30, 0x18, 0xC0, 0x70, 0x18, 0xC0,
  0x70, 0x18, 0x0C, 0x3F, 0x01, 0xCF, 0xFC, 0x1D, 0xC1, 0xE1, 0xB0, 0x0E,
  0x1E, 0x00, 0x71, 0xC0, 0x07, 0x18, 0x00, 0x73, 0x80, 0x07, 0x38, 0x00,
  0x73, 0x80, 0x06, 0x30, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0x67, 0x00,
  0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x60,
  0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xCC, 0x00, 0x18, 0xC0, 0x01, 0x80,
  0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0x83, 0xC0, 0xF0, 0x0E, 0x1C, 0x00,
  0x61, 0x80, 0x07, 0x38, 0x00, 0x73, 0x00, 0x03, 0x70, 0x00, 0x36, 0x00,
  0x03, 0x60, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x6E, 0x00, 0x06, 0x60, 0x00, 0xE6, 0x00, 0x1C, 0x70, 0x01, 0xC3,
  0x80, 0x38, 0x3C, 0x0F, 0x01, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x03, 0x1F,
  0xC0, 0x0D, 0xFF, 0x80, 0x7F, 0x0F, 0x01, 0xF0, 0x0E, 0x07, 0x80, 0x38,
  0x1C, 0x00, 0x60, 0x60, 0x01, 0xC1, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38,
  0x00, 0x70, 0xC0, 0x01, 0xC3, 0x00, 0x07, 0x0C, 0x00, 0x18, 0x70, 0x00,
  0x61, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x18, 0x00, 0x30, 0x60, 0x01, 0xC1,
  0xC0, 0x0E, 0x0F, 0x00, 0x78, 0x3F, 0x03, 0xC0, 0xEF, 0xFE, 0x03, 0x1F,
  0xE0, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xFC, 0x70, 0x7F, 0xE7, 0x0F, 0x07, 0x61, 0xE0, 0x1E,
  0x1C, 0x01, 0xE3, 0x80, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0C, 0x60, 0x00,
  0xCE, 0x00, 0x0C, 0xE0, 0x00, 0xCE, 0x00, 0x1C, 0xC0, 0x01, 0xCC, 0x00,
  0x18, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x03, 0x8E, 0x00, 0x38, 0xE0,
  0x07, 0x87, 0x00, 0xF0, 0x78, 0x1F, 0x03, 0xFF, 0xB0, 0x1F, 0xE3, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x0C, 0x1F,
  0xE1, 0x8F, 0xF8, 0x33, 0xE1, 0x06, 0xE0, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xF0, 0x3C, 0x0F,
  0x0E, 0x00, 0x71, 0x80, 0x0E, 0x70, 0x00, 0xCE, 0x00, 0x19, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xD8, 0x00, 0x3B,
  0x80, 0x06, 0x70, 0x01, 0xC7, 0x80, 0xF0, 0x7F, 0xFC, 0x03, 0xFE, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xFF, 0x80,
  0x3F, 0xC0, 0x18, 0x00, 0x71, 0x80, 0x07, 0x38, 0x00, 0x73, 0x80, 0x06,
  0x38, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0xE3, 0x00, 0x0E, 0x70, 0x00,
  0xC7, 0x00, 0x0C, 0x70, 0x00, 0xC6, 0x00, 0x1C, 0x60, 0x01, 0xC6, 0x00,
  0x1C, 0xE0, 0x01, 0x8E, 0x00, 0x18, 0xE0, 0x01, 0x8E, 0x00, 0x38, 0xE0,
  0x07, 0x87, 0x00, 0xF8, 0x70, 0x3B, 0x03, 0xFF, 0x30, 0x1F, 0xE3, 0x00,
  0xC0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x66, 0x00, 0x0E, 0x60, 0x01,
  0xC7, 0x00, 0x18, 0x70, 0x03, 0x83, 0x00, 0x30, 0x30, 0x07, 0x03, 0x00,
  0x60, 0x38, 0x0E, 0x01, 0x80, 0xC0, 0x18, 0x1C, 0x01, 0x83, 0x80, 0x1C,
  0x30, 0x00, 0xC7, 0x00, 0x0C, 0x60, 0x00, 0xCE, 0x00, 0x0E, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x30,
  0x0F, 0x80, 0x60, 0x1B, 0x00, 0xC0, 0x36, 0x03, 0x80, 0xEC, 0x07, 0x81,
  0x98, 0x1B, 0x03, 0x30, 0x36, 0x0C, 0x60, 0xEC, 0x18, 0xE1, 0x98, 0x71,
  0xC3, 0x30, 0xC3, 0x8C, 0x61, 0x83, 0x18, 0xC6, 0x06, 0x61, 0x8C, 0x0C,
  0xC3, 0x18, 0x19, 0x86, 0x60, 0x36, 0x0C, 0xC0, 0x6C, 0x09, 0x80, 0xF0,
  0x16, 0x01, 0xE0, 0x2C, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01,
  0xC0, 0x18, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x1C,
  0x00, 0xE0, 0x18, 0x03, 0x80, 0x38, 0x0E, 0x00, 0x30, 0x38, 0x00, 0x70,
  0xF0, 0x00, 0x71, 0xC0, 0x00, 0x67, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x73, 0x80,
  0x01, 0xC3, 0x00, 0x03, 0x87, 0x00, 0x0E, 0x07, 0x00, 0x38, 0x0E, 0x00,
  0xE0, 0x0E, 0x03, 0x80, 0x0C, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x60, 0x70, 0x00, 0x38, 0x1C, 0x00,
  0x1C, 0x07, 0x00, 0x07, 0x00, 0xC0, 0x03, 0x80, 0x38, 0x00, 0xC0, 0x0E,
  0x00, 0x70, 0x01, 0x80, 0x38, 0x00, 0x60, 0x0E, 0x00, 0x1C, 0x07, 0x00,
  0x07, 0x01, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0x38, 0x30, 0x00, 0x0E, 0x1C,
  0x00, 0x01, 0x8E, 0x00, 0x00, 0x63, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07,
  0x60, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x06, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xC0,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x07, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60, 0x60, 0x60,
  0x60, 0xE0, 0x02, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x1F,
  0x00, 0x78, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00,
  0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xE0, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x3F, 0x80, 0x0C, 0xFF, 0x80,
  0x1B, 0x83, 0x80, 0x76, 0x03, 0x80, 0xD8, 0x03, 0xC7, 0xB0, 0x03, 0xFE,
  0x00, 0x01, 0xF0,
};

const GFXglyph RobotoMono_LightItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 7, 31, 25, 9, -31 },
  { 29, 10, 9, 25, 10, -32 },
  { 41, 25, 31, 25, 1, -31 },
  { 138, 21, 39, 25, 3, -35 },
  { 241, 20, 31, 25, 3, -31 },
  { 319, 21, 31, 25, 2, -31 },
  { 401, 4, 9, 25, 12, -32 },
  { 406, 14, 44, 25, 7, -34 },
  { 483, 13, 44, 25, 4, -34 },
  { 555, 19, 19, 25, 5, -31 },
  { 601, 21, 22, 25, 2, -25 },
  { 659, 6, 10, 25, 5, -4 },
  { 667, 15, 2, 25, 5, -15 },
  { 671, 4, 4, 25, 9, -4 },
  { 673, 21, 34, 25, 3, -31 },
  { 763, 20, 31, 25, 3, -31 },
  { 841, 12, 31, 25, 6, -31 },
  { 888, 21, 31, 25, 1, -31 },
  { 970, 21, 31, 25, 1, -31 },
  { 1052, 21, 31, 25, 1, -31 },
  { 1134, 22, 31, 25, 3, -31 },
  { 1220, 18, 31, 25, 3, -31 },
  { 1290, 20, 31, 25, 5, -31 },
  { 1368, 21, 31, 25, 3, -31 },
  { 1450, 19, 31, 25, 4, -31 },
  { 1524, 8, 22, 25, 10, -22 },
  { 1546, 10, 28, 25, 8, -22 },
  { 1581, 20, 18, 25, 3, -23 },
  { 1626, 20, 11, 25, 3, -19 },
  { 1654, 20, 18, 25, 2, -23 },
  { 1699, 17, 31, 25, 6, -31 },
  { 1765, 24, 31, 25, 1, -31 },
  { 1858, 21, 31, 25, 0, -31 },
  { 1940, 22, 31, 25, 2, -31 },
  { 2026, 22, 31, 25, 2, -31 },
  { 2112, 23, 31, 25, 1, -31 },
  { 2202, 23, 31, 25, 2, -31 },
  { 2292, 23, 31, 25, 2, -31 },
  { 2382, 22, 31, 25, 2, -31 },
  { 2468, 24, 31, 25, 1, -31 },
  { 2561, 22, 31, 25, 2, -31 },
  { 2647, 22, 31, 25, 2, -31 },
  { 2733, 24, 31, 25, 2, -31 },
  { 2826, 18, 31, 25, 2, -31 },
  { 2896, 24, 31, 25, 1, -31 },
  { 2989, 24, 31, 25, 1, -31 },
  { 3082, 22, 31, 25, 2, -31 },
  { 3168, 23, 31, 25, 2, -31 },
  { 3258, 22, 36, 25, 2, -31 },
  { 3357, 22, 31, 25, 2, -31 },
  { 3443, 22, 31, 25, 2, -31 },
  { 3529, 21, 31, 25, 5, -31 },
  { 3611, 23, 31, 25, 2, -31 },
  { 3701, 21, 31, 25, 5, -31 },
  { 3783, 23, 31, 25, 4, -31 },
  { 3873, 26, 31, 25, 0, -31 },
  { 3974, 21, 31, 25, 5, -31 },
  { 4056, 23, 31, 25, 1, -31 },
  { 4146, 14, 42, 25, 6, -35 },
  { 4220, 9, 34, 25, 8, -31 },
  { 4259, 13, 42, 25, 6, -35 },
  { 4328, 15, 17, 25, 5, -31 },
  { 4360, 18, 2, 25, 1, 0 },
  { 4365, 6, 5, 25, 12, -31 },
  { 4369, 20, 23, 25, 2, -23 },
  { 4427, 20, 32, 25, 2, -32 },
  { 4507, 19, 23, 25, 3, -23 },
  { 4562, 21, 32, 25, 3, -32 },
  { 4646, 20, 23, 25, 2, -23 },
  { 4704, 21, 33, 25, 5, -33 },
  { 4791, 22, 32, 25, 1, -23 },
  { 4879, 20, 32, 25, 2, -32 },
  { 4959, 18, 31, 25, 2, -31 },
  { 5029, 20, 40, 25, 0, -31 },
  { 5129, 21, 32, 25, 2, -32 },
  { 5213, 18, 32, 25, 2, -32 },
  { 5285, 24, 23, 25, 0, -23 },
  { 5354, 20, 23, 25, 2, -23 },
  { 5412, 20, 23, 25, 2, -23 },
  { 5470, 22, 32, 25, 0, -23 },
  { 5558, 20, 32, 25, 3, -23 },
  { 5638, 19, 23, 25, 5, -23 },
  { 5693, 19, 23, 25, 3, -23 },
  { 5748, 17, 29, 25, 5, -29 },
  { 5810, 20, 23, 25, 3, -23 },
  { 5868, 20, 23, 25, 4, -23 },
  { 5926, 23, 23, 25, 3, -23 },
  { 5993, 23, 23, 25, 1, -23 },
  { 6060, 26, 32, 25, -1, -23 },
  { 6164, 22, 23, 25, 1, -23 },
  { 6228, 16, 42, 25, 7, -34 },
  { 6312, 8, 38, 25, 8, -31 },
  { 6350, 16, 43, 25, 4, -34 },
  { 6436, 23, 8, 25, 1, -17 },
};

const GFXfont RobotoMono_LightItalic43pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic43pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic43pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _ROBOTOMONO_LIGHTITALIC43PT7B_H_
