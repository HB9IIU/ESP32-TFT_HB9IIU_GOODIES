#ifndef _ROBOTOMONO_LIGHTITALIC59PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F,
  0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03,
  0x80, 0x70, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x3C, 0x07, 0xC0, 0xF0, 0x1E, 0x00, 0x3C,
  0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x0E, 0x38, 0x38, 0xC0, 0xE7, 0x03, 0x9C,
  0x0E, 0x70, 0x31, 0xC1, 0xC6, 0x07, 0x18, 0x1C, 0xE0, 0x70, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x38, 0x07, 0x00,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x38,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x1C, 0x01,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFC, 0x00, 0x38, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x01, 0xE0,
  0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xE0, 0x78, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0xF0, 0x70, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0xF0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x38, 0xF0, 0x00,
  0x03, 0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x07, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x1F, 0x03, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0xFC, 0x01, 0xFE,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x70, 0x0C, 0x01, 0x8E, 0x00, 0xC0, 0x1C, 0xE0, 0x0C,
  0x03, 0x8E, 0x01, 0xC0, 0x70, 0xE0, 0x1C, 0x0F, 0x0E, 0x01, 0xC0, 0xE0,
  0xC0, 0x1C, 0x1C, 0x0E, 0x01, 0x83, 0x80, 0xE0, 0x38, 0x38, 0x0E, 0x07,
  0x07, 0x00, 0x70, 0xF0, 0xE0, 0x07, 0xFE, 0x0E, 0x00, 0x1F, 0x81, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x83,
  0xF8, 0x00, 0x70, 0x7F, 0xC0, 0x0F, 0x0F, 0x1E, 0x00, 0xE1, 0xC0, 0xE0,
  0x1C, 0x1C, 0x07, 0x03, 0x83, 0x80, 0x70, 0x38, 0x38, 0x07, 0x07, 0x03,
  0x00, 0x70, 0xE0, 0x70, 0x07, 0x0E, 0x07, 0x00, 0x71, 0xC0, 0x70, 0x06,
  0x38, 0x07, 0x00, 0xE1, 0x80, 0x70, 0x0E, 0x00, 0x07, 0x00, 0xC0, 0x00,
  0x38, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x07, 0x80, 0x38, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0xF0,
  0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0xE0, 0x0F, 0x00, 0x03, 0x80, 0x78, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x71, 0xF0, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xF9, 0xC0, 0x00, 0x07, 0xC7,
  0x80, 0x1C, 0x3C, 0x0F, 0x00, 0x71, 0xE0, 0x3C, 0x03, 0xC7, 0x80, 0x78,
  0x0E, 0x3C, 0x00, 0xE0, 0x38, 0xE0, 0x03, 0xC1, 0xE7, 0x80, 0x07, 0x87,
  0x1C, 0x00, 0x1E, 0x3C, 0x70, 0x00, 0x3C, 0xE1, 0xC0, 0x00, 0x77, 0x87,
  0x00, 0x01, 0xFC, 0x1C, 0x00, 0x03, 0xE0, 0x70, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x7E, 0x03, 0xC0, 0x03, 0xFC, 0x0F, 0x80, 0x3E, 0xF0, 0x1F, 0xC7,
  0xF1, 0xE0, 0x3F, 0xFF, 0x03, 0x80, 0x3F, 0xF0, 0x0F, 0x00, 0x0E, 0x00,
  0x00, 0x3B, 0xDC, 0xE7, 0x39, 0xDC, 0xE7, 0x39, 0xCC, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x70, 0x0E, 0x01, 0x9F, 0x03,
  0x83, 0xFF, 0xF0, 0xE3, 0xFC, 0xFF, 0xB7, 0xFC, 0x07, 0xFF, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF7, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x01,
  0xE0, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x18,
  0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x0E, 0x0E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x78, 0x70, 0xF0, 0xE0,
  0x40, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0xF8, 0x07,
  0x80, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xC0, 0x78, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0xE0, 0xF0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x0F, 0x1C, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0xF3,
  0xC0, 0x00, 0xFF, 0x38, 0x00, 0x1E, 0xF3, 0x80, 0x03, 0xCE, 0x38, 0x00,
  0xF8, 0xE7, 0x80, 0x1E, 0x0E, 0x78, 0x03, 0xC0, 0xE7, 0x80, 0x78, 0x1E,
  0x70, 0x1F, 0x01, 0xE7, 0x03, 0xC0, 0x1C, 0x70, 0x78, 0x01, 0xCF, 0x0F,
  0x00, 0x1C, 0xF3, 0xE0, 0x01, 0xCF, 0x78, 0x00, 0x3C, 0xFF, 0x00, 0x03,
  0xCF, 0xE0, 0x00, 0x38, 0xFC, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x78, 0xE0,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x0F, 0x07, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x1C, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x03,
  0xE0, 0x1F, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x7F, 0x01,
  0xFE, 0x0F, 0xFE, 0x3F, 0xCE, 0xFE, 0x0E, 0xF8, 0x1E, 0xC0, 0x1E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x70, 0x38, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x1C, 0x1E, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xC0, 0x1E, 0x00,
  0x78, 0x00, 0x78, 0x07, 0x80, 0x01, 0xC0, 0x78, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x78, 0x3C, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0xF0,
  0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x1C, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x01, 0xEE, 0x00,
  0x00, 0x0F, 0x38, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xC7, 0x80, 0x00,
  0x0E, 0x1C, 0x00, 0x00, 0x78, 0x70, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1E, 0x03,
  0x80, 0x00, 0xF0, 0x0E, 0x00, 0x07, 0x80, 0x38, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x1C, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xE0, 0x01, 0xC0, 0x0F, 0x00, 0x07, 0x00, 0x38, 0x00, 0x3C, 0x01, 0xC0,
  0x00, 0xF0, 0x0F, 0x00, 0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC1, 0xF8, 0x00, 0x0E, 0x7F, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFC, 0x3F, 0x00, 0x3F, 0x00, 0x7C, 0x01,
  0xE0, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0F, 0x07, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x07, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x03, 0xF1, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x10, 0x00,
  0x78, 0x7F, 0xC0, 0x1C, 0x7F, 0xFC, 0x07, 0x3F, 0xBF, 0x83, 0xFE, 0x01,
  0xF0, 0xFE, 0x00, 0x3C, 0x3F, 0x00, 0x07, 0x8F, 0x80, 0x00, 0xE7, 0xC0,
  0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xDC, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x9E, 0x00,
  0x01, 0xC7, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x38, 0x3C, 0x00, 0x1E, 0x07,
  0x80, 0x0F, 0x01, 0xF0, 0x0F, 0x80, 0x3F, 0x9F, 0xC0, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0x80, 0x3C, 0x00,
  0xF8, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x70, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x1E, 0x00, 0x00,
  0xE0, 0xF0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xC0, 0x3C, 0x00, 0x1E, 0x00, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0xF0, 0x00, 0x38, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x07, 0x80,
  0x00, 0x3C, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x1C, 0x00, 0x00,
  0x78, 0xE0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x0F, 0x81, 0xE0,
  0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x80, 0x1F, 0xC7, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xBF, 0x80, 0x7C, 0x03,
  0xE0, 0x7C, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x0E, 0x3C, 0x00,
  0x07, 0x1C, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x79, 0xC0, 0x00, 0x7C, 0xF0, 0x00, 0x7E,
  0x3C, 0x00, 0xFF, 0x1F, 0x01, 0xF7, 0x07, 0xFF, 0xF3, 0x81, 0xFF, 0xE3,
  0xC0, 0x3F, 0xC1, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xC1, 0xF0, 0xFC, 0x1F, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x0F, 0xC3, 0xF0, 0xFC,
  0x1E, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xE0,
  0x0F, 0x00, 0x70, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x30,
  0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x07, 0xFE, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0x00, 0xF8, 0xF8,
  0x01, 0xE7, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x0E,
  0x03, 0xC0, 0x00, 0x06, 0x03, 0x80, 0x00, 0x07, 0x07, 0x00, 0xFE, 0x07,
  0x0E, 0x03, 0xFF, 0x07, 0x0E, 0x07, 0x87, 0x03, 0x1C, 0x0F, 0x03, 0x03,
  0x1C, 0x1E, 0x03, 0x03, 0x38, 0x1C, 0x07, 0x03, 0x38, 0x38, 0x06, 0x03,
  0x30, 0x38, 0x06, 0x03, 0x70, 0x70, 0x06, 0x07, 0x70, 0x70, 0x0E, 0x07,
  0x60, 0x60, 0x0C, 0x07, 0xE0, 0xE0, 0x0C, 0x06, 0xE0, 0xE0, 0x1C, 0x06,
  0xE0, 0xE0, 0x1C, 0x06, 0xC0, 0xC0, 0x18, 0x0E, 0xC0, 0xC0, 0x18, 0x0C,
  0xC0, 0xC0, 0x38, 0x0C, 0xC0, 0xC0, 0x78, 0x1C, 0xC0, 0xC0, 0x78, 0x18,
  0xC0, 0xC0, 0xF0, 0x38, 0xC0, 0xC1, 0xF8, 0x30, 0xC0, 0xE7, 0xB8, 0xE0,
  0xC0, 0xFF, 0x1F, 0xE0, 0xE0, 0x7E, 0x0F, 0x80, 0xE0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x30, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x78, 0xE0,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x1E, 0x0E, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x70,
  0x0E, 0x00, 0x07, 0x80, 0x70, 0x00, 0x38, 0x03, 0x80, 0x03, 0xC0, 0x1C,
  0x00, 0x1C, 0x00, 0xE0, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x78, 0x00, 0x38, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x03,
  0xC0, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x87,
  0x80, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x07, 0x1E, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x70, 0x01, 0xFC, 0x01, 0xC0, 0x00, 0xF0,
  0x07, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x0F, 0x03, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xE0, 0x78, 0x00,
  0x07, 0x81, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x1F,
  0x00, 0xF0, 0x01, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0xFC, 0x03, 0x80, 0x00, 0xF0, 0x1E,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x0F, 0x07, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC3, 0xC0, 0x00,
  0x07, 0x0F, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07,
  0x83, 0x80, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x7C, 0x07, 0x00, 0x07, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7C,
  0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x38, 0x1E, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xF1,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x0F, 0x07, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x01, 0xE0, 0x38, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x3C, 0x03,
  0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x07, 0x83, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x3C, 0x38, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x1E, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x1E,
  0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x78, 0x07,
  0x00, 0x03, 0xE0, 0x0E, 0x00, 0x1F, 0x80, 0x1C, 0x00, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x1E, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x7F, 0xFC, 0x70, 0x01, 0xFF, 0xF3, 0xC0,
  0x07, 0xFF, 0xCF, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x38, 0xF0, 0x00,
  0x00, 0xE3, 0xC0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00,
  0x78, 0x70, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x1C,
  0x1E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0xC0, 0x07, 0xF7, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0xF0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x78,
  0x0E, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x07, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0x70, 0x1E, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x1E, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0xF0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x00, 0xF0, 0x1C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x38, 0x07, 0x00,
  0x00, 0x1C, 0x07, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x20, 0x3F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x01, 0xC0, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x01, 0xC0,
  0x00, 0x3C, 0x03, 0x80, 0x00, 0xF8, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x80, 0xE0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x0F, 0x80, 0x78,
  0x00, 0x0F, 0x80, 0x3C, 0x00, 0x0F, 0x80, 0x1C, 0x00, 0x0F, 0x80, 0x0E,
  0x00, 0x0F, 0x80, 0x07, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x03,
  0xC0, 0x0F, 0x80, 0x01, 0xC0, 0x0F, 0x80, 0x00, 0xE0, 0x0F, 0x80, 0x00,
  0x70, 0x0F, 0x80, 0x00, 0x38, 0x0F, 0x80, 0x00, 0x3C, 0x0F, 0x80, 0x00,
  0x1E, 0x0F, 0x80, 0x00, 0x0E, 0x0F, 0x80, 0x00, 0x07, 0x0F, 0x80, 0x00,
  0x03, 0x8F, 0x80, 0x00, 0x01, 0xCF, 0xC0, 0x00, 0x01, 0xEF, 0xE0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x9C, 0x00, 0x00, 0x3F, 0x8F, 0x00,
  0x00, 0x1F, 0x03, 0xC0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x01, 0xC0, 0x07,
  0x80, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x0E, 0x00,
  0x01, 0xC0, 0x07, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x1E, 0x01, 0xC0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x03, 0xC0, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x03, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0x60, 0x01,
  0xDC, 0x07, 0xB8, 0x01, 0xEE, 0x03, 0x9C, 0x00, 0xE7, 0x01, 0xCE, 0x00,
  0xF3, 0x80, 0xE7, 0x00, 0x73, 0xC0, 0x73, 0x80, 0x79, 0xC0, 0x38, 0xE0,
  0x38, 0xE0, 0x3C, 0x70, 0x3C, 0x70, 0x1C, 0x38, 0x1C, 0x38, 0x0E, 0x1C,
  0x1E, 0x1C, 0x07, 0x0E, 0x0E, 0x1E, 0x03, 0x87, 0x0E, 0x0E, 0x01, 0xC1,
  0xCF, 0x07, 0x01, 0xE0, 0xE7, 0x03, 0x80, 0xE0, 0x77, 0x81, 0xC0, 0x70,
  0x3B, 0x81, 0xE0, 0x38, 0x1F, 0xC0, 0xF0, 0x1C, 0x0F, 0xC0, 0x70, 0x0E,
  0x03, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x1C, 0x07, 0x00, 0xF0, 0x0E, 0x03,
  0x80, 0x70, 0x0F, 0x01, 0xC0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x03, 0x80,
  0xF0, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xF0,
  0x1C, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x1C,
  0x07, 0x80, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x01, 0xE0, 0x00, 0x07, 0x03, 0xE0, 0x00, 0x0F, 0x03, 0xE0,
  0x00, 0x0F, 0x03, 0xF0, 0x00, 0x0E, 0x03, 0xF0, 0x00, 0x0E, 0x03, 0xF0,
  0x00, 0x0E, 0x07, 0xF8, 0x00, 0x1E, 0x07, 0xB8, 0x00, 0x1E, 0x07, 0xB8,
  0x00, 0x1E, 0x07, 0x3C, 0x00, 0x1C, 0x07, 0x1C, 0x00, 0x1C, 0x07, 0x1C,
  0x00, 0x1C, 0x0F, 0x1E, 0x00, 0x3C, 0x0F, 0x0E, 0x00, 0x3C, 0x0E, 0x0F,
  0x00, 0x3C, 0x0E, 0x07, 0x00, 0x38, 0x0E, 0x07, 0x00, 0x38, 0x0E, 0x07,
  0x80, 0x38, 0x1E, 0x03, 0x80, 0x78, 0x1E, 0x03, 0x80, 0x78, 0x1C, 0x03,
  0xC0, 0x70, 0x1C, 0x01, 0xC0, 0x70, 0x1C, 0x01, 0xC0, 0x70, 0x1C, 0x01,
  0xE0, 0x70, 0x3C, 0x00, 0xE0, 0xF0, 0x3C, 0x00, 0xE0, 0xF0, 0x38, 0x00,
  0xF0, 0xE0, 0x38, 0x00, 0x70, 0xE0, 0x38, 0x00, 0x78, 0xE0, 0x38, 0x00,
  0x39, 0xE0, 0x78, 0x00, 0x39, 0xE0, 0x78, 0x00, 0x3D, 0xE0, 0x70, 0x00,
  0x1D, 0xC0, 0x70, 0x00, 0x1D, 0xC0, 0x70, 0x00, 0x1F, 0xC0, 0xF0, 0x00,
  0x0F, 0xC0, 0xF0, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x0F, 0xC0, 0xE0, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x80, 0x07, 0xC0, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x07, 0x80, 0x03, 0x80,
  0x78, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x70, 0x3C, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x1E, 0x1C, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x03, 0x8F, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x77, 0x80,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x73, 0x80, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0xC3, 0x80, 0x00,
  0x1C, 0x1C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0xF0,
  0x1E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x80, 0x0E, 0x00, 0x1F, 0x80, 0x1C, 0x00, 0x0F, 0x80, 0x78, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x1E, 0x07, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00,
  0x70, 0x78, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x03, 0xE0, 0x70, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0x7E, 0x01,
  0xC0, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0xFC, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x78, 0x1C, 0x00, 0x00, 0xE0, 0xF0,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0x70, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x1D, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x0F,
  0x70, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0xBC,
  0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x01, 0xEE, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xF3, 0x80, 0x00,
  0x03, 0xCE, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xE0, 0x03, 0xC0, 0x07,
  0xC0, 0x3E, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x0C, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xF0, 0x01, 0xF8, 0x03, 0xC0, 0x01, 0xF0,
  0x0E, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x1E, 0x03,
  0x80, 0x00, 0x38, 0x1E, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x1E, 0x03, 0x80, 0x01, 0xF0, 0x1E, 0x00, 0x0F, 0x80,
  0x7F, 0x87, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x1C,
  0x00, 0xF0, 0x00, 0x70, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x03,
  0xC0, 0x0E, 0x00, 0x07, 0x00, 0x78, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x78,
  0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x78, 0x38, 0x00, 0x01, 0xE0, 0xE0,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFC,
  0x03, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xE3, 0xC0,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x70, 0x78, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x0F,
  0xC0, 0x0F, 0xF7, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x0F, 0x00,
  0x00, 0x1C, 0x1E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xF0, 0x70, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x07, 0x07, 0x80, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x07, 0x83, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1C, 0x03, 0xC0, 0x00,
  0x78, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0xC0, 0x3E,
  0x00, 0x07, 0xF7, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x01,
  0xE7, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0x38,
  0x00, 0x03, 0xC0, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x78, 0x0F, 0x00,
  0x01, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x38, 0x01, 0xC0, 0x01,
  0xE0, 0x07, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x38, 0x03, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x78, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x01, 0xC1,
  0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x01, 0xC7, 0x80, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x3B, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x70,
  0x01, 0xC0, 0x0E, 0x70, 0x03, 0xC0, 0x0E, 0x70, 0x03, 0xC0, 0x0E, 0x70,
  0x07, 0xC0, 0x1E, 0x70, 0x07, 0xC0, 0x1C, 0x70, 0x07, 0xC0, 0x1C, 0x70,
  0x0F, 0xC0, 0x3C, 0x70, 0x0F, 0xC0, 0x38, 0x70, 0x0F, 0xC0, 0x38, 0x70,
  0x1C, 0xC0, 0x38, 0x70, 0x1C, 0xC0, 0x70, 0x70, 0x1C, 0xC0, 0x70, 0x70,
  0x38, 0xC0, 0x70, 0x70, 0x38, 0xC0, 0xF0, 0x70, 0x38, 0xC0, 0xE0, 0x70,
  0x70, 0xC0, 0xE0, 0x70, 0x70, 0xC0, 0xE0, 0x70, 0x70, 0xC1, 0xC0, 0x70,
  0xE0, 0xE1, 0xC0, 0x70, 0xE0, 0xE1, 0xC0, 0x70, 0xE0, 0xE3, 0xC0, 0x71,
  0xC0, 0xE3, 0x80, 0x71, 0xC0, 0xE3, 0x80, 0x71, 0xC0, 0xE3, 0x80, 0x73,
  0x80, 0xE7, 0x00, 0x73, 0x80, 0xE7, 0x00, 0x73, 0x80, 0xE7, 0x00, 0x77,
  0x00, 0xEE, 0x00, 0x77, 0x00, 0xEE, 0x00, 0x77, 0x00, 0xEE, 0x00, 0x7E,
  0x00, 0xEE, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x07, 0x80, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x03,
  0x87, 0x80, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x00, 0x1D, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x00, 0x79, 0xC0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0xE0,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x78,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x78, 0x00, 0x00, 0x78, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x0F, 0x00, 0x38, 0x00, 0x3C, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x0E, 0x0F, 0x00, 0x00,
  0x3C, 0x38, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07,
  0xB8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xF0, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x1D, 0xC0, 0x01, 0xEE, 0x00,
  0x0E, 0x70, 0x00, 0xF1, 0xC0, 0x07, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x83,
  0x80, 0x38, 0x1C, 0x03, 0xC0, 0x70, 0x1C, 0x03, 0x81, 0xE0, 0x1C, 0x0E,
  0x00, 0xE0, 0xF0, 0x03, 0x87, 0x00, 0x1C, 0x70, 0x00, 0xE7, 0x80, 0x07,
  0x38, 0x00, 0x3F, 0xC0, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF8, 0xF0, 0xE0, 0xE1, 0xC1, 0xC3, 0x83, 0x83, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0xFC, 0x1F,
  0xC0, 0x3E, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x70, 0x78,
  0x00, 0x0E, 0x0E, 0x00, 0x01, 0xE2, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xF8, 0x00, 0x70,
  0xF8, 0x00, 0x0E, 0x1E, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x78, 0xE0, 0x00,
  0x0F, 0x3C, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x38, 0xF0, 0x00, 0x0F, 0x1E,
  0x00, 0x03, 0xE3, 0xC0, 0x00, 0xFC, 0x3C, 0x00, 0x3B, 0x87, 0xC0, 0x1E,
  0xF0, 0x7F, 0xFF, 0x9E, 0x07, 0xFF, 0xE3, 0xC0, 0x7F, 0xF0, 0x78, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x0E,
  0x1F, 0xF8, 0x01, 0xCF, 0xFF, 0x80, 0x3B, 0xF1, 0xF8, 0x0F, 0xF0, 0x0F,
  0x81, 0xF8, 0x00, 0x78, 0x3E, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xE0, 0xE0,
  0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x0F,
  0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x1E, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x71, 0xE0, 0x00,
  0x1E, 0x38, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1F,
  0x00, 0x07, 0x87, 0xE0, 0x01, 0xE0, 0xFF, 0x00, 0xF8, 0x1C, 0xFF, 0xFE,
  0x03, 0x8F, 0xFF, 0x80, 0x70, 0x7F, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xE0, 0xFC,
  0x03, 0xE0, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x38, 0x78, 0x00,
  0x0F, 0x1C, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1D, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x73, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x0F, 0x1C, 0x00, 0x07, 0x87,
  0x80, 0x01, 0xE0, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x07, 0xE1, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x0E, 0x00, 0x3F,
  0xF0, 0x70, 0x07, 0xFF, 0xE7, 0x80, 0x7F, 0x1F, 0xBC, 0x07, 0xC0, 0x1F,
  0xE0, 0x7C, 0x00, 0x7E, 0x03, 0xC0, 0x01, 0xF0, 0x3C, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0F, 0x07, 0x00,
  0x00, 0x78, 0x38, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x1C, 0x0F, 0x00, 0x01,
  0xE0, 0x38, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF8, 0x0F, 0x00, 0x0F, 0xC0,
  0x3E, 0x01, 0xFC, 0x00, 0xFE, 0xFE, 0xE0, 0x03, 0xFF, 0xE7, 0x00, 0x0F,
  0xFC, 0x38, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xC1, 0xF0, 0x01, 0xF0, 0x07,
  0x80, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xC0, 0xF0, 0x00, 0x1E, 0x0E,
  0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE3, 0xC0, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x0E, 0x7F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x20, 0x3C, 0x00, 0x07, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x3E,
  0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x10, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFF, 0xE1, 0xC0, 0x1F, 0xFF, 0x8E, 0x01, 0xFC,
  0x7E, 0xF0, 0x1F, 0x00, 0x7F, 0x81, 0xF0, 0x01, 0xF8, 0x0F, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x83,
  0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01,
  0xE1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x3C, 0x1C, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x70, 0x3C, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x03,
  0xE0, 0x3E, 0x00, 0x3F, 0x00, 0xF8, 0x07, 0xF0, 0x03, 0xFB, 0xFB, 0x80,
  0x0F, 0xFF, 0x9C, 0x00, 0x3F, 0xF0, 0xE0, 0x00, 0x10, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xC0, 0x20, 0x00, 0x1E, 0x03, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x00,
  0x7C, 0x03, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x7C,
  0x00, 0x38, 0x3F, 0xF0, 0x03, 0x8F, 0xFF, 0x80, 0x79, 0xF0, 0xFC, 0x07,
  0x3C, 0x03, 0xE0, 0x77, 0x00, 0x1E, 0x07, 0xE0, 0x00, 0xF0, 0x7C, 0x00,
  0x0F, 0x0F, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0xE1, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1E,
  0x1C, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xC3, 0xC0,
  0x00, 0x1C, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x3C, 0x38, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x03, 0x87, 0x80, 0x00, 0x38, 0x70,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x78, 0x70, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x30, 0x7F, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x27, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x1E, 0x00,
  0x0F, 0x80, 0xE0, 0x00, 0xF8, 0x07, 0x00, 0x0F, 0x80, 0x38, 0x00, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0xF0, 0x1F, 0x00, 0x07,
  0x01, 0xF0, 0x00, 0x38, 0x1F, 0x00, 0x01, 0xC3, 0xE0, 0x00, 0x1E, 0x3E,
  0x00, 0x00, 0xF3, 0xE0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x3B, 0xF8, 0x00,
  0x01, 0xFD, 0xE0, 0x00, 0x0F, 0xCF, 0x00, 0x00, 0xFC, 0x3C, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0x38, 0x07, 0x80, 0x01, 0xC0, 0x1E, 0x00, 0x0E, 0x00,
  0x78, 0x00, 0x70, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x3C,
  0x01, 0xC0, 0x01, 0xE0, 0x0E, 0x00, 0x07, 0x80, 0x70, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x78, 0x03, 0x9F, 0xE0,
  0xFF, 0x01, 0xDF, 0xF9, 0xFF, 0xC1, 0xDE, 0x7F, 0xF1, 0xE0, 0xFC, 0x0F,
  0xE0, 0x78, 0x78, 0x07, 0xC0, 0x1C, 0x3C, 0x01, 0xE0, 0x0E, 0x1C, 0x00,
  0xE0, 0x07, 0x0E, 0x00, 0x70, 0x03, 0x8F, 0x00, 0x78, 0x01, 0xC7, 0x00,
  0x3C, 0x01, 0xE3, 0x80, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x00, 0x70, 0xE0,
  0x07, 0x00, 0x38, 0x70, 0x03, 0x80, 0x1C, 0x78, 0x03, 0xC0, 0x0E, 0x38,
  0x01, 0xC0, 0x0F, 0x1C, 0x00, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0x03, 0x87,
  0x00, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x00, 0xE3, 0xC0, 0x1E, 0x00, 0x71,
  0xC0, 0x0E, 0x00, 0x78, 0xE0, 0x07, 0x00, 0x38, 0x70, 0x03, 0x80, 0x1C,
  0x38, 0x01, 0xC0, 0x0E, 0x3C, 0x00, 0xE0, 0x07, 0x1C, 0x00, 0xF0, 0x07,
  0x8E, 0x00, 0x70, 0x03, 0xC7, 0x00, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x00,
  0xE1, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x38, 0x3F, 0xF0,
  0x07, 0x8F, 0xFF, 0x80, 0x71, 0xF0, 0xFC, 0x07, 0x3C, 0x03, 0xE0, 0x77,
  0x00, 0x1E, 0x07, 0xE0, 0x00, 0xE0, 0x7C, 0x00, 0x0F, 0x0F, 0x80, 0x00,
  0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0F, 0x0E,
  0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0xE1, 0xE0, 0x00,
  0x0E, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1E, 0x1C, 0x00, 0x01, 0xE1,
  0xC0, 0x00, 0x1C, 0x3C, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x1C, 0x38, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x3C, 0x38, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x38,
  0x78, 0x00, 0x03, 0x87, 0x80, 0x00, 0x38, 0x70, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x78, 0x70, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x70, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xC3, 0xF0, 0x03,
  0xE0, 0x0F, 0x80, 0x7C, 0x00, 0x3C, 0x0F, 0x80, 0x03, 0xC0, 0xF0, 0x00,
  0x1E, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x70, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E,
  0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xCF, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x78, 0x70, 0x00, 0x07,
  0x87, 0x80, 0x00, 0xF0, 0x38, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0x1E,
  0x00, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x03, 0x87, 0xFE,
  0x00, 0x0E, 0x7F, 0xFC, 0x00, 0x7B, 0xF1, 0xF8, 0x01, 0xDE, 0x01, 0xF0,
  0x07, 0xE0, 0x03, 0xC0, 0x1F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x1E, 0x01,
  0xC0, 0x00, 0x38, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x0F, 0x03, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0xF0, 0x38, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x1C, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x3C, 0x0E,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x3C, 0x07, 0xE0,
  0x01, 0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0x73, 0xF3, 0xF8, 0x01, 0xC7, 0xFF,
  0xC0, 0x07, 0x0F, 0xFC, 0x00, 0x3C, 0x01, 0x80, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFE, 0x1C, 0x07, 0xFF, 0xE3,
  0x81, 0xFC, 0x3E, 0xF0, 0x7C, 0x01, 0xFE, 0x1F, 0x00, 0x0F, 0x83, 0xC0,
  0x01, 0xF0, 0xF0, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x78,
  0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x38, 0xE0, 0x00,
  0x07, 0x3C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0xF1, 0xC0, 0x00, 0x1E, 0x38, 0x00, 0x03, 0x87, 0x80, 0x00, 0x70, 0xF0,
  0x00, 0x0E, 0x0E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x3F,
  0x03, 0xE0, 0x1F, 0xC0, 0x3F, 0x1F, 0xB8, 0x03, 0xFF, 0xE7, 0x00, 0x3F,
  0xF0, 0xE0, 0x00, 0x40, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0x03, 0xC1,
  0xFF, 0xC1, 0xC3, 0xFF, 0xE0, 0xE3, 0xFF, 0xF0, 0x73, 0xE0, 0x00, 0x3B,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x01, 0xFC, 0x1F,
  0x80, 0x7C, 0x00, 0x78, 0x1F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x70,
  0x00, 0x0E, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x1E,
  0x00, 0x00, 0xE3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x07,
  0xC0, 0x7F, 0xCF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x9E, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x78, 0x00, 0x03, 0x8F, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x1E, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x0E, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x1C,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x1E, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x3C, 0x70, 0x00, 0x07, 0x8E, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1E,
  0x1C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x1E, 0x0F, 0x00,
  0x07, 0xC1, 0xE0, 0x03, 0xB8, 0x1E, 0x00, 0xF7, 0x03, 0xFB, 0xFD, 0xC0,
  0x3F, 0xFE, 0x38, 0x01, 0xFF, 0x07, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x1C,
  0x78, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x38, 0x38, 0x00, 0x07, 0x83, 0x80,
  0x00, 0x70, 0x3C, 0x00, 0x0F, 0x01, 0xC0, 0x01, 0xE0, 0x1C, 0x00, 0x1C,
  0x01, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x0E,
  0x00, 0x70, 0x00, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x70, 0x1E,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x38, 0x70, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x03, 0x80, 0x0F, 0xC0, 0x07, 0x00, 0x1F, 0x80, 0x1E, 0x00, 0x77, 0x00,
  0x3C, 0x00, 0xEE, 0x00, 0x78, 0x01, 0xDC, 0x01, 0xF0, 0x07, 0x38, 0x03,
  0x60, 0x0E, 0x70, 0x0E, 0xC0, 0x38, 0x60, 0x1D, 0xC0, 0x70, 0xE0, 0x73,
  0x80, 0xE1, 0xC0, 0xE7, 0x03, 0x83, 0x81, 0x8E, 0x07, 0x07, 0x07, 0x1C,
  0x0E, 0x0E, 0x0E, 0x38, 0x38, 0x1C, 0x38, 0x70, 0x70, 0x38, 0x70, 0xE1,
  0xC0, 0x70, 0xC1, 0xC3, 0x80, 0xE3, 0x81, 0x87, 0x01, 0xC7, 0x03, 0x1C,
  0x03, 0x9C, 0x06, 0x38, 0x07, 0x38, 0x0C, 0x60, 0x0E, 0x60, 0x19, 0xC0,
  0x1D, 0xC0, 0x33, 0x80, 0x3B, 0x00, 0x76, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0xFC, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x01, 0xE0,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1C, 0x0F, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x0F, 0x7C, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x7C, 0x38, 0x00,
  0x00, 0xF8, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x03, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x1E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0,
  0xF8, 0x00, 0x01, 0xF0, 0x03, 0x80, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x78, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x07, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x3C, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00,
  0x00, 0xF3, 0x80, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0x0F, 0xFE, 0x00, 0x07, 0x1F, 0x3F,
  0x00, 0x07, 0x3C, 0x07, 0x80, 0x0E, 0x78, 0x03, 0xC0, 0x0E, 0x70, 0x01,
  0xF0, 0x1C, 0x70, 0x00, 0xFC, 0x7C, 0xE0, 0x00, 0x7F, 0xF8, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xC0,
};

const GFXglyph RobotoMono_LightItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 11, 42, 35, 12, -42 },
  { 59, 14, 13, 35, 13, -44 },
  { 82, 34, 42, 35, 1, -42 },
  { 261, 28, 54, 35, 4, -48 },
  { 450, 28, 44, 35, 4, -43 },
  { 604, 30, 44, 35, 2, -43 },
  { 769, 5, 13, 35, 17, -44 },
  { 778, 18, 61, 35, 10, -47 },
  { 916, 19, 61, 35, 5, -47 },
  { 1061, 26, 26, 35, 7, -42 },
  { 1146, 29, 31, 35, 3, -35 },
  { 1259, 8, 14, 35, 7, -5 },
  { 1273, 22, 3, 35, 6, -20 },
  { 1282, 5, 5, 35, 13, -5 },
  { 1286, 28, 46, 35, 4, -42 },
  { 1447, 28, 44, 35, 4, -43 },
  { 1601, 16, 42, 35, 9, -42 },
  { 1685, 29, 43, 35, 1, -43 },
  { 1841, 29, 44, 35, 1, -43 },
  { 2001, 30, 42, 35, 1, -42 },
  { 2159, 29, 43, 35, 5, -42 },
  { 2315, 26, 43, 35, 3, -42 },
  { 2455, 27, 42, 35, 7, -42 },
  { 2597, 29, 44, 35, 4, -43 },
  { 2757, 25, 43, 35, 6, -43 },
  { 2892, 10, 30, 35, 14, -30 },
  { 2930, 13, 39, 35, 11, -30 },
  { 2994, 26, 24, 35, 5, -31 },
  { 3072, 27, 14, 35, 4, -26 },
  { 3120, 27, 24, 35, 3, -31 },
  { 3201, 22, 43, 35, 9, -43 },
  { 3320, 32, 42, 35, 2, -42 },
  { 3488, 29, 42, 35, 0, -42 },
  { 3641, 30, 42, 35, 2, -42 },
  { 3799, 30, 44, 35, 3, -43 },
  { 3964, 31, 42, 35, 2, -42 },
  { 4127, 31, 42, 35, 3, -42 },
  { 4290, 31, 42, 35, 3, -42 },
  { 4453, 30, 44, 35, 3, -43 },
  { 4618, 33, 42, 35, 1, -42 },
  { 4792, 31, 42, 35, 2, -42 },
  { 4955, 31, 43, 35, 2, -42 },
  { 5122, 33, 42, 35, 3, -42 },
  { 5296, 25, 42, 35, 3, -42 },
  { 5428, 33, 42, 35, 2, -42 },
  { 5602, 32, 42, 35, 2, -42 },
  { 5770, 29, 44, 35, 3, -43 },
  { 5930, 31, 42, 35, 3, -42 },
  { 6093, 30, 50, 35, 3, -43 },
  { 6281, 30, 42, 35, 3, -42 },
  { 6439, 30, 44, 35, 3, -43 },
  { 6604, 30, 42, 35, 6, -42 },
  { 6762, 31, 43, 35, 3, -42 },
  { 6929, 30, 42, 35, 6, -42 },
  { 7087, 32, 42, 35, 5, -42 },
  { 7255, 36, 42, 35, 0, -42 },
  { 7444, 30, 42, 35, 6, -42 },
  { 7602, 32, 42, 35, 1, -42 },
  { 7770, 19, 57, 35, 8, -48 },
  { 7906, 13, 46, 35, 11, -42 },
  { 7981, 19, 57, 35, 8, -48 },
  { 8117, 21, 23, 35, 7, -42 },
  { 8178, 26, 3, 35, 1, 0 },
  { 8188, 7, 8, 35, 17, -43 },
  { 8195, 27, 33, 35, 3, -32 },
  { 8307, 27, 45, 35, 3, -44 },
  { 8459, 26, 33, 35, 4, -32 },
  { 8567, 29, 45, 35, 4, -44 },
  { 8731, 28, 33, 35, 3, -32 },
  { 8847, 29, 45, 35, 7, -45 },
  { 9011, 29, 44, 35, 2, -32 },
  { 9171, 28, 44, 35, 2, -44 },
  { 9325, 25, 42, 35, 3, -42 },
  { 9457, 27, 55, 35, 0, -42 },
  { 9643, 29, 44, 35, 3, -44 },
  { 9803, 25, 44, 35, 3, -44 },
  { 9941, 33, 32, 35, 0, -32 },
  { 10073, 28, 32, 35, 2, -32 },
  { 10185, 28, 33, 35, 3, -32 },
  { 10301, 30, 44, 35, 0, -32 },
  { 10466, 27, 44, 35, 4, -32 },
  { 10615, 25, 32, 35, 7, -32 },
  { 10715, 27, 33, 35, 4, -32 },
  { 10827, 23, 40, 35, 7, -39 },
  { 10942, 27, 32, 35, 4, -31 },
  { 11050, 28, 31, 35, 5, -31 },
  { 11159, 31, 31, 35, 4, -31 },
  { 11280, 32, 31, 35, 1, -31 },
  { 11404, 36, 44, 35, -1, -31 },
  { 11602, 30, 31, 35, 1, -31 },
  { 11719, 23, 58, 35, 9, -46 },
  { 11886, 10, 52, 35, 12, -42 },
  { 11951, 23, 58, 35, 5, -46 },
  { 12118, 32, 11, 35, 1, -23 },
};

const GFXfont RobotoMono_LightItalic59pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic59pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic59pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _ROBOTOMONO_LIGHTITALIC59PT7B_H_
