#ifndef _ROBOTOMONO_LIGHTITALIC12PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0x24, 0x80, 0x80, 0xFC, 0x0A, 0x24, 0x53, 0x72, 0x85, 0x3F,
  0x28, 0x50, 0x10, 0xC4, 0x91, 0x40, 0x81, 0x82, 0x8B, 0xC2, 0x00, 0x42,
  0xAA, 0xB4, 0x20, 0xE6, 0x69, 0x18, 0x18, 0x48, 0x91, 0xC2, 0x0A, 0x63,
  0x46, 0x74, 0xE0, 0x12, 0x44, 0x88, 0x88, 0x88, 0x84, 0x40, 0x22, 0x11,
  0x11, 0x11, 0x22, 0x24, 0x80, 0x10, 0x4D, 0xC8, 0x51, 0x20, 0x20, 0x82,
  0x7E, 0x20, 0x80, 0x58, 0xF8, 0x80, 0x04, 0x20, 0x84, 0x10, 0x84, 0x10,
  0x82, 0x00, 0x32, 0x63, 0x1B, 0xE6, 0x31, 0xF0, 0x3C, 0x92, 0x92, 0x40,
  0x19, 0x94, 0x41, 0x08, 0x42, 0x10, 0xF8, 0x18, 0x94, 0x41, 0x38, 0x20,
  0x62, 0x78, 0x04, 0x31, 0x45, 0x29, 0x2F, 0xC2, 0x08, 0x3D, 0x04, 0x1C,
  0x48, 0x20, 0xA2, 0x70, 0x19, 0x11, 0x6C, 0xC6, 0x31, 0x70, 0xFC, 0x10,
  0x84, 0x10, 0x82, 0x10, 0xC0, 0x31, 0x24, 0x52, 0x72, 0x28, 0xA2, 0xF0,
  0x32, 0x63, 0x18, 0xBC, 0x22, 0xE0, 0x40, 0x20, 0x20, 0x00, 0x94, 0x1B,
  0x30, 0x60, 0x80, 0xF8, 0x3E, 0xE0, 0x86, 0xC8, 0x00, 0x69, 0x11, 0x24,
  0x40, 0x80, 0x1C, 0x45, 0x6B, 0x5A, 0xB5, 0x6F, 0x40, 0x78, 0x08, 0x21,
  0x8A, 0x28, 0x97, 0xD1, 0x84, 0x38, 0x49, 0x0A, 0x27, 0x88, 0x91, 0x22,
  0xF8, 0x31, 0x28, 0x60, 0x82, 0x08, 0xA2, 0xF0, 0x38, 0x49, 0x0A, 0x14,
  0x28, 0x51, 0x24, 0xF0, 0x7D, 0x08, 0x20, 0xFA, 0x08, 0x20, 0xF8, 0x7D,
  0x04, 0x20, 0xFA, 0x08, 0x20, 0x80, 0x31, 0x28, 0x60, 0x82, 0x68, 0xA2,
  0x70, 0x22, 0x85, 0x0A, 0x17, 0xC8, 0x91, 0x42, 0x84, 0x3E, 0x10, 0x40,
  0x81, 0x02, 0x04, 0x08, 0xF8, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x44,
  0x70, 0x45, 0x29, 0x28, 0xE2, 0x89, 0x24, 0x88, 0x42, 0x11, 0x08, 0x42,
  0x10, 0xF8, 0x22, 0x45, 0x9B, 0x55, 0xCA, 0x91, 0x42, 0x84, 0x22, 0x45,
  0x8A, 0x95, 0x4A, 0x93, 0x46, 0x84, 0x31, 0x28, 0x61, 0x86, 0x28, 0xA2,
  0xF0, 0x79, 0x14, 0x61, 0x8B, 0xC8, 0x20, 0x80, 0x31, 0x28, 0x61, 0x86,
  0x18, 0xA2, 0xF0, 0x60, 0x71, 0x24, 0x61, 0x8B, 0xC9, 0x24, 0x88, 0x31,
  0x28, 0x50, 0x30, 0x20, 0xA2, 0xF0, 0xFC, 0x41, 0x08, 0x20, 0x82, 0x08,
  0x40, 0x46, 0x18, 0x61, 0x8A, 0x28, 0xA2, 0xF0, 0x86, 0x18, 0x92, 0x51,
  0x45, 0x18, 0x20, 0x96, 0x5B, 0x6D, 0xDB, 0x6D, 0xA4, 0x90, 0x42, 0x44,
  0x90, 0xC1, 0x02, 0x0A, 0x24, 0x84, 0x85, 0x14, 0x94, 0x50, 0x82, 0x08,
  0x40, 0x3E, 0x08, 0x10, 0x41, 0x04, 0x08, 0x20, 0xFC, 0x34, 0x44, 0x44,
  0x88, 0x88, 0x8C, 0x91, 0x24, 0x91, 0x24, 0x64, 0x92, 0x4A, 0x49, 0x60,
  0x10, 0x8C, 0xAC, 0x80, 0xF8, 0x90, 0x7C, 0x5F, 0x18, 0xFC, 0x42, 0x2D,
  0x98, 0xC6, 0x31, 0xF0, 0x7C, 0x61, 0x08, 0xF8, 0x04, 0x13, 0x52, 0x8A,
  0x28, 0xA2, 0xF8, 0x7C, 0x7F, 0x08, 0x3C, 0x1C, 0x87, 0xA8, 0x20, 0x84,
  0x10, 0x40, 0x3D, 0x14, 0x51, 0x45, 0xF0, 0xA6, 0x60, 0x20, 0x85, 0x99,
  0x45, 0x14, 0x51, 0x84, 0x10, 0x18, 0x22, 0x10, 0x84, 0xF8, 0x0C, 0x03,
  0x02, 0x08, 0x20, 0x84, 0x10, 0x42, 0x30, 0x41, 0x04, 0x66, 0xA3, 0x0A,
  0x24, 0x98, 0x70, 0x84, 0x22, 0x10, 0x84, 0xF8, 0x7F, 0x26, 0x4C, 0xA9,
  0x54, 0x80, 0x7D, 0x14, 0x51, 0x46, 0x10, 0x7C, 0x63, 0x18, 0xF8, 0x7D,
  0x14, 0x51, 0x46, 0xE8, 0x20, 0x7C, 0x63, 0x18, 0xF8, 0x42, 0x7D, 0x04,
  0x10, 0x42, 0x00, 0x7C, 0x18, 0x38, 0xF8, 0x27, 0xC8, 0x42, 0x21, 0x06,
  0x8C, 0x63, 0x18, 0xFC, 0x8E, 0x25, 0x14, 0x60, 0x80, 0xA6, 0x9D, 0xB6,
  0x92, 0x40, 0x66, 0x50, 0x41, 0x84, 0x98, 0x80, 0x42, 0x88, 0xA1, 0x43,
  0x02, 0x08, 0x20, 0x80, 0x7C, 0x21, 0x08, 0x43, 0xF0, 0x19, 0x08, 0x44,
  0x41, 0x08, 0x42, 0x18, 0x25, 0x24, 0x92, 0x52, 0x00, 0x20, 0x84, 0x21,
  0x0C, 0x84, 0x22, 0x30, 0x61, 0x24, 0x30,
};

const GFXglyph RobotoMono_LightItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 9, 7, 2, -9 },
  { 5, 2, 3, 7, 3, -9 },
  { 6, 7, 9, 7, 0, -9 },
  { 14, 6, 11, 7, 1, -10 },
  { 23, 6, 9, 7, 1, -9 },
  { 30, 7, 9, 7, 0, -9 },
  { 38, 1, 3, 7, 3, -9 },
  { 39, 4, 13, 7, 2, -10 },
  { 46, 4, 13, 7, 1, -10 },
  { 53, 6, 6, 7, 1, -9 },
  { 58, 6, 6, 7, 1, -7 },
  { 63, 2, 3, 7, 1, -1 },
  { 64, 5, 1, 7, 1, -4 },
  { 65, 1, 1, 7, 3, -1 },
  { 66, 6, 10, 7, 1, -9 },
  { 74, 5, 9, 7, 1, -9 },
  { 80, 3, 9, 7, 2, -9 },
  { 84, 6, 9, 7, 0, -9 },
  { 91, 6, 9, 7, 0, -9 },
  { 98, 6, 9, 7, 0, -9 },
  { 105, 6, 9, 7, 1, -9 },
  { 112, 5, 9, 7, 1, -9 },
  { 118, 6, 9, 7, 1, -9 },
  { 125, 6, 9, 7, 1, -9 },
  { 132, 5, 9, 7, 1, -9 },
  { 138, 2, 6, 7, 3, -6 },
  { 140, 3, 8, 7, 2, -6 },
  { 143, 5, 5, 7, 1, -6 },
  { 147, 5, 3, 7, 1, -5 },
  { 149, 5, 5, 7, 1, -6 },
  { 153, 4, 9, 7, 2, -9 },
  { 158, 7, 9, 7, 0, -9 },
  { 166, 6, 9, 7, 0, -9 },
  { 173, 7, 9, 7, 0, -9 },
  { 181, 6, 9, 7, 1, -9 },
  { 188, 7, 9, 7, 0, -9 },
  { 196, 6, 9, 7, 1, -9 },
  { 203, 6, 9, 7, 1, -9 },
  { 210, 6, 9, 7, 1, -9 },
  { 217, 7, 9, 7, 0, -9 },
  { 225, 7, 9, 7, 0, -9 },
  { 233, 7, 9, 7, 0, -9 },
  { 241, 6, 9, 7, 1, -9 },
  { 248, 5, 9, 7, 1, -9 },
  { 254, 7, 9, 7, 0, -9 },
  { 262, 7, 9, 7, 0, -9 },
  { 270, 6, 9, 7, 1, -9 },
  { 277, 6, 9, 7, 1, -9 },
  { 284, 6, 10, 7, 1, -9 },
  { 292, 6, 9, 7, 1, -9 },
  { 299, 6, 9, 7, 1, -9 },
  { 306, 6, 9, 7, 1, -9 },
  { 313, 6, 9, 7, 1, -9 },
  { 320, 6, 9, 7, 1, -9 },
  { 327, 6, 9, 7, 1, -9 },
  { 334, 7, 9, 7, 0, -9 },
  { 342, 6, 9, 7, 1, -9 },
  { 349, 7, 9, 7, 0, -9 },
  { 357, 4, 12, 7, 2, -10 },
  { 363, 3, 10, 7, 2, -9 },
  { 367, 3, 12, 7, 2, -10 },
  { 372, 5, 5, 7, 1, -9 },
  { 376, 5, 1, 7, 0, 0 },
  { 377, 2, 2, 7, 3, -9 },
  { 378, 5, 6, 7, 1, -6 },
  { 382, 5, 9, 7, 1, -9 },
  { 388, 5, 6, 7, 1, -6 },
  { 392, 6, 9, 7, 1, -9 },
  { 399, 5, 6, 7, 1, -6 },
  { 403, 6, 9, 7, 1, -9 },
  { 410, 6, 9, 7, 0, -6 },
  { 417, 6, 9, 7, 0, -9 },
  { 424, 5, 9, 7, 1, -9 },
  { 430, 6, 12, 7, 0, -9 },
  { 439, 6, 9, 7, 1, -9 },
  { 446, 5, 9, 7, 1, -9 },
  { 452, 7, 6, 7, 0, -6 },
  { 458, 6, 6, 7, 0, -6 },
  { 463, 5, 6, 7, 1, -6 },
  { 467, 6, 8, 7, 0, -6 },
  { 473, 5, 8, 7, 1, -6 },
  { 478, 6, 6, 7, 1, -6 },
  { 483, 5, 6, 7, 1, -6 },
  { 487, 5, 8, 7, 1, -8 },
  { 492, 5, 6, 7, 1, -6 },
  { 496, 6, 6, 7, 1, -6 },
  { 501, 6, 6, 7, 1, -6 },
  { 506, 7, 6, 7, 0, -6 },
  { 512, 7, 9, 7, 0, -6 },
  { 520, 6, 6, 7, 0, -6 },
  { 525, 5, 11, 7, 2, -9 },
  { 532, 3, 11, 7, 2, -9 },
  { 537, 5, 11, 7, 1, -9 },
  { 544, 7, 3, 7, 0, -5 },
};

const GFXfont RobotoMono_LightItalic12pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic12pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _ROBOTOMONO_LIGHTITALIC12PT7B_H_
