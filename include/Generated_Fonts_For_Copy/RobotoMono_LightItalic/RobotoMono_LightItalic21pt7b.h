#ifndef _ROBOTOMONO_LIGHTITALIC21PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x32, 0x22, 0x22, 0x64, 0x40, 0x04, 0xC0, 0xCC, 0xA5, 0x29,
  0x00, 0x03, 0x10, 0x11, 0x00, 0x88, 0x08, 0xC3, 0xFF, 0x82, 0x20, 0x22,
  0x01, 0x10, 0x08, 0x80, 0x88, 0x3F, 0xF8, 0x22, 0x02, 0x20, 0x11, 0x01,
  0x98, 0x00, 0x01, 0x00, 0x80, 0xF8, 0x63, 0x30, 0x48, 0x12, 0x00, 0xC0,
  0x18, 0x03, 0x80, 0x30, 0x02, 0x00, 0xB0, 0x24, 0x09, 0x84, 0x3E, 0x02,
  0x00, 0x80, 0x38, 0x12, 0x04, 0x4E, 0x22, 0x89, 0x16, 0x82, 0x20, 0x10,
  0x08, 0x86, 0xD1, 0x64, 0x91, 0x44, 0x41, 0x10, 0x38, 0x0F, 0x06, 0x61,
  0x18, 0xC4, 0x13, 0x05, 0x81, 0xC0, 0x60, 0x6C, 0x51, 0x18, 0x26, 0x0E,
  0x81, 0xB0, 0xE7, 0xCC, 0x7A, 0x80, 0x04, 0x31, 0x84, 0x21, 0x84, 0x10,
  0xC2, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x10, 0x40, 0x80, 0x10,
  0x60, 0x81, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x30, 0x82, 0x18,
  0x42, 0x18, 0xC2, 0x00, 0x08, 0x04, 0x02, 0x19, 0x37, 0xE0, 0xC0, 0xB0,
  0x88, 0xC6, 0x00, 0x06, 0x01, 0x00, 0x40, 0x10, 0xFF, 0xFF, 0xF0, 0xC0,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x25, 0xAC, 0xFF, 0x5C, 0x00, 0x60, 0x08,
  0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20,
  0x08, 0x01, 0x00, 0x40, 0x18, 0x06, 0x00, 0x0F, 0x86, 0x33, 0x04, 0x81,
  0x60, 0xD0, 0x74, 0x25, 0x11, 0x58, 0x7C, 0x3C, 0x09, 0x02, 0x41, 0x90,
  0xC3, 0xE0, 0x04, 0xFC, 0x82, 0x08, 0x20, 0x86, 0x10, 0x41, 0x04, 0x10,
  0xC2, 0x00, 0x0F, 0x83, 0x18, 0xC1, 0x10, 0x20, 0x04, 0x00, 0x80, 0x20,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x3F, 0xF0, 0x1F,
  0x0C, 0x22, 0x0D, 0x03, 0x00, 0xC0, 0x20, 0x30, 0x78, 0x01, 0x00, 0x60,
  0x0A, 0x06, 0x81, 0x30, 0xC7, 0xC0, 0x00, 0x40, 0x18, 0x05, 0x01, 0xA0,
  0x6C, 0x09, 0x02, 0x20, 0x84, 0x20, 0x8C, 0x11, 0xFF, 0xC0, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x1F, 0xCC, 0x02, 0x00, 0x80, 0x20, 0x13, 0x07, 0xF1,
  0x04, 0x01, 0x80, 0x60, 0x1A, 0x04, 0x81, 0x30, 0x87, 0xC0, 0x03, 0x86,
  0x06, 0x06, 0x02, 0x02, 0x71, 0x44, 0xC1, 0x40, 0xE0, 0x70, 0x38, 0x14,
  0x1B, 0x18, 0xF8, 0xFF, 0xC0, 0x30, 0x08, 0x04, 0x01, 0x00, 0x80, 0x60,
  0x10, 0x08, 0x02, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x0C, 0x00, 0x0F, 0x83,
  0x18, 0xC1, 0x10, 0x32, 0x04, 0x40, 0x84, 0x60, 0xF8, 0x21, 0x88, 0x11,
  0x03, 0x60, 0x6C, 0x08, 0x82, 0x0F, 0x80, 0x1E, 0x10, 0x90, 0x28, 0x18,
  0x0C, 0x06, 0x03, 0x83, 0x43, 0x9E, 0x80, 0x40, 0x40, 0x60, 0xE1, 0xC0,
  0x23, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x10, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0x10, 0x8C, 0x40, 0x00, 0x83, 0x87, 0x1C, 0x0C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x20, 0x1E, 0x00,
  0x60, 0x06, 0x00, 0xC1, 0xC3, 0x83, 0x80, 0x80, 0x00, 0x3E, 0x63, 0xC1,
  0x81, 0x01, 0x02, 0x06, 0x0C, 0x10, 0x30, 0x20, 0x00, 0x00, 0x20, 0x60,
  0x07, 0x83, 0x08, 0x80, 0xB3, 0x94, 0x93, 0x22, 0x64, 0x4C, 0x89, 0xA2,
  0x34, 0x4A, 0x99, 0x4C, 0xC8, 0x00, 0x84, 0x0F, 0x80, 0x01, 0x00, 0x60,
  0x28, 0x0A, 0x04, 0x81, 0x20, 0x88, 0x22, 0x10, 0x84, 0x13, 0xFC, 0x81,
  0x40, 0x50, 0x18, 0x04, 0x3F, 0x08, 0x32, 0x04, 0x81, 0x20, 0x48, 0x36,
  0x19, 0xFC, 0x40, 0x90, 0x34, 0x0F, 0x03, 0x80, 0xA0, 0xCF, 0xE0, 0x0F,
  0x83, 0x18, 0x81, 0x10, 0x34, 0x06, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x10,
  0x02, 0x03, 0x60, 0x44, 0x18, 0x86, 0x0F, 0x80, 0x3F, 0x04, 0x30, 0x83,
  0x10, 0x22, 0x06, 0xC0, 0xD0, 0x1A, 0x02, 0x40, 0x48, 0x0B, 0x03, 0x60,
  0x48, 0x11, 0x0C, 0x3F, 0x00, 0x3F, 0xE4, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x18, 0x03, 0xFC, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00,
  0x3F, 0xE0, 0x1F, 0xE6, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03,
  0xFC, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x00, 0x0F,
  0x83, 0x18, 0x81, 0x10, 0x34, 0x00, 0x80, 0x10, 0x06, 0x00, 0x87, 0xD0,
  0x0A, 0x03, 0x60, 0x44, 0x08, 0xC3, 0x0F, 0xC0, 0x20, 0x24, 0x04, 0x80,
  0x90, 0x34, 0x04, 0x80, 0x90, 0x13, 0xFE, 0x40, 0x58, 0x1A, 0x02, 0x40,
  0x48, 0x09, 0x01, 0x20, 0x60, 0x3F, 0xE0, 0x40, 0x08, 0x03, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x3F, 0xC0, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x40, 0xC8, 0x11, 0x84, 0x1F, 0x00, 0x30,
  0x32, 0x04, 0x20, 0x82, 0x10, 0x22, 0x02, 0x40, 0x68, 0x05, 0xC0, 0x64,
  0x04, 0x60, 0x42, 0x04, 0x30, 0xC1, 0x08, 0x18, 0x80, 0xC0, 0x10, 0x18,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x06, 0x03, 0xFE, 0x30, 0x66, 0x0C, 0xC3, 0x98, 0x57, 0x1E, 0x92, 0x92,
  0x92, 0x52, 0x4C, 0x49, 0x9B, 0x23, 0x40, 0x48, 0x09, 0x01, 0x20, 0x20,
  0x20, 0x26, 0x04, 0xC0, 0x9C, 0x36, 0x84, 0x90, 0x93, 0x12, 0x22, 0x44,
  0xD8, 0xDB, 0x0A, 0x41, 0x48, 0x19, 0x03, 0x20, 0x60, 0x0F, 0x86, 0x33,
  0x04, 0x81, 0x40, 0x50, 0x14, 0x07, 0x01, 0x80, 0x60, 0x18, 0x0F, 0x02,
  0x41, 0x98, 0xC3, 0xE0, 0x1F, 0x86, 0x08, 0x80, 0x90, 0x12, 0x02, 0x40,
  0x48, 0x13, 0x0C, 0x7F, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x20,
  0x00, 0x0F, 0x83, 0x18, 0x81, 0x30, 0x34, 0x06, 0x80, 0x70, 0x1C, 0x02,
  0x80, 0x50, 0x0A, 0x01, 0x40, 0x4C, 0x18, 0x86, 0x0F, 0x80, 0x18, 0x01,
  0x80, 0x20, 0x3F, 0x04, 0x18, 0x81, 0x10, 0x32, 0x06, 0x40, 0x98, 0x32,
  0x0C, 0x7E, 0x08, 0x41, 0x0C, 0x20, 0x8C, 0x11, 0x03, 0x20, 0x20, 0x0F,
  0x82, 0x18, 0x81, 0x90, 0x32, 0x00, 0x40, 0x06, 0x00, 0x70, 0x01, 0x80,
  0x10, 0x03, 0x40, 0x6C, 0x08, 0x83, 0x0F, 0x80, 0xFF, 0xE0, 0x80, 0x10,
  0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x0C, 0x00, 0x20, 0x24, 0x04, 0x80, 0x90, 0x34, 0x04,
  0x80, 0x90, 0x12, 0x02, 0x40, 0x58, 0x1A, 0x02, 0x60, 0x44, 0x18, 0x86,
  0x0F, 0x80, 0xC0, 0x78, 0x09, 0x03, 0x20, 0x44, 0x18, 0x82, 0x10, 0xC3,
  0x10, 0x26, 0x04, 0x80, 0x90, 0x14, 0x02, 0x80, 0x60, 0x0C, 0x00, 0x84,
  0x30, 0x86, 0x31, 0x46, 0x28, 0xC5, 0x29, 0xA5, 0x24, 0xA4, 0xA4, 0x94,
  0xA2, 0x94, 0x62, 0x8C, 0x61, 0x84, 0x20, 0x80, 0x10, 0x18, 0xC1, 0x82,
  0x18, 0x10, 0x80, 0x48, 0x02, 0xC0, 0x1C, 0x00, 0x40, 0x07, 0x00, 0x68,
  0x06, 0x60, 0x21, 0x02, 0x08, 0x30, 0x23, 0x01, 0x80, 0xC0, 0x68, 0x19,
  0x02, 0x30, 0x82, 0x30, 0x44, 0x0D, 0x00, 0xE0, 0x18, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x0C, 0x00, 0x1F, 0xF0, 0x02, 0x00, 0x40, 0x0C,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x60, 0x04, 0x00, 0x80, 0x10, 0x03, 0x00,
  0x20, 0x04, 0x00, 0xFF, 0xC0, 0x1E, 0x20, 0x40, 0x83, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x83, 0x04, 0x08, 0x10, 0x20, 0x41, 0x82, 0x07, 0x80, 0x88,
  0x44, 0x44, 0x42, 0x22, 0x22, 0x11, 0x11, 0x1C, 0x10, 0x41, 0x04, 0x30,
  0x82, 0x08, 0x20, 0x86, 0x10, 0x41, 0x04, 0x10, 0x43, 0x38, 0x08, 0x30,
  0x51, 0x22, 0x48, 0xB1, 0xC1, 0xFF, 0x80, 0xCC, 0x1F, 0x08, 0x26, 0x0C,
  0x02, 0x00, 0x8F, 0xE4, 0x0A, 0x02, 0x81, 0xB0, 0xE7, 0xD8, 0x10, 0x0C,
  0x02, 0x00, 0x80, 0x20, 0x0B, 0xC3, 0x09, 0x82, 0x40, 0xD0, 0x34, 0x0D,
  0x02, 0x40, 0xB0, 0x6C, 0x32, 0xF8, 0x1F, 0x0C, 0x26, 0x0D, 0x01, 0x40,
  0x30, 0x0C, 0x03, 0x00, 0x41, 0x98, 0x43, 0xE0, 0x00, 0x20, 0x0C, 0x01,
  0x80, 0x20, 0x04, 0x3E, 0x8C, 0x33, 0x06, 0x40, 0x88, 0x13, 0x02, 0x60,
  0x4C, 0x08, 0x83, 0x10, 0xC1, 0xE8, 0x1F, 0x0C, 0x26, 0x0D, 0x01, 0x7F,
  0xFF, 0xFC, 0x03, 0x00, 0x40, 0x18, 0x63, 0xE0, 0x03, 0xE0, 0xC0, 0x30,
  0x04, 0x00, 0x81, 0xFF, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18,
  0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x1F, 0x4C, 0x36, 0x0D, 0x02, 0x40,
  0xB0, 0x2C, 0x0B, 0x02, 0x41, 0x90, 0xC3, 0xD0, 0x04, 0x03, 0x20, 0x87,
  0xC0, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x0B, 0xE3, 0x09, 0x83, 0x40,
  0xD0, 0x34, 0x09, 0x02, 0xC0, 0xB0, 0x28, 0x1A, 0x04, 0x03, 0x01, 0x80,
  0x00, 0x03, 0xE0, 0x10, 0x18, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0xC0,
  0x43, 0xFE, 0x00, 0xC0, 0x20, 0x00, 0x00, 0x0F, 0x80, 0x60, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01,
  0x0F, 0x80, 0x10, 0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x32, 0x18, 0x88,
  0x6C, 0x16, 0x07, 0x81, 0x10, 0x46, 0x10, 0x8C, 0x12, 0x06, 0x1F, 0x01,
  0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x60, 0x21, 0xFF, 0x3E, 0xE6, 0x31, 0x42, 0x14, 0x23, 0x42, 0x24,
  0x62, 0x44, 0x2C, 0x42, 0x84, 0x28, 0x46, 0x8C, 0x40, 0x2F, 0x9C, 0x26,
  0x0D, 0x03, 0x40, 0x90, 0x24, 0x0B, 0x02, 0x80, 0xA0, 0x68, 0x10, 0x1F,
  0x0C, 0x26, 0x0D, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x02, 0xC1, 0x90, 0xC3,
  0xE0, 0x17, 0x83, 0x08, 0xC1, 0x10, 0x32, 0x06, 0x40, 0xC8, 0x13, 0x02,
  0x60, 0xCC, 0x31, 0x7C, 0x20, 0x04, 0x01, 0x80, 0x20, 0x00, 0x1F, 0x4C,
  0x36, 0x0D, 0x02, 0x40, 0xB0, 0x2C, 0x0B, 0x02, 0x41, 0x90, 0xC3, 0xD0,
  0x04, 0x01, 0x00, 0x40, 0x30, 0x6F, 0xA8, 0x18, 0x08, 0x04, 0x06, 0x03,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x00, 0x1F, 0x8C, 0x32, 0x04, 0x80, 0x30,
  0x03, 0x80, 0x18, 0x02, 0xC0, 0x90, 0x63, 0xE0, 0x08, 0x04, 0x02, 0x1F,
  0xF1, 0x00, 0x80, 0x40, 0x20, 0x10, 0x18, 0x08, 0x04, 0x03, 0x00, 0xF0,
  0x40, 0xA0, 0x70, 0x30, 0x38, 0x14, 0x0A, 0x05, 0x02, 0x83, 0x43, 0x9E,
  0x80, 0x80, 0xE0, 0x24, 0x11, 0x04, 0x42, 0x10, 0x82, 0x40, 0xB0, 0x28,
  0x0E, 0x01, 0x00, 0xC4, 0x34, 0x62, 0x4A, 0x24, 0xA4, 0x4A, 0x45, 0x28,
  0x52, 0x86, 0x28, 0x63, 0x06, 0x30, 0x43, 0x00, 0x30, 0x31, 0x84, 0x08,
  0x80, 0xD8, 0x07, 0x00, 0x60, 0x0E, 0x01, 0x90, 0x11, 0x82, 0x08, 0xC0,
  0x40, 0x20, 0x12, 0x02, 0x30, 0x61, 0x04, 0x10, 0xC1, 0x08, 0x19, 0x00,
  0xB0, 0x0A, 0x00, 0xE0, 0x04, 0x00, 0x80, 0x18, 0x01, 0x00, 0xE0, 0x00,
  0x7F, 0xC0, 0x20, 0x10, 0x08, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x0F, 0xF8, 0x03, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0xE0,
  0x60, 0x30, 0x10, 0x30, 0x30, 0x20, 0x20, 0x30, 0x10, 0x08, 0x11, 0x12,
  0x22, 0x22, 0x26, 0x44, 0x44, 0x44, 0x88, 0x18, 0x0C, 0x04, 0x04, 0x04,
  0x04, 0x0C, 0x0C, 0x04, 0x03, 0x06, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10,
  0x30, 0x60, 0xC0, 0x38, 0x14, 0x63, 0xC3, 0x60, 0x0C,
};

const GFXglyph RobotoMono_LightItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 15, 12, 4, -15 },
  { 9, 5, 5, 12, 5, -16 },
  { 13, 13, 15, 12, 0, -15 },
  { 38, 10, 19, 12, 1, -17 },
  { 62, 10, 15, 12, 1, -15 },
  { 81, 10, 15, 12, 1, -15 },
  { 100, 2, 5, 12, 6, -16 },
  { 102, 6, 22, 12, 4, -17 },
  { 119, 6, 22, 12, 2, -17 },
  { 136, 9, 9, 12, 3, -15 },
  { 147, 10, 11, 12, 1, -12 },
  { 161, 3, 5, 12, 2, -2 },
  { 163, 8, 1, 12, 2, -7 },
  { 164, 3, 2, 12, 4, -2 },
  { 165, 11, 16, 12, 1, -15 },
  { 187, 10, 15, 12, 1, -15 },
  { 206, 6, 15, 12, 3, -15 },
  { 218, 11, 15, 12, 0, -15 },
  { 239, 10, 15, 12, 1, -15 },
  { 258, 11, 15, 12, 0, -15 },
  { 279, 10, 15, 12, 2, -15 },
  { 298, 9, 15, 12, 1, -15 },
  { 315, 10, 15, 12, 2, -15 },
  { 334, 11, 15, 12, 1, -15 },
  { 355, 9, 15, 12, 2, -15 },
  { 372, 4, 11, 12, 5, -11 },
  { 378, 5, 14, 12, 4, -11 },
  { 387, 9, 9, 12, 2, -11 },
  { 398, 10, 5, 12, 1, -9 },
  { 405, 10, 9, 12, 1, -11 },
  { 417, 8, 15, 12, 3, -15 },
  { 432, 11, 15, 12, 1, -15 },
  { 453, 10, 15, 12, 0, -15 },
  { 472, 10, 15, 12, 1, -15 },
  { 491, 11, 15, 12, 1, -15 },
  { 512, 11, 15, 12, 1, -15 },
  { 533, 11, 15, 12, 1, -15 },
  { 554, 11, 15, 12, 1, -15 },
  { 575, 11, 15, 12, 1, -15 },
  { 596, 11, 15, 12, 1, -15 },
  { 617, 11, 15, 12, 1, -15 },
  { 638, 11, 15, 12, 1, -15 },
  { 659, 12, 15, 12, 1, -15 },
  { 682, 9, 15, 12, 1, -15 },
  { 699, 11, 15, 12, 1, -15 },
  { 720, 11, 15, 12, 1, -15 },
  { 741, 10, 15, 12, 1, -15 },
  { 760, 11, 15, 12, 1, -15 },
  { 781, 11, 18, 12, 1, -15 },
  { 806, 11, 15, 12, 1, -15 },
  { 827, 11, 15, 12, 1, -15 },
  { 848, 11, 15, 12, 2, -15 },
  { 869, 11, 15, 12, 1, -15 },
  { 890, 11, 15, 12, 2, -15 },
  { 911, 11, 15, 12, 2, -15 },
  { 932, 13, 15, 12, 0, -15 },
  { 957, 11, 15, 12, 2, -15 },
  { 978, 12, 15, 12, 0, -15 },
  { 1001, 7, 20, 12, 3, -17 },
  { 1019, 4, 16, 12, 4, -15 },
  { 1027, 6, 20, 12, 3, -17 },
  { 1042, 7, 8, 12, 3, -15 },
  { 1049, 9, 1, 12, 0, 0 },
  { 1051, 3, 2, 12, 6, -15 },
  { 1052, 10, 11, 12, 1, -11 },
  { 1066, 10, 16, 12, 1, -16 },
  { 1086, 10, 11, 12, 1, -11 },
  { 1100, 11, 16, 12, 1, -16 },
  { 1122, 10, 11, 12, 1, -11 },
  { 1136, 11, 16, 12, 2, -16 },
  { 1158, 10, 15, 12, 1, -11 },
  { 1177, 10, 16, 12, 1, -16 },
  { 1197, 9, 15, 12, 1, -15 },
  { 1214, 10, 19, 12, 0, -15 },
  { 1238, 10, 16, 12, 1, -16 },
  { 1258, 9, 16, 12, 1, -16 },
  { 1276, 12, 11, 12, 0, -11 },
  { 1293, 10, 11, 12, 1, -11 },
  { 1307, 10, 11, 12, 1, -11 },
  { 1321, 11, 15, 12, 0, -11 },
  { 1342, 10, 15, 12, 1, -11 },
  { 1361, 9, 11, 12, 3, -11 },
  { 1374, 10, 11, 12, 1, -11 },
  { 1388, 9, 14, 12, 2, -14 },
  { 1404, 9, 11, 12, 2, -11 },
  { 1417, 10, 11, 12, 2, -11 },
  { 1431, 12, 11, 12, 1, -11 },
  { 1448, 12, 11, 12, 0, -11 },
  { 1465, 12, 15, 12, 0, -11 },
  { 1488, 10, 11, 12, 1, -11 },
  { 1502, 8, 20, 12, 3, -16 },
  { 1522, 4, 18, 12, 4, -15 },
  { 1531, 8, 20, 12, 2, -16 },
  { 1551, 12, 4, 12, 0, -8 },
};

const GFXfont RobotoMono_LightItalic21pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic21pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic21pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _ROBOTOMONO_LIGHTITALIC21PT7B_H_
