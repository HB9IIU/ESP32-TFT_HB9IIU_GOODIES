#ifndef _ROBOTOMONO_LIGHTITALIC30PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0xC6, 0x31, 0x88, 0x46, 0x31, 0x8C, 0x42, 0x31, 0x80, 0x00,
  0x01, 0x8C, 0x00, 0x46, 0x8D, 0x16, 0x2C, 0x51, 0xA3, 0x00, 0x00, 0x61,
  0x80, 0x10, 0x40, 0x0C, 0x30, 0x03, 0x08, 0x00, 0x82, 0x00, 0x61, 0x81,
  0xFF, 0xFC, 0x04, 0x10, 0x03, 0x0C, 0x00, 0x82, 0x00, 0x21, 0x80, 0x18,
  0x60, 0x04, 0x10, 0x01, 0x0C, 0x0F, 0xFF, 0xE0, 0x20, 0x80, 0x18, 0x60,
  0x06, 0x10, 0x01, 0x04, 0x00, 0xC3, 0x00, 0x30, 0x80, 0x00, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x30, 0x07, 0xF8, 0x38, 0x61, 0x80, 0xC6, 0x03,
  0x30, 0x0C, 0xC0, 0x33, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x01, 0xB0, 0x06, 0xC0, 0x1B, 0x00,
  0xC6, 0x07, 0x1E, 0x38, 0x1F, 0x80, 0x18, 0x00, 0x40, 0x01, 0x00, 0x08,
  0x00, 0xF8, 0x04, 0x20, 0x30, 0x82, 0xC2, 0x1A, 0x08, 0xC8, 0x22, 0x31,
  0x98, 0xCC, 0xC1, 0xE2, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x11, 0xE0,
  0xCC, 0xC6, 0x61, 0x11, 0x04, 0xC4, 0x16, 0x10, 0xD0, 0x43, 0x01, 0x98,
  0x03, 0xC0, 0x00, 0xC0, 0x07, 0xE0, 0x18, 0x40, 0x60, 0xC0, 0xC1, 0x81,
  0x83, 0x03, 0x0C, 0x06, 0x30, 0x0C, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78,
  0x01, 0x98, 0x26, 0x30, 0xD8, 0x31, 0xA0, 0x62, 0xC0, 0x6D, 0x80, 0x73,
  0x00, 0xE3, 0x03, 0xC7, 0x1E, 0xC3, 0xF1, 0x80, 0x2D, 0xB4, 0xB0, 0x00,
  0x80, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x20, 0x30, 0x18, 0x08, 0x0C,
  0x06, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0x40, 0x20, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06,
  0x01, 0x80, 0x40, 0x30, 0x08, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18,
  0x08, 0x0C, 0x0C, 0x06, 0x06, 0x06, 0x06, 0x02, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x80, 0x04, 0x0E, 0x23, 0xBD, 0xF8, 0x3E, 0x01, 0xC0, 0x1B, 0x01,
  0x8C, 0x1C, 0x61, 0xC1, 0x84, 0x08, 0x00, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x3F, 0xFF, 0xFF, 0xFC, 0x0C,
  0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x19,
  0x8C, 0x63, 0x33, 0x00, 0xFF, 0xE0, 0x7D, 0x80, 0x00, 0x0C, 0x00, 0x20,
  0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00,
  0x08, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00,
  0x00, 0x01, 0xC0, 0x1F, 0xC0, 0xC1, 0x86, 0x03, 0x30, 0x0C, 0xC0, 0x32,
  0x00, 0xD8, 0x07, 0x60, 0x3D, 0x83, 0xB4, 0x18, 0xD0, 0xC3, 0xC6, 0x0B,
  0x70, 0x2F, 0x01, 0xB8, 0x06, 0xC0, 0x13, 0x00, 0xCC, 0x03, 0x18, 0x18,
  0x71, 0xC0, 0x7E, 0x00, 0x03, 0x87, 0x9E, 0x4C, 0x68, 0x30, 0x18, 0x0C,
  0x04, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x0C, 0x06,
  0x02, 0x01, 0x01, 0x80, 0x00, 0xC0, 0x07, 0xF0, 0x18, 0x30, 0x60, 0x31,
  0x80, 0x63, 0x00, 0xCC, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x07, 0xFF, 0xDF, 0xFF, 0x80, 0x00, 0xC0,
  0x1F, 0xC0, 0xC1, 0x86, 0x03, 0x30, 0x0C, 0xC0, 0x10, 0x00, 0xC0, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x7E, 0x01, 0xF8, 0x00, 0x70, 0x00, 0x40, 0x01,
  0x80, 0x06, 0xC0, 0x1B, 0x00, 0x6C, 0x03, 0x38, 0x18, 0x70, 0xE0, 0xFE,
  0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xA0, 0x03, 0xC0, 0x0D, 0x80, 0x33,
  0x00, 0xC6, 0x01, 0x08, 0x06, 0x10, 0x18, 0x60, 0x60, 0xC1, 0x81, 0x86,
  0x03, 0x08, 0x04, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x07, 0xFE, 0x18, 0x00, 0x30, 0x00, 0x40,
  0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0xC0, 0x3F, 0xE0, 0x70, 0x60,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x60, 0x0C, 0xC0,
  0x18, 0x80, 0x61, 0x81, 0x81, 0xC7, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x1C,
  0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0xF8, 0x7F, 0xE3,
  0x81, 0xB8, 0x0D, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x02, 0xC0,
  0x36, 0x01, 0x98, 0x18, 0x63, 0x81, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x30,
  0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0,
  0x06, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x0F,
  0xF0, 0x38, 0x70, 0xC0, 0x61, 0x80, 0x46, 0x00, 0x8C, 0x01, 0x18, 0x06,
  0x10, 0x08, 0x30, 0x70, 0x3F, 0x80, 0x7F, 0x03, 0x83, 0x0C, 0x03, 0x10,
  0x06, 0x60, 0x0C, 0xC0, 0x19, 0x80, 0x33, 0x00, 0xC7, 0x01, 0x87, 0x0E,
  0x07, 0xF0, 0x00, 0x03, 0x80, 0x7F, 0x0E, 0x1C, 0x60, 0x66, 0x01, 0x20,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0D, 0x80, 0x66, 0x0F,
  0x1F, 0xD8, 0x7C, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x03,
  0xE0, 0x3C, 0x00, 0x19, 0xC6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x33,
  0x9C, 0x06, 0x1C, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x0C, 0x18, 0x30, 0x61, 0x86, 0x00, 0x00, 0x04, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x10, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x20, 0x01, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x60, 0x1E, 0x03, 0xC0, 0xF0, 0x1E,
  0x01, 0x80, 0x08, 0x00, 0x00, 0x03, 0x01, 0xFC, 0x38, 0x66, 0x03, 0x60,
  0x3C, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x08, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x01, 0xFC, 0x07, 0x06, 0x0C, 0x03, 0x18, 0x01, 0x10, 0xF1,
  0x21, 0x91, 0x62, 0x11, 0x46, 0x11, 0x44, 0x31, 0xCC, 0x21, 0xCC, 0x21,
  0x88, 0x23, 0x88, 0x62, 0x88, 0x42, 0x88, 0xC4, 0x8F, 0x3C, 0x86, 0x10,
  0xC0, 0x00, 0x60, 0x00, 0x38, 0xE0, 0x1F, 0xC0, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0xC0, 0x06, 0x80, 0x0D, 0x80, 0x33, 0x00, 0x66, 0x01, 0x8C, 0x03,
  0x08, 0x0C, 0x10, 0x18, 0x20, 0x20, 0x60, 0xC0, 0xC1, 0xFF, 0x87, 0xFF,
  0x08, 0x06, 0x30, 0x04, 0x40, 0x09, 0x80, 0x1A, 0x00, 0x3C, 0x00, 0x60,
  0x0F, 0xF8, 0x10, 0x38, 0x60, 0x18, 0xC0, 0x31, 0x80, 0x23, 0x00, 0xC4,
  0x01, 0x88, 0x06, 0x30, 0x18, 0x7F, 0xE0, 0xFF, 0xC1, 0x80, 0xC2, 0x00,
  0xC4, 0x01, 0x98, 0x01, 0x30, 0x06, 0x60, 0x0C, 0xC0, 0x31, 0x00, 0xE7,
  0xFF, 0x8F, 0xFC, 0x00, 0x01, 0xC0, 0x0F, 0xE0, 0x30, 0x60, 0xC0, 0x63,
  0x00, 0xC6, 0x00, 0xD8, 0x01, 0xB0, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x19,
  0x80, 0x23, 0x00, 0xC3, 0x03, 0x07, 0x1C, 0x03, 0xF0, 0x00, 0x0F, 0xF0,
  0x18, 0x38, 0x18, 0x0C, 0x18, 0x06, 0x18, 0x06, 0x10, 0x02, 0x10, 0x03,
  0x30, 0x03, 0x30, 0x03, 0x30, 0x02, 0x30, 0x02, 0x20, 0x06, 0x60, 0x06,
  0x60, 0x06, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x18, 0x40, 0x30, 0xC0, 0x60,
  0xFF, 0xC0, 0xFF, 0x00, 0x0F, 0xFF, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x3F, 0xF8,
  0x3F, 0xF8, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0x0F, 0xFF,
  0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x30, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x0F, 0xE0, 0x30, 0x60, 0xC0, 0x63,
  0x00, 0x44, 0x00, 0xD8, 0x01, 0xB0, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x1F, 0xD0, 0x01, 0xA0, 0x02, 0x40, 0x04, 0xC0, 0x19,
  0x80, 0x33, 0x00, 0x63, 0x01, 0xC3, 0x8E, 0x03, 0xF8, 0x00, 0x18, 0x01,
  0x18, 0x03, 0x18, 0x03, 0x10, 0x03, 0x10, 0x03, 0x30, 0x02, 0x30, 0x02,
  0x30, 0x06, 0x30, 0x06, 0x3F, 0xFE, 0x3F, 0xFE, 0x60, 0x04, 0x60, 0x04,
  0x60, 0x0C, 0x40, 0x0C, 0x40, 0x0C, 0x40, 0x08, 0xC0, 0x08, 0xC0, 0x08,
  0xC0, 0x18, 0x80, 0x18, 0x0F, 0xFF, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x30, 0x60, 0x60,
  0x79, 0xC0, 0x1F, 0x80, 0x0C, 0x03, 0x84, 0x03, 0x82, 0x03, 0x83, 0x03,
  0x81, 0x83, 0x80, 0xC3, 0x80, 0x63, 0x80, 0x23, 0x80, 0x33, 0x80, 0x1B,
  0x80, 0x0F, 0xE0, 0x07, 0xB0, 0x03, 0x0C, 0x01, 0x06, 0x01, 0x81, 0x80,
  0xC0, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x10, 0x06, 0x08, 0x03, 0x0C, 0x00,
  0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1C, 0x03, 0x8E,
  0x03, 0x87, 0x01, 0xC2, 0x81, 0xE1, 0x60, 0xB0, 0xB0, 0xD8, 0xD8, 0x48,
  0x64, 0x64, 0x32, 0x66, 0x19, 0x33, 0x08, 0xF1, 0x8C, 0x78, 0xC6, 0x38,
  0x43, 0x0C, 0x21, 0x84, 0x30, 0x80, 0x18, 0x40, 0x0C, 0x60, 0x06, 0x30,
  0x02, 0x18, 0x03, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x1C, 0x03, 0x1C, 0x03,
  0x1C, 0x03, 0x16, 0x03, 0x36, 0x02, 0x33, 0x06, 0x33, 0x06, 0x31, 0x06,
  0x21, 0x86, 0x21, 0x86, 0x60, 0x84, 0x60, 0xCC, 0x60, 0xCC, 0x60, 0x4C,
  0x40, 0x6C, 0x40, 0x68, 0xC0, 0x28, 0xC0, 0x38, 0xC0, 0x38, 0xC0, 0x18,
  0x01, 0x80, 0x1F, 0xC0, 0xC1, 0x86, 0x03, 0x30, 0x0C, 0xC0, 0x36, 0x00,
  0x58, 0x01, 0x40, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00,
  0x38, 0x00, 0xA0, 0x06, 0xC0, 0x1B, 0x00, 0xCC, 0x03, 0x18, 0x18, 0x79,
  0xC0, 0x7E, 0x00, 0x1F, 0xF8, 0x30, 0x38, 0x40, 0x18, 0x80, 0x33, 0x00,
  0x66, 0x00, 0x4C, 0x01, 0x98, 0x03, 0x20, 0x0C, 0x40, 0x39, 0x81, 0xE3,
  0xFF, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x03, 0xF8, 0x06,
  0x0C, 0x0C, 0x06, 0x18, 0x06, 0x10, 0x02, 0x30, 0x03, 0x20, 0x03, 0x60,
  0x03, 0x60, 0x03, 0x60, 0x02, 0x60, 0x02, 0x40, 0x06, 0x40, 0x06, 0xC0,
  0x06, 0xC0, 0x04, 0x40, 0x0C, 0x60, 0x08, 0x60, 0x18, 0x30, 0x30, 0x3C,
  0xE0, 0x1F, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x10, 0x0F,
  0xF8, 0x08, 0x1C, 0x08, 0x06, 0x18, 0x06, 0x18, 0x03, 0x18, 0x02, 0x18,
  0x02, 0x10, 0x06, 0x10, 0x06, 0x30, 0x1C, 0x30, 0x78, 0x3F, 0xE0, 0x30,
  0x60, 0x20, 0x60, 0x20, 0x20, 0x60, 0x30, 0x60, 0x30, 0x60, 0x10, 0x40,
  0x18, 0x40, 0x18, 0xC0, 0x0C, 0x00, 0xE0, 0x03, 0xF8, 0x0E, 0x0E, 0x0C,
  0x06, 0x18, 0x03, 0x18, 0x03, 0x10, 0x03, 0x18, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x0C, 0xC0, 0x04, 0x40, 0x0C, 0x60, 0x0C, 0x70, 0x18, 0x3C, 0x70, 0x1F,
  0xE0, 0xFF, 0xFE, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x80, 0x00, 0x30, 0x02, 0x60, 0x0C, 0xC0, 0x19, 0x00,
  0x32, 0x00, 0x6C, 0x00, 0x98, 0x01, 0x30, 0x06, 0x60, 0x0C, 0x80, 0x19,
  0x00, 0x36, 0x00, 0x4C, 0x00, 0x98, 0x03, 0x30, 0x06, 0x60, 0x0C, 0xC0,
  0x31, 0x80, 0x61, 0x81, 0x83, 0x8E, 0x03, 0xF8, 0x00, 0xC0, 0x07, 0x80,
  0x19, 0x00, 0x33, 0x00, 0xC6, 0x01, 0x8C, 0x02, 0x18, 0x0C, 0x30, 0x10,
  0x20, 0x60, 0x40, 0xC0, 0xC3, 0x01, 0x86, 0x03, 0x18, 0x06, 0x30, 0x04,
  0xC0, 0x09, 0x80, 0x16, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80,
  0x00, 0xC1, 0x83, 0xC1, 0x82, 0xC3, 0x86, 0xC3, 0x86, 0xC3, 0x84, 0xC7,
  0x8C, 0xC5, 0x8C, 0xC5, 0x88, 0xCC, 0x88, 0xC8, 0x98, 0xD8, 0x98, 0x98,
  0x90, 0x90, 0xB0, 0xB0, 0xB0, 0xB0, 0xA0, 0xA0, 0xA0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x0C, 0x01, 0xC1, 0x00, 0x60,
  0x60, 0x30, 0x18, 0x18, 0x03, 0x06, 0x00, 0xC3, 0x00, 0x19, 0x80, 0x06,
  0xC0, 0x00, 0xB0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x03, 0x60,
  0x00, 0xCC, 0x00, 0x63, 0x00, 0x30, 0x60, 0x1C, 0x18, 0x06, 0x02, 0x03,
  0x00, 0xC1, 0x80, 0x30, 0xE0, 0x06, 0x00, 0xC0, 0x06, 0xC0, 0x19, 0x80,
  0x61, 0x00, 0xC3, 0x03, 0x06, 0x0C, 0x04, 0x18, 0x0C, 0x60, 0x19, 0x80,
  0x33, 0x00, 0x2C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x0F, 0xFF, 0x8F, 0xFF, 0xC0, 0x07, 0xC1, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10,
  0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x10, 0x04, 0x03, 0xF0, 0xF8, 0x00, 0xC3, 0x0C, 0x10,
  0x41, 0x86, 0x18, 0x20, 0x83, 0x0C, 0x30, 0x41, 0x06, 0x18, 0x60, 0x82,
  0x0C, 0x30, 0xC0, 0x0F, 0x80, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x02,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0x80, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x1F, 0x0F, 0x80,
  0x03, 0x01, 0xC0, 0x50, 0x34, 0x19, 0x86, 0x63, 0x18, 0x82, 0x60, 0xD0,
  0x3C, 0x0C, 0xFF, 0xFF, 0xFF, 0xD9, 0x90, 0x07, 0xE0, 0xE3, 0x8C, 0x06,
  0x40, 0x36, 0x01, 0x80, 0x0C, 0x00, 0x63, 0xFF, 0x78, 0x17, 0x00, 0xB0,
  0x0D, 0x00, 0x68, 0x07, 0x60, 0x7B, 0x8E, 0xCF, 0xC6, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x7C, 0x17,
  0x78, 0x70, 0x73, 0x80, 0xCC, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0xC8,
  0x03, 0x60, 0x0D, 0x80, 0x36, 0x01, 0x98, 0x06, 0x70, 0x31, 0x63, 0x8C,
  0xFC, 0x00, 0x07, 0xE0, 0xF3, 0x8E, 0x06, 0x60, 0x36, 0x00, 0xB0, 0x07,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x2C, 0x03, 0x30,
  0x30, 0xC7, 0x03, 0xF0, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x80, 0x03, 0x03, 0xE6, 0x1E, 0xEC, 0x70, 0x70, 0xC0,
  0x63, 0x00, 0xC6, 0x01, 0x98, 0x03, 0x30, 0x06, 0x60, 0x08, 0xC0, 0x11,
  0x80, 0x63, 0x00, 0xC6, 0x01, 0x86, 0x07, 0x0E, 0x34, 0x0F, 0xC8, 0x00,
  0x07, 0xE0, 0x39, 0xC1, 0x81, 0x8C, 0x06, 0x60, 0x09, 0x00, 0x2C, 0x00,
  0xBF, 0xFE, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80,
  0xC3, 0x8E, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xF0, 0x30, 0x01, 0x80, 0x04,
  0x00, 0x30, 0x00, 0xC0, 0x3F, 0xFC, 0xFF, 0xF0, 0x20, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x00, 0x03, 0xE6, 0x1E,
  0xEC, 0x70, 0x70, 0xC0, 0x63, 0x00, 0xC6, 0x01, 0x98, 0x03, 0x30, 0x06,
  0x60, 0x08, 0xC0, 0x11, 0x80, 0x63, 0x00, 0xC6, 0x01, 0x86, 0x07, 0x0E,
  0x34, 0x0F, 0xC8, 0x00, 0x30, 0x00, 0x60, 0x01, 0x86, 0x07, 0x06, 0x1C,
  0x07, 0xE0, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x7C, 0x13, 0xB8, 0x50, 0x33, 0x80, 0xCC, 0x03,
  0x30, 0x0C, 0xC0, 0x32, 0x00, 0xC8, 0x03, 0x60, 0x0D, 0x80, 0x26, 0x01,
  0x98, 0x06, 0x40, 0x1B, 0x00, 0x6C, 0x01, 0x80, 0x00, 0x40, 0x0E, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC3, 0xF8, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02,
  0x00, 0x60, 0xFF, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x10, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01,
  0x80, 0x06, 0x00, 0x70, 0x3F, 0x80, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x03, 0x30, 0x38, 0xC1, 0xC2,
  0x0C, 0x08, 0x60, 0x67, 0x01, 0xB8, 0x07, 0xE0, 0x1D, 0x80, 0x63, 0x03,
  0x06, 0x0C, 0x18, 0x30, 0x30, 0xC0, 0xE3, 0x01, 0x88, 0x03, 0x00, 0x0F,
  0xE1, 0xFE, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x0F, 0xFF, 0xFF, 0xF0, 0x37, 0x8F,
  0x1E, 0xFD, 0x8C, 0x38, 0x66, 0x18, 0x32, 0x0C, 0x19, 0x06, 0x0D, 0x83,
  0x04, 0xC1, 0x82, 0x60, 0x83, 0x30, 0x41, 0x90, 0x60, 0xC8, 0x30, 0x4C,
  0x18, 0x26, 0x08, 0x13, 0x04, 0x19, 0x06, 0x0C, 0x19, 0xF0, 0x4E, 0xE1,
  0x40, 0xCE, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0xC8, 0x03, 0x20, 0x0D,
  0x80, 0x26, 0x00, 0x98, 0x06, 0x60, 0x19, 0x00, 0x6C, 0x01, 0xB0, 0x04,
  0x07, 0xE0, 0x79, 0xC3, 0x83, 0x98, 0x06, 0x60, 0x0B, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0x80, 0x0A, 0x00, 0x68, 0x01, 0xB0, 0x04, 0xC0, 0x31, 0x81,
  0x87, 0x1C, 0x0F, 0xE0, 0x0D, 0xF8, 0x17, 0x78, 0x38, 0x30, 0xE0, 0x31,
  0x80, 0x63, 0x00, 0xC6, 0x01, 0x88, 0x03, 0x10, 0x06, 0x60, 0x0C, 0xC0,
  0x11, 0x80, 0x63, 0x00, 0xC6, 0x03, 0x0B, 0x1C, 0x33, 0xF0, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x07, 0xCC,
  0x79, 0xB3, 0x83, 0x8C, 0x06, 0x60, 0x19, 0x80, 0x6C, 0x01, 0xB0, 0x06,
  0xC0, 0x13, 0x00, 0x4C, 0x03, 0x30, 0x0C, 0xC0, 0x31, 0x81, 0xC7, 0x1A,
  0x0F, 0xC8, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03,
  0x00, 0x31, 0xF3, 0x7F, 0x3C, 0x03, 0x80, 0x30, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08,
  0x00, 0x07, 0xE0, 0x79, 0xC3, 0x01, 0x8C, 0x02, 0x20, 0x0C, 0xC0, 0x03,
  0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x04, 0xC0, 0x13,
  0x00, 0xC7, 0x0E, 0x0F, 0xF0, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x7F,
  0xFF, 0xFF, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x20, 0xFC, 0x30,
  0x0C, 0xC0, 0x32, 0x00, 0xD8, 0x02, 0x60, 0x19, 0x80, 0x66, 0x01, 0x98,
  0x06, 0x40, 0x1B, 0x00, 0x4C, 0x03, 0x30, 0x0C, 0xC0, 0x31, 0x81, 0xC7,
  0x1B, 0x0F, 0xC8, 0x80, 0x0F, 0x00, 0x6C, 0x01, 0xB0, 0x0C, 0x40, 0x31,
  0x81, 0x86, 0x04, 0x08, 0x30, 0x20, 0x80, 0xC6, 0x03, 0x30, 0x04, 0xC0,
  0x16, 0x00, 0x78, 0x01, 0xC0, 0x02, 0x00, 0xC1, 0x83, 0xC1, 0x83, 0xC3,
  0x82, 0xC2, 0x86, 0xC2, 0x84, 0xC6, 0x8C, 0xC4, 0x8C, 0xCC, 0x88, 0xC8,
  0x98, 0x48, 0x90, 0x58, 0x90, 0x50, 0xB0, 0x70, 0xA0, 0x60, 0xE0, 0x60,
  0xC0, 0x40, 0xC0, 0x18, 0x03, 0x86, 0x03, 0x81, 0x81, 0x80, 0xC1, 0x80,
  0x31, 0x80, 0x19, 0x80, 0x07, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xB0,
  0x01, 0xD8, 0x01, 0xC6, 0x00, 0xC1, 0x00, 0xC0, 0xC0, 0xC0, 0x31, 0xC0,
  0x1C, 0x30, 0x01, 0xC6, 0x00, 0x61, 0x80, 0x30, 0x60, 0x0C, 0x08, 0x06,
  0x03, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x60, 0x04, 0x18, 0x01, 0x8C, 0x00,
  0x66, 0x00, 0x19, 0x80, 0x02, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x3C, 0x00, 0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0x00, 0x60, 0x30,
  0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x30,
  0x06, 0x01, 0x81, 0xE0, 0x30, 0x03, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x08, 0x42, 0x31, 0x8C, 0x42, 0x11, 0x8C, 0x62, 0x10, 0x84, 0x63,
  0x10, 0x84, 0x23, 0x18, 0xC4, 0x00, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18,
  0x01, 0xC0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x70, 0x08, 0x00, 0x18, 0x00,
  0x7E, 0x03, 0x63, 0x03, 0xC1, 0x86, 0x80, 0xFC, 0x00, 0x38,
};

const GFXglyph RobotoMono_LightItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 5, 21, 18, 6, -21 },
  { 15, 7, 7, 18, 7, -23 },
  { 22, 18, 21, 18, 0, -21 },
  { 70, 14, 28, 18, 2, -25 },
  { 119, 14, 22, 18, 2, -22 },
  { 158, 15, 22, 18, 1, -22 },
  { 200, 3, 7, 18, 8, -23 },
  { 203, 9, 31, 18, 5, -24 },
  { 238, 9, 31, 18, 3, -24 },
  { 273, 13, 13, 18, 4, -21 },
  { 295, 14, 16, 18, 2, -18 },
  { 323, 5, 7, 18, 3, -3 },
  { 328, 11, 1, 18, 3, -10 },
  { 330, 3, 3, 18, 6, -3 },
  { 332, 14, 23, 18, 2, -21 },
  { 373, 14, 22, 18, 2, -22 },
  { 412, 9, 21, 18, 4, -21 },
  { 436, 15, 22, 18, 0, -22 },
  { 478, 14, 22, 18, 1, -22 },
  { 517, 15, 21, 18, 1, -21 },
  { 557, 15, 21, 18, 2, -21 },
  { 597, 13, 21, 18, 2, -21 },
  { 632, 14, 21, 18, 3, -21 },
  { 669, 15, 22, 18, 2, -22 },
  { 711, 13, 22, 18, 3, -22 },
  { 747, 5, 16, 18, 7, -16 },
  { 757, 7, 20, 18, 5, -16 },
  { 775, 14, 13, 18, 2, -16 },
  { 798, 14, 7, 18, 2, -13 },
  { 811, 13, 13, 18, 2, -16 },
  { 833, 12, 22, 18, 4, -22 },
  { 866, 16, 21, 18, 1, -21 },
  { 908, 15, 21, 18, 0, -21 },
  { 948, 15, 21, 18, 1, -21 },
  { 988, 15, 22, 18, 2, -22 },
  { 1030, 16, 21, 18, 1, -21 },
  { 1072, 16, 21, 18, 1, -21 },
  { 1114, 16, 21, 18, 1, -21 },
  { 1156, 15, 22, 18, 2, -22 },
  { 1198, 16, 21, 18, 1, -21 },
  { 1240, 16, 21, 18, 1, -21 },
  { 1282, 16, 21, 18, 1, -21 },
  { 1324, 17, 21, 18, 1, -21 },
  { 1369, 12, 21, 18, 2, -21 },
  { 1401, 17, 21, 18, 1, -21 },
  { 1446, 16, 21, 18, 1, -21 },
  { 1488, 14, 22, 18, 2, -22 },
  { 1527, 15, 21, 18, 2, -21 },
  { 1567, 16, 26, 18, 1, -22 },
  { 1619, 16, 21, 18, 1, -21 },
  { 1661, 16, 22, 18, 1, -22 },
  { 1705, 15, 21, 18, 3, -21 },
  { 1745, 15, 21, 18, 2, -21 },
  { 1785, 15, 21, 18, 3, -21 },
  { 1825, 16, 21, 18, 3, -21 },
  { 1867, 18, 21, 18, 0, -21 },
  { 1915, 15, 21, 18, 3, -21 },
  { 1955, 17, 21, 18, 0, -21 },
  { 2000, 10, 29, 18, 4, -24 },
  { 2037, 6, 23, 18, 6, -21 },
  { 2055, 9, 29, 18, 4, -24 },
  { 2088, 10, 11, 18, 4, -21 },
  { 2102, 12, 2, 18, 1, 0 },
  { 2105, 3, 4, 18, 9, -22 },
  { 2107, 13, 16, 18, 2, -16 },
  { 2133, 14, 23, 18, 1, -23 },
  { 2174, 13, 16, 18, 2, -16 },
  { 2200, 15, 23, 18, 2, -23 },
  { 2244, 14, 16, 18, 2, -16 },
  { 2272, 14, 23, 18, 4, -23 },
  { 2313, 15, 22, 18, 1, -16 },
  { 2355, 14, 23, 18, 1, -23 },
  { 2396, 12, 22, 18, 2, -22 },
  { 2429, 14, 28, 18, 0, -22 },
  { 2478, 14, 23, 18, 2, -23 },
  { 2519, 12, 23, 18, 2, -23 },
  { 2554, 17, 16, 18, 0, -16 },
  { 2588, 14, 16, 18, 1, -16 },
  { 2616, 14, 16, 18, 2, -16 },
  { 2644, 15, 22, 18, 0, -16 },
  { 2686, 14, 22, 18, 2, -16 },
  { 2725, 12, 16, 18, 4, -16 },
  { 2749, 14, 16, 18, 2, -16 },
  { 2777, 12, 20, 18, 3, -20 },
  { 2807, 14, 16, 18, 2, -16 },
  { 2835, 14, 16, 18, 3, -16 },
  { 2863, 16, 16, 18, 2, -16 },
  { 2895, 17, 16, 18, 0, -16 },
  { 2929, 18, 22, 18, 0, -16 },
  { 2979, 15, 16, 18, 1, -16 },
  { 3009, 11, 29, 18, 5, -23 },
  { 3049, 5, 26, 18, 6, -21 },
  { 3066, 11, 29, 18, 3, -23 },
  { 3106, 16, 6, 18, 1, -12 },
};

const GFXfont RobotoMono_LightItalic30pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic30pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic30pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _ROBOTOMONO_LIGHTITALIC30PT7B_H_
