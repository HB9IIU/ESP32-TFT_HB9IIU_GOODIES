#ifndef _ROBOTOMONO_LIGHTITALIC24PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x33, 0x22, 0x22, 0x66, 0x44, 0x00, 0x0C, 0xC0, 0x65, 0x14,
  0xD2, 0xC8, 0x01, 0x88, 0x04, 0x20, 0x11, 0x80, 0x84, 0x02, 0x10, 0xFF,
  0xF0, 0x42, 0x01, 0x08, 0x0C, 0x40, 0x21, 0x00, 0x8C, 0x3F, 0xFC, 0x10,
  0x80, 0x46, 0x03, 0x10, 0x08, 0x40, 0x63, 0x00, 0x01, 0x00, 0x20, 0x0C,
  0x07, 0xC1, 0x84, 0x60, 0xC8, 0x0B, 0x01, 0x20, 0x06, 0x00, 0x60, 0x07,
  0x00, 0x38, 0x01, 0x00, 0x34, 0x06, 0x80, 0xD8, 0x13, 0x0E, 0x3F, 0x00,
  0x80, 0x30, 0x00, 0x3C, 0x04, 0x40, 0x44, 0x24, 0x44, 0x44, 0xC4, 0x48,
  0x79, 0x00, 0x30, 0x02, 0x00, 0x40, 0x09, 0xE0, 0x91, 0x12, 0x12, 0x21,
  0x62, 0x30, 0x22, 0x01, 0xC0, 0x07, 0x80, 0x8C, 0x18, 0x41, 0x04, 0x10,
  0xC1, 0x98, 0x1B, 0x00, 0xC0, 0x1C, 0x03, 0x61, 0x62, 0x3C, 0x32, 0xC1,
  0xA8, 0x0C, 0xC0, 0xC6, 0x3C, 0x3E, 0x60, 0x7A, 0x80, 0x03, 0x06, 0x0C,
  0x18, 0x10, 0x30, 0x20, 0x60, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0x80,
  0x80, 0x80, 0x80, 0xC0, 0xC0, 0x40, 0x40, 0x20, 0x30, 0x10, 0x08, 0x0C,
  0x04, 0x06, 0x02, 0x02, 0x02, 0x03, 0x03, 0x03, 0x03, 0x02, 0x02, 0x02,
  0x06, 0x06, 0x04, 0x04, 0x0C, 0x08, 0x10, 0x30, 0x60, 0xC0, 0x80, 0x06,
  0x01, 0x00, 0x43, 0x11, 0xF7, 0xC3, 0x81, 0xC0, 0xC8, 0x63, 0x10, 0x40,
  0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x07, 0xFF, 0xFF, 0xF0, 0x60,
  0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x6D, 0x28, 0xFF, 0xF0, 0x00, 0x60,
  0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x04, 0x00, 0x80,
  0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x00, 0x0F,
  0x82, 0x18, 0x81, 0xB0, 0x34, 0x06, 0x81, 0xF0, 0x7E, 0x13, 0x8C, 0x53,
  0x0A, 0xC1, 0x60, 0x28, 0x0D, 0x01, 0x20, 0x62, 0x18, 0x3E, 0x00, 0x0C,
  0xFE, 0xE3, 0x08, 0x20, 0x82, 0x18, 0x61, 0x04, 0x10, 0xC3, 0x08, 0x20,
  0x07, 0xC0, 0x86, 0x10, 0x33, 0x01, 0x20, 0x30, 0x03, 0x00, 0x20, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xFF, 0xE0, 0x0F, 0xC3, 0x0C, 0xC0, 0x90, 0x14, 0x02, 0x00, 0xC0, 0x10,
  0x0C, 0x0F, 0x00, 0x30, 0x03, 0x00, 0x28, 0x05, 0x01, 0xA0, 0x22, 0x1C,
  0x3E, 0x00, 0x00, 0x30, 0x07, 0x00, 0xE0, 0x1A, 0x01, 0x20, 0x22, 0x04,
  0x60, 0xC6, 0x18, 0x41, 0x04, 0x20, 0x47, 0xFF, 0xFF, 0xF0, 0x0C, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x1F, 0xF1, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02,
  0x00, 0x2F, 0x07, 0xB8, 0x20, 0xC0, 0x04, 0x00, 0x40, 0x04, 0x80, 0xC8,
  0x0C, 0xC1, 0x86, 0x30, 0x3E, 0x00, 0x01, 0xC0, 0xE0, 0x30, 0x0C, 0x03,
  0x00, 0x40, 0x0B, 0xE2, 0x86, 0x60, 0x48, 0x0D, 0x01, 0xE0, 0x3C, 0x06,
  0x80, 0x90, 0x31, 0x0C, 0x1F, 0x00, 0xFF, 0xE0, 0x08, 0x03, 0x00, 0x40,
  0x18, 0x02, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x08, 0x03, 0x00,
  0x40, 0x18, 0x02, 0x00, 0x80, 0x00, 0x07, 0xE0, 0xC3, 0x18, 0x31, 0x01,
  0x30, 0x13, 0x03, 0x10, 0x21, 0xCC, 0x0F, 0x83, 0x04, 0x60, 0x64, 0x02,
  0x40, 0x24, 0x06, 0x40, 0x46, 0x1C, 0x3F, 0x00, 0x1F, 0x86, 0x18, 0x81,
  0x20, 0x34, 0x07, 0x80, 0xF0, 0x1E, 0x02, 0x40, 0xCC, 0x28, 0xFB, 0x00,
  0x40, 0x18, 0x02, 0x00, 0xC0, 0x60, 0x78, 0x00, 0x37, 0x00, 0x00, 0x00,
  0x00, 0xCC, 0x0C, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x08, 0x21,
  0x8C, 0x00, 0x00, 0x20, 0x18, 0x1E, 0x0E, 0x07, 0x01, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x30, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x20, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xC0, 0xF0, 0x70,
  0x78, 0x18, 0x00, 0x3E, 0x31, 0xB0, 0x70, 0x30, 0x18, 0x08, 0x0C, 0x0C,
  0x0C, 0x0C, 0x0C, 0x04, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x07,
  0xE0, 0x61, 0x84, 0x04, 0x43, 0x16, 0x6C, 0xA6, 0x25, 0x22, 0x33, 0x11,
  0x90, 0x8C, 0x88, 0xA4, 0x45, 0x26, 0x29, 0xDE, 0x44, 0x43, 0x00, 0x0C,
  0x20, 0x3F, 0x00, 0x00, 0xC0, 0x1C, 0x01, 0x40, 0x34, 0x02, 0x40, 0x24,
  0x04, 0x40, 0x46, 0x08, 0x60, 0x82, 0x10, 0x21, 0xFE, 0x30, 0x22, 0x02,
  0x60, 0x34, 0x03, 0xC0, 0x30, 0x1F, 0xC1, 0x06, 0x10, 0x33, 0x01, 0x30,
  0x12, 0x03, 0x20, 0x62, 0x1C, 0x7F, 0x86, 0x06, 0x40, 0x24, 0x02, 0x40,
  0x24, 0x06, 0xC0, 0x4C, 0x18, 0xFF, 0x00, 0x07, 0xC0, 0xC2, 0x10, 0x33,
  0x01, 0x20, 0x16, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x24, 0x06, 0x40, 0xC2, 0x18, 0x1F, 0x00, 0x1F, 0x83, 0x0C,
  0x30, 0x23, 0x03, 0x20, 0x12, 0x01, 0x20, 0x16, 0x01, 0x60, 0x14, 0x03,
  0x40, 0x34, 0x02, 0x40, 0x6C, 0x04, 0xC0, 0x88, 0x30, 0xFC, 0x00, 0x1F,
  0xF8, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x3F, 0xC3, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18,
  0x00, 0x80, 0x04, 0x00, 0x3F, 0xC3, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0xC2, 0x10, 0x33,
  0x01, 0x20, 0x16, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x3F, 0xC0, 0x2C,
  0x02, 0xC0, 0x24, 0x02, 0x60, 0x63, 0x0C, 0x1F, 0x80, 0x30, 0x09, 0x80,
  0xC8, 0x04, 0x40, 0x22, 0x01, 0x10, 0x09, 0x80, 0xCC, 0x06, 0x7F, 0xE2,
  0x01, 0x10, 0x08, 0x80, 0x4C, 0x06, 0x60, 0x32, 0x01, 0x10, 0x08, 0x80,
  0x40, 0x1F, 0xF8, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x30, 0x01, 0x80, 0xFF, 0xC0, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00,
  0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x80,
  0x48, 0x0C, 0xC0, 0x86, 0x30, 0x3E, 0x00, 0x10, 0x1C, 0x40, 0xC1, 0x06,
  0x0C, 0x30, 0x31, 0x80, 0x8C, 0x02, 0x60, 0x0B, 0x00, 0x3E, 0x01, 0xC8,
  0x06, 0x30, 0x10, 0x40, 0x41, 0x81, 0x02, 0x0C, 0x0C, 0x30, 0x10, 0xC0,
  0x60, 0x18, 0x04, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0xFF, 0xC0, 0x10,
  0x19, 0xC1, 0xCA, 0x0E, 0x50, 0xE2, 0x85, 0x14, 0x68, 0xB2, 0x4D, 0xB6,
  0x45, 0x32, 0x31, 0x11, 0x88, 0x88, 0x4C, 0x02, 0x60, 0x32, 0x01, 0x90,
  0x08, 0x80, 0x40, 0x30, 0x19, 0x80, 0xCE, 0x04, 0x50, 0x22, 0xC1, 0x12,
  0x09, 0x90, 0xCC, 0xC6, 0x42, 0x22, 0x11, 0x10, 0xC8, 0x82, 0x4C, 0x16,
  0x60, 0xF2, 0x03, 0x10, 0x18, 0x80, 0xC0, 0x07, 0xC0, 0xC6, 0x10, 0x33,
  0x03, 0x20, 0x16, 0x01, 0x40, 0x14, 0x01, 0x40, 0x3C, 0x03, 0xC0, 0x2C,
  0x02, 0xC0, 0x64, 0x04, 0x40, 0xC2, 0x18, 0x3F, 0x00, 0x1F, 0xE0, 0x81,
  0x84, 0x04, 0x20, 0x33, 0x01, 0x98, 0x0C, 0x80, 0x44, 0x06, 0x20, 0xE1,
  0xFC, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0,
  0x00, 0x07, 0xC1, 0xC6, 0x10, 0x33, 0x01, 0x60, 0x16, 0x01, 0x40, 0x14,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x02, 0xC0, 0x2C, 0x06, 0x40, 0xC6,
  0x18, 0x3F, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x1F, 0xC1, 0x06, 0x10, 0x33,
  0x01, 0x30, 0x12, 0x01, 0x20, 0x32, 0x06, 0x21, 0xC7, 0xF0, 0x61, 0x04,
  0x18, 0x40, 0x84, 0x0C, 0x40, 0xCC, 0x04, 0xC0, 0x60, 0x07, 0xC1, 0x83,
  0x30, 0x33, 0x01, 0x20, 0x13, 0x00, 0x10, 0x01, 0xC0, 0x07, 0x80, 0x0C,
  0x00, 0x60, 0x02, 0xC0, 0x2C, 0x02, 0x40, 0x66, 0x0C, 0x3F, 0x80, 0xFF,
  0xF0, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30,
  0x00, 0x30, 0x19, 0x80, 0xC8, 0x04, 0x40, 0x22, 0x01, 0x10, 0x09, 0x80,
  0xCC, 0x06, 0x40, 0x22, 0x01, 0x10, 0x08, 0x80, 0x4C, 0x06, 0x20, 0x21,
  0x03, 0x0C, 0x30, 0x3F, 0x00, 0x80, 0x30, 0x0E, 0x01, 0x60, 0x6C, 0x09,
  0x83, 0x10, 0x42, 0x08, 0x42, 0x08, 0x41, 0x98, 0x32, 0x02, 0xC0, 0x50,
  0x0E, 0x01, 0x80, 0x30, 0x00, 0x42, 0x0E, 0x10, 0xF1, 0x85, 0x8C, 0x2C,
  0x63, 0x65, 0x93, 0x2C, 0x99, 0x64, 0xD3, 0x46, 0x9A, 0x34, 0xD1, 0xC7,
  0x8E, 0x18, 0x50, 0xC3, 0x06, 0x18, 0x20, 0xC1, 0x00, 0x18, 0x0E, 0x10,
  0x10, 0x30, 0x60, 0x21, 0x80, 0x42, 0x00, 0xC8, 0x00, 0xB0, 0x01, 0xC0,
  0x03, 0x00, 0x07, 0x00, 0x1A, 0x00, 0x66, 0x01, 0x84, 0x02, 0x08, 0x0C,
  0x18, 0x30, 0x10, 0xC0, 0x30, 0x80, 0x3C, 0x06, 0xC0, 0xC4, 0x08, 0x61,
  0x86, 0x30, 0x22, 0x02, 0x60, 0x3C, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x00, 0x1F, 0xF8, 0x00, 0xC0, 0x0C,
  0x00, 0x40, 0x06, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01,
  0x00, 0x10, 0x01, 0x80, 0x18, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xE0, 0x0F,
  0x0F, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x10, 0x10, 0x30, 0x30,
  0x20, 0x20, 0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0x40, 0x78, 0xF0, 0x84,
  0x21, 0x84, 0x21, 0x08, 0x61, 0x08, 0x42, 0x18, 0x42, 0x10, 0xC0, 0x0F,
  0x0F, 0x02, 0x02, 0x02, 0x02, 0x02, 0x06, 0x06, 0x04, 0x04, 0x04, 0x04,
  0x0C, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x18, 0x18, 0x18, 0xF0, 0xF0, 0x04,
  0x0E, 0x0A, 0x1A, 0x12, 0x22, 0x63, 0x41, 0xC1, 0xFF, 0xC0, 0x89, 0x10,
  0x07, 0x83, 0x18, 0xC1, 0x90, 0x10, 0x02, 0x00, 0xC7, 0xFB, 0x02, 0x40,
  0x58, 0x0B, 0x03, 0x31, 0xA3, 0xEC, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03,
  0x00, 0x6F, 0x0B, 0x31, 0x83, 0x20, 0x24, 0x05, 0x80, 0xB0, 0x14, 0x02,
  0x80, 0xD0, 0x16, 0x06, 0xE1, 0x93, 0xE0, 0x0F, 0x0E, 0x66, 0x0D, 0x01,
  0xC0, 0x60, 0x08, 0x02, 0x00, 0x80, 0x20, 0x2C, 0x19, 0x0C, 0x3E, 0x00,
  0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0xE6, 0x39, 0xC6, 0x0C,
  0x40, 0x4C, 0x04, 0x80, 0xC8, 0x0C, 0x80, 0x88, 0x08, 0x80, 0x88, 0x18,
  0xC3, 0x87, 0xD8, 0x07, 0x83, 0x98, 0xC1, 0x90, 0x16, 0x02, 0x80, 0x5F,
  0xFE, 0x00, 0xC0, 0x08, 0x01, 0x81, 0x18, 0x61, 0xF0, 0x03, 0xF0, 0x60,
  0x0C, 0x00, 0x80, 0x08, 0x0F, 0xFC, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00,
  0x07, 0x31, 0xCE, 0x30, 0x62, 0x02, 0x60, 0x24, 0x06, 0x40, 0x64, 0x04,
  0x40, 0x44, 0x04, 0x40, 0xC6, 0x1C, 0x3E, 0xC0, 0x08, 0x00, 0x88, 0x18,
  0xC3, 0x03, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x47, 0x0B,
  0x39, 0x83, 0x20, 0x2C, 0x05, 0x80, 0xA0, 0x34, 0x06, 0x80, 0xD0, 0x16,
  0x02, 0xC0, 0x50, 0x18, 0x01, 0x80, 0x60, 0x00, 0x00, 0x3F, 0x0F, 0xC0,
  0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10,
  0xFF, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x30,
  0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0xC1, 0xF0, 0x00, 0x18, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x03, 0x03, 0x30, 0x62, 0x08, 0x23, 0x02, 0x60,
  0x2C, 0x07, 0xC0, 0x66, 0x04, 0x20, 0x43, 0x04, 0x18, 0x40, 0x8C, 0x0C,
  0x1F, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00,
  0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x3F, 0xF0, 0x2E,
  0x31, 0x9E, 0xC8, 0x62, 0xC2, 0x16, 0x10, 0xA1, 0x85, 0x0C, 0x28, 0x43,
  0x42, 0x1E, 0x10, 0xB0, 0x85, 0x0C, 0x28, 0x63, 0x00, 0x23, 0x85, 0x9C,
  0xC1, 0x90, 0x16, 0x02, 0xC0, 0x50, 0x1A, 0x03, 0x40, 0x48, 0x0B, 0x01,
  0x60, 0x28, 0x0C, 0x07, 0x81, 0xCC, 0x30, 0x66, 0x02, 0x40, 0x24, 0x02,
  0xC0, 0x2C, 0x02, 0xC0, 0x6C, 0x04, 0x40, 0xC6, 0x18, 0x3F, 0x00, 0x13,
  0xC1, 0x66, 0x18, 0x31, 0x01, 0x30, 0x13, 0x01, 0x30, 0x12, 0x03, 0x20,
  0x32, 0x02, 0x60, 0x67, 0x0C, 0x6F, 0x84, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0x0E, 0x67, 0x39, 0x83, 0x20, 0x2C, 0x05, 0x01, 0xA0, 0x34,
  0x04, 0x80, 0x90, 0x12, 0x06, 0x61, 0xC7, 0xD8, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x60, 0x23, 0xCB, 0xD3, 0x80, 0x80, 0x60, 0x18, 0x04, 0x01,
  0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x00, 0x0F, 0x0E, 0x76, 0x05,
  0x01, 0x60, 0x0C, 0x01, 0xE0, 0x0E, 0x00, 0xA0, 0x38, 0x0B, 0x06, 0x7E,
  0x00, 0x08, 0x04, 0x06, 0x1F, 0xF1, 0x80, 0x80, 0x40, 0x20, 0x30, 0x18,
  0x0C, 0x04, 0x02, 0x01, 0x00, 0xC0, 0x3E, 0x60, 0x68, 0x0D, 0x01, 0x20,
  0x24, 0x05, 0x81, 0xB0, 0x34, 0x06, 0x80, 0x90, 0x12, 0x06, 0x61, 0x47,
  0xD8, 0xC0, 0x3C, 0x06, 0x40, 0x44, 0x0C, 0x60, 0x86, 0x18, 0x21, 0x02,
  0x30, 0x22, 0x03, 0x40, 0x14, 0x01, 0x80, 0x18, 0x00, 0x86, 0x18, 0x61,
  0x86, 0x38, 0xA2, 0x8A, 0x29, 0xA4, 0x92, 0x49, 0x2C, 0xA2, 0x8A, 0x28,
  0xC3, 0x0C, 0x30, 0xC3, 0x00, 0x10, 0x0C, 0x60, 0x40, 0x83, 0x03, 0x18,
  0x06, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x0D, 0x80, 0x23, 0x01, 0x04,
  0x08, 0x18, 0xE0, 0x30, 0x20, 0x0C, 0xC0, 0x23, 0x01, 0x84, 0x04, 0x10,
  0x30, 0x61, 0x80, 0x84, 0x02, 0x30, 0x0C, 0x80, 0x36, 0x00, 0x70, 0x01,
  0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x00,
  0x3F, 0xF3, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xFF, 0xE0, 0x00, 0x81, 0x81, 0x80,
  0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x0C, 0x1C, 0x0C, 0x01, 0x00,
  0xC0, 0x60, 0x30, 0x10, 0x08, 0x04, 0x02, 0x01, 0x80, 0x60, 0x08, 0x11,
  0x13, 0x22, 0x22, 0x26, 0x44, 0x44, 0x44, 0xC8, 0x88, 0x80, 0x08, 0x0E,
  0x01, 0x80, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x06, 0x03, 0x00, 0x80, 0x30,
  0x38, 0x30, 0x10, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01, 0x01, 0x81, 0x81,
  0x00, 0x3C, 0x0D, 0x8C, 0x24, 0x19, 0xB0, 0x3C,
};

const GFXglyph RobotoMono_LightItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 17, 14, 5, -17 },
  { 10, 6, 5, 14, 5, -18 },
  { 14, 14, 17, 14, 0, -17 },
  { 44, 11, 22, 14, 2, -20 },
  { 75, 12, 17, 14, 1, -17 },
  { 101, 12, 17, 14, 1, -17 },
  { 127, 2, 5, 14, 7, -18 },
  { 129, 8, 25, 14, 4, -19 },
  { 154, 8, 25, 14, 2, -19 },
  { 179, 10, 10, 14, 3, -17 },
  { 192, 12, 12, 14, 1, -14 },
  { 210, 3, 5, 14, 3, -2 },
  { 212, 8, 1, 14, 3, -8 },
  { 213, 2, 2, 14, 5, -2 },
  { 214, 11, 18, 14, 2, -17 },
  { 239, 11, 17, 14, 2, -17 },
  { 263, 6, 17, 14, 4, -17 },
  { 276, 12, 17, 14, 0, -17 },
  { 302, 11, 17, 14, 1, -17 },
  { 326, 12, 17, 14, 0, -17 },
  { 352, 12, 17, 14, 2, -17 },
  { 378, 11, 17, 14, 1, -17 },
  { 402, 11, 17, 14, 3, -17 },
  { 426, 12, 17, 14, 1, -17 },
  { 452, 11, 17, 14, 2, -17 },
  { 476, 4, 12, 14, 6, -12 },
  { 482, 6, 15, 14, 4, -12 },
  { 494, 11, 10, 14, 2, -13 },
  { 508, 11, 6, 14, 2, -11 },
  { 517, 11, 10, 14, 1, -13 },
  { 531, 9, 17, 14, 4, -17 },
  { 551, 13, 17, 14, 1, -17 },
  { 579, 12, 17, 14, 0, -17 },
  { 605, 12, 17, 14, 1, -17 },
  { 631, 12, 17, 14, 1, -17 },
  { 657, 12, 17, 14, 1, -17 },
  { 683, 13, 17, 14, 1, -17 },
  { 711, 13, 17, 14, 1, -17 },
  { 739, 12, 17, 14, 1, -17 },
  { 765, 13, 17, 14, 1, -17 },
  { 793, 13, 17, 14, 1, -17 },
  { 821, 12, 17, 14, 1, -17 },
  { 847, 14, 17, 14, 1, -17 },
  { 877, 10, 17, 14, 1, -17 },
  { 899, 13, 17, 14, 1, -17 },
  { 927, 13, 17, 14, 1, -17 },
  { 955, 12, 17, 14, 1, -17 },
  { 981, 13, 17, 14, 1, -17 },
  { 1009, 12, 20, 14, 1, -17 },
  { 1039, 12, 17, 14, 1, -17 },
  { 1065, 12, 17, 14, 1, -17 },
  { 1091, 12, 17, 14, 3, -17 },
  { 1117, 13, 17, 14, 1, -17 },
  { 1145, 11, 17, 14, 3, -17 },
  { 1169, 13, 17, 14, 2, -17 },
  { 1197, 15, 17, 14, 0, -17 },
  { 1229, 12, 17, 14, 3, -17 },
  { 1255, 13, 17, 14, 0, -17 },
  { 1283, 8, 24, 14, 3, -20 },
  { 1307, 5, 18, 14, 5, -17 },
  { 1319, 8, 24, 14, 3, -20 },
  { 1343, 8, 9, 14, 3, -17 },
  { 1352, 10, 1, 14, 1, 0 },
  { 1354, 3, 4, 14, 7, -18 },
  { 1356, 11, 13, 14, 1, -13 },
  { 1374, 11, 18, 14, 1, -18 },
  { 1399, 10, 13, 14, 2, -13 },
  { 1416, 12, 18, 14, 2, -18 },
  { 1443, 11, 13, 14, 1, -13 },
  { 1461, 12, 18, 14, 3, -18 },
  { 1488, 12, 18, 14, 1, -13 },
  { 1515, 11, 18, 14, 1, -18 },
  { 1540, 10, 17, 14, 1, -17 },
  { 1562, 11, 22, 14, 0, -17 },
  { 1593, 12, 18, 14, 1, -18 },
  { 1620, 10, 18, 14, 1, -18 },
  { 1643, 13, 13, 14, 0, -13 },
  { 1665, 11, 13, 14, 1, -13 },
  { 1683, 12, 13, 14, 1, -13 },
  { 1703, 12, 18, 14, 0, -13 },
  { 1730, 11, 18, 14, 2, -13 },
  { 1755, 10, 13, 14, 3, -13 },
  { 1772, 10, 13, 14, 2, -13 },
  { 1789, 9, 16, 14, 3, -16 },
  { 1807, 11, 13, 14, 2, -13 },
  { 1825, 12, 13, 14, 2, -13 },
  { 1845, 12, 13, 14, 2, -13 },
  { 1865, 14, 13, 14, 0, -13 },
  { 1888, 14, 18, 14, 0, -13 },
  { 1920, 12, 13, 14, 1, -13 },
  { 1940, 9, 24, 14, 4, -19 },
  { 1967, 4, 21, 14, 5, -17 },
  { 1978, 9, 24, 14, 2, -19 },
  { 2005, 14, 4, 14, 0, -9 },
};

const GFXfont RobotoMono_LightItalic24pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic24pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic24pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _ROBOTOMONO_LIGHTITALIC24PT7B_H_
