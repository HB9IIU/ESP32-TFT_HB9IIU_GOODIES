#ifndef _ROBOTOMONO_LIGHTITALIC71PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC71PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xC0, 0x00, 0x1C,
  0x07, 0x3C, 0x07, 0x3C, 0x07, 0x3C, 0x0F, 0x38, 0x0F, 0x38, 0x0E, 0x38,
  0x0E, 0x78, 0x0E, 0x78, 0x0E, 0x70, 0x1E, 0x70, 0x1C, 0x70, 0x1C, 0x70,
  0x1C, 0xF0, 0x1C, 0xE0, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x01, 0xC0,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x00, 0x70, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F,
  0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x1E, 0x03, 0x80, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0x41, 0xE0, 0x07, 0x00, 0x18, 0x78, 0x01, 0xC0, 0x0F, 0x1C, 0x00, 0x70,
  0x07, 0x87, 0x00, 0x1C, 0x03, 0xC1, 0xC0, 0x07, 0x00, 0xE0, 0x70, 0x03,
  0xC0, 0x78, 0x3C, 0x00, 0xF0, 0x3C, 0x0F, 0x00, 0x38, 0x0E, 0x01, 0xC0,
  0x1E, 0x07, 0x80, 0x70, 0x07, 0x83, 0xC0, 0x1E, 0x03, 0xC1, 0xE0, 0x07,
  0x81, 0xE0, 0x70, 0x00, 0xF9, 0xF8, 0x3C, 0x00, 0x1F, 0xFC, 0x1E, 0x00,
  0x03, 0xFC, 0x07, 0x00, 0x00, 0x18, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x3F, 0x00, 0x00, 0xF0, 0x3F, 0xF0, 0x00, 0x38, 0x1F, 0xFC, 0x00,
  0x1E, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0xF0, 0x03, 0x83, 0xC0, 0x3C,
  0x01, 0xE0, 0xF0, 0x07, 0x00, 0xF0, 0x38, 0x01, 0xC0, 0x78, 0x1E, 0x00,
  0x70, 0x1C, 0x07, 0x80, 0x1C, 0x0F, 0x01, 0xC0, 0x07, 0x07, 0x80, 0x70,
  0x01, 0xC1, 0xC0, 0x1C, 0x00, 0x70, 0xF0, 0x07, 0x00, 0x3C, 0x78, 0x01,
  0xC0, 0x0E, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x00, 0xE0, 0x7C, 0x00, 0x00, 0x3E, 0x3E, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x78,
  0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00,
  0x1E, 0x3F, 0x00, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xF8,
  0xF0, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x0E, 0x0F, 0x81, 0xE0, 0x01, 0xC3,
  0xE0, 0x3E, 0x00, 0x78, 0xF8, 0x03, 0xE0, 0x0F, 0x3E, 0x00, 0x3C, 0x01,
  0xE7, 0x80, 0x07, 0xC0, 0x79, 0xF0, 0x00, 0x78, 0x0F, 0x3C, 0x00, 0x0F,
  0x83, 0xE7, 0x80, 0x00, 0xF8, 0x79, 0xF0, 0x00, 0x0F, 0x1F, 0x3C, 0x00,
  0x01, 0xF3, 0xC7, 0x80, 0x00, 0x1E, 0xF8, 0xF0, 0x00, 0x03, 0xFE, 0x1E,
  0x00, 0x00, 0x3F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x7C,
  0x07, 0x80, 0x00, 0x3F, 0xC0, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0x80, 0x07,
  0xEF, 0x80, 0xFC, 0x03, 0xF8, 0xF0, 0x0F, 0xFF, 0xFE, 0x1F, 0x00, 0xFF,
  0xFF, 0x01, 0xF0, 0x07, 0xFF, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x20,
  0x3C, 0xF3, 0xCF, 0x3C, 0xE3, 0x9E, 0x79, 0xC7, 0x1C, 0xF3, 0xCE, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x07, 0x00, 0x19, 0xF0, 0x0E, 0x01,
  0xF7, 0xF8, 0x1C, 0x1F, 0xEF, 0xFE, 0x38, 0xFF, 0xE3, 0xFF, 0x7F, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x0F, 0x9E, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x03,
  0xE0, 0x3C, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x78, 0x01, 0xF0, 0x00, 0xF8, 0x01, 0xC0, 0x00, 0xE0, 0x01, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0xF8, 0x3E, 0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x3C, 0x1F, 0x07, 0x83,
  0xC0, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x10, 0xF9, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFC, 0x7F, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x3E,
  0x3C, 0x00, 0x00, 0x3F, 0x1E, 0x00, 0x00, 0x3F, 0x8F, 0x00, 0x00, 0x3F,
  0xCF, 0x00, 0x00, 0x7D, 0xE7, 0x80, 0x00, 0x7C, 0xF3, 0xC0, 0x00, 0x7C,
  0x79, 0xE0, 0x00, 0x7C, 0x3C, 0xF0, 0x00, 0xF8, 0x3E, 0xF8, 0x00, 0xF8,
  0x1E, 0x78, 0x00, 0xF8, 0x0F, 0x3C, 0x00, 0xF8, 0x07, 0x9E, 0x01, 0xF0,
  0x03, 0xCF, 0x01, 0xF0, 0x01, 0xE7, 0x81, 0xF0, 0x01, 0xF7, 0xC1, 0xF0,
  0x00, 0xF3, 0xC3, 0xE0, 0x00, 0x79, 0xE3, 0xE0, 0x00, 0x3C, 0xF3, 0xE0,
  0x00, 0x1E, 0x7B, 0xE0, 0x00, 0x0F, 0x3F, 0xC0, 0x00, 0x0F, 0x1F, 0xC0,
  0x00, 0x07, 0x8F, 0xC0, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x3F, 0xFC, 0x3F, 0xF7, 0x9F,
  0xF0, 0xF7, 0xF8, 0x1E, 0xF8, 0x03, 0x9C, 0x00, 0xF2, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xF8,
  0xFF, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x7C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x19, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x03, 0xE3, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x03,
  0xE7, 0x80, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0xF0,
  0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00,
  0x7C, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0xF0, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x0F, 0x80, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xE8, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x3F, 0xF0, 0x00, 0x03, 0xDF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFE, 0xFF, 0xC0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x07, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x3C, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x0F, 0xF8, 0x00, 0x78, 0x7F, 0xFC, 0x01, 0xE3, 0xFF, 0xFC, 0x03,
  0xCF, 0xFF, 0xFC, 0x07, 0x3E, 0x00, 0xFC, 0x1E, 0xF0, 0x00, 0x7C, 0x3F,
  0xC0, 0x00, 0x78, 0x7E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0xF3, 0xF0,
  0x00, 0x01, 0xE7, 0xC0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xDF, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x3E, 0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF8,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xF0, 0x1F, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x03, 0xF8, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x07,
  0x80, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF8, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0xF0, 0x3E,
  0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x3E,
  0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xE0,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x0F, 0xFD, 0xFE, 0x00, 0x3F, 0x80, 0x3E, 0x00, 0xFC,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x3C, 0x1F, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x01, 0xE7, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3E,
  0x78, 0x00, 0x00, 0xFC, 0xF0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xE1,
  0xE0, 0x00, 0x3F, 0xC3, 0xE0, 0x00, 0xF7, 0x83, 0xE0, 0x07, 0xCE, 0x07,
  0xF0, 0x3F, 0x3C, 0x07, 0xFF, 0xFC, 0x78, 0x03, 0xFF, 0xF0, 0xF0, 0x03,
  0xFF, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x80, 0x3E,
  0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x07, 0xC0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0x7C, 0x00, 0x00, 0x08, 0x00, 0x3E, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x81, 0xFC, 0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x0F,
  0x80, 0x01, 0xF3, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xDF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00,
  0x00, 0x70, 0x0F, 0x00, 0x7F, 0x00, 0x60, 0x3C, 0x03, 0xFF, 0x80, 0xE0,
  0x70, 0x0F, 0xFF, 0x81, 0xC1, 0xC0, 0x3E, 0x0F, 0x03, 0x87, 0x80, 0xF0,
  0x0C, 0x07, 0x0E, 0x03, 0xC0, 0x38, 0x0E, 0x1C, 0x07, 0x00, 0x70, 0x1C,
  0x70, 0x1E, 0x00, 0xE0, 0x38, 0xE0, 0x38, 0x01, 0x80, 0x73, 0xC0, 0xE0,
  0x07, 0x00, 0xE7, 0x01, 0xC0, 0x0E, 0x01, 0xCE, 0x07, 0x80, 0x1C, 0x03,
  0xBC, 0x0E, 0x00, 0x30, 0x06, 0x70, 0x1C, 0x00, 0xE0, 0x1C, 0xE0, 0x38,
  0x01, 0xC0, 0x39, 0xC0, 0xE0, 0x03, 0x80, 0x73, 0x81, 0xC0, 0x06, 0x00,
  0xEE, 0x03, 0x80, 0x1C, 0x01, 0x9C, 0x07, 0x00, 0x38, 0x07, 0x38, 0x0E,
  0x00, 0x70, 0x0E, 0x70, 0x1C, 0x01, 0xC0, 0x18, 0xE0, 0x70, 0x07, 0x80,
  0x71, 0xC0, 0xE0, 0x0F, 0x00, 0xE3, 0x81, 0xE0, 0x3E, 0x03, 0x87, 0x01,
  0xC0, 0xFC, 0x07, 0x0E, 0x03, 0x83, 0xB8, 0x1C, 0x1C, 0x07, 0xFE, 0x38,
  0xF0, 0x38, 0x07, 0xF8, 0x7F, 0xC0, 0x78, 0x0F, 0xE0, 0x7F, 0x00, 0x70,
  0x07, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x60, 0x00, 0x03, 0xF0, 0x07,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7D, 0xC0, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x03, 0xE7,
  0x80, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3E, 0x00, 0x00, 0x78, 0x07,
  0x80, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1E,
  0x0F, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x00, 0x03, 0xDF, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00,
  0x0F, 0xF0, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x0F, 0x00, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0x1F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x78, 0x00,
  0x01, 0xF0, 0x07, 0x80, 0x00, 0x7E, 0x00, 0x78, 0x00, 0x1F, 0xC0, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x0F, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x07, 0x83, 0xE0, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1F,
  0x07, 0x80, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0x7E, 0x07, 0x80, 0x00,
  0x0F, 0xC0, 0x78, 0x00, 0x01, 0xF8, 0x07, 0x80, 0x00, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x1F, 0xE0, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x1F, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3E, 0x00,
  0x00, 0x3E, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x07, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x01, 0xF0, 0x03, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x78, 0x00,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x0F, 0x80,
  0xF0, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x07, 0x83,
  0xE0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x0F, 0x81, 0xE0, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0x7C, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x0F, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x07, 0x80,
  0x00, 0xFE, 0x00, 0x3C, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x7C, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x00, 0x1F, 0x1F, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x03, 0xFF, 0xF8, 0xF0, 0x00, 0x3F, 0xFF, 0x8F, 0x00, 0x03,
  0xFF, 0xF8, 0xF0, 0x00, 0x7F, 0xFF, 0x8F, 0x00, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x00, 0x1C, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3C, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x80, 0x3C, 0x00,
  0x00, 0x3F, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x00, 0x3F,
  0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x03,
  0xC0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x3F, 0x00,
  0x00, 0x3C, 0x00, 0x3F, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x80, 0x3F,
  0x00, 0x00, 0x03, 0xC0, 0x3F, 0x00, 0x00, 0x01, 0xE0, 0x3F, 0x00, 0x00,
  0x00, 0xF0, 0x3F, 0x00, 0x00, 0x00, 0xF0, 0x3F, 0x00, 0x00, 0x00, 0x78,
  0x3F, 0x00, 0x00, 0x00, 0x3C, 0x3F, 0x00, 0x00, 0x00, 0x1E, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xBF, 0xE0, 0x00, 0x00,
  0x07, 0xBF, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x3C, 0x00, 0x00, 0x01, 0xFE,
  0x1F, 0x00, 0x00, 0x00, 0xFE, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x01,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0xEE, 0x00, 0x03, 0xFC, 0x01, 0xEE,
  0x00, 0x03, 0xDC, 0x01, 0xEE, 0x00, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x07,
  0xBC, 0x01, 0xEF, 0x00, 0x0F, 0x3C, 0x01, 0xCF, 0x00, 0x0F, 0x3C, 0x03,
  0xC7, 0x00, 0x1E, 0x38, 0x03, 0xC7, 0x00, 0x1E, 0x78, 0x03, 0xC7, 0x00,
  0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x78, 0x78,
  0x03, 0xC7, 0x80, 0xF8, 0x78, 0x07, 0x83, 0x80, 0xF0, 0xF0, 0x07, 0x83,
  0x81, 0xE0, 0xF0, 0x07, 0x83, 0x81, 0xE0, 0xF0, 0x07, 0x83, 0xC3, 0xC0,
  0xF0, 0x07, 0x83, 0xC3, 0xC0, 0xF0, 0x07, 0x83, 0xC7, 0x80, 0xE0, 0x0F,
  0x01, 0xC7, 0x81, 0xE0, 0x0F, 0x01, 0xCF, 0x01, 0xE0, 0x0F, 0x01, 0xEF,
  0x01, 0xE0, 0x0F, 0x01, 0xFE, 0x01, 0xE0, 0x0F, 0x01, 0xFE, 0x01, 0xE0,
  0x0F, 0x01, 0xFC, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00,
  0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1E, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x03, 0xF0, 0x00, 0x00, 0x78,
  0x07, 0xE0, 0x00, 0x01, 0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xC0, 0x1F, 0xC0,
  0x00, 0x07, 0x80, 0x7F, 0x80, 0x00, 0x0F, 0x00, 0xFF, 0x00, 0x00, 0x1E,
  0x01, 0xEF, 0x00, 0x00, 0x7C, 0x03, 0xDE, 0x00, 0x00, 0xF0, 0x07, 0xBC,
  0x00, 0x01, 0xE0, 0x1F, 0x3C, 0x00, 0x03, 0xC0, 0x3C, 0x78, 0x00, 0x07,
  0x80, 0x78, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0xF0, 0x00, 0x3E, 0x01, 0xE1,
  0xE0, 0x00, 0x78, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x0F, 0x83, 0xC0, 0x01,
  0xE0, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x07, 0x80, 0x78,
  0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x01, 0xE0, 0x1E, 0x00,
  0x78, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x1E,
  0x00, 0x78, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0x1E, 0x00, 0xF0, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x07,
  0x80, 0x03, 0xC0, 0xF0, 0x0F, 0x00, 0x07, 0x83, 0xE0, 0x1E, 0x00, 0x0F,
  0x07, 0x80, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x78, 0x00, 0x1E, 0x1E, 0x01,
  0xE0, 0x00, 0x3C, 0x3C, 0x03, 0xC0, 0x00, 0x3C, 0x78, 0x07, 0x80, 0x00,
  0x79, 0xF0, 0x0F, 0x00, 0x00, 0xF3, 0xC0, 0x1E, 0x00, 0x00, 0xF7, 0x80,
  0x7C, 0x00, 0x01, 0xEF, 0x00, 0xF0, 0x00, 0x03, 0xDE, 0x01, 0xE0, 0x00,
  0x03, 0xFC, 0x03, 0xC0, 0x00, 0x07, 0xF8, 0x07, 0x80, 0x00, 0x0F, 0xE0,
  0x0F, 0x00, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x78, 0x00,
  0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0x3C,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x03, 0xDF, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x7C,
  0x0F, 0x00, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00,
  0xF8, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x07, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x00, 0xFC,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x3C, 0x00,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x00, 0x3E, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x3E, 0x01,
  0xE0, 0x00, 0x03, 0xF0, 0x0F, 0x00, 0x00, 0x7F, 0x00, 0x78, 0x00, 0x3F,
  0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x01, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x01, 0xF3, 0xC0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00,
  0x03, 0xC7, 0xC0, 0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x07,
  0xC1, 0xE0, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x78, 0x00,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x0E, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x07,
  0xF8, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x1E, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x3C, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x00, 0xF8, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x07, 0x80, 0x01, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x1F, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x3C, 0x00, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0x03, 0xC3,
  0xE0, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0x0F, 0x83, 0xC0, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x3F,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x1F, 0x78,
  0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xF0, 0x0F,
  0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x1E,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x00, 0xE1, 0xE0, 0x00,
  0x00, 0x1E, 0x7C, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7F, 0x80,
  0x07, 0xC0, 0x03, 0xFC, 0x00, 0x3E, 0x00, 0x1D, 0xE0, 0x01, 0xF0, 0x01,
  0xEF, 0x00, 0x1F, 0x80, 0x0F, 0x78, 0x00, 0xFC, 0x00, 0x7B, 0xC0, 0x07,
  0xE0, 0x07, 0x9E, 0x00, 0x7F, 0x00, 0x3C, 0xF0, 0x03, 0xF8, 0x01, 0xE7,
  0x80, 0x1D, 0xC0, 0x0E, 0x3C, 0x01, 0xEE, 0x00, 0xF1, 0xE0, 0x0F, 0x70,
  0x07, 0x8F, 0x00, 0x73, 0x80, 0x3C, 0x78, 0x07, 0x9C, 0x03, 0xC3, 0xC0,
  0x3C, 0xE0, 0x1E, 0x1E, 0x01, 0xC7, 0x00, 0xF0, 0xF0, 0x1E, 0x38, 0x07,
  0x07, 0x80, 0xF1, 0xC0, 0x78, 0x3C, 0x07, 0x0E, 0x03, 0xC1, 0xE0, 0x78,
  0x70, 0x1C, 0x0F, 0x03, 0xC3, 0x81, 0xE0, 0x78, 0x1C, 0x1C, 0x0F, 0x03,
  0xC1, 0xE0, 0xE0, 0x78, 0x1E, 0x0F, 0x07, 0x03, 0x80, 0xF0, 0x70, 0x38,
  0x3C, 0x07, 0x87, 0x81, 0xC1, 0xE0, 0x3C, 0x3C, 0x0E, 0x0E, 0x01, 0xE1,
  0xC0, 0x70, 0xF0, 0x0F, 0x1E, 0x03, 0x87, 0x80, 0x78, 0xF0, 0x1C, 0x3C,
  0x03, 0xC7, 0x00, 0xF1, 0xC0, 0x1E, 0x78, 0x07, 0x9E, 0x00, 0xF3, 0xC0,
  0x3C, 0xF0, 0x07, 0x1C, 0x01, 0xE7, 0x00, 0x39, 0xE0, 0x0F, 0x78, 0x01,
  0xCF, 0x00, 0x7B, 0xC0, 0x0E, 0x70, 0x03, 0xDC, 0x00, 0x77, 0x80, 0x1E,
  0xE0, 0x03, 0xBC, 0x00, 0xFF, 0x00, 0x1D, 0xC0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x20, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE1, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x00, 0x03,
  0xDF, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xF7, 0x80, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x8F,
  0x00, 0x00, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0x1F, 0x3C, 0x00,
  0x00, 0x07, 0xC7, 0x80, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x3E, 0x0F,
  0x00, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x7C,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00,
  0xF0, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0x3C, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3C, 0x70,
  0x00, 0x7C, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78,
  0x01, 0xE0, 0x38, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x3C,
  0x07, 0x80, 0x1C, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x1E,
  0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x0E, 0x7C, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xF8, 0x3E, 0x0F,
  0x07, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0x87, 0xF8,
  0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x3E,
  0x07, 0x80, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0x80, 0x3C, 0x0F, 0xE0, 0x00, 0x3C, 0x1F, 0x80, 0x00, 0x3C,
  0x3E, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x78,
  0xF8, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x01, 0xF8, 0xF0, 0x00, 0x03, 0xF0,
  0xF0, 0x00, 0x07, 0xF0, 0xF8, 0x00, 0x0F, 0xF0, 0x7C, 0x00, 0x3E, 0xF0,
  0x7F, 0x01, 0xFC, 0xF0, 0x3F, 0xFF, 0xF8, 0xF0, 0x1F, 0xFF, 0xE0, 0xF0,
  0x07, 0xFF, 0x80, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0xFF, 0x00, 0x03, 0xC1, 0xFF, 0xE0, 0x01, 0xE3, 0xFF, 0xFC, 0x00, 0xF3,
  0xFD, 0xFF, 0x00, 0x7B, 0xE0, 0x0F, 0x80, 0x3F, 0xC0, 0x03, 0xE0, 0x1F,
  0x80, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1E, 0x07,
  0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07,
  0x8F, 0x80, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x1F, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x83, 0xC0, 0x00,
  0x07, 0x83, 0xF0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x07, 0xC0, 0xFE, 0x00,
  0x07, 0xC0, 0x7F, 0xC0, 0x07, 0xE0, 0x3D, 0xF8, 0x1F, 0xE0, 0x1E, 0x7F,
  0xFF, 0xE0, 0x1E, 0x1F, 0xFF, 0xC0, 0x0F, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x7E,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1F, 0x0F, 0x00,
  0x00, 0x1E, 0x3E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x79, 0xF0, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x78, 0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xE0, 0x7C, 0x00, 0x3F, 0xFF,
  0x0F, 0x00, 0x0F, 0xFF, 0xF1, 0xE0, 0x03, 0xFE, 0x7F, 0x3C, 0x00, 0xFC,
  0x01, 0xF7, 0x80, 0x3E, 0x00, 0x0F, 0xF0, 0x0F, 0x80, 0x00, 0xFC, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x78, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x1E, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x0F, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x7C, 0x1E,
  0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x3E, 0x07, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x01, 0xF8,
  0x01, 0xE0, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x3F, 0xE0, 0x03, 0xF0, 0x1F,
  0xBC, 0x00, 0x3F, 0xFF, 0xE7, 0x00, 0x03, 0xFF, 0xF0, 0xE0, 0x00, 0x3F,
  0xF8, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0xFF,
  0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x0F, 0xC0, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x07, 0xC0, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0xE1, 0xE0, 0x00,
  0x00, 0x71, 0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E, 0xF8, 0x00,
  0x00, 0x1E, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x80, 0x7C, 0x00, 0x00, 0xE0, 0x1F, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0xF0, 0x00, 0x7F, 0xFE, 0x0E, 0x00, 0x0F, 0xFF, 0xF1, 0xE0,
  0x01, 0xFF, 0x3F, 0x9E, 0x00, 0x7F, 0x00, 0x7D, 0xE0, 0x07, 0xC0, 0x01,
  0xDE, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0x00, 0x00, 0xFC, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x1E, 0x00,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x07, 0x80,
  0x01, 0xFC, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x03, 0xF0, 0x1F, 0xBC, 0x00,
  0x1F, 0xFF, 0xF3, 0xC0, 0x00, 0xFF, 0xFC, 0x78, 0x00, 0x07, 0xFF, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x20, 0x00, 0x03, 0xE0, 0x07, 0x00, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x7F, 0xC0, 0x03, 0xC0, 0xFF, 0xF8, 0x01, 0xE1, 0xFF, 0xFE, 0x00,
  0xF1, 0xFE, 0xFF, 0x80, 0x79, 0xF0, 0x07, 0xC0, 0x39, 0xE0, 0x01, 0xF0,
  0x3D, 0xC0, 0x00, 0x78, 0x1F, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x0F,
  0x07, 0xC0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF8, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xF1, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x03, 0xC0,
  0x00, 0x0F, 0xC0, 0x78, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x01, 0xF8, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x3F,
  0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x07, 0x81,
  0xF8, 0x00, 0x00, 0xF0, 0x7E, 0x00, 0x00, 0x1E, 0x1F, 0x80, 0x00, 0x03,
  0xC7, 0xE0, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x1E, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xDE, 0x00, 0x00, 0x0F, 0xF3, 0xE0,
  0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x7E, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x1E, 0x00,
  0x00, 0x7C, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x00, 0x7C, 0x0F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x20, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xE1, 0xFC, 0x03, 0xF8, 0x00, 0xE3, 0xFF, 0x07, 0xFE, 0x00, 0x73, 0xFF,
  0xC7, 0xFF, 0x80, 0x7B, 0xF7, 0xF7, 0xEF, 0xE0, 0x3F, 0x80, 0xFF, 0x80,
  0xF0, 0x1F, 0x80, 0x3F, 0x00, 0x78, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x07,
  0x80, 0x0F, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03,
  0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x01,
  0xE0, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F,
  0x00, 0x0E, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0x81, 0xC0, 0x03, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x00, 0x70, 0x3C, 0x00, 0x3C,
  0x00, 0x78, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x0E, 0x00, 0x1E, 0x00, 0x1E,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x80, 0x07, 0x83, 0xC0,
  0x03, 0xC0, 0x03, 0x81, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x0F, 0x00,
  0x0E, 0x00, 0x1E, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x3F, 0xE0, 0x01, 0xE0, 0x7F, 0xFC, 0x00, 0xF0,
  0xFF, 0xFF, 0x00, 0x78, 0xFF, 0x7F, 0xC0, 0x38, 0xF8, 0x03, 0xE0, 0x3C,
  0xF0, 0x00, 0xF8, 0x1E, 0xE0, 0x00, 0x3C, 0x0F, 0xE0, 0x00, 0x1F, 0x07,
  0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE1,
  0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F,
  0x0F, 0x80, 0x00, 0x07, 0x87, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3E, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x1F, 0xC0, 0x0F, 0x80,
  0x1F, 0x80, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3C,
  0x0F, 0x80, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x07, 0x87, 0x80, 0x00, 0x03,
  0xC7, 0xC0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x07, 0xC3, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0x07, 0xE0, 0x3E, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x07, 0xE0, 0x03,
  0xF0, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x1F, 0xE0,
  0x00, 0x1E, 0x1F, 0xFF, 0x00, 0x03, 0xC7, 0xFF, 0xF8, 0x00, 0x7B, 0xFC,
  0xFF, 0x80, 0x0F, 0xF8, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0x00, 0x7F,
  0x00, 0x01, 0xE0, 0x0F, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x3E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xF0,
  0x78, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0xFC, 0x00, 0x03, 0xE0, 0x1F, 0xC0, 0x00, 0xF8, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x7B, 0xE0, 0x3F, 0xC0, 0x1F, 0x3F, 0xFF, 0xE0, 0x03, 0xC3, 0xFF,
  0xF8, 0x00, 0x78, 0x1F, 0xFC, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x07,
  0x80, 0x1F, 0xFF, 0x87, 0x80, 0x1F, 0xFF, 0xE3, 0xC0, 0x1F, 0xE1, 0xF9,
  0xE0, 0x3F, 0x80, 0x3E, 0xF0, 0x1F, 0x00, 0x07, 0xF8, 0x1F, 0x00, 0x01,
  0xFC, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x03, 0xC3, 0xE0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x01, 0xF0, 0xF0,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x0F, 0x81,
  0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x0F, 0xE0,
  0x1F, 0x00, 0x1F, 0xF0, 0x07, 0xE0, 0x3F, 0x78, 0x01, 0xFF, 0xFF, 0x38,
  0x00, 0x7F, 0xFE, 0x3C, 0x00, 0x1F, 0xFC, 0x1E, 0x00, 0x00, 0xE0, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x0F, 0xFE, 0x03,
  0xC0, 0xFF, 0xFC, 0x07, 0x87, 0xFF, 0xF8, 0x1E, 0x1F, 0xFF, 0xE0, 0x3C,
  0x7F, 0x00, 0x40, 0x79, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x01,
  0xFF, 0x8F, 0xF8, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1F, 0x0F,
  0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x07, 0xE0, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x20, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x87, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03,
  0xC3, 0xE0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x1E, 0x1F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x87, 0x80, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x00, 0xF0, 0xF8, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0x7C, 0x3C, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x1F, 0x03, 0xC0,
  0x00, 0x0F, 0x81, 0xE0, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x0F, 0xC0, 0x7C,
  0x00, 0x0E, 0xE0, 0x1F, 0x00, 0x1E, 0xF0, 0x0F, 0xC0, 0x7E, 0x78, 0x03,
  0xFF, 0xFE, 0x3C, 0x00, 0xFF, 0xFE, 0x1E, 0x00, 0x1F, 0xFC, 0x0E, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x01,
  0xF7, 0x80, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x78, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x01, 0xF0, 0x03,
  0x80, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0xE0, 0x0F,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x3F, 0xC0, 0x01, 0xC0, 0x01, 0xEF, 0x00, 0x0F, 0x00, 0x07,
  0xBC, 0x00, 0x3C, 0x00, 0x1C, 0xF0, 0x00, 0xF0, 0x00, 0xF3, 0xC0, 0x07,
  0xE0, 0x03, 0xCF, 0x00, 0x1F, 0x80, 0x0E, 0x3C, 0x00, 0xEE, 0x00, 0x78,
  0xF0, 0x03, 0xB8, 0x01, 0xE3, 0xC0, 0x0E, 0xE0, 0x0F, 0x0F, 0x00, 0x73,
  0x80, 0x3C, 0x3C, 0x01, 0xCE, 0x00, 0xE0, 0x70, 0x0F, 0x38, 0x07, 0x81,
  0xC0, 0x38, 0xE0, 0x1E, 0x07, 0x01, 0xE3, 0x80, 0x70, 0x1C, 0x07, 0x0E,
  0x03, 0xC0, 0x70, 0x1C, 0x38, 0x0E, 0x01, 0xC0, 0xF0, 0xE0, 0x38, 0x07,
  0x03, 0x83, 0x81, 0xE0, 0x1C, 0x1E, 0x0F, 0x07, 0x00, 0x70, 0x70, 0x3C,
  0x3C, 0x01, 0xC1, 0xC0, 0x70, 0xF0, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0x1C,
  0x38, 0x07, 0x1E, 0x00, 0x71, 0xE0, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x71,
  0xC0, 0x07, 0x3C, 0x01, 0xCF, 0x00, 0x1C, 0xE0, 0x07, 0x38, 0x00, 0x73,
  0x80, 0x1D, 0xE0, 0x01, 0xDE, 0x00, 0x77, 0x00, 0x07, 0x70, 0x01, 0xDC,
  0x00, 0x1D, 0xC0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x22, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x0F, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x00, 0x3C,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x00, 0x79, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0xFB, 0xC0, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0x0F, 0x87, 0x80,
  0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x1F,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x3C,
  0x00, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x00,
  0x7B, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1C, 0x3F, 0xFF, 0x80, 0x00, 0x78, 0xFE, 0x7F, 0x80, 0x00,
  0xE1, 0xF0, 0x1F, 0x80, 0x01, 0xC7, 0x80, 0x1F, 0x80, 0x07, 0x8E, 0x00,
  0x1F, 0x80, 0x1E, 0x3C, 0x00, 0x1F, 0x80, 0x7C, 0x70, 0x00, 0x0F, 0xE7,
  0xF0, 0xE0, 0x00, 0x0F, 0xFF, 0xC3, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00,
};

const GFXglyph RobotoMono_LightItalic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 42, 0, -1 },
  { 1, 13, 50, 42, 14, -50 },
  { 83, 16, 15, 42, 16, -53 },
  { 113, 41, 50, 42, 1, -50 },
  { 370, 35, 65, 42, 4, -58 },
  { 655, 34, 52, 42, 4, -51 },
  { 876, 35, 52, 42, 3, -51 },
  { 1104, 6, 15, 42, 20, -53 },
  { 1116, 22, 73, 42, 12, -57 },
  { 1317, 22, 73, 42, 6, -57 },
  { 1518, 31, 30, 42, 9, -50 },
  { 1635, 34, 37, 42, 4, -42 },
  { 1793, 10, 17, 42, 8, -7 },
  { 1815, 25, 3, 42, 8, -24 },
  { 1825, 7, 7, 42, 15, -7 },
  { 1832, 34, 54, 42, 5, -50 },
  { 2062, 33, 52, 42, 5, -51 },
  { 2277, 19, 50, 42, 11, -50 },
  { 2396, 35, 51, 42, 1, -51 },
  { 2620, 34, 52, 42, 2, -51 },
  { 2841, 36, 50, 42, 1, -50 },
  { 3066, 35, 51, 42, 6, -50 },
  { 3290, 31, 52, 42, 4, -51 },
  { 3492, 33, 50, 42, 8, -50 },
  { 3699, 35, 52, 42, 4, -51 },
  { 3927, 31, 51, 42, 7, -51 },
  { 4125, 12, 37, 42, 17, -37 },
  { 4181, 16, 47, 42, 13, -37 },
  { 4275, 31, 30, 42, 6, -38 },
  { 4392, 33, 18, 42, 5, -32 },
  { 4467, 32, 30, 42, 4, -38 },
  { 4587, 27, 51, 42, 11, -51 },
  { 4760, 39, 51, 42, 2, -51 },
  { 5009, 35, 50, 42, 0, -50 },
  { 5228, 36, 50, 42, 3, -50 },
  { 5453, 36, 52, 42, 4, -51 },
  { 5687, 37, 50, 42, 2, -50 },
  { 5919, 38, 50, 42, 3, -50 },
  { 6157, 38, 50, 42, 3, -50 },
  { 6395, 36, 52, 42, 4, -51 },
  { 6629, 39, 50, 42, 2, -50 },
  { 6873, 37, 50, 42, 3, -50 },
  { 7105, 38, 51, 42, 2, -50 },
  { 7348, 41, 50, 42, 3, -50 },
  { 7605, 29, 50, 42, 4, -50 },
  { 7787, 40, 50, 42, 2, -50 },
  { 8037, 39, 50, 42, 2, -50 },
  { 8281, 35, 52, 42, 4, -51 },
  { 8509, 37, 50, 42, 4, -50 },
  { 8741, 37, 60, 42, 3, -51 },
  { 9019, 36, 50, 42, 3, -50 },
  { 9244, 37, 52, 42, 3, -51 },
  { 9485, 36, 50, 42, 8, -50 },
  { 9710, 37, 51, 42, 4, -50 },
  { 9946, 35, 51, 42, 8, -51 },
  { 10170, 37, 50, 42, 7, -50 },
  { 10402, 43, 51, 42, 0, -51 },
  { 10677, 35, 51, 42, 8, -51 },
  { 10901, 38, 50, 42, 1, -50 },
  { 11139, 23, 69, 42, 10, -58 },
  { 11338, 14, 55, 42, 14, -51 },
  { 11435, 22, 69, 42, 10, -58 },
  { 11625, 24, 27, 42, 9, -50 },
  { 11706, 30, 4, 42, 2, 0 },
  { 11721, 9, 9, 42, 20, -52 },
  { 11732, 32, 39, 42, 4, -38 },
  { 11888, 33, 54, 42, 3, -53 },
  { 12111, 31, 39, 42, 5, -38 },
  { 12263, 35, 54, 42, 5, -53 },
  { 12500, 33, 39, 42, 4, -38 },
  { 12661, 35, 54, 42, 8, -54 },
  { 12898, 36, 53, 42, 2, -38 },
  { 13137, 33, 53, 42, 3, -53 },
  { 13356, 30, 51, 42, 4, -51 },
  { 13548, 32, 66, 42, 1, -51 },
  { 13812, 35, 53, 42, 4, -53 },
  { 14044, 30, 53, 42, 4, -53 },
  { 14243, 41, 38, 42, -1, -38 },
  { 14438, 33, 38, 42, 3, -38 },
  { 14595, 33, 39, 42, 4, -38 },
  { 14756, 35, 52, 42, 1, -38 },
  { 14984, 33, 52, 42, 5, -38 },
  { 15199, 31, 38, 42, 8, -38 },
  { 15347, 32, 39, 42, 5, -38 },
  { 15503, 28, 48, 42, 8, -47 },
  { 15671, 33, 39, 42, 5, -38 },
  { 15832, 34, 38, 42, 6, -38 },
  { 15994, 38, 38, 42, 5, -38 },
  { 16175, 39, 38, 42, 1, -38 },
  { 16361, 43, 53, 42, -1, -38 },
  { 16646, 36, 38, 42, 2, -38 },
  { 16817, 27, 69, 42, 11, -55 },
  { 17050, 13, 62, 42, 14, -50 },
  { 17151, 28, 69, 42, 6, -55 },
  { 17393, 39, 12, 42, 1, -27 },
};

const GFXfont RobotoMono_LightItalic71pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic71pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic71pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _ROBOTOMONO_LIGHTITALIC71PT7B_H_
