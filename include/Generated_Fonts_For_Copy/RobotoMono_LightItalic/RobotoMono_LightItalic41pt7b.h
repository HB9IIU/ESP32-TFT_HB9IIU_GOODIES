#ifndef _ROBOTOMONO_LIGHTITALIC41PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x06, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x1C,
  0x1C, 0x1C, 0x18, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0xF0, 0xE0, 0x30, 0xCC, 0x37, 0x19, 0x86, 0x61,
  0x98, 0x66, 0x19, 0x84, 0xC3, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30,
  0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00,
  0x0C, 0x0C, 0x00, 0x30, 0x30, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x03,
  0x03, 0x00, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0x60,
  0x60, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x18, 0x18,
  0x07, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00,
  0x0C, 0x06, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x01,
  0x81, 0x80, 0x03, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x3C,
  0x0E, 0x0E, 0x00, 0xC1, 0x80, 0x1C, 0x70, 0x01, 0x8C, 0x00, 0x31, 0x80,
  0x06, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00,
  0xCC, 0x00, 0x39, 0xC0, 0x07, 0x18, 0x01, 0xC3, 0xC0, 0xF0, 0x3F, 0xFC,
  0x01, 0xFE, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x04, 0x00, 0x07, 0xE0, 0x01, 0xC6, 0x00, 0x30, 0xC0, 0x0C, 0x0C,
  0x09, 0x81, 0x83, 0xB0, 0x30, 0x66, 0x06, 0x18, 0xC1, 0x86, 0x18, 0x30,
  0xC3, 0x06, 0x30, 0x73, 0x8C, 0x07, 0xE3, 0x80, 0x30, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0xE0, 0x0C, 0x7F, 0x03, 0x8C,
  0x70, 0x63, 0x06, 0x18, 0x60, 0xC7, 0x18, 0x18, 0xC3, 0x03, 0x30, 0x60,
  0x6C, 0x0C, 0x0C, 0x81, 0x83, 0x00, 0x30, 0x60, 0x03, 0xB8, 0x00, 0x3E,
  0x00, 0x00, 0x10, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x38, 0x30, 0x03,
  0x03, 0x80, 0x70, 0x18, 0x06, 0x03, 0x80, 0x60, 0x38, 0x06, 0x07, 0x00,
  0x60, 0x60, 0x07, 0x1C, 0x00, 0x73, 0x80, 0x03, 0x70, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0E, 0xE0, 0x03, 0xC6, 0x03, 0x38, 0x70,
  0x37, 0x03, 0x87, 0xE0, 0x18, 0x6E, 0x01, 0xC6, 0xC0, 0x0C, 0xCC, 0x00,
  0xFC, 0xC0, 0x07, 0x8C, 0x00, 0x30, 0xE0, 0x0F, 0x87, 0x01, 0xDC, 0x3F,
  0xF8, 0xC1, 0xFE, 0x0E, 0x6D, 0xBD, 0xB6, 0xC0, 0x00, 0x08, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x00, 0x0E, 0x00, 0x20, 0x00, 0x02, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0C,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x08, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x10, 0x30, 0x3F, 0x0C, 0x3F,
  0xFB, 0x7F, 0x0F, 0xFC, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1D, 0x80, 0x0E,
  0x70, 0x03, 0x0C, 0x01, 0x83, 0x80, 0xE0, 0x70, 0x70, 0x0C, 0x08, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x07,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0xCE, 0x73, 0x19, 0xCC, 0xC4,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x6F, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0x80, 0xE0, 0xE0, 0x0C, 0x38, 0x01, 0x86,
  0x00, 0x39, 0xC0, 0x03, 0x30, 0x00, 0x66, 0x00, 0x1D, 0xC0, 0x0F, 0xB8,
  0x03, 0xB6, 0x00, 0xEE, 0xC0, 0x31, 0xD8, 0x1C, 0x3B, 0x07, 0x06, 0xE1,
  0xC0, 0xDC, 0x60, 0x1B, 0x38, 0x07, 0x6E, 0x00, 0xEF, 0x80, 0x19, 0xC0,
  0x03, 0x30, 0x00, 0xE6, 0x00, 0x18, 0xC0, 0x07, 0x1C, 0x00, 0xC1, 0x80,
  0x38, 0x38, 0x0E, 0x03, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x00, 0x60, 0x3C,
  0x3F, 0x9F, 0x7F, 0x8F, 0x81, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0xC0, 0x70, 0x1C, 0x0E,
  0x00, 0xE0, 0xC0, 0x06, 0x1C, 0x00, 0x61, 0x80, 0x06, 0x38, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFC, 0x00, 0x1C, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0,
  0x78, 0x0E, 0x07, 0x00, 0x60, 0xE0, 0x07, 0x0C, 0x00, 0x71, 0xC0, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0xC0,
  0x01, 0xCC, 0x00, 0x1C, 0xE0, 0x01, 0x86, 0x00, 0x38, 0x70, 0x07, 0x03,
  0x80, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x06, 0xC0, 0x00, 0xEC, 0x00, 0x1C,
  0xC0, 0x03, 0x8C, 0x00, 0x31, 0xC0, 0x06, 0x1C, 0x00, 0xC1, 0x80, 0x1C,
  0x18, 0x03, 0x81, 0x80, 0x70, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x38, 0x1C,
  0x03, 0x03, 0x80, 0x30, 0x70, 0x03, 0x06, 0x00, 0x70, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0x80, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x1C,
  0x00, 0x37, 0xFC, 0x01, 0xFF, 0xF0, 0x0E, 0x03, 0xC0, 0x20, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x70, 0x00, 0xC3, 0x80, 0x06, 0x0C, 0x00, 0x70, 0x60,
  0x07, 0x03, 0x80, 0x30, 0x0E, 0x07, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x0F, 0x80, 0x07, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03,
  0x8F, 0xC0, 0xCF, 0xFC, 0x37, 0x07, 0x8F, 0x00, 0xE7, 0x80, 0x1D, 0xC0,
  0x07, 0x60, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x00,
  0xD8, 0x00, 0x76, 0x00, 0x19, 0x80, 0x0E, 0x70, 0x03, 0x0C, 0x01, 0xC3,
  0xC1, 0xE0, 0x7F, 0xF0, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF8,
  0x07, 0x81, 0xC0, 0x70, 0x07, 0x03, 0x00, 0x18, 0x38, 0x00, 0xC1, 0x80,
  0x06, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x1C, 0x1C, 0x00, 0xC0,
  0x60, 0x0C, 0x03, 0xC1, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0x07,
  0x80, 0xE0, 0x0E, 0x0E, 0x00, 0x30, 0x60, 0x01, 0x87, 0x00, 0x0E, 0x30,
  0x00, 0x71, 0x80, 0x03, 0x8C, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x0E,
  0x1C, 0x00, 0xE0, 0x70, 0x1E, 0x01, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x00,
  0x20, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x78, 0x1C, 0x18, 0x03, 0x8E, 0x00,
  0x67, 0x00, 0x19, 0x80, 0x06, 0x60, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xB8, 0x00, 0x6E, 0x00, 0x39, 0x80, 0x1E, 0x70,
  0x0D, 0x8E, 0x07, 0xC3, 0xFF, 0xB0, 0x3F, 0x8C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x1F, 0x00, 0x7F, 0x80, 0x1F, 0x00, 0x00, 0x0C, 0x3C, 0x78, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x87,
  0x8F, 0x1C, 0x00, 0x01, 0x80, 0xF0, 0x3C, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x1C, 0x0E,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x18, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x9F, 0xFF, 0xF0, 0x10, 0x00, 0x03, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xC0, 0x07, 0xF8, 0x1F, 0xFC, 0x38, 0x0E, 0x70, 0x06, 0x60, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x03, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xE0, 0x07, 0x80, 0xE0, 0x1C, 0x00, 0xC0,
  0x70, 0x00, 0xC0, 0xC0, 0x01, 0x83, 0x07, 0xC1, 0x0C, 0x1F, 0xC3, 0x18,
  0x60, 0x86, 0x61, 0x83, 0x0C, 0xC3, 0x06, 0x1B, 0x0C, 0x08, 0x36, 0x18,
  0x10, 0x4C, 0x60, 0x60, 0x90, 0xC0, 0xC3, 0x61, 0x81, 0x06, 0xC3, 0x06,
  0x0D, 0x84, 0x0C, 0x13, 0x08, 0x38, 0x66, 0x10, 0x70, 0x8C, 0x31, 0x63,
  0x18, 0x7E, 0xFC, 0x30, 0x70, 0xF0, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x10, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0D,
  0x80, 0x01, 0xD8, 0x00, 0x19, 0x80, 0x03, 0x98, 0x00, 0x31, 0x80, 0x07,
  0x1C, 0x00, 0x60, 0xC0, 0x0E, 0x0C, 0x00, 0xC0, 0xC0, 0x1C, 0x0C, 0x01,
  0x80, 0xC0, 0x38, 0x0C, 0x03, 0x00, 0xE0, 0x70, 0x0E, 0x06, 0x00, 0x60,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xC0, 0x06, 0x18, 0x00, 0x61, 0x80, 0x07,
  0x30, 0x00, 0x73, 0x00, 0x03, 0x70, 0x00, 0x36, 0x00, 0x03, 0xE0, 0x00,
  0x30, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x0E, 0x01, 0xE0, 0xC0, 0x07, 0x0C,
  0x00, 0x70, 0xC0, 0x03, 0x0C, 0x00, 0x31, 0xC0, 0x03, 0x1C, 0x00, 0x71,
  0x80, 0x07, 0x18, 0x00, 0xE1, 0x80, 0x1C, 0x18, 0x07, 0x83, 0xFF, 0xE0,
  0x3F, 0xFF, 0x03, 0x00, 0x38, 0x30, 0x01, 0xC3, 0x00, 0x0C, 0x30, 0x00,
  0xE7, 0x00, 0x06, 0x70, 0x00, 0x66, 0x00, 0x0E, 0x60, 0x00, 0xC6, 0x00,
  0x1C, 0xE0, 0x01, 0x8E, 0x00, 0x78, 0xC0, 0x1F, 0x0F, 0xFF, 0xC0, 0xFF,
  0xF0, 0x00, 0x00, 0x08, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0x01,
  0xC0, 0x70, 0x07, 0x07, 0x00, 0x18, 0x30, 0x00, 0xC3, 0x80, 0x07, 0x18,
  0x00, 0x39, 0xC0, 0x01, 0xCC, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x73,
  0x80, 0x03, 0x0C, 0x00, 0x38, 0x60, 0x01, 0x83, 0x80, 0x1C, 0x0C, 0x01,
  0xC0, 0x70, 0x1C, 0x01, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x60, 0x1E, 0x01, 0x80, 0x38, 0x06, 0x00, 0x70, 0x38,
  0x00, 0xE0, 0xE0, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00,
  0x70, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x60, 0x00, 0x61,
  0x80, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x18, 0xE0, 0x00, 0xE3, 0x80,
  0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x70, 0xC0, 0x01, 0x87, 0x00, 0x0E,
  0x1C, 0x00, 0x70, 0x70, 0x03, 0x81, 0x80, 0x3C, 0x06, 0x03, 0xE0, 0x1F,
  0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0x01, 0xC0, 0x70, 0x07, 0x07, 0x00,
  0x18, 0x70, 0x00, 0xE3, 0x00, 0x07, 0x38, 0x00, 0x39, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x1F, 0xF7, 0x01, 0xFF, 0x38, 0x00, 0x19, 0xC0,
  0x00, 0xCE, 0x00, 0x06, 0x70, 0x00, 0x73, 0x80, 0x03, 0x8C, 0x00, 0x18,
  0x60, 0x00, 0xC3, 0x80, 0x06, 0x0E, 0x00, 0x70, 0x38, 0x0F, 0x01, 0xFF,
  0xF0, 0x03, 0xFE, 0x00, 0x06, 0x00, 0x0E, 0x0C, 0x00, 0x18, 0x18, 0x00,
  0x30, 0x70, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x07,
  0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x38, 0x00, 0x30, 0x60, 0x00, 0x60,
  0xC0, 0x00, 0xC1, 0x80, 0x03, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1C,
  0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0xE0, 0xC0, 0x01, 0xC1, 0x80,
  0x03, 0x07, 0x00, 0x06, 0x0E, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00,
  0x70, 0x60, 0x00, 0xE0, 0xC0, 0x01, 0x83, 0x80, 0x03, 0x06, 0x00, 0x06,
  0x0C, 0x00, 0x1C, 0x00, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC3, 0x80, 0x03, 0x06, 0x00, 0x1C,
  0x18, 0x00, 0x60, 0x60, 0x03, 0x81, 0xC0, 0x1C, 0x03, 0x81, 0xE0, 0x07,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x06, 0x00, 0x1E, 0x0C, 0x00, 0x78, 0x38,
  0x01, 0xE0, 0x70, 0x07, 0x80, 0xC0, 0x1E, 0x01, 0x80, 0x78, 0x03, 0x01,
  0xE0, 0x06, 0x07, 0x80, 0x1C, 0x1E, 0x00, 0x38, 0x78, 0x00, 0x61, 0xE0,
  0x00, 0xC7, 0x80, 0x01, 0x9E, 0x00, 0x07, 0x78, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0x38, 0x00, 0x3C, 0x70, 0x00, 0x70, 0x70, 0x00, 0xC0, 0xE0, 0x03,
  0x80, 0xE0, 0x07, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x30,
  0x03, 0x80, 0x60, 0x03, 0x01, 0xC0, 0x07, 0x03, 0x80, 0x07, 0x06, 0x00,
  0x0E, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0x00, 0x0E, 0x0E, 0x00,
  0x3C, 0x1E, 0x00, 0xF8, 0x3C, 0x01, 0xE0, 0xF8, 0x07, 0xC1, 0xB0, 0x0D,
  0x83, 0x60, 0x3B, 0x06, 0xE0, 0x66, 0x0C, 0xC1, 0xDC, 0x19, 0x83, 0x30,
  0x73, 0x0C, 0x60, 0xC6, 0x18, 0xC1, 0x8C, 0x61, 0x83, 0x1D, 0xC7, 0x06,
  0x1B, 0x0E, 0x1C, 0x3E, 0x18, 0x38, 0x78, 0x30, 0x60, 0xF0, 0x60, 0xC1,
  0xC1, 0xC1, 0x83, 0x83, 0x83, 0x00, 0x06, 0x0E, 0x00, 0x0C, 0x1C, 0x00,
  0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0xE0, 0xC0, 0x01, 0xC1, 0x80, 0x03,
  0x07, 0x00, 0x06, 0x0E, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x0E, 0x0E, 0x00,
  0x18, 0x1C, 0x00, 0x30, 0x7C, 0x00, 0x60, 0xF8, 0x00, 0xC1, 0xB0, 0x03,
  0x83, 0x70, 0x07, 0x06, 0x60, 0x0C, 0x0C, 0xC0, 0x18, 0x39, 0xC0, 0x30,
  0x71, 0x80, 0x60, 0xC3, 0x81, 0xC1, 0x83, 0x03, 0x83, 0x06, 0x06, 0x06,
  0x0E, 0x0C, 0x1C, 0x0C, 0x18, 0x38, 0x18, 0x70, 0x60, 0x38, 0xE0, 0xC0,
  0x31, 0xC1, 0x80, 0x63, 0x03, 0x00, 0xE6, 0x0E, 0x00, 0xCC, 0x1C, 0x01,
  0xB8, 0x30, 0x03, 0xF0, 0x60, 0x03, 0xC0, 0xC0, 0x07, 0x83, 0x80, 0x07,
  0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x08, 0x00, 0x0F, 0xF0,
  0x01, 0xFF, 0xC0, 0x38, 0x1E, 0x07, 0x00, 0x60, 0xE0, 0x07, 0x0C, 0x00,
  0x31, 0xC0, 0x03, 0x18, 0x00, 0x33, 0x80, 0x03, 0x30, 0x00, 0x33, 0x00,
  0x03, 0x70, 0x00, 0x37, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x60,
  0x00, 0x76, 0x00, 0x07, 0xE0, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0xEE,
  0x00, 0x0C, 0xE0, 0x00, 0xC6, 0x00, 0x1C, 0x60, 0x01, 0x87, 0x00, 0x30,
  0x30, 0x07, 0x03, 0x81, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x60, 0x0F, 0x01, 0x80, 0x0E, 0x0E, 0x00, 0x18,
  0x38, 0x00, 0x60, 0xC0, 0x01, 0xC3, 0x00, 0x07, 0x0C, 0x00, 0x18, 0x30,
  0x00, 0x61, 0xC0, 0x01, 0x87, 0x00, 0x0E, 0x18, 0x00, 0x70, 0x60, 0x03,
  0x81, 0x80, 0x3C, 0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x07, 0xFC, 0x00,
  0x7F, 0xF0, 0x07, 0x01, 0xC0, 0x70, 0x06, 0x07, 0x00, 0x38, 0x70, 0x00,
  0xC3, 0x00, 0x06, 0x38, 0x00, 0x39, 0x80, 0x01, 0xCC, 0x00, 0x06, 0xE0,
  0x00, 0x36, 0x00, 0x03, 0xB0, 0x00, 0x1D, 0x80, 0x00, 0xFC, 0x00, 0x06,
  0xE0, 0x00, 0x37, 0x00, 0x01, 0xB0, 0x00, 0x1D, 0x80, 0x00, 0xEC, 0x00,
  0x06, 0x60, 0x00, 0x73, 0x80, 0x03, 0x1C, 0x00, 0x38, 0x60, 0x01, 0x83,
  0x80, 0x1C, 0x0C, 0x01, 0xC0, 0x70, 0x3C, 0x01, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x40, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x03, 0x80, 0x78, 0x1C, 0x00,
  0xE0, 0xC0, 0x07, 0x06, 0x00, 0x18, 0x30, 0x00, 0xE1, 0x80, 0x07, 0x1C,
  0x00, 0x30, 0xE0, 0x01, 0x86, 0x00, 0x1C, 0x30, 0x00, 0xC1, 0x80, 0x0E,
  0x0C, 0x00, 0xE0, 0xE0, 0x3E, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0x80,
  0x60, 0x0C, 0x03, 0x00, 0x60, 0x1C, 0x07, 0x00, 0x60, 0x38, 0x03, 0x01,
  0x80, 0x1C, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x07, 0x00, 0x1C, 0x38, 0x00,
  0x61, 0x80, 0x03, 0x0C, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0xF0, 0x0F, 0x01, 0xC0, 0xE0, 0x07, 0x07, 0x00, 0x18, 0x70,
  0x00, 0xE3, 0x80, 0x07, 0x18, 0x00, 0x18, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00,
  0xE3, 0x00, 0x0E, 0x1C, 0x00, 0xE0, 0x70, 0x0F, 0x01, 0xFF, 0xE0, 0x03,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x1C, 0x30, 0x00,
  0x60, 0xC0, 0x01, 0x87, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0x61,
  0x80, 0x03, 0x86, 0x00, 0x0C, 0x18, 0x00, 0x30, 0xE0, 0x00, 0xC3, 0x00,
  0x03, 0x0C, 0x00, 0x1C, 0x30, 0x00, 0x70, 0xC0, 0x01, 0x83, 0x00, 0x06,
  0x1C, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x03, 0x86, 0x00, 0x0E, 0x18,
  0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x1C, 0x18, 0x00,
  0x60, 0x70, 0x03, 0x80, 0xC0, 0x1C, 0x03, 0x81, 0xE0, 0x07, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xE0, 0x00, 0x3B, 0x00, 0x03, 0x98, 0x00, 0x18, 0xC0,
  0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x61, 0xC0, 0x07, 0x06, 0x00, 0x30,
  0x30, 0x03, 0x81, 0x80, 0x18, 0x0C, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0x80,
  0xE0, 0x0C, 0x06, 0x00, 0x60, 0x70, 0x03, 0x03, 0x00, 0x18, 0x18, 0x00,
  0xC1, 0x80, 0x07, 0x0C, 0x00, 0x38, 0xE0, 0x00, 0xC6, 0x00, 0x06, 0x70,
  0x00, 0x33, 0x00, 0x01, 0xB8, 0x00, 0x0D, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x30, 0x1F, 0x01,
  0xC0, 0x6C, 0x07, 0x01, 0xB0, 0x1C, 0x0E, 0xC0, 0xF0, 0x33, 0x03, 0xC0,
  0xCC, 0x0F, 0x07, 0x30, 0x6C, 0x18, 0xC1, 0xB0, 0x63, 0x06, 0xC1, 0x8C,
  0x33, 0x0C, 0x30, 0xCC, 0x30, 0xC3, 0x30, 0xC3, 0x18, 0xC7, 0x0C, 0x63,
  0x18, 0x31, 0x8C, 0x60, 0xCC, 0x31, 0x83, 0x30, 0xCC, 0x0C, 0xC3, 0x30,
  0x36, 0x06, 0xC0, 0xD8, 0x1F, 0x03, 0x60, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xC0, 0x18, 0x00, 0x07, 0x00, 0x07, 0x81, 0x80, 0x03, 0x80, 0xE0,
  0x03, 0x80, 0x30, 0x03, 0x80, 0x1C, 0x01, 0x80, 0x06, 0x01, 0xC0, 0x03,
  0x81, 0xC0, 0x01, 0xC1, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x38, 0xE0, 0x00,
  0x0C, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x3B, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x18, 0x38, 0x00, 0x1C, 0x0C,
  0x00, 0x1C, 0x07, 0x00, 0x1C, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x0E, 0x00, 0x18, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x3B, 0x80, 0x03, 0x9C, 0x00, 0x38, 0x60, 0x01, 0x83, 0x00, 0x1C,
  0x1C, 0x01, 0xC0, 0x60, 0x0C, 0x03, 0x00, 0xE0, 0x1C, 0x0E, 0x00, 0x60,
  0x60, 0x03, 0x07, 0x00, 0x1C, 0x30, 0x00, 0x63, 0x00, 0x03, 0x38, 0x00,
  0x19, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0,
  0x03, 0xF8, 0x1F, 0xC0, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38,
  0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x60, 0x60, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x18, 0x18, 0x18, 0x18, 0x18, 0x0C, 0x0C, 0x0C,
  0x0C, 0x0C, 0x06, 0x06, 0x06, 0x06, 0x06, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x01, 0xF8, 0x1F, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70,
  0x3F, 0x83, 0xF8, 0x00, 0x00, 0x60, 0x03, 0x80, 0x1E, 0x00, 0x6C, 0x03,
  0xB0, 0x0C, 0xC0, 0x73, 0x01, 0x8C, 0x0C, 0x18, 0x70, 0x61, 0x81, 0x8E,
  0x06, 0x30, 0x1D, 0xC0, 0x36, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xE3, 0x1C, 0x61, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1C, 0x0E,
  0x07, 0x00, 0xE1, 0xC0, 0x0C, 0x30, 0x01, 0xC8, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x0F, 0xF8, 0x1F, 0xFF, 0x0F, 0xC0, 0xE3, 0x80, 0x1C,
  0xE0, 0x03, 0x18, 0x00, 0x67, 0x00, 0x0C, 0xE0, 0x03, 0x9C, 0x00, 0xF3,
  0x80, 0x3E, 0x38, 0x1F, 0xC3, 0xFF, 0x38, 0x3F, 0xC7, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x8F, 0xC0, 0x77, 0xFC,
  0x0D, 0xC1, 0xC1, 0xE0, 0x1C, 0x38, 0x01, 0x86, 0x00, 0x31, 0xC0, 0x07,
  0x38, 0x00, 0xE6, 0x00, 0x1C, 0xC0, 0x03, 0x98, 0x00, 0x73, 0x00, 0x0E,
  0xE0, 0x01, 0x9C, 0x00, 0x33, 0x00, 0x0E, 0x60, 0x01, 0x8C, 0x00, 0x71,
  0xC0, 0x0C, 0x78, 0x03, 0x8F, 0x81, 0xE1, 0x9F, 0xF8, 0x31, 0xFE, 0x00,
  0x01, 0xFC, 0x01, 0xFF, 0x80, 0xF0, 0x70, 0x70, 0x0E, 0x38, 0x01, 0xCC,
  0x00, 0x77, 0x00, 0x0D, 0x80, 0x03, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x0E,
  0xC0, 0x03, 0x38, 0x01, 0xC6, 0x00, 0xE1, 0xE0, 0x70, 0x3F, 0xF8, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x1F, 0x8E, 0x07, 0xFC, 0xC0, 0xF0, 0xEC, 0x1C, 0x03, 0xC3, 0x80,
  0x1C, 0x30, 0x01, 0xC7, 0x00, 0x1C, 0x60, 0x01, 0x8E, 0x00, 0x18, 0xE0,
  0x01, 0x8C, 0x00, 0x18, 0xC0, 0x03, 0x8C, 0x00, 0x38, 0xC0, 0x03, 0x0C,
  0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xE0, 0x07, 0x06, 0x00, 0xF0,
  0x70, 0x3E, 0x03, 0xFF, 0x60, 0x1F, 0xC6, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0xE0, 0x1E, 0x0E, 0x07, 0x00, 0xE1, 0xC0, 0x0C, 0x30, 0x01, 0xCE, 0x00,
  0x19, 0x80, 0x03, 0x70, 0x00, 0x6F, 0xFF, 0xFD, 0xFF, 0xFF, 0xB0, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x20, 0xE0, 0x0E, 0x0E, 0x03, 0x80, 0xFF, 0xE0, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x0F,
  0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7E, 0x38, 0x0F, 0xF9,
  0x80, 0xF0, 0xEC, 0x0E, 0x01, 0xE0, 0xE0, 0x07, 0x06, 0x00, 0x38, 0x70,
  0x01, 0xC3, 0x00, 0x0C, 0x38, 0x00, 0x61, 0xC0, 0x03, 0x0C, 0x00, 0x18,
  0x60, 0x01, 0xC3, 0x00, 0x0E, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00,
  0x18, 0x30, 0x01, 0xC1, 0xC0, 0x0E, 0x06, 0x00, 0xF0, 0x38, 0x1F, 0x00,
  0xFF, 0xD8, 0x03, 0xF8, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x02, 0x00, 0x38, 0x38, 0x03, 0x80, 0xE0, 0x38, 0x03, 0xCF, 0x80, 0x0F,
  0xF8, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x87, 0xE0, 0x63, 0xFE, 0x0C, 0xE1, 0xE1, 0xB0, 0x0C,
  0x3C, 0x01, 0xC7, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0xE6, 0x00, 0x1C,
  0xC0, 0x03, 0x18, 0x00, 0x67, 0x00, 0x0C, 0xE0, 0x01, 0x9C, 0x00, 0x73,
  0x00, 0x0E, 0x60, 0x01, 0x8C, 0x00, 0x33, 0x80, 0x06, 0x70, 0x00, 0xCC,
  0x00, 0x39, 0x80, 0x07, 0x30, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x0F, 0xFC, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x07, 0xFF, 0xFE, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x21, 0xE0, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x07, 0x0C, 0x00, 0xE0,
  0xC0, 0x3C, 0x1C, 0x07, 0x81, 0xC0, 0xE0, 0x18, 0x1C, 0x01, 0x83, 0x80,
  0x18, 0xF0, 0x03, 0x9E, 0x00, 0x3B, 0x80, 0x03, 0x7C, 0x00, 0x3E, 0xE0,
  0x03, 0xCE, 0x00, 0x30, 0x70, 0x07, 0x03, 0x80, 0x70, 0x38, 0x06, 0x01,
  0xC0, 0x60, 0x0C, 0x06, 0x00, 0xE0, 0x60, 0x07, 0x0E, 0x00, 0x30, 0xE0,
  0x03, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x7F, 0xFF, 0xEF, 0xFF, 0xF8,
  0x1C, 0xF0, 0xF8, 0x37, 0xF3, 0xF8, 0x78, 0x7C, 0x38, 0xE0, 0xF0, 0x31,
  0x80, 0xC0, 0x63, 0x01, 0x80, 0xCE, 0x07, 0x01, 0x98, 0x0C, 0x07, 0x30,
  0x18, 0x0C, 0x60, 0x30, 0x18, 0xC0, 0x60, 0x33, 0x80, 0xC0, 0x67, 0x03,
  0x81, 0xCC, 0x06, 0x03, 0x98, 0x0C, 0x06, 0x30, 0x18, 0x0C, 0x60, 0x30,
  0x19, 0xC0, 0x60, 0x33, 0x01, 0xC0, 0xE6, 0x03, 0x01, 0xCC, 0x06, 0x03,
  0x18, 0x0C, 0x06, 0x00, 0x1C, 0x3F, 0x03, 0x1F, 0xF0, 0x67, 0x0F, 0x0D,
  0x80, 0xE1, 0xE0, 0x0E, 0x38, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x07, 0x30,
  0x00, 0xE6, 0x00, 0x18, 0xC0, 0x03, 0x38, 0x00, 0x67, 0x00, 0x0C, 0xE0,
  0x03, 0x98, 0x00, 0x73, 0x00, 0x0C, 0x60, 0x01, 0x9C, 0x00, 0x33, 0x80,
  0x06, 0x60, 0x01, 0xCC, 0x00, 0x39, 0x80, 0x06, 0x00, 0x00, 0xFC, 0x00,
  0x7F, 0xE0, 0x1E, 0x0E, 0x07, 0x00, 0xE1, 0xC0, 0x0C, 0x70, 0x01, 0xCC,
  0x00, 0x1B, 0x80, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x37, 0x00, 0x0E, 0x60,
  0x01, 0x8C, 0x00, 0x71, 0xC0, 0x1C, 0x1C, 0x07, 0x01, 0xFF, 0xC0, 0x1F,
  0xE0, 0x00, 0x07, 0x1F, 0x80, 0x33, 0xFE, 0x01, 0xB8, 0x78, 0x0F, 0x00,
  0xE0, 0x70, 0x07, 0x03, 0x00, 0x18, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0C,
  0x00, 0x38, 0x60, 0x01, 0xC3, 0x00, 0x0E, 0x18, 0x00, 0x61, 0xC0, 0x03,
  0x0E, 0x00, 0x18, 0x60, 0x01, 0xC3, 0x00, 0x0C, 0x18, 0x00, 0xE0, 0xC0,
  0x06, 0x0F, 0x00, 0x70, 0x7C, 0x0F, 0x03, 0x3F, 0xF0, 0x18, 0xFE, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xF8, 0xE0,
  0xFF, 0x98, 0x3C, 0x1B, 0x0E, 0x01, 0xE3, 0x80, 0x1C, 0x60, 0x03, 0x9C,
  0x00, 0x73, 0x00, 0x0C, 0xE0, 0x01, 0x9C, 0x00, 0x33, 0x00, 0x06, 0x60,
  0x01, 0xCC, 0x00, 0x39, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0,
  0x07, 0x1C, 0x00, 0xE1, 0x80, 0x3C, 0x38, 0x1F, 0x03, 0xFF, 0x60, 0x3F,
  0x8C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0C, 0x1F, 0xC7,
  0x3F, 0xE1, 0xDF, 0x08, 0x6E, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x01,
  0xFC, 0x01, 0xFF, 0xC0, 0xF0, 0x78, 0x70, 0x07, 0x38, 0x01, 0xCC, 0x00,
  0x33, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0xC0,
  0x03, 0xB0, 0x00, 0xCE, 0x00, 0x71, 0xC0, 0x38, 0x3F, 0xFC, 0x07, 0xFE,
  0x00, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x38, 0x00, 0xE7, 0x00, 0x1C,
  0xE0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x9C, 0x00, 0x73,
  0x80, 0x0E, 0x60, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0xCE,
  0x00, 0x39, 0xC0, 0x07, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xE0, 0x07, 0x1C,
  0x00, 0xE1, 0x80, 0x3C, 0x38, 0x1F, 0x83, 0xFF, 0x60, 0x3F, 0x8C, 0x00,
  0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0x70, 0x00, 0xC6, 0x00, 0x38,
  0xC0, 0x06, 0x18, 0x01, 0xC3, 0x80, 0x30, 0x30, 0x0E, 0x06, 0x01, 0x80,
  0xC0, 0x70, 0x1C, 0x0C, 0x01, 0x83, 0x00, 0x30, 0xE0, 0x06, 0x18, 0x00,
  0xE7, 0x00, 0x0C, 0xC0, 0x01, 0xB8, 0x00, 0x36, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x1F, 0x01, 0xC0, 0x6C, 0x07,
  0x01, 0xB0, 0x1C, 0x0C, 0xC0, 0xF0, 0x33, 0x03, 0xC1, 0xCC, 0x1B, 0x06,
  0x30, 0x6C, 0x18, 0xC3, 0x30, 0xC3, 0x0C, 0xC3, 0x0C, 0x33, 0x0C, 0x31,
  0x8C, 0x60, 0xC6, 0x11, 0x83, 0x30, 0x46, 0x0C, 0xC1, 0xB0, 0x12, 0x06,
  0xC0, 0x58, 0x1E, 0x01, 0x60, 0x78, 0x07, 0x01, 0xE0, 0x1C, 0x07, 0x00,
  0x60, 0x1C, 0x01, 0x80, 0x60, 0x00, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0xE0,
  0x60, 0x07, 0x01, 0xC0, 0x38, 0x03, 0x81, 0xC0, 0x0E, 0x0E, 0x00, 0x1C,
  0x30, 0x00, 0x31, 0xC0, 0x00, 0xEE, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x70, 0x00, 0x38, 0xC0, 0x01,
  0xC3, 0x80, 0x07, 0x07, 0x00, 0x38, 0x0C, 0x01, 0xC0, 0x38, 0x0E, 0x00,
  0x60, 0x70, 0x01, 0xC3, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x03, 0x87, 0x00,
  0x01, 0x81, 0x80, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x18,
  0x00, 0xE0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x70, 0x03, 0x80, 0x70, 0x00,
  0xC0, 0x38, 0x00, 0x60, 0x38, 0x00, 0x38, 0x18, 0x00, 0x0C, 0x1C, 0x00,
  0x06, 0x0C, 0x00, 0x03, 0x0E, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x37, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x09, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC4, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0xC0, 0x07, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C,
  0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0xC0,
  0xC0, 0xC0, 0x01, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xF8, 0x00, 0x60, 0x00, 0x0F, 0x00,
  0x00, 0xFF, 0x00, 0x37, 0x9E, 0x00, 0xD8, 0x1C, 0x06, 0xE0, 0x38, 0x3B,
  0x00, 0x7F, 0xCC, 0x00, 0xFE, 0x00, 0x00, 0x40,
};

const GFXglyph RobotoMono_LightItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 8, 29, 24, 8, -29 },
  { 30, 10, 9, 24, 9, -31 },
  { 42, 23, 29, 24, 1, -29 },
  { 126, 19, 38, 24, 3, -34 },
  { 217, 19, 30, 24, 3, -30 },
  { 289, 20, 30, 24, 2, -30 },
  { 364, 3, 9, 24, 12, -31 },
  { 368, 13, 42, 24, 7, -33 },
  { 437, 12, 42, 24, 4, -33 },
  { 500, 18, 18, 24, 5, -29 },
  { 541, 20, 21, 24, 2, -24 },
  { 594, 5, 10, 24, 5, -4 },
  { 601, 15, 2, 24, 4, -14 },
  { 605, 4, 4, 24, 9, -4 },
  { 607, 19, 31, 24, 3, -29 },
  { 681, 19, 30, 24, 3, -30 },
  { 753, 11, 29, 24, 6, -29 },
  { 793, 20, 30, 24, 1, -30 },
  { 868, 20, 30, 24, 1, -30 },
  { 943, 20, 29, 24, 1, -29 },
  { 1016, 21, 29, 24, 3, -29 },
  { 1093, 18, 29, 24, 2, -29 },
  { 1159, 19, 29, 24, 5, -29 },
  { 1228, 21, 30, 24, 2, -30 },
  { 1307, 18, 30, 24, 4, -30 },
  { 1375, 7, 22, 24, 10, -22 },
  { 1395, 10, 28, 24, 7, -22 },
  { 1430, 19, 17, 24, 3, -22 },
  { 1471, 19, 10, 24, 3, -18 },
  { 1495, 19, 17, 24, 2, -22 },
  { 1536, 16, 30, 24, 6, -30 },
  { 1596, 23, 29, 24, 1, -29 },
  { 1680, 20, 29, 24, 0, -29 },
  { 1753, 20, 29, 24, 2, -29 },
  { 1826, 21, 30, 24, 2, -30 },
  { 1905, 22, 29, 24, 1, -29 },
  { 1985, 22, 29, 24, 2, -29 },
  { 2065, 22, 29, 24, 2, -29 },
  { 2145, 21, 30, 24, 2, -30 },
  { 2224, 23, 29, 24, 1, -29 },
  { 2308, 21, 29, 24, 2, -29 },
  { 2385, 22, 29, 24, 1, -29 },
  { 2465, 23, 29, 24, 2, -29 },
  { 2549, 17, 29, 24, 2, -29 },
  { 2611, 23, 29, 24, 1, -29 },
  { 2695, 23, 29, 24, 1, -29 },
  { 2779, 20, 30, 24, 2, -30 },
  { 2854, 22, 29, 24, 2, -29 },
  { 2934, 21, 35, 24, 2, -30 },
  { 3026, 21, 29, 24, 2, -29 },
  { 3103, 21, 30, 24, 2, -30 },
  { 3182, 21, 29, 24, 4, -29 },
  { 3259, 22, 29, 24, 2, -29 },
  { 3339, 21, 29, 24, 4, -29 },
  { 3416, 22, 29, 24, 4, -29 },
  { 3496, 25, 29, 24, 0, -29 },
  { 3587, 21, 29, 24, 4, -29 },
  { 3664, 22, 29, 24, 1, -29 },
  { 3744, 13, 39, 24, 6, -33 },
  { 3808, 8, 32, 24, 8, -29 },
  { 3840, 13, 39, 24, 5, -33 },
  { 3904, 14, 16, 24, 5, -29 },
  { 3932, 17, 2, 24, 1, 0 },
  { 3937, 5, 5, 24, 12, -30 },
  { 3941, 19, 22, 24, 2, -22 },
  { 3994, 19, 31, 24, 2, -31 },
  { 4068, 18, 22, 24, 3, -22 },
  { 4118, 20, 31, 24, 3, -31 },
  { 4196, 19, 22, 24, 2, -22 },
  { 4249, 20, 31, 24, 5, -31 },
  { 4327, 21, 31, 24, 1, -22 },
  { 4409, 19, 31, 24, 2, -31 },
  { 4483, 18, 29, 24, 2, -29 },
  { 4549, 19, 38, 24, 0, -29 },
  { 4640, 20, 31, 24, 2, -31 },
  { 4718, 18, 31, 24, 2, -31 },
  { 4788, 23, 22, 24, 0, -22 },
  { 4852, 19, 22, 24, 2, -22 },
  { 4905, 19, 22, 24, 2, -22 },
  { 4958, 21, 30, 24, 0, -22 },
  { 5037, 19, 30, 24, 3, -22 },
  { 5109, 18, 22, 24, 5, -22 },
  { 5159, 18, 22, 24, 3, -22 },
  { 5209, 16, 27, 24, 5, -27 },
  { 5263, 19, 22, 24, 3, -22 },
  { 5316, 19, 22, 24, 4, -22 },
  { 5369, 22, 22, 24, 3, -22 },
  { 5430, 22, 22, 24, 1, -22 },
  { 5491, 25, 31, 24, -1, -22 },
  { 5588, 21, 22, 24, 1, -22 },
  { 5646, 16, 40, 24, 6, -32 },
  { 5726, 8, 36, 24, 8, -29 },
  { 5762, 16, 40, 24, 3, -32 },
  { 5842, 22, 8, 24, 1, -16 },
};

const GFXfont RobotoMono_LightItalic41pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic41pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic41pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _ROBOTOMONO_LIGHTITALIC41PT7B_H_
