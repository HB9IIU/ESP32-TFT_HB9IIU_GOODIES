#ifndef _ROBOTOMONO_LIGHTITALIC46PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0C, 0x06, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0x03, 0x03,
  0x81, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x03, 0xC1,
  0xE0, 0xE0, 0x00, 0x30, 0x66, 0x0C, 0xC3, 0x98, 0x77, 0x0C, 0xE1, 0x98,
  0x33, 0x06, 0x61, 0xCC, 0x33, 0x86, 0x00, 0x00, 0x07, 0x03, 0x80, 0x01,
  0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x38, 0x1C, 0x00, 0x0C, 0x06, 0x00,
  0x03, 0x01, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x60, 0x30, 0x00, 0x18, 0x0C,
  0x00, 0x0C, 0x06, 0x00, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x00, 0x60,
  0x30, 0x00, 0x18, 0x0C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x01, 0x80, 0x00,
  0xC0, 0x60, 0x00, 0x70, 0x38, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x03, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0xC0, 0x60, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF0, 0x06, 0x03, 0x00, 0x03, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x30,
  0x18, 0x00, 0x1C, 0x0E, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0xE0, 0x70, 0x00, 0x30, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x7C, 0x3C, 0x03, 0xC0, 0x78, 0x1C, 0x00, 0xE0, 0x60,
  0x01, 0x83, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x30, 0x00, 0x70, 0xC0, 0x01,
  0xC3, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x18, 0x60,
  0x00, 0xE1, 0xC0, 0x07, 0x87, 0x80, 0x3C, 0x0F, 0x03, 0xE0, 0x1F, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x03,
  0x0E, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x23, 0x81, 0x80, 0xCC, 0x06,
  0x06, 0x30, 0x18, 0x38, 0xC0, 0x61, 0xC3, 0x01, 0x86, 0x0C, 0x0C, 0x30,
  0x38, 0x71, 0xC0, 0x77, 0x86, 0x00, 0xFC, 0x30, 0x01, 0xC1, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0xFC, 0x01, 0x87, 0xF8, 0x0E, 0x38, 0x60, 0x31, 0xC1, 0xC1, 0x86, 0x03,
  0x0E, 0x18, 0x0C, 0x30, 0x60, 0x31, 0x83, 0x81, 0xCE, 0x0E, 0x06, 0x30,
  0x38, 0x18, 0x00, 0x60, 0xE0, 0x01, 0x83, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xC7,
  0x00, 0x0E, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x0C, 0x00, 0xC0, 0x38,
  0x01, 0x80, 0x70, 0x03, 0x00, 0xC0, 0x06, 0x03, 0x80, 0x0E, 0x0E, 0x00,
  0x1C, 0x38, 0x00, 0x39, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x38, 0xE0, 0x38, 0xE1,
  0xC0, 0x73, 0x81, 0xC0, 0xEE, 0x01, 0xC1, 0x9C, 0x03, 0x87, 0x70, 0x03,
  0x8E, 0xE0, 0x07, 0x39, 0xC0, 0x07, 0x63, 0x80, 0x07, 0xC7, 0x00, 0x0F,
  0x0E, 0x00, 0x1E, 0x0E, 0x00, 0xFE, 0x0E, 0x03, 0xDC, 0x0F, 0xFE, 0x1C,
  0x0F, 0xF8, 0x3C, 0x37, 0x77, 0x66, 0x6E, 0xCC, 0xC0, 0x00, 0x04, 0x00,
  0x30, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03,
  0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xC0,
  0x07, 0x00, 0x38, 0x03, 0x80, 0x0C, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x40, 0x60, 0x2F, 0x06, 0x0E, 0xFC, 0x67, 0xF3, 0xFF, 0xF8, 0x07, 0xFC,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x33, 0x00, 0x07, 0x38, 0x00, 0xE1,
  0x80, 0x1C, 0x1C, 0x03, 0x80, 0xE0, 0x70, 0x0F, 0x02, 0x00, 0x40, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x38, 0x70, 0xE1, 0xC7, 0x0E, 0x38,
  0x71, 0xC1, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1E, 0x1F, 0x00,
  0xE0, 0x1C, 0x07, 0x00, 0x38, 0x38, 0x00, 0x60, 0xC0, 0x01, 0x87, 0x00,
  0x07, 0x18, 0x00, 0x1C, 0xE0, 0x00, 0xF3, 0x80, 0x07, 0xCC, 0x00, 0x3F,
  0x30, 0x01, 0xDD, 0xC0, 0x1E, 0x67, 0x00, 0xE1, 0x9C, 0x07, 0x06, 0x70,
  0x38, 0x39, 0x83, 0xC0, 0xE6, 0x1C, 0x03, 0xB8, 0xE0, 0x0C, 0xE7, 0x00,
  0x33, 0xF8, 0x01, 0xCF, 0x80, 0x07, 0x3C, 0x00, 0x1C, 0xE0, 0x00, 0x63,
  0x80, 0x03, 0x8E, 0x00, 0x0C, 0x18, 0x00, 0x70, 0x70, 0x03, 0x80, 0xC0,
  0x1C, 0x03, 0xC0, 0xF0, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x10,
  0x07, 0x03, 0xF0, 0xFF, 0x7F, 0x7F, 0x87, 0xE0, 0x68, 0x06, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00,
  0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1E, 0x0F, 0x00, 0xE0, 0x1E, 0x07,
  0x00, 0x38, 0x38, 0x00, 0x70, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00,
  0x1C, 0x60, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0xE0, 0x07, 0xC3, 0xE0, 0x1E, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0xE0, 0x03,
  0x83, 0x80, 0x03, 0x07, 0x00, 0x06, 0x1C, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80, 0x01,
  0xC3, 0x00, 0x07, 0x07, 0x00, 0x0E, 0x0F, 0x00, 0x78, 0x0F, 0x01, 0xE0,
  0x0F, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x37, 0x00,
  0x00, 0xEE, 0x00, 0x03, 0x98, 0x00, 0x0E, 0x30, 0x00, 0x38, 0x60, 0x00,
  0xE1, 0xC0, 0x01, 0x83, 0x80, 0x07, 0x07, 0x00, 0x1C, 0x0C, 0x00, 0x70,
  0x18, 0x01, 0xC0, 0x70, 0x03, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0xE0, 0x06, 0x03, 0x80, 0x0C, 0x0E, 0x00, 0x38, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0xFC, 0x00, 0x6F, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0x80,
  0xF0, 0x18, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0xE3, 0x00, 0x03, 0x8C, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x03,
  0x81, 0xC0, 0x1C, 0x03, 0x81, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x39, 0xFF, 0x03, 0x3F, 0xF8, 0x77,
  0x03, 0xC6, 0xC0, 0x1C, 0x78, 0x00, 0xE7, 0x00, 0x0E, 0xE0, 0x00, 0x6E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x6E, 0x00, 0x06,
  0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xC6, 0x00, 0x1C, 0x70, 0x03,
  0x83, 0x80, 0x78, 0x3C, 0x0F, 0x01, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x7F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80,
  0x1F, 0x0F, 0x00, 0xF0, 0x0E, 0x07, 0x00, 0x1C, 0x3C, 0x00, 0x70, 0xE0,
  0x01, 0xC3, 0x80, 0x03, 0x0C, 0x00, 0x1C, 0x70, 0x00, 0x70, 0xC0, 0x01,
  0xC3, 0x00, 0x0E, 0x0E, 0x00, 0x38, 0x1C, 0x03, 0xC0, 0x78, 0x1E, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0x1E, 0x01, 0xE0, 0x1E, 0x0E, 0x00,
  0x38, 0x70, 0x00, 0x71, 0xC0, 0x01, 0xCE, 0x00, 0x03, 0x38, 0x00, 0x0C,
  0xE0, 0x00, 0x33, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x38, 0xE0,
  0x01, 0xE1, 0xC0, 0x0F, 0x03, 0xC0, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xC3, 0xC0, 0xF0, 0x1E, 0x1C,
  0x00, 0xE1, 0xC0, 0x07, 0x38, 0x00, 0x73, 0x00, 0x07, 0x70, 0x00, 0x37,
  0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x07,
  0x60, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0xF7, 0x00, 0x1E, 0x38, 0x07,
  0x61, 0xE1, 0xEE, 0x0F, 0xFC, 0xE0, 0x7F, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x00,
  0x0E, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0xF0, 0xF8, 0xF0,
  0x01, 0xC0, 0x7C, 0x0F, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00,
  0xE0, 0x18, 0x07, 0x01, 0xC0, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F,
  0x00, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x80, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xE0, 0x18, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xF1, 0xF0, 0xF0, 0x1E,
  0x70, 0x03, 0x9C, 0x00, 0xEE, 0x00, 0x1B, 0x80, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xC1, 0xE0, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x03, 0x00, 0xE0,
  0x00, 0x60, 0x70, 0x00, 0x18, 0x18, 0x1F, 0x06, 0x0C, 0x1F, 0xE1, 0x87,
  0x0E, 0x1C, 0x21, 0x83, 0x06, 0x0C, 0x61, 0x81, 0x83, 0x30, 0x60, 0x60,
  0x8C, 0x30, 0x10, 0x26, 0x0C, 0x0C, 0x19, 0x86, 0x03, 0x06, 0x61, 0x80,
  0xC1, 0x98, 0x60, 0x20, 0x64, 0x18, 0x18, 0x13, 0x06, 0x06, 0x0C, 0xC3,
  0x03, 0x83, 0x30, 0xC0, 0xE0, 0x8C, 0x38, 0x78, 0x63, 0x06, 0x36, 0x30,
  0xC1, 0xF9, 0xFC, 0x18, 0x3C, 0x3C, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x30, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xEC, 0x00,
  0x01, 0x98, 0x00, 0x07, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x38, 0xE0, 0x00,
  0x61, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x07, 0x00, 0x0E, 0x06, 0x00, 0x1C,
  0x0C, 0x00, 0x70, 0x18, 0x00, 0xE0, 0x30, 0x03, 0x80, 0x70, 0x07, 0x00,
  0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x01, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x71,
  0xC0, 0x00, 0xE3, 0x80, 0x00, 0xC6, 0x00, 0x01, 0x9C, 0x00, 0x03, 0x30,
  0x00, 0x07, 0xE0, 0x00, 0x0E, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x38, 0x01, 0xE0, 0x60, 0x01, 0xC0, 0xC0, 0x01, 0xC3, 0x80,
  0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x30, 0x00,
  0x30, 0x60, 0x00, 0xE1, 0xC0, 0x03, 0x83, 0x80, 0x0F, 0x07, 0x00, 0x78,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x30, 0x03, 0xC0, 0xE0, 0x01, 0xC1,
  0xC0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18,
  0x00, 0x0C, 0x70, 0x00, 0x18, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x00,
  0x03, 0x86, 0x00, 0x0E, 0x0C, 0x00, 0x7C, 0x38, 0x03, 0xF0, 0x7F, 0xFF,
  0x80, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0x83,
  0xC0, 0x1C, 0x03, 0xC0, 0x70, 0x03, 0x81, 0xC0, 0x03, 0x87, 0x00, 0x07,
  0x0E, 0x00, 0x06, 0x38, 0x00, 0x0C, 0x70, 0x00, 0x1C, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x18, 0xC0, 0x00, 0x71, 0xC0, 0x00, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x0E,
  0x07, 0x00, 0x1C, 0x0E, 0x00, 0xF0, 0x0F, 0x03, 0xC0, 0x0F, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x06, 0x00, 0xF0, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x1C,
  0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x0C, 0x00, 0x0E, 0x0C, 0x00, 0x0E,
  0x1C, 0x00, 0x06, 0x1C, 0x00, 0x06, 0x1C, 0x00, 0x06, 0x1C, 0x00, 0x06,
  0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E,
  0x38, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x1C,
  0x70, 0x00, 0x1C, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x60, 0x00, 0x70,
  0x60, 0x00, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x03, 0xC0, 0xE0, 0x0F, 0x80,
  0xE0, 0x7E, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0xF8, 0xF8, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x1E, 0x07,
  0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x06, 0x1C, 0x00, 0x07, 0x1C,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x0F, 0xFC, 0x60, 0x0F, 0xFC, 0x60, 0x0F, 0xFC, 0x60, 0x00, 0x1C, 0xE0,
  0x00, 0x1C, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x70,
  0x00, 0x38, 0x70, 0x00, 0x38, 0x30, 0x00, 0x38, 0x38, 0x00, 0x30, 0x1C,
  0x00, 0xF0, 0x1E, 0x03, 0xE0, 0x0F, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x60, 0x70, 0x00, 0x18,
  0x1C, 0x00, 0x06, 0x07, 0x00, 0x03, 0x81, 0x80, 0x00, 0xE0, 0x60, 0x00,
  0x38, 0x18, 0x00, 0x0C, 0x0E, 0x00, 0x03, 0x03, 0x80, 0x00, 0xC0, 0xE0,
  0x00, 0x70, 0x30, 0x00, 0x1C, 0x0C, 0x00, 0x07, 0x03, 0x00, 0x01, 0x81,
  0xC0, 0x00, 0x60, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x06, 0x00, 0x03,
  0x81, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x30, 0x38, 0x00, 0x0C, 0x0E, 0x00,
  0x07, 0x03, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x18, 0x1C,
  0x00, 0x06, 0x07, 0x00, 0x01, 0x81, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x38,
  0x18, 0x00, 0x0E, 0x06, 0x00, 0x03, 0x03, 0x80, 0x00, 0xC0, 0xE0, 0x00,
  0x30, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xE0, 0xE0,
  0x00, 0xE0, 0xE0, 0x01, 0xC0, 0xE0, 0x03, 0xC0, 0x70, 0x07, 0x80, 0x3C,
  0x1F, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x1C,
  0x01, 0x80, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x03, 0x80, 0x0E, 0x01,
  0xC0, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x30, 0x38, 0x00, 0x0C,
  0x1C, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x77, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xEE, 0x00, 0x01, 0xF1, 0xC0, 0x00, 0xF8, 0x70,
  0x00, 0x3C, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x80, 0x70, 0x00, 0xC0,
  0x1C, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x01,
  0xC0, 0x07, 0x00, 0x60, 0x00, 0xE0, 0x18, 0x00, 0x3C, 0x0E, 0x00, 0x07,
  0x03, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x03, 0xC0, 0xF0,
  0x00, 0xF0, 0x3C, 0x00, 0x7C, 0x1F, 0x00, 0x1E, 0x07, 0xC0, 0x0F, 0x81,
  0xF0, 0x03, 0x60, 0x6C, 0x01, 0xF8, 0x1B, 0x80, 0x6E, 0x06, 0xE0, 0x3B,
  0x83, 0x98, 0x1C, 0xC0, 0xE6, 0x07, 0x30, 0x39, 0x83, 0x8C, 0x0C, 0x60,
  0xC7, 0x03, 0x1C, 0x71, 0xC0, 0xC7, 0x18, 0x70, 0x70, 0xCE, 0x18, 0x1C,
  0x33, 0x06, 0x07, 0x0D, 0xC3, 0x81, 0x83, 0x60, 0xE0, 0x60, 0xF8, 0x38,
  0x38, 0x3C, 0x0C, 0x0E, 0x07, 0x03, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x00,
  0x70, 0x30, 0x00, 0x1C, 0x0C, 0x00, 0x07, 0x07, 0x00, 0x01, 0x81, 0xC0,
  0x00, 0x60, 0x70, 0x00, 0x18, 0x1C, 0x00, 0x0E, 0x06, 0x00, 0x03, 0x81,
  0x80, 0x00, 0xE0, 0xE0, 0x00, 0x30, 0x00, 0x03, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x60, 0x78, 0x00, 0x18, 0x1F, 0x00, 0x0E, 0x07, 0xC0, 0x03, 0x81,
  0xF0, 0x00, 0xE0, 0x6E, 0x00, 0x38, 0x1B, 0x80, 0x0C, 0x0E, 0x60, 0x03,
  0x03, 0x9C, 0x01, 0xC0, 0xE7, 0x00, 0x70, 0x38, 0xC0, 0x1C, 0x0C, 0x38,
  0x07, 0x03, 0x0E, 0x01, 0x81, 0xC1, 0x80, 0x60, 0x70, 0x70, 0x38, 0x1C,
  0x0C, 0x0E, 0x07, 0x03, 0x83, 0x81, 0x80, 0xE0, 0xC0, 0x60, 0x18, 0x30,
  0x38, 0x07, 0x1C, 0x0E, 0x01, 0xC7, 0x03, 0x80, 0x31, 0xC0, 0xC0, 0x0E,
  0x70, 0x30, 0x03, 0x98, 0x1C, 0x00, 0x66, 0x07, 0x00, 0x1F, 0x81, 0xC0,
  0x07, 0xE0, 0x70, 0x00, 0xF8, 0x18, 0x00, 0x3E, 0x06, 0x00, 0x07, 0x03,
  0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF,
  0x00, 0x1F, 0x1E, 0x01, 0xE0, 0x1C, 0x07, 0x00, 0x38, 0x38, 0x00, 0xE1,
  0xC0, 0x01, 0x87, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x00,
  0x00, 0xDC, 0x00, 0x03, 0x70, 0x00, 0x0D, 0x80, 0x00, 0x76, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x6E, 0x00, 0x01, 0xB0,
  0x00, 0x0E, 0xC0, 0x00, 0x3B, 0x00, 0x00, 0xEC, 0x00, 0x03, 0x30, 0x00,
  0x1C, 0xC0, 0x00, 0x73, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x18, 0x00, 0x70,
  0x70, 0x03, 0x81, 0xE0, 0x1E, 0x03, 0xC1, 0xF0, 0x07, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0xE0, 0x03, 0xC0, 0x70, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C,
  0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x07, 0x00, 0x01, 0x83, 0x80, 0x00,
  0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x60, 0x00, 0x70, 0x30, 0x00,
  0x78, 0x38, 0x00, 0x78, 0x1C, 0x00, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xF8, 0xF8, 0x03, 0xC0, 0x3C, 0x07, 0x80,
  0x1C, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0C, 0x00, 0x06, 0x1C, 0x00,
  0x06, 0x18, 0x00, 0x07, 0x38, 0x00, 0x07, 0x38, 0x00, 0x07, 0x30, 0x00,
  0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x06, 0x70, 0x00, 0x06, 0x60, 0x00,
  0x0E, 0x60, 0x00, 0x0E, 0x60, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x0C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x18, 0xE0, 0x00,
  0x38, 0x60, 0x00, 0x30, 0x70, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x38, 0x01,
  0xE0, 0x38, 0x03, 0xC0, 0x1E, 0x0F, 0x80, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x40, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xF8, 0x07, 0x00, 0x3C, 0x07, 0x00, 0x1C, 0x06, 0x00,
  0x0E, 0x06, 0x00, 0x0E, 0x06, 0x00, 0x06, 0x0E, 0x00, 0x06, 0x0E, 0x00,
  0x06, 0x0E, 0x00, 0x0E, 0x0C, 0x00, 0x0E, 0x0C, 0x00, 0x0E, 0x1C, 0x00,
  0x1C, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x1C, 0x01, 0xE0, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x38, 0x07, 0x00, 0x38, 0x07, 0x00, 0x38, 0x03,
  0x00, 0x38, 0x03, 0x80, 0x30, 0x03, 0x80, 0x30, 0x01, 0x80, 0x70, 0x01,
  0xC0, 0x70, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x60, 0x00,
  0xE0, 0x60, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xF0, 0x78, 0x03, 0xC0, 0x1C, 0x07, 0x00,
  0x0E, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x06, 0x0E, 0x00, 0x07, 0x0C, 0x00,
  0x07, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x18, 0xE0, 0x00, 0x18, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00,
  0x70, 0x38, 0x00, 0xE0, 0x1E, 0x03, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x07, 0x0C, 0x00, 0x06, 0x1C, 0x00, 0x06, 0x1C, 0x00, 0x06,
  0x1C, 0x00, 0x0E, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x0C,
  0x38, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x1C,
  0x30, 0x00, 0x1C, 0x30, 0x00, 0x18, 0x70, 0x00, 0x18, 0x70, 0x00, 0x38,
  0x70, 0x00, 0x38, 0x60, 0x00, 0x38, 0x60, 0x00, 0x38, 0xE0, 0x00, 0x30,
  0xE0, 0x00, 0x30, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xC0, 0x00, 0x70,
  0xC0, 0x00, 0x60, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xC0,
  0x70, 0x03, 0x80, 0x70, 0x07, 0x80, 0x3C, 0x1F, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77,
  0x00, 0x01, 0xC6, 0x00, 0x03, 0x8C, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38,
  0x00, 0x30, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0x80, 0xC0, 0x07, 0x01, 0x80,
  0x0E, 0x03, 0x00, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x03,
  0x80, 0x38, 0x0E, 0x00, 0x30, 0x1C, 0x00, 0x60, 0x30, 0x00, 0xC0, 0xE0,
  0x01, 0xC1, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0C, 0x00, 0x06, 0x38, 0x00,
  0x0C, 0x60, 0x00, 0x19, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x0C, 0x03, 0xB0, 0x0E, 0x01, 0x98, 0x07, 0x00, 0xCC,
  0x03, 0x80, 0xE6, 0x03, 0xC0, 0x63, 0x01, 0xE0, 0x31, 0x81, 0xF0, 0x38,
  0xC0, 0xD8, 0x1C, 0x60, 0x6C, 0x0C, 0x30, 0x76, 0x06, 0x18, 0x33, 0x07,
  0x0C, 0x19, 0x83, 0x06, 0x1C, 0xC1, 0x83, 0x0C, 0x61, 0xC1, 0x86, 0x30,
  0xE0, 0xC7, 0x18, 0x60, 0x63, 0x0C, 0x30, 0x31, 0x86, 0x38, 0x19, 0xC3,
  0x18, 0x1C, 0xC1, 0x8C, 0x0E, 0x60, 0xCE, 0x07, 0x70, 0x66, 0x03, 0xB0,
  0x3B, 0x01, 0xD8, 0x1D, 0x80, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x3E,
  0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03,
  0xC0, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x3C,
  0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x07,
  0x01, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x70,
  0x00, 0x01, 0x8F, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x38, 0x07, 0x00, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x01, 0xC0, 0x01, 0x80, 0x38, 0x00, 0x1C, 0x07, 0x80,
  0x01, 0xC0, 0xF0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x39,
  0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x07, 0x07, 0x00, 0x1C, 0x0E,
  0x00, 0x38, 0x1C, 0x00, 0xE0, 0x18, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70,
  0x1C, 0x00, 0x60, 0x30, 0x00, 0xE0, 0xE0, 0x01, 0xC3, 0x80, 0x01, 0x86,
  0x00, 0x03, 0x1C, 0x00, 0x07, 0x70, 0x00, 0x06, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x84, 0x0F, 0xE0, 0x3F, 0x80, 0xC0, 0x70, 0x38, 0x0C, 0x06, 0x03,
  0x01, 0xC0, 0xE0, 0x30, 0x18, 0x0C, 0x07, 0x03, 0x80, 0xC0, 0x60, 0x30,
  0x1C, 0x0E, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x38, 0x0C, 0x06, 0x03, 0x01,
  0xC0, 0xE0, 0x30, 0x18, 0x0C, 0x07, 0x03, 0x80, 0xC0, 0x60, 0x30, 0x01,
  0xFE, 0x03, 0xF8, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x30,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF8, 0x01, 0xB8, 0x03, 0x98,
  0x03, 0x18, 0x07, 0x1C, 0x0E, 0x1C, 0x0C, 0x0C, 0x1C, 0x0C, 0x18, 0x0C,
  0x38, 0x0E, 0x30, 0x0E, 0x70, 0x06, 0xE0, 0x06, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xE1, 0xC7, 0x0E, 0x18, 0x70, 0x00, 0x1E, 0x00, 0x07,
  0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0x00, 0xE0, 0xE0, 0x03, 0x87, 0x00, 0x1C,
  0x70, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0x80, 0x18, 0xF0, 0x01, 0xCF,
  0x00, 0x0E, 0x70, 0x00, 0x73, 0x00, 0x03, 0x18, 0x00, 0x39, 0xC0, 0x01,
  0xC6, 0x00, 0x1E, 0x38, 0x03, 0xF1, 0xE0, 0x7B, 0x87, 0xFF, 0x9C, 0x0F,
  0xF0, 0xE0, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x83, 0xC0, 0x1C, 0xFF, 0x80, 0xCF, 0xFE,
  0x06, 0xE0, 0x78, 0x3C, 0x01, 0xC3, 0xC0, 0x07, 0x1C, 0x00, 0x38, 0xE0,
  0x01, 0xC7, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x01, 0x9C, 0x00, 0x0C,
  0xE0, 0x00, 0x67, 0x00, 0x07, 0x30, 0x00, 0x39, 0x80, 0x01, 0xDC, 0x00,
  0x0C, 0xE0, 0x00, 0xE7, 0x00, 0x06, 0x38, 0x00, 0x71, 0xE0, 0x07, 0x0F,
  0x00, 0x78, 0xEE, 0x0F, 0x87, 0x3F, 0xF8, 0x38, 0xFF, 0x00, 0x00, 0x3E,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0x01, 0xC0, 0xE0, 0x07, 0x0E,
  0x00, 0x38, 0xE0, 0x00, 0xC7, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x07, 0x38, 0x00, 0x38,
  0xC0, 0x01, 0x87, 0x00, 0x1C, 0x1C, 0x01, 0xC0, 0xF0, 0x3C, 0x03, 0xFF,
  0xC0, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x60,
  0x0F, 0xF9, 0xC0, 0x7F, 0xFB, 0x81, 0xE0, 0x3F, 0x07, 0x80, 0x3E, 0x0E,
  0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80,
  0x03, 0x86, 0x00, 0x07, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x18, 0x70, 0x00,
  0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x06,
  0x0E, 0x00, 0x0C, 0x0C, 0x00, 0x38, 0x1C, 0x00, 0xF0, 0x38, 0x03, 0xE0,
  0x3C, 0x1F, 0xC0, 0x3F, 0xF3, 0x00, 0x3F, 0xC6, 0x00, 0x00, 0x3E, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0x01, 0xC0, 0xE0, 0x07, 0x0E, 0x00,
  0x38, 0xE0, 0x00, 0xC7, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xD8,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x0C, 0x1C, 0x00, 0xE0, 0xF0, 0x1E, 0x03, 0xFF, 0xE0,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7C, 0x08,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x03, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFE, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0xFF, 0x8C, 0x07, 0xFF, 0xB8, 0x1E, 0x03, 0xF0, 0x78, 0x03, 0xE0, 0xE0,
  0x03, 0xC3, 0x80, 0x07, 0x07, 0x00, 0x06, 0x1C, 0x00, 0x1C, 0x38, 0x00,
  0x38, 0x60, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0x87, 0x00, 0x07,
  0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x60,
  0xE0, 0x00, 0xC0, 0xC0, 0x03, 0x81, 0xC0, 0x0F, 0x03, 0x80, 0x3E, 0x03,
  0xC1, 0xFC, 0x03, 0xFF, 0xB0, 0x03, 0xFC, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x70, 0x38, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0x3F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x83, 0xE0, 0x18, 0x7F, 0xC0, 0xCF, 0xFF, 0x06,
  0xE0, 0x38, 0x7E, 0x00, 0xE3, 0xC0, 0x07, 0x1E, 0x00, 0x18, 0xE0, 0x00,
  0xC6, 0x00, 0x06, 0x30, 0x00, 0x33, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xE0,
  0x00, 0xE7, 0x00, 0x07, 0x30, 0x00, 0x31, 0x80, 0x01, 0x9C, 0x00, 0x1C,
  0xE0, 0x00, 0xE7, 0x00, 0x07, 0x30, 0x00, 0x39, 0x80, 0x01, 0x9C, 0x00,
  0x0C, 0xE0, 0x00, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x0F, 0xFE,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x08, 0x70, 0x01, 0xE0,
  0xE0, 0x07, 0x81, 0xC0, 0x1E, 0x03, 0x80, 0x78, 0x06, 0x01, 0xC0, 0x0C,
  0x0F, 0x00, 0x38, 0x3C, 0x00, 0x70, 0xF0, 0x00, 0xE3, 0xC0, 0x01, 0xDE,
  0x00, 0x03, 0x7C, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xB8, 0x00, 0x3C, 0x38,
  0x00, 0x70, 0x78, 0x00, 0xE0, 0x70, 0x01, 0x80, 0x70, 0x07, 0x00, 0xF0,
  0x0E, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x60, 0x01, 0xC0,
  0xC0, 0x01, 0xC3, 0x80, 0x03, 0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78,
  0x1E, 0x03, 0x7F, 0x9F, 0xC1, 0xFF, 0xEF, 0xF8, 0x7C, 0x3F, 0x06, 0x1C,
  0x07, 0x81, 0xC7, 0x01, 0xC0, 0x71, 0x80, 0x70, 0x1C, 0x60, 0x18, 0x07,
  0x38, 0x06, 0x01, 0x8E, 0x03, 0x80, 0x63, 0x80, 0xE0, 0x18, 0xC0, 0x38,
  0x0E, 0x30, 0x0C, 0x03, 0x8C, 0x03, 0x00, 0xC7, 0x00, 0xC0, 0x31, 0xC0,
  0x70, 0x0C, 0x70, 0x1C, 0x03, 0x18, 0x07, 0x01, 0xC6, 0x01, 0x80, 0x71,
  0x80, 0x60, 0x18, 0xE0, 0x18, 0x06, 0x38, 0x0E, 0x01, 0x8E, 0x03, 0x80,
  0xE3, 0x00, 0xE0, 0x38, 0xC0, 0x30, 0x0E, 0x00, 0x00, 0x0F, 0x80, 0x61,
  0xFF, 0x03, 0x3F, 0xFC, 0x1B, 0x80, 0xE1, 0xF8, 0x03, 0x8F, 0x00, 0x1C,
  0x78, 0x00, 0x63, 0x80, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xCE, 0x00,
  0x0E, 0x70, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x18, 0xC0, 0x00, 0xCE,
  0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xC0, 0x00,
  0xC6, 0x00, 0x06, 0x70, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xE0,
  0x00, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xE0,
  0x3C, 0x0F, 0x00, 0x70, 0x78, 0x00, 0xE1, 0xC0, 0x03, 0x8E, 0x00, 0x07,
  0x38, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x60,
  0x00, 0x1D, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xB8, 0x00, 0x0E, 0xE0, 0x00,
  0x39, 0x80, 0x00, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x38, 0x30, 0x01, 0xE0,
  0xE0, 0x0F, 0x01, 0xE0, 0x78, 0x03, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x00,
  0x87, 0xC0, 0x06, 0x3F, 0xE0, 0x0C, 0xFF, 0xE0, 0x1F, 0x01, 0xE0, 0x7C,
  0x01, 0xC0, 0xF0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x06, 0x00,
  0x0E, 0x0C, 0x00, 0x0C, 0x38, 0x00, 0x18, 0x70, 0x00, 0x30, 0xE0, 0x00,
  0xE1, 0xC0, 0x01, 0xC3, 0x00, 0x03, 0x86, 0x00, 0x06, 0x1C, 0x00, 0x1C,
  0x38, 0x00, 0x38, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x07, 0x03,
  0xC0, 0x1E, 0x0F, 0xC0, 0xF8, 0x1D, 0xFF, 0xE0, 0x38, 0xFF, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x0F, 0xF8, 0xC1, 0xFF, 0xEE, 0x1E, 0x03, 0xF1,
  0xE0, 0x0F, 0x8E, 0x00, 0x3C, 0xE0, 0x01, 0xC7, 0x00, 0x06, 0x70, 0x00,
  0x73, 0x80, 0x03, 0x98, 0x00, 0x1D, 0xC0, 0x00, 0xCE, 0x00, 0x06, 0x70,
  0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x06,
  0x38, 0x00, 0x31, 0xC0, 0x03, 0x87, 0x00, 0x3C, 0x38, 0x03, 0xE0, 0xF0,
  0x7F, 0x03, 0xFF, 0xB0, 0x0F, 0xF1, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xE0, 0x61, 0xFF,
  0x0E, 0x7F, 0xF0, 0xEF, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF8, 0x1E, 0x01, 0xE1, 0xE0, 0x07, 0x0E,
  0x00, 0x1C, 0x60, 0x00, 0xE3, 0x00, 0x07, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x19,
  0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x38, 0x00, 0xE0, 0xF0, 0x1E, 0x03, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x0F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xC0, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x61,
  0x80, 0x03, 0x86, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80,
  0x03, 0x0E, 0x00, 0x1C, 0x30, 0x00, 0x70, 0xC0, 0x01, 0xC7, 0x00, 0x07,
  0x1C, 0x00, 0x18, 0x70, 0x00, 0x61, 0x80, 0x03, 0x86, 0x00, 0x0E, 0x18,
  0x00, 0x38, 0x60, 0x00, 0xE1, 0x80, 0x03, 0x06, 0x00, 0x1C, 0x1C, 0x00,
  0xF0, 0x70, 0x07, 0xC0, 0xE0, 0x77, 0x03, 0xFF, 0x9C, 0x03, 0xFC, 0x60,
  0xE0, 0x00, 0x1D, 0x80, 0x00, 0xE6, 0x00, 0x03, 0x9C, 0x00, 0x1C, 0x70,
  0x00, 0x60, 0xC0, 0x03, 0x83, 0x00, 0x1C, 0x0E, 0x00, 0x70, 0x38, 0x03,
  0x80, 0x60, 0x0E, 0x01, 0x80, 0x70, 0x07, 0x01, 0x80, 0x1C, 0x0E, 0x00,
  0x30, 0x30, 0x00, 0xC1, 0xC0, 0x03, 0x86, 0x00, 0x0E, 0x38, 0x00, 0x19,
  0xC0, 0x00, 0x67, 0x00, 0x01, 0xB8, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x18, 0x03, 0xF0, 0x0C, 0x03,
  0xB8, 0x0F, 0x01, 0xDC, 0x07, 0x80, 0xCE, 0x06, 0xC0, 0xE7, 0x03, 0x60,
  0x61, 0x81, 0xB0, 0x30, 0xC1, 0x98, 0x38, 0x60, 0xCC, 0x18, 0x30, 0xE6,
  0x0C, 0x18, 0x63, 0x0C, 0x0C, 0x31, 0x86, 0x06, 0x30, 0xC7, 0x03, 0x18,
  0x63, 0x01, 0x98, 0x31, 0x80, 0xCC, 0x19, 0xC0, 0x6E, 0x0C, 0xC0, 0x36,
  0x03, 0x60, 0x1B, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03,
  0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0C, 0x00, 0x0E, 0x00, 0x07,
  0x83, 0x80, 0x07, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x1C, 0x07,
  0x80, 0x0E, 0x07, 0x80, 0x03, 0x87, 0x80, 0x00, 0xC7, 0x80, 0x00, 0x73,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xDC, 0x00, 0x03, 0xCE, 0x00, 0x03,
  0xC3, 0x80, 0x01, 0xC1, 0xC0, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x0E, 0x01, 0xC0, 0x03, 0x81, 0xC0, 0x01, 0xC1, 0xC0, 0x00, 0x70,
  0x07, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0x30,
  0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0x38, 0x00, 0x78, 0x03, 0x80, 0x07,
  0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0xC0, 0x18, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x60, 0xE0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x07, 0x38, 0x00, 0x00, 0x33, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0xC0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x3F, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x60, 0x00, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x38,
  0x1C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x1C, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x07, 0x03,
  0x81, 0x80, 0xC0, 0x00, 0x01, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0xCF, 0xFC, 0x00, 0xEE, 0x0F, 0x00, 0x66, 0x01,
  0xC0, 0x77, 0x00, 0x78, 0x73, 0x00, 0x1F, 0xF1, 0x80, 0x07, 0xF0, 0x00,
  0x00, 0x60, 0x00,
};

const GFXglyph RobotoMono_LightItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 9, 33, 27, 9, -33 },
  { 39, 11, 11, 27, 10, -35 },
  { 55, 26, 33, 27, 1, -33 },
  { 163, 22, 43, 27, 3, -38 },
  { 282, 22, 34, 27, 3, -33 },
  { 376, 23, 33, 27, 2, -33 },
  { 471, 4, 11, 27, 13, -35 },
  { 477, 14, 48, 27, 8, -37 },
  { 561, 14, 48, 27, 4, -37 },
  { 645, 20, 20, 27, 6, -33 },
  { 695, 22, 24, 27, 3, -27 },
  { 761, 7, 11, 27, 5, -4 },
  { 771, 17, 3, 27, 5, -16 },
  { 778, 4, 4, 27, 10, -4 },
  { 780, 22, 36, 27, 3, -33 },
  { 879, 22, 33, 27, 3, -33 },
  { 970, 12, 33, 27, 7, -33 },
  { 1020, 22, 33, 27, 1, -33 },
  { 1111, 23, 33, 27, 1, -33 },
  { 1206, 23, 33, 27, 1, -33 },
  { 1301, 22, 33, 27, 4, -33 },
  { 1392, 20, 33, 27, 3, -33 },
  { 1475, 22, 33, 27, 5, -33 },
  { 1566, 22, 33, 27, 3, -33 },
  { 1657, 20, 33, 27, 4, -33 },
  { 1740, 8, 24, 27, 11, -24 },
  { 1764, 11, 31, 27, 8, -24 },
  { 1807, 20, 19, 27, 4, -24 },
  { 1855, 21, 12, 27, 3, -21 },
  { 1887, 20, 19, 27, 3, -24 },
  { 1935, 18, 33, 27, 7, -33 },
  { 2010, 26, 33, 27, 1, -33 },
  { 2118, 23, 33, 27, 0, -33 },
  { 2213, 23, 33, 27, 2, -33 },
  { 2308, 23, 34, 27, 3, -33 },
  { 2406, 24, 33, 27, 2, -33 },
  { 2505, 24, 33, 27, 2, -33 },
  { 2604, 25, 33, 27, 2, -33 },
  { 2708, 24, 34, 27, 2, -33 },
  { 2810, 26, 33, 27, 1, -33 },
  { 2918, 24, 33, 27, 2, -33 },
  { 3017, 24, 33, 27, 2, -33 },
  { 3116, 26, 33, 27, 2, -33 },
  { 3224, 20, 33, 27, 2, -33 },
  { 3307, 26, 33, 27, 1, -33 },
  { 3415, 26, 33, 27, 1, -33 },
  { 3523, 22, 33, 27, 3, -33 },
  { 3614, 25, 33, 27, 2, -33 },
  { 3718, 24, 39, 27, 2, -33 },
  { 3835, 24, 33, 27, 2, -33 },
  { 3934, 24, 33, 27, 2, -33 },
  { 4033, 23, 33, 27, 5, -33 },
  { 4128, 24, 33, 27, 3, -33 },
  { 4227, 23, 33, 27, 5, -33 },
  { 4322, 25, 33, 27, 4, -33 },
  { 4426, 28, 33, 27, 0, -33 },
  { 4542, 23, 33, 27, 5, -33 },
  { 4637, 25, 33, 27, 1, -33 },
  { 4741, 14, 44, 27, 7, -37 },
  { 4818, 9, 36, 27, 9, -33 },
  { 4859, 15, 44, 27, 6, -37 },
  { 4942, 16, 18, 27, 6, -33 },
  { 4978, 20, 2, 27, 1, 0 },
  { 4983, 6, 6, 27, 13, -34 },
  { 4988, 21, 25, 27, 2, -25 },
  { 5054, 21, 35, 27, 2, -35 },
  { 5146, 21, 25, 27, 3, -25 },
  { 5212, 23, 35, 27, 3, -35 },
  { 5313, 21, 25, 27, 3, -25 },
  { 5379, 23, 35, 27, 5, -35 },
  { 5480, 23, 35, 27, 1, -25 },
  { 5581, 21, 35, 27, 2, -35 },
  { 5673, 20, 33, 27, 2, -33 },
  { 5756, 21, 43, 27, 0, -33 },
  { 5869, 23, 35, 27, 2, -35 },
  { 5970, 20, 35, 27, 2, -35 },
  { 6058, 26, 25, 27, 0, -25 },
  { 6140, 21, 25, 27, 2, -25 },
  { 6206, 22, 25, 27, 2, -25 },
  { 6275, 23, 34, 27, 0, -25 },
  { 6373, 21, 34, 27, 3, -25 },
  { 6463, 20, 25, 27, 5, -25 },
  { 6526, 21, 25, 27, 3, -25 },
  { 6592, 19, 31, 27, 5, -31 },
  { 6666, 22, 24, 27, 3, -24 },
  { 6732, 22, 24, 27, 4, -24 },
  { 6798, 25, 24, 27, 3, -24 },
  { 6873, 25, 24, 27, 1, -24 },
  { 6948, 28, 34, 27, -1, -24 },
  { 7067, 24, 24, 27, 1, -24 },
  { 7139, 18, 45, 27, 7, -36 },
  { 7241, 9, 41, 27, 9, -33 },
  { 7288, 18, 45, 27, 4, -36 },
  { 7390, 25, 9, 27, 1, -18 },
};

const GFXfont RobotoMono_LightItalic46pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic46pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic46pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _ROBOTOMONO_LIGHTITALIC46PT7B_H_
