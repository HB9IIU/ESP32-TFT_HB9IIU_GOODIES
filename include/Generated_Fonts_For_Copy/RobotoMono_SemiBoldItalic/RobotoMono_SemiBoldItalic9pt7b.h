#ifndef _ROBOTOMONO_SEMIBOLDITALIC9PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x6A, 0x20, 0xFC, 0x2B, 0xD5, 0xF6, 0x50, 0x13, 0x52, 0x41, 0xE5,
  0xC4, 0x8D, 0xE4, 0x6D, 0x30, 0x03, 0x94, 0x46, 0xCD, 0xE0, 0xE0, 0x29,
  0x29, 0x22, 0x40, 0x44, 0x92, 0x92, 0x80, 0x2F, 0x6A, 0x33, 0xFE, 0x40,
  0x68, 0xF0, 0x80, 0x08, 0x8C, 0x46, 0x22, 0x00, 0x0F, 0x9F, 0x9A, 0xE0,
  0xF5, 0xA4, 0x80, 0x03, 0xD2, 0x22, 0x23, 0xC0, 0x03, 0xC2, 0x61, 0x49,
  0xC0, 0x19, 0x95, 0x2F, 0x98, 0x7A, 0x1C, 0x3D, 0x38, 0x32, 0x1D, 0xBD,
  0x38, 0xF2, 0x24, 0x48, 0x03, 0xD2, 0xE5, 0x69, 0xC0, 0x0F, 0x99, 0xE2,
  0xC0, 0xC0, 0x80, 0x60, 0x04, 0xA0, 0x1E, 0x86, 0x78, 0x3E, 0x41, 0x87,
  0xC0, 0x0F, 0x12, 0x40, 0x40, 0x7B, 0xF7, 0xBB, 0x30, 0x31, 0x94, 0xAF,
  0xC4, 0x7A, 0x5C, 0x9C, 0xF8, 0x03, 0xD3, 0x8C, 0x6D, 0xC0, 0x7A, 0x52,
  0x99, 0x70, 0x7A, 0x1E, 0x8C, 0x78, 0x7A, 0x1E, 0x8C, 0x40, 0x7A, 0x51,
  0xBD, 0xB8, 0x4A, 0x5E, 0x99, 0x48, 0x79, 0x08, 0x42, 0x78, 0x08, 0x42,
  0x19, 0x38, 0x4D, 0x46, 0x14, 0xD2, 0x60, 0x44, 0x44, 0xCF, 0x6B, 0xDE,
  0xD8, 0xC8, 0x6B, 0x5A, 0xF9, 0x48, 0x03, 0xD2, 0x98, 0xED, 0xC0, 0x7A,
  0x52, 0xEC, 0x40, 0x03, 0xD2, 0x98, 0xED, 0xC3, 0x7A, 0x56, 0xED, 0x4C,
  0x03, 0xD0, 0xE1, 0xC5, 0xC0, 0xFA, 0x10, 0x84, 0x20, 0x4A, 0x52, 0x9D,
  0x38, 0x9C, 0xA9, 0x4C, 0x20, 0xBF, 0xBD, 0x6A, 0x50, 0x4C, 0xC3, 0x0C,
  0x52, 0x60, 0x9D, 0x98, 0x84, 0x20, 0x78, 0x8C, 0xC4, 0x7C, 0x69, 0x24,
  0xA6, 0xAA, 0x94, 0x64, 0x96, 0x96, 0x6E, 0x80, 0xF0, 0xD0, 0x72, 0xDD,
  0x27, 0x00, 0x42, 0x1C, 0x94, 0xEB, 0xC0, 0x32, 0x71, 0xA7, 0x00, 0x08,
  0x4E, 0x9D, 0xE9, 0xC0, 0x32, 0x7F, 0x87, 0x00, 0x3A, 0x3C, 0x84, 0x23,
  0x00, 0x3A, 0x77, 0xA7, 0x49, 0x80, 0x42, 0x1C, 0x94, 0xEA, 0x40, 0x11,
  0x73, 0x22, 0xF0, 0x11, 0x35, 0x12, 0x22, 0xC0, 0x42, 0x12, 0xE6, 0x7A,
  0x60, 0x71, 0x13, 0x22, 0xF0, 0x7D, 0x6B, 0x5B, 0x80, 0x72, 0x53, 0xA9,
  0x00, 0x32, 0x73, 0xB7, 0x00, 0x72, 0xD3, 0xAF, 0x42, 0x00, 0x3A, 0x77,
  0xA7, 0x08, 0x40, 0x7C, 0x88, 0x80, 0x32, 0x5D, 0x37, 0x00, 0x4F, 0x44,
  0xC6, 0x99, 0x9A, 0xE0, 0x9B, 0xAA, 0x40, 0xDD, 0xBA, 0xA0, 0x4B, 0x88,
  0xAD, 0x80, 0x4D, 0x25, 0x14, 0x21, 0x0C, 0x00, 0x78, 0x88, 0x8F, 0x80,
  0x32, 0x24, 0xC4, 0x44, 0x20, 0x6A, 0xAA, 0x45, 0x32, 0x92, 0x80, 0x45,
  0xC0,
};

const GFXglyph RobotoMono_SemiBoldItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 6, 5, 2, -6 },
  { 3, 2, 3, 5, 2, -7 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 5, 8, 5, 0, -7 },
  { 13, 4, 7, 5, 1, -7 },
  { 17, 5, 7, 5, 0, -7 },
  { 22, 1, 3, 5, 2, -7 },
  { 23, 3, 9, 5, 1, -7 },
  { 27, 3, 9, 5, 1, -7 },
  { 31, 4, 4, 5, 1, -6 },
  { 33, 5, 4, 5, 0, -5 },
  { 36, 2, 3, 5, 1, -1 },
  { 37, 4, 1, 5, 1, -3 },
  { 38, 1, 1, 5, 2, -1 },
  { 39, 5, 7, 5, 0, -6 },
  { 44, 4, 7, 5, 1, -7 },
  { 48, 3, 6, 5, 1, -6 },
  { 51, 5, 7, 5, 0, -7 },
  { 56, 5, 7, 5, 0, -7 },
  { 61, 5, 6, 5, 0, -6 },
  { 65, 5, 6, 5, 0, -6 },
  { 69, 5, 6, 5, 0, -6 },
  { 73, 4, 6, 5, 1, -6 },
  { 76, 5, 7, 5, 0, -7 },
  { 81, 4, 7, 5, 1, -7 },
  { 85, 2, 5, 5, 2, -5 },
  { 87, 3, 7, 5, 1, -5 },
  { 90, 4, 4, 5, 1, -5 },
  { 92, 5, 3, 5, 0, -4 },
  { 94, 5, 4, 5, 0, -5 },
  { 97, 4, 7, 5, 1, -7 },
  { 101, 5, 6, 5, 0, -6 },
  { 105, 5, 6, 5, 0, -6 },
  { 109, 5, 6, 5, 0, -6 },
  { 113, 5, 7, 5, 0, -7 },
  { 118, 5, 6, 5, 0, -6 },
  { 122, 5, 6, 5, 0, -6 },
  { 126, 5, 6, 5, 0, -6 },
  { 130, 5, 6, 5, 0, -6 },
  { 134, 5, 6, 5, 0, -6 },
  { 138, 5, 6, 5, 0, -6 },
  { 142, 5, 6, 5, 0, -6 },
  { 146, 6, 6, 5, 0, -6 },
  { 151, 4, 6, 5, 0, -6 },
  { 154, 5, 6, 5, 0, -6 },
  { 158, 5, 6, 5, 0, -6 },
  { 162, 5, 7, 5, 0, -7 },
  { 167, 5, 6, 5, 0, -6 },
  { 171, 5, 8, 5, 0, -7 },
  { 176, 5, 6, 5, 0, -6 },
  { 180, 5, 7, 5, 0, -7 },
  { 185, 5, 6, 5, 1, -6 },
  { 189, 5, 6, 5, 0, -6 },
  { 193, 5, 6, 5, 1, -6 },
  { 197, 5, 6, 5, 1, -6 },
  { 201, 6, 6, 5, 0, -6 },
  { 206, 5, 6, 5, 1, -6 },
  { 210, 5, 6, 5, 0, -6 },
  { 214, 3, 8, 5, 1, -7 },
  { 217, 2, 7, 5, 2, -6 },
  { 219, 3, 8, 5, 1, -7 },
  { 222, 3, 3, 5, 1, -6 },
  { 224, 4, 1, 5, 0, 0 },
  { 225, 2, 2, 5, 2, -7 },
  { 226, 5, 5, 5, 0, -5 },
  { 230, 5, 7, 5, 0, -7 },
  { 235, 5, 5, 5, 0, -5 },
  { 239, 5, 7, 5, 0, -7 },
  { 244, 5, 5, 5, 0, -5 },
  { 248, 5, 7, 5, 1, -7 },
  { 253, 5, 7, 5, 0, -5 },
  { 258, 5, 7, 5, 0, -7 },
  { 263, 4, 7, 5, 0, -7 },
  { 267, 4, 9, 5, 0, -7 },
  { 272, 5, 7, 5, 0, -7 },
  { 277, 4, 7, 5, 0, -7 },
  { 281, 5, 5, 5, 0, -5 },
  { 285, 5, 5, 5, 0, -5 },
  { 289, 5, 5, 5, 0, -5 },
  { 293, 5, 7, 5, 0, -5 },
  { 298, 5, 7, 5, 0, -5 },
  { 303, 4, 5, 5, 1, -5 },
  { 306, 5, 5, 5, 0, -5 },
  { 310, 4, 6, 5, 1, -6 },
  { 313, 4, 5, 5, 1, -5 },
  { 316, 4, 5, 5, 1, -5 },
  { 319, 4, 5, 5, 1, -5 },
  { 322, 5, 5, 5, 0, -5 },
  { 326, 6, 7, 5, 0, -5 },
  { 332, 5, 5, 5, 0, -5 },
  { 336, 4, 9, 5, 1, -7 },
  { 341, 2, 8, 5, 2, -6 },
  { 343, 3, 9, 5, 1, -7 },
  { 347, 5, 2, 5, 0, -4 },
};

const GFXfont RobotoMono_SemiBoldItalic9pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic9pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC9PT7B_H_
