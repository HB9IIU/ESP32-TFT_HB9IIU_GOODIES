#ifndef _ROBOTOMONO_SEMIBOLDITALIC49PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x07, 0xC0, 0xFC, 0x0F,
  0xE0, 0xFE, 0x0F, 0xC0, 0x78, 0x00, 0x3E, 0x0F, 0x3E, 0x1F, 0x3E, 0x1F,
  0x3C, 0x1F, 0x3C, 0x1E, 0x3C, 0x1E, 0x7C, 0x1E, 0x7C, 0x1E, 0x78, 0x3E,
  0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0xF0, 0x3C, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x1E, 0x0F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x78, 0x3C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x01, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x01,
  0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x1E, 0x0F, 0x00,
  0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x80, 0x3E, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0xF8, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x7F, 0x83, 0xF8, 0x1F, 0x80, 0x7E, 0x0F, 0xE0, 0x1F, 0xC3, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x3F, 0x80, 0x1F, 0x8F, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E,
  0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x87, 0xF0, 0x1F, 0xE0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x78, 0x78, 0x10, 0xF8, 0x78, 0x3C,
  0xF0, 0x78, 0x3C, 0xF0, 0x78, 0x78, 0xF0, 0x78, 0xF0, 0xF0, 0x78, 0xF0,
  0xF8, 0xF9, 0xE0, 0x7F, 0xF3, 0xC0, 0x7F, 0xE7, 0xC0, 0x3F, 0xC7, 0x80,
  0x0F, 0x8F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF1, 0xF0, 0x01, 0xE7, 0xF8,
  0x03, 0xCF, 0xFC, 0x03, 0xCF, 0xFE, 0x07, 0x9F, 0x1E, 0x0F, 0x1E, 0x1F,
  0x0F, 0x3E, 0x1F, 0x1E, 0x3E, 0x1E, 0x3C, 0x3C, 0x1E, 0x0C, 0x3C, 0x1E,
  0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xF0, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xE0, 0x7C,
  0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x83, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x3F,
  0x7F, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x0F, 0x8F, 0xFF,
  0x83, 0xF1, 0xFF, 0xF0, 0x7E, 0x7F, 0x3F, 0x0F, 0x9F, 0xC7, 0xF3, 0xF3,
  0xF0, 0x7E, 0x7E, 0xFE, 0x0F, 0xFF, 0x9F, 0x80, 0xFF, 0xF3, 0xF0, 0x1F,
  0xFC, 0x7E, 0x01, 0xFF, 0x0F, 0xE0, 0x1F, 0xE1, 0xFC, 0x07, 0xF8, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xE7,
  0xE0, 0x1F, 0xF0, 0xFE, 0x00, 0x20, 0x00, 0x00, 0x3E, 0x7C, 0xF9, 0xF3,
  0xCF, 0x9F, 0x3E, 0x78, 0xF1, 0xE3, 0xCF, 0x80, 0x00, 0x02, 0x00, 0x07,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0x80, 0x01, 0x00,
  0x00, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x18, 0x0E, 0x03, 0x7C, 0x1C,
  0x3E, 0xFE, 0x79, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x0F, 0x9E, 0x00, 0x3E, 0x3E, 0x00, 0xF8, 0x3E, 0x03, 0xF0, 0x7C, 0x0F,
  0xC0, 0xFC, 0x07, 0x00, 0xF0, 0x04, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0xFC, 0x3F, 0x0F, 0xC7, 0xE1, 0xF0, 0xFC, 0x3E, 0x07, 0x00,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xE0, 0x1C, 0x3F, 0x9F, 0xDF, 0xFF, 0xFF, 0xFD, 0xFC, 0x7C, 0x08, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x1F,
  0x80, 0x3E, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F,
  0x00, 0xFF, 0x7F, 0x01, 0xFE, 0x7E, 0x07, 0xFE, 0x7E, 0x0F, 0xFE, 0x7E,
  0x3F, 0xFE, 0x7E, 0x7E, 0x7E, 0x7F, 0xFC, 0x7E, 0x7F, 0xF0, 0xFE, 0xFF,
  0xE0, 0xFC, 0xFF, 0x80, 0xFC, 0xFF, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x7C,
  0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x7F, 0x9F, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x00, 0x0F, 0x00, 0x7F, 0x03, 0xFF, 0x1F, 0xFF, 0x7F, 0xFE, 0x7F,
  0xFE, 0xFF, 0xFE, 0xFE, 0x7E, 0xF0, 0x7E, 0xC0, 0x7E, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x81, 0xFE, 0x0F, 0xE0, 0x7E, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F,
  0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFC, 0x0F, 0xE0, 0xFE,
  0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF8, 0x03, 0xF8, 0x7E, 0x00,
  0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFB, 0xF0,
  0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0xC7,
  0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7C,
  0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x3F, 0x03,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFA, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x8F, 0x80,
  0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x0F, 0xF0, 0xFF, 0x00, 0x30, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x8F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03,
  0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xFC, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF1, 0xFC, 0x07, 0xEF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0x83, 0xF9, 0xFC, 0x03, 0xFB, 0xF0, 0x07,
  0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFD, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7,
  0xE0, 0x1F, 0x8F, 0xE0, 0x7F, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0x83, 0xF8,
  0x3F, 0x80, 0xFC, 0x1F, 0x80, 0x7F, 0x0F, 0xC0, 0x3F, 0x87, 0xE0, 0x1F,
  0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x1F, 0xEF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xF8, 0x1F, 0x83, 0xF8,
  0x07, 0xE1, 0xF8, 0x03, 0xF1, 0xFC, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E,
  0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xE0, 0x1F, 0xC7,
  0xF0, 0x1F, 0xC1, 0xFF, 0x7F, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0xFE, 0x0F, 0xE7, 0xF0, 0x1F, 0x9F, 0x80, 0x3F, 0x7E, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xE7,
  0xF0, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xF7, 0xC0, 0xFF,
  0xBF, 0x00, 0x70, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0xFE, 0x0F, 0xE1, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F, 0xE0, 0x7C, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x07, 0xE0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x07, 0xE0, 0x10, 0x00, 0x00, 0xF0, 0x07, 0xE0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7E, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03,
  0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F,
  0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x08, 0x00, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x0C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF9, 0xFC, 0x0F, 0xE7, 0xE0, 0x1F, 0xBF, 0x80, 0x7E, 0xFC,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3E, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x03,
  0xC0, 0x01, 0xC0, 0x78, 0x00, 0x1E, 0x0F, 0x07, 0xF1, 0xE0, 0xF0, 0xFF,
  0x8E, 0x1E, 0x1F, 0xF8, 0xE1, 0xE3, 0xE3, 0x8E, 0x3C, 0x7C, 0x78, 0xE3,
  0xC7, 0x87, 0x8E, 0x78, 0xF0, 0x70, 0xE7, 0x8F, 0x07, 0x0E, 0x78, 0xE0,
  0xF1, 0xE7, 0x1E, 0x0F, 0x1E, 0xF1, 0xE0, 0xE1, 0xCF, 0x1E, 0x0E, 0x1C,
  0xF1, 0xE1, 0xE1, 0xCF, 0x1E, 0x1E, 0x38, 0xF1, 0xE1, 0xC3, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xFF, 0xFF, 0x0F, 0x0F, 0xFF, 0xE0, 0xF0, 0xFC, 0xFC,
  0x07, 0x81, 0x03, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x80, 0x01, 0xFC, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0xFD, 0xF0, 0x00,
  0x1F, 0x9F, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF1,
  0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0xFC, 0x0F, 0x80,
  0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x07, 0xE1, 0xF8,
  0x00, 0x7E, 0x3F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x07,
  0xE7, 0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xC0, 0x7F, 0xC1, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x0F,
  0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03,
  0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xE0, 0x1F, 0xE0, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8,
  0x1F, 0xC0, 0xFF, 0x83, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0,
  0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1,
  0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0xC7, 0xE0, 0x07, 0xF0, 0xFC, 0x03,
  0xFE, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01,
  0xFC, 0x0F, 0xE0, 0xFE, 0x01, 0xF8, 0x7F, 0x00, 0x7F, 0x1F, 0x80, 0x0F,
  0xCF, 0xE0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF8,
  0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0xC0, 0xFF, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xF8, 0x7F, 0xC0,
  0xFE, 0x07, 0xF8, 0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07,
  0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xC7, 0xE0,
  0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7,
  0xE0, 0x03, 0xF3, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x1F,
  0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0xFE, 0x7F, 0x00,
  0x3F, 0x1F, 0x80, 0x1F, 0xC7, 0xE0, 0x0F, 0xE1, 0xF8, 0x07, 0xF8, 0x7E,
  0x03, 0xFC, 0x3F, 0x83, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF0, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x81, 0xFC, 0x0F, 0xE0, 0xFE, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x1F, 0x80,
  0x0F, 0xC7, 0xE0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x81, 0xFF, 0xEF, 0xE0, 0x7F, 0xFB, 0xF0, 0x3F,
  0xFC, 0xFC, 0x0F, 0xFF, 0x3F, 0x03, 0xFF, 0xCF, 0xC0, 0x03, 0xF3, 0xF0,
  0x00, 0xFC, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0x8F, 0xE0, 0x07, 0xE1,
  0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0xC0, 0x7F, 0x83, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x80, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F,
  0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x01,
  0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0,
  0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F,
  0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F,
  0xC0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0,
  0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x0F,
  0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x1F, 0x80,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0xC3, 0xF0, 0x03,
  0xF0, 0x7E, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0x81, 0xFC, 0x0F, 0xF0, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xFE,
  0x07, 0xE0, 0x07, 0xF8, 0x1F, 0x80, 0x1F, 0xE0, 0x3F, 0x00, 0x7F, 0x80,
  0x7E, 0x01, 0xFE, 0x00, 0xFC, 0x03, 0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x07,
  0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0xFE, 0x00, 0x1F, 0x83, 0xFC, 0x00, 0x3F,
  0x0F, 0xF0, 0x00, 0x7E, 0x3F, 0xC0, 0x00, 0xFC, 0xFF, 0x00, 0x03, 0xFB,
  0xFC, 0x00, 0x07, 0xEF, 0xF0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFC, 0xFC, 0x00, 0x0F, 0xF1, 0xFC,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xF0,
  0x01, 0xF8, 0x07, 0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x80,
  0xFC, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0xFF,
  0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x81, 0xFF, 0x07, 0xF8, 0x1F, 0xF0, 0x7F,
  0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0xC7, 0xFE, 0x0F, 0xFC, 0x7F,
  0xE0, 0xFB, 0xCF, 0xFE, 0x0F, 0xBC, 0xFF, 0xE0, 0xFB, 0xDF, 0x7E, 0x1F,
  0xBD, 0xF7, 0xC1, 0xFB, 0xDE, 0x7C, 0x1F, 0xBF, 0xE7, 0xC1, 0xF3, 0xFC,
  0xFC, 0x1F, 0x3F, 0xCF, 0xC1, 0xF1, 0xF8, 0xF8, 0x3F, 0x1F, 0x8F, 0x83,
  0xF1, 0xF0, 0xF8, 0x3F, 0x1F, 0x1F, 0x83, 0xE1, 0xE1, 0xF8, 0x3E, 0x1E,
  0x1F, 0x83, 0xE1, 0xE1, 0xF0, 0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xF0,
  0x7E, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x0F, 0xC0,
  0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E,
  0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x01, 0xF8,
  0x1F, 0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x3F,
  0xC0, 0x3F, 0x01, 0xFE, 0x01, 0xF8, 0x1F, 0xF0, 0x0F, 0xC0, 0xFF, 0x80,
  0xFE, 0x07, 0xFE, 0x07, 0xE0, 0x3F, 0xF0, 0x3F, 0x01, 0xFF, 0x81, 0xF8,
  0x0F, 0xFE, 0x0F, 0xC0, 0xFF, 0xF0, 0x7E, 0x07, 0xEF, 0x87, 0xF0, 0x3F,
  0x7C, 0x3F, 0x01, 0xF9, 0xF1, 0xF8, 0x0F, 0xCF, 0x8F, 0xC0, 0xFE, 0x7C,
  0x7E, 0x07, 0xE3, 0xE3, 0xF0, 0x3F, 0x0F, 0xBF, 0x81, 0xF8, 0x7D, 0xF8,
  0x0F, 0xC3, 0xEF, 0xC0, 0x7E, 0x0F, 0x7E, 0x07, 0xF0, 0x7F, 0xF0, 0x3F,
  0x03, 0xFF, 0x81, 0xF8, 0x1F, 0xF8, 0x0F, 0xC0, 0x7F, 0xC0, 0x7E, 0x03,
  0xFE, 0x03, 0xF0, 0x1F, 0xF0, 0x3F, 0x80, 0xFF, 0x81, 0xF8, 0x03, 0xFC,
  0x0F, 0xC0, 0x1F, 0xC0, 0x7E, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0xF0, 0x3F,
  0x80, 0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0xFE,
  0x03, 0xF8, 0x7F, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x8F, 0xE0, 0x07, 0xE3,
  0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0x80, 0x07,
  0xF7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x9F, 0x80,
  0x07, 0xEF, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xBF,
  0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x7F,
  0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xE3, 0xF8, 0x03, 0xF0, 0x7E, 0x01,
  0xFC, 0x1F, 0xC0, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x80, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7E, 0x03, 0xFE, 0x07, 0xE0, 0x0F,
  0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x7F, 0x0F,
  0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00,
  0x7E, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x7F, 0xC1,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0xFE,
  0x03, 0xF8, 0x7F, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x8F, 0xE0, 0x07, 0xF3,
  0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xDF, 0x80, 0x03,
  0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0x9F, 0x80,
  0x07, 0xEF, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF,
  0x00, 0x0F, 0xEF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F,
  0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF8, 0x03, 0xF0, 0x7E, 0x01,
  0xFC, 0x1F, 0xC0, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xC0,
  0xFF, 0x81, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1,
  0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00,
  0x7E, 0x3F, 0x80, 0x1F, 0xC7, 0xE0, 0x07, 0xF0, 0xFC, 0x01, 0xFE, 0x1F,
  0x81, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8,
  0x1F, 0xC0, 0x3F, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xF0,
  0x3F, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xFC, 0x1F, 0x80,
  0x3F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xE3,
  0xF0, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0x81,
  0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0,
  0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E,
  0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x03, 0xF8, 0x0F,
  0xF0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x07,
  0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x07, 0xE0, 0xFC,
  0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x87, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x7E,
  0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0,
  0x0F, 0xC3, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1,
  0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE1, 0xFC, 0x00,
  0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x1F,
  0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x7E, 0x1F, 0xC0, 0x0F,
  0xC1, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x00, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x3F, 0x00, 0x0F,
  0xC7, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0xC3, 0xF0,
  0x03, 0xF8, 0x7F, 0x00, 0x7E, 0x0F, 0xE0, 0x1F, 0xC0, 0xFC, 0x03, 0xF0,
  0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x07, 0xF0, 0x0F, 0xC0,
  0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x07, 0xF0, 0x03, 0xE0, 0xFC, 0x00,
  0x7E, 0x3F, 0x80, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x3F,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xBF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x0F,
  0x83, 0xF7, 0xE0, 0xF8, 0x3F, 0x7C, 0x1F, 0x83, 0xE7, 0xC1, 0xF8, 0x3E,
  0x7C, 0x1F, 0x87, 0xE7, 0xC1, 0xF8, 0x7E, 0x7C, 0x3F, 0x87, 0xC7, 0xC3,
  0xF8, 0xFC, 0x7C, 0x3F, 0x8F, 0xC7, 0xC7, 0xF8, 0xF8, 0x7C, 0x7F, 0x8F,
  0x87, 0xC7, 0xF9, 0xF8, 0x7C, 0xFF, 0x9F, 0x87, 0xCF, 0xF9, 0xF0, 0x7C,
  0xFF, 0x9F, 0x07, 0xCF, 0xFB, 0xF0, 0x7D, 0xFF, 0xBE, 0x07, 0xDE, 0xFB,
  0xE0, 0x7D, 0xEF, 0xFE, 0x07, 0xFE, 0xFF, 0xE0, 0x7F, 0xCF, 0xFC, 0x0F,
  0xFC, 0xFF, 0xC0, 0xFF, 0xCF, 0xFC, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x8F,
  0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x00,
  0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xE0,
  0x7E, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x01,
  0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x07,
  0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7E, 0x1F,
  0xC0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x3F, 0x7F,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFE, 0xFC,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x03, 0xF8, 0x7E,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0xE0, 0x3F,
  0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x7F, 0x80, 0x1F,
  0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0xC7, 0xE0,
  0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x81, 0xF8, 0x0F, 0xE0,
  0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC3,
  0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x1F, 0x1F, 0x80, 0x03, 0xF7, 0xF0, 0x00,
  0x7E, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E,
  0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x3F,
  0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0x00, 0x1E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0x7C, 0x03, 0xE7, 0x80, 0xF8, 0xF0,
  0x1F, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x3E, 0x07, 0x87, 0xC0, 0xF1,
  0xF0, 0x1F, 0x7E, 0x03, 0xEF, 0x80, 0x7F, 0xF0, 0x07, 0x80, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFE, 0x3F, 0x0F, 0xC3, 0xE0, 0xF8, 0x7C, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE1, 0xFE, 0x3F, 0xC3, 0xF0, 0x1F,
  0xCF, 0xE0, 0x1F, 0x9F, 0x80, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F,
  0xE0, 0x3F, 0x3F, 0x00, 0x7E, 0xFE, 0x00, 0xFD, 0xF8, 0x03, 0xF3, 0xF0,
  0x07, 0xE7, 0xE0, 0x1F, 0xCF, 0xC0, 0x7F, 0x9F, 0xE7, 0xFF, 0x3F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFD, 0xF8, 0x3F, 0xE3, 0xF0, 0x04, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0xFE, 0x00, 0xFD, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFE, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0, 0x1F, 0x87, 0xE0, 0x0F,
  0xE3, 0xF0, 0x07, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0,
  0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x07, 0xF3, 0xF0, 0x03, 0xF1, 0xFC,
  0x03, 0xF8, 0xFF, 0x03, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F,
  0x7F, 0xFC, 0x1F, 0x9F, 0xFC, 0x0F, 0xC7, 0xF8, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0x3E,
  0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xFC,
  0x7F, 0x03, 0xF8, 0x3F, 0xCF, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x7F,
  0x8F, 0xC0, 0x3F, 0xFB, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0xFC, 0x00,
  0xFC, 0x1F, 0x80, 0x3F, 0x87, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F,
  0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x7E, 0x1F, 0x80, 0x1F,
  0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xC0, 0xFC,
  0x01, 0xF8, 0x1F, 0x80, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFE, 0xFC, 0x00, 0x7F,
  0x9F, 0x80, 0x01, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0xE0, 0x7E,
  0x1F, 0xC0, 0x3E, 0x3F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x20, 0x7F, 0x00, 0x30, 0x7F, 0x80, 0xF8, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x7F, 0x20, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xC1, 0x80,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x87, 0xC0, 0x7F, 0xFB, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFC, 0x1F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F,
  0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF0,
  0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xC7, 0xE0, 0x03,
  0xF1, 0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0x83, 0xF0,
  0x07, 0xE0, 0xFC, 0x03, 0xF8, 0x3F, 0x81, 0xFE, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFE, 0xFC, 0x00, 0xFF, 0x3F,
  0x00, 0x04, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x20, 0x01, 0xF8, 0x0C, 0x00,
  0xFE, 0x07, 0x80, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0xFF, 0x00, 0xFC,
  0xFF, 0xC0, 0x7E, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F,
  0xF0, 0x7F, 0x8F, 0xE0, 0x1F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1,
  0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0xFE, 0x00, 0xFC, 0x7E, 0x00, 0x7E,
  0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07,
  0xE7, 0xE0, 0x07, 0xF3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00,
  0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x9F, 0x80,
  0x1F, 0x8F, 0xC0, 0x0F, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x0F, 0xF0, 0xFC, 0x03, 0xFC, 0x1F, 0x80, 0xFF, 0x03,
  0xF0, 0x3F, 0xC0, 0x7E, 0x0F, 0xF0, 0x0F, 0xC3, 0xFC, 0x03, 0xF0, 0xFF,
  0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xCF, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xC7, 0xF0, 0x07, 0xF0,
  0xFE, 0x00, 0xFC, 0x0F, 0xE0, 0x1F, 0x81, 0xFC, 0x03, 0xF0, 0x1F, 0xC0,
  0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x07, 0xF0, 0x7E, 0x00,
  0x7F, 0x0F, 0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x7F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xCF, 0xC7, 0xC0, 0x7D, 0xFD, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFC, 0x7E, 0x1F, 0x0F, 0x87, 0xE1, 0xF0,
  0xF8, 0x7E, 0x1F, 0x1F, 0x87, 0xC3, 0xF1, 0xF8, 0x7C, 0x3F, 0x1F, 0x87,
  0xC3, 0xF1, 0xF0, 0xFC, 0x3E, 0x1F, 0x0F, 0xC3, 0xE3, 0xF0, 0xFC, 0x3E,
  0x3F, 0x0F, 0x87, 0xE3, 0xF0, 0xF8, 0x7E, 0x3F, 0x0F, 0x87, 0xE3, 0xE1,
  0xF8, 0x7C, 0x3E, 0x1F, 0x87, 0xC7, 0xE1, 0xF8, 0x7C, 0x7E, 0x1F, 0x0F,
  0xC7, 0xE1, 0xF0, 0xFC, 0x7C, 0x1F, 0x0F, 0xC7, 0xC3, 0xF0, 0xF8, 0x7C,
  0x3F, 0x0F, 0x8F, 0xC3, 0xE0, 0xF8, 0x0F, 0xC7, 0xF8, 0x07, 0xE7, 0xFE,
  0x03, 0xF7, 0xFF, 0x81, 0xF7, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0x83,
  0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0,
  0x0F, 0xC7, 0xE0, 0x07, 0xE7, 0xF0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8,
  0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x3F,
  0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3,
  0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF9, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC,
  0x7E, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xC0, 0xFE, 0x3F, 0x80,
  0x7E, 0x3F, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFE, 0x00,
  0xFC, 0x7E, 0x01, 0xFC, 0x7F, 0x03, 0xF8, 0x3F, 0xCF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x30,
  0x00, 0x03, 0xF3, 0xFC, 0x00, 0x7E, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x03,
  0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x01, 0xFC, 0x1F,
  0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x1F,
  0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC3, 0xF8,
  0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xE0, 0x1F, 0xC1, 0xFE, 0x07, 0xF0,
  0x3F, 0xF7, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0x7F,
  0xF8, 0x07, 0xE3, 0xFC, 0x00, 0xFC, 0x0C, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x1F, 0x81, 0xFF, 0xCF, 0xC1, 0xFF, 0xF7,
  0xE1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFE, 0x07, 0xF8, 0xFE, 0x01,
  0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x7F, 0x3F, 0x00, 0x3F, 0x1F, 0x80,
  0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE7, 0xF0, 0x03, 0xF3, 0xF0,
  0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x7E, 0x1F,
  0x80, 0x3F, 0x0F, 0xC0, 0x3F, 0x87, 0xF0, 0x3F, 0x83, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFD, 0xF8, 0x03, 0xFC, 0xFC,
  0x00, 0x20, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE1, 0xFF, 0x07,
  0xC7, 0xFE, 0x0F, 0xCF, 0xFE, 0x0F, 0xDF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x1F, 0xF0, 0xFE, 0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0x3F, 0x1F,
  0x00, 0x3F, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x7C, 0xFC,
  0x00, 0xFC, 0xFE, 0x00, 0xFC, 0x7F, 0x03, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0x08, 0x00, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x3F,
  0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x7E,
  0x3F, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E,
  0x7E, 0x00, 0xFE, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0xFC, 0x00, 0xFC,
  0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8,
  0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFE, 0x07, 0xF8, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFD, 0xF0, 0x3F, 0xF9, 0xF0, 0x1F, 0xE3, 0xF0,
  0x01, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x1F,
  0x9F, 0x80, 0x0F, 0xC7, 0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x07,
  0xE0, 0xFC, 0x03, 0xF0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x81,
  0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0xFC, 0x00, 0xF8, 0x7E, 0x00, 0x7C,
  0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x3F, 0x00, 0x07, 0xDF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x1E, 0x07, 0xFF, 0x03, 0xC0, 0xFB, 0xE0, 0xF8, 0x3F, 0x7C,
  0x1F, 0x07, 0xCF, 0x87, 0xE0, 0xF9, 0xF0, 0xFC, 0x3F, 0x3E, 0x1F, 0x87,
  0xC7, 0xC7, 0xF0, 0xF8, 0xF8, 0xFE, 0x3F, 0x1F, 0x1D, 0xC7, 0xC3, 0xE7,
  0xB8, 0xF8, 0x7C, 0xF7, 0x3F, 0x0F, 0xBC, 0xE7, 0xC1, 0xF7, 0x9C, 0xF8,
  0x3E, 0xF3, 0x9E, 0x07, 0xFC, 0x77, 0xC0, 0xFF, 0x8E, 0xF8, 0x1E, 0xE1,
  0xDE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xE0, 0xFE, 0x01,
  0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F,
  0xC0, 0x1F, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x3F,
  0x80, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0x1F, 0x83, 0xF8, 0x00,
  0xFC, 0x1F, 0xC0, 0x03, 0xF1, 0xFC, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFE,
  0x7E, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xE0, 0x7F,
  0x00, 0x7F, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xF0,
  0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x1F,
  0x80, 0x3F, 0x80, 0x7E, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x03, 0xF0,
  0x1F, 0x80, 0x0F, 0xC0, 0xFE, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x1F,
  0xC0, 0x01, 0xF0, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x9F, 0xC0,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFB, 0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x04, 0x00, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3C,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x07, 0x9F, 0xFF, 0x01, 0xF3, 0xFF, 0xF0, 0x3E, 0xFF, 0xFF, 0x9F,
  0x9F, 0x07, 0xFF, 0xF7, 0xC0, 0x7F, 0xFC, 0xF0, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
};

const GFXglyph RobotoMono_SemiBoldItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 12, 35, 29, 9, -35 },
  { 54, 16, 13, 29, 8, -37 },
  { 80, 29, 35, 29, 0, -35 },
  { 207, 26, 45, 29, 2, -40 },
  { 354, 24, 36, 29, 3, -35 },
  { 462, 27, 36, 29, 1, -35 },
  { 584, 7, 13, 29, 12, -37 },
  { 596, 16, 50, 29, 8, -39 },
  { 696, 17, 50, 29, 4, -39 },
  { 803, 23, 25, 29, 4, -35 },
  { 875, 24, 26, 29, 2, -29 },
  { 953, 10, 15, 29, 5, -6 },
  { 972, 20, 5, 29, 6, -18 },
  { 985, 9, 9, 29, 8, -8 },
  { 996, 25, 38, 29, 2, -35 },
  { 1115, 24, 36, 29, 3, -35 },
  { 1223, 16, 35, 29, 6, -35 },
  { 1293, 26, 35, 29, 0, -35 },
  { 1407, 26, 36, 29, 1, -35 },
  { 1524, 26, 35, 29, 0, -35 },
  { 1638, 26, 36, 29, 2, -35 },
  { 1755, 23, 36, 29, 2, -35 },
  { 1859, 26, 35, 29, 3, -35 },
  { 1973, 25, 36, 29, 2, -35 },
  { 2086, 22, 35, 29, 4, -35 },
  { 2183, 12, 29, 29, 9, -28 },
  { 2227, 14, 37, 29, 7, -28 },
  { 2292, 23, 23, 29, 3, -27 },
  { 2359, 25, 16, 29, 2, -23 },
  { 2409, 23, 22, 29, 2, -26 },
  { 2473, 22, 35, 29, 6, -35 },
  { 2570, 28, 35, 29, 1, -35 },
  { 2693, 28, 35, 29, -2, -35 },
  { 2816, 27, 35, 29, 1, -35 },
  { 2935, 26, 36, 29, 2, -35 },
  { 3052, 26, 35, 29, 1, -35 },
  { 3166, 28, 35, 29, 1, -35 },
  { 3289, 29, 35, 29, 1, -35 },
  { 3416, 26, 36, 29, 2, -35 },
  { 3533, 29, 35, 29, 0, -35 },
  { 3660, 26, 35, 29, 2, -35 },
  { 3774, 27, 36, 29, 2, -35 },
  { 3896, 31, 35, 29, 1, -35 },
  { 4032, 23, 35, 29, 1, -35 },
  { 4133, 28, 35, 29, 1, -35 },
  { 4256, 29, 35, 29, 0, -35 },
  { 4383, 26, 36, 29, 2, -35 },
  { 4500, 28, 35, 29, 1, -35 },
  { 4623, 26, 41, 29, 2, -35 },
  { 4757, 27, 35, 29, 1, -35 },
  { 4876, 28, 36, 29, 1, -35 },
  { 5002, 27, 35, 29, 4, -35 },
  { 5121, 27, 36, 29, 2, -35 },
  { 5243, 27, 35, 29, 4, -35 },
  { 5362, 28, 35, 29, 3, -35 },
  { 5485, 32, 35, 29, -1, -35 },
  { 5625, 27, 35, 29, 5, -35 },
  { 5744, 29, 35, 29, 0, -35 },
  { 5871, 18, 48, 29, 6, -40 },
  { 5979, 12, 38, 29, 9, -35 },
  { 6036, 18, 48, 29, 6, -40 },
  { 6144, 19, 19, 29, 5, -35 },
  { 6190, 22, 5, 29, 0, 0 },
  { 6204, 9, 6, 29, 13, -35 },
  { 6211, 23, 27, 29, 2, -26 },
  { 6289, 25, 38, 29, 1, -37 },
  { 6408, 24, 27, 29, 2, -26 },
  { 6489, 27, 38, 29, 2, -37 },
  { 6618, 24, 27, 29, 2, -26 },
  { 6699, 27, 38, 29, 4, -38 },
  { 6828, 26, 36, 29, 1, -26 },
  { 6945, 25, 37, 29, 1, -37 },
  { 7061, 22, 36, 29, 2, -36 },
  { 7160, 23, 47, 29, 1, -36 },
  { 7296, 27, 37, 29, 1, -37 },
  { 7421, 22, 37, 29, 2, -37 },
  { 7523, 28, 26, 29, -1, -26 },
  { 7614, 25, 26, 29, 1, -26 },
  { 7696, 24, 27, 29, 2, -26 },
  { 7777, 27, 36, 29, -1, -26 },
  { 7899, 25, 36, 29, 2, -26 },
  { 8012, 24, 26, 29, 4, -26 },
  { 8090, 24, 27, 29, 2, -26 },
  { 8171, 22, 33, 29, 4, -32 },
  { 8262, 24, 27, 29, 3, -26 },
  { 8343, 25, 26, 29, 4, -26 },
  { 8425, 27, 26, 29, 3, -26 },
  { 8513, 29, 26, 29, 0, -26 },
  { 8608, 30, 37, 29, 0, -26 },
  { 8747, 26, 26, 29, 1, -26 },
  { 8832, 19, 47, 29, 7, -38 },
  { 8944, 11, 45, 29, 9, -35 },
  { 9006, 18, 47, 29, 5, -38 },
  { 9112, 27, 11, 29, 0, -20 },
};

const GFXfont RobotoMono_SemiBoldItalic49pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic49pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic49pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC49PT7B_H_
