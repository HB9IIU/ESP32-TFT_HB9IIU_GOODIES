#ifndef _ROBOTOMONO_SEMIBOLDITALIC51PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xF8, 0x00,
  0x3E, 0x1F, 0x3C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1E, 0x78, 0x1E,
  0x78, 0x3E, 0x78, 0x3E, 0xF8, 0x3C, 0xF8, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C,
  0xF0, 0x7C, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3C,
  0x1F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0xF8, 0x3C, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x7C, 0x1E, 0x00, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xC1, 0xE0, 0x00, 0x1F,
  0x07, 0x80, 0x00, 0x78, 0x3E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x83,
  0xC0, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0xC1, 0xE0,
  0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFE, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x78, 0x3E, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x00,
  0xFC, 0x0F, 0xC0, 0x1F, 0xC1, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x0F,
  0xE0, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1,
  0xF8, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF8, 0x1F, 0xE0, 0x7F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xC7, 0xC0, 0x03,
  0xC1, 0xE0, 0x43, 0xE0, 0xF0, 0x79, 0xF0, 0x78, 0x7C, 0xF8, 0x3C, 0x3C,
  0x7C, 0x3E, 0x3C, 0x3E, 0x1F, 0x3E, 0x1F, 0x0F, 0x1E, 0x07, 0xFF, 0x9E,
  0x03, 0xFF, 0x9E, 0x00, 0xFF, 0x9F, 0x00, 0x3F, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC7, 0xF0, 0x03, 0xCF, 0xFC, 0x03,
  0xEF, 0xFF, 0x01, 0xE7, 0xFF, 0x81, 0xE7, 0xC3, 0xC1, 0xF3, 0xE1, 0xF0,
  0xF1, 0xE0, 0xF8, 0xF0, 0xF0, 0x7C, 0xF0, 0x78, 0x3C, 0x18, 0x3C, 0x1E,
  0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x02, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xEF, 0xE0, 0x01, 0xF8, 0x3E, 0x00, 0x3F, 0x03, 0xF0, 0x03,
  0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x0F,
  0xE0, 0x03, 0xF1, 0xFC, 0x00, 0x3F, 0x3F, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x03, 0xF1, 0xFF, 0xF8, 0x3F,
  0x3F, 0xDF, 0x83, 0xF7, 0xF9, 0xFC, 0x7E, 0x7F, 0x0F, 0xE7, 0xE7, 0xE0,
  0x7E, 0xFE, 0xFE, 0x07, 0xFF, 0xCF, 0xE0, 0x3F, 0xFC, 0xFC, 0x03, 0xFF,
  0x8F, 0xE0, 0x1F, 0xF0, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFB,
  0xF8, 0x07, 0xFE, 0x1F, 0xC0, 0x06, 0x00, 0x00, 0x3E, 0x79, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3C, 0xF9, 0xF3, 0xE7, 0x8F, 0x00, 0x00, 0x03, 0x00, 0x03,
  0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x80, 0x78, 0x00, 0x70, 0x3C,
  0x0E, 0x3E, 0x1E, 0x1F, 0x3F, 0xCF, 0x3F, 0xBF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xEF, 0x00, 0x03, 0xF7, 0xC0, 0x03, 0xF1, 0xF0, 0x03,
  0xF0, 0xF8, 0x03, 0xF0, 0x3E, 0x03, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0xC0,
  0x18, 0x03, 0x80, 0x04, 0x01, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x07, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x1F, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7C,
  0x3E, 0x07, 0x80, 0x40, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x3E, 0x3F, 0xBF, 0xDF,
  0xEF, 0xFF, 0xFB, 0xFC, 0xFC, 0x18, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F,
  0xEF, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0x80, 0x7E, 0x1F, 0xC0, 0x3F, 0x0F,
  0xC0, 0x1F, 0xC7, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x03, 0xF9,
  0xF8, 0x03, 0xFC, 0xFC, 0x03, 0xFE, 0x7E, 0x07, 0xFE, 0x7F, 0x07, 0xFF,
  0x3F, 0x0F, 0xFF, 0x9F, 0x8F, 0xCF, 0xCF, 0xDF, 0xCF, 0xE7, 0xFF, 0x87,
  0xF3, 0xFF, 0x83, 0xF3, 0xFF, 0x01, 0xF9, 0xFF, 0x00, 0xFC, 0xFF, 0x00,
  0x7E, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0,
  0x0F, 0xC7, 0xF0, 0x0F, 0xC1, 0xF8, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x80, 0x07, 0xC0, 0x1F,
  0xE0, 0x7F, 0xF1, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F,
  0x7F, 0x7C, 0x3F, 0xB0, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFE, 0x07, 0xF0, 0x3F,
  0x80, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x3F,
  0x8F, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFD, 0xFF,
  0x81, 0xFC, 0x07, 0xF0, 0x7F, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xE1, 0xF8,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x7F,
  0x00, 0x1F, 0x8F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x3F,
  0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xEF, 0xC0, 0x03, 0xF3,
  0xF0, 0x00, 0xFD, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x1F,
  0x87, 0xE0, 0x07, 0xC1, 0xF8, 0x03, 0xF0, 0xFE, 0x01, 0xF8, 0x3F, 0x80,
  0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F,
  0x07, 0xE0, 0x1F, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x78, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFC, 0x7F, 0xC0, 0x1E,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xE3, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x0F, 0xE0, 0x0F, 0xE0,
  0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x8F, 0xC0, 0x3F, 0x3F, 0xF0,
  0x3F, 0x7F, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x7F, 0xE1, 0xFE,
  0x7F, 0x80, 0xFE, 0x7F, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x7F, 0x01, 0xFC,
  0x3F, 0x83, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xBF, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0x80,
  0x7E, 0x0F, 0xE0, 0x1F, 0xC3, 0xF0, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x3F,
  0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xE0, 0xFE, 0x07, 0xF0,
  0x1F, 0xC3, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xF0, 0x7F, 0x03, 0xF8,
  0x0F, 0xE1, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0x8F,
  0xE0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x80, 0x3F,
  0x8F, 0xE0, 0x1F, 0xE1, 0xFC, 0x0F, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFE, 0xFF, 0x0F, 0xF0, 0x7F, 0x1F,
  0x80, 0x7E, 0x7F, 0x00, 0xFE, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xF3, 0xF8, 0x3F,
  0xE7, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x07, 0xFE, 0xFC,
  0x07, 0xF1, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x3F, 0x83, 0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xF8,
  0x3F, 0xC0, 0xFC, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x01, 0xFC, 0x0F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0xFE, 0x03,
  0xE0, 0x04, 0x00, 0x00, 0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x7E, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0,
  0x0F, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x3F,
  0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x10, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xF8, 0x0C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x9F, 0xE0, 0x7F, 0x3F, 0x80, 0x7E,
  0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x0F, 0x80,
  0x03, 0x80, 0xF8, 0x00, 0x1E, 0x0F, 0x87, 0xF8, 0xF0, 0x78, 0x7F, 0xE3,
  0x87, 0x87, 0xFF, 0x1C, 0x3C, 0x7E, 0x78, 0xE3, 0xC3, 0xC3, 0xC7, 0x1E,
  0x3C, 0x1C, 0x38, 0xF1, 0xE0, 0xE1, 0xCF, 0x1E, 0x0F, 0x0E, 0x78, 0xF0,
  0x78, 0x73, 0xC7, 0x83, 0xC7, 0x9C, 0x3C, 0x1C, 0x3D, 0xE3, 0xC1, 0xE1,
  0xCF, 0x1E, 0x0F, 0x0E, 0x78, 0xF0, 0x78, 0xF3, 0xC7, 0x83, 0x87, 0x1E,
  0x3C, 0x3C, 0x38, 0xF1, 0xF7, 0xE3, 0x87, 0x87, 0xFF, 0xFC, 0x3C, 0x3F,
  0xBF, 0xC0, 0xF0, 0xF8, 0xFC, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x10, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0x7C, 0x00,
  0x01, 0xFB, 0xE0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F,
  0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xFC, 0x0F, 0x80,
  0x0F, 0xC0, 0x7E, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xF8,
  0x7F, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF3, 0xF8,
  0x00, 0x1F, 0x9F, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xF0, 0x0F, 0xF8, 0x1F, 0x80, 0x1F, 0xC0,
  0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x1F, 0x83, 0xF8,
  0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x07,
  0xF0, 0x7F, 0x00, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x03, 0xF8,
  0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01,
  0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF0,
  0xFE, 0x00, 0x3F, 0x87, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0xC1, 0xF8,
  0x07, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xFC, 0x07, 0xF0, 0x7F, 0x00, 0x7E,
  0x0F, 0xC0, 0x0F, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x9F, 0xC0,
  0x03, 0xF3, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0x8F, 0xE0, 0x07, 0xF0, 0xFC,
  0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x83, 0xFC, 0x0F, 0xE0, 0x3F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00,
  0x7E, 0x0F, 0xF8, 0x07, 0xE0, 0x3F, 0xC0, 0xFE, 0x01, 0xFC, 0x0F, 0xE0,
  0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E,
  0x0F, 0xC0, 0x07, 0xE1, 0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x07, 0xE1, 0xFC,
  0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07,
  0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3, 0xF0, 0x00, 0xFC, 0x3F,
  0x00, 0x0F, 0xC3, 0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xF0, 0x03,
  0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x07,
  0xE0, 0x3F, 0xE0, 0x7E, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x81, 0xFC, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xC0, 0x0F,
  0xE3, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x9F, 0xC0, 0x03, 0xF3, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x03,
  0xFF, 0xEF, 0xE0, 0x7F, 0xFD, 0xFC, 0x0F, 0xFF, 0x3F, 0x81, 0xFF, 0xE7,
  0xF0, 0x3F, 0xFC, 0xFE, 0x00, 0x1F, 0x9F, 0xC0, 0x07, 0xF3, 0xF8, 0x00,
  0xFE, 0x7F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F,
  0xC0, 0x1F, 0xC1, 0xFC, 0x07, 0xF8, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x3F,
  0x80, 0x1F, 0xC0, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0,
  0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x03,
  0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC,
  0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x03,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x80, 0x0F,
  0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0,
  0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x07, 0xF0, 0x01, 0xF8, 0x1F,
  0x80, 0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0,
  0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x0F,
  0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00,
  0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x03, 0xF0,
  0x01, 0xFE, 0x03, 0xF0, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xF0,
  0x0F, 0xF0, 0x07, 0xE0, 0x1F, 0xE0, 0x07, 0xE0, 0x3F, 0xC0, 0x07, 0xE0,
  0x7F, 0x80, 0x0F, 0xE0, 0xFF, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x0F, 0xE1,
  0xFE, 0x00, 0x0F, 0xC3, 0xFC, 0x00, 0x0F, 0xC7, 0xF8, 0x00, 0x0F, 0xCF,
  0xF0, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xF7, 0xF0, 0x00, 0x3F, 0xE7,
  0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x3F, 0x01,
  0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0x3F, 0xC0, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF0,
  0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x1F,
  0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC1, 0xFF, 0x83, 0xFF, 0x0F, 0xFC,
  0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF9, 0xFF, 0xC0, 0xFF, 0xE7, 0xFF, 0x03,
  0xEF, 0xBE, 0xFC, 0x0F, 0xBE, 0xFB, 0xE0, 0x7E, 0xFF, 0xCF, 0x81, 0xF9,
  0xFF, 0x7E, 0x07, 0xE7, 0xF9, 0xF8, 0x1F, 0x9F, 0xE7, 0xE0, 0x7E, 0x7F,
  0x1F, 0x81, 0xF1, 0xFC, 0x7C, 0x0F, 0xC7, 0xE3, 0xF0, 0x3F, 0x1F, 0x8F,
  0xC0, 0xFC, 0x7C, 0x3F, 0x03, 0xF1, 0xF0, 0xFC, 0x0F, 0xC3, 0x83, 0xF0,
  0x3E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F,
  0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x0F, 0xC0,
  0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0x1F, 0xC0, 0xFF, 0x00, 0x7E,
  0x03, 0xFC, 0x01, 0xF8, 0x0F, 0xF8, 0x07, 0xE0, 0x3F, 0xE0, 0x3F, 0x81,
  0xFF, 0x80, 0xFE, 0x07, 0xFE, 0x03, 0xF8, 0x1F, 0xFC, 0x0F, 0xC0, 0x7F,
  0xF0, 0x3F, 0x01, 0xFF, 0xC0, 0xFC, 0x07, 0xFF, 0x07, 0xF0, 0x3F, 0xBE,
  0x1F, 0xC0, 0xFE, 0xF8, 0x7E, 0x03, 0xF3, 0xE1, 0xF8, 0x0F, 0xCF, 0x87,
  0xE0, 0x3F, 0x1F, 0x1F, 0x80, 0xFC, 0x7C, 0xFE, 0x07, 0xF1, 0xF3, 0xF8,
  0x1F, 0xC7, 0xEF, 0xC0, 0x7E, 0x0F, 0xBF, 0x01, 0xF8, 0x3E, 0xFC, 0x07,
  0xE0, 0xFB, 0xF0, 0x3F, 0x81, 0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0x03, 0xF8,
  0x1F, 0xF8, 0x0F, 0xC0, 0x7F, 0xE0, 0x3F, 0x00, 0xFF, 0x80, 0xFC, 0x03,
  0xFE, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xC0, 0x3F, 0xE0, 0x7E, 0x00, 0x7F,
  0x01, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFC, 0x0F, 0xE0,
  0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00,
  0x3F, 0x1F, 0xC0, 0x07, 0xF3, 0xF0, 0x00, 0xFE, 0x7E, 0x00, 0x1F, 0xDF,
  0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xEF, 0xC0, 0x01,
  0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xEF, 0xE0, 0x01, 0xFD, 0xFC,
  0x00, 0x3F, 0xBF, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F,
  0x9F, 0x80, 0x07, 0xF3, 0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0x8F, 0xE0,
  0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFC,
  0x00, 0x7F, 0x07, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0xC1, 0xF8, 0x00,
  0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xE0, 0x01, 0xF8,
  0x3F, 0x00, 0x1F, 0xC1, 0xF8, 0x01, 0xFE, 0x0F, 0xC0, 0x3F, 0xE0, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFC, 0x0F, 0xF0, 0x7F, 0x00, 0xFE, 0x0F,
  0xC0, 0x0F, 0xC3, 0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x9F, 0xC0, 0x07,
  0xF3, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xDF, 0xC0, 0x01, 0xFB, 0xF8,
  0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x3F,
  0x3F, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x1F, 0xBF, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0xFE, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF3,
  0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0x8F, 0xE0, 0x07, 0xF0, 0xFC, 0x00,
  0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xFC, 0x1F, 0xE0, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x60, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xF0, 0x0F, 0xF8, 0x1F, 0x80, 0x1F, 0xC0,
  0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x1F, 0x83, 0xF8,
  0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x03,
  0xF8, 0x3F, 0x00, 0x3F, 0x83, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0xC0,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x3F,
  0x00, 0x3F, 0x01, 0xFC, 0x01, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00,
  0xFE, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0x7F, 0x01, 0xF8,
  0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x01,
  0xFC, 0x3F, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0xFE, 0x00,
  0xFE, 0x1F, 0xC0, 0x07, 0xE1, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x07, 0xF1,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC,
  0x00, 0x1F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x07, 0xF8, 0x0F,
  0xF0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x03,
  0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7F, 0x0F,
  0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00,
  0x7E, 0x1F, 0xC0, 0x0F, 0xE1, 0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xC1,
  0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC3, 0xF8, 0x00, 0xFC, 0x3F, 0x80,
  0x1F, 0xC3, 0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8,
  0x3F, 0x00, 0x1F, 0x87, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xE0,
  0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F,
  0x07, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xE0, 0x7E,
  0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x83, 0xFC, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF7, 0xE0,
  0x00, 0xFE, 0x7E, 0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F,
  0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x3F,
  0x00, 0x7F, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x0F,
  0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x81, 0xF8, 0x01,
  0xF8, 0x3F, 0x80, 0x1F, 0x83, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x87,
  0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x8F, 0xE0, 0x01, 0xF8, 0xFC, 0x00,
  0x0F, 0x9F, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x07, 0xC1, 0xFB, 0xF0, 0x7C, 0x0F, 0xDF, 0x83, 0xE0, 0x7E,
  0xFC, 0x1F, 0x07, 0xE7, 0xE1, 0xF8, 0x3F, 0x3F, 0x0F, 0xC1, 0xF9, 0xF8,
  0x7E, 0x0F, 0x8F, 0xC7, 0xF0, 0xFC, 0x7E, 0x3F, 0x87, 0xE3, 0xF1, 0xFC,
  0x3F, 0x1F, 0x8F, 0xE1, 0xF0, 0xF8, 0xFF, 0x1F, 0x87, 0xC7, 0xF8, 0xFC,
  0x3E, 0x3F, 0xC7, 0xC1, 0xF3, 0xFE, 0x3E, 0x0F, 0x9F, 0xF3, 0xF0, 0x7C,
  0xF7, 0x9F, 0x83, 0xEF, 0xBC, 0xF8, 0x1F, 0x7D, 0xEF, 0xC0, 0xFB, 0xCF,
  0x7E, 0x07, 0xFE, 0x7B, 0xE0, 0x3F, 0xF3, 0xDF, 0x01, 0xFF, 0x1F, 0xF8,
  0x0F, 0xF8, 0xFF, 0xC0, 0x7F, 0xC7, 0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x1F,
  0xE1, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x83,
  0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFE, 0x00, 0xFE, 0x07, 0xF0,
  0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x03, 0xF1, 0xFE, 0x00, 0x00, 0x7E, 0x3F, 0x80,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x3F,
  0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00, 0xFE,
  0x0F, 0xC0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x03,
  0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0xE0,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0xC0, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFE, 0x7E, 0x00, 0x1F,
  0xC7, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0x3F,
  0x00, 0x7F, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x01, 0xF8, 0x1F,
  0xC0, 0x1F, 0x83, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC7, 0xF0, 0x00,
  0xFC, 0x7E, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xE0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xF8, 0x0F,
  0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x07,
  0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x01,
  0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x80,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x00, 0xFF, 0xE0,
  0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0xC0, 0x1F, 0x7C, 0x03, 0xF7, 0xC0, 0x3E, 0x7C, 0x07, 0xE3, 0xC0,
  0x7C, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1F, 0x01, 0xE3, 0xF0, 0x1F,
  0x3E, 0x01, 0xF7, 0xE0, 0x1F, 0xFC, 0x01, 0xF0, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0xFC,
  0x3F, 0x1F, 0x87, 0xE1, 0xF0, 0x7C, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0xF3,
  0xFE, 0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0x7F, 0x3F, 0x80, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x01, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0x80, 0x7E, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01,
  0xFC, 0xFE, 0x07, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFE,
  0xFC, 0x3F, 0xFC, 0xFC, 0x0F, 0xF8, 0xFC, 0x01, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x9F,
  0xE0, 0x07, 0xEF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x0F, 0xF0, 0x3F, 0x83, 0xF8, 0x0F, 0xE1, 0xFC, 0x01, 0xF8,
  0x7F, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0xC7, 0xE0, 0x07, 0xF1, 0xF8, 0x01,
  0xFC, 0x7E, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xE3, 0xF0,
  0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x8F, 0xC0, 0x0F, 0xC7,
  0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0xC1, 0xFE, 0x1F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFC, 0xFF, 0xF0, 0x3F, 0x1F,
  0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F,
  0xC0, 0xFE, 0x3F, 0x80, 0x7E, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFE, 0x01, 0xF8, 0x7F,
  0x03, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x0F,
  0xF8, 0xFC, 0x01, 0xFF, 0xDF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x03, 0xF8, 0x3F,
  0x80, 0x3F, 0x83, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x07, 0xF0, 0x03,
  0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7F, 0x07,
  0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00,
  0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xE0,
  0x7F, 0x83, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFE, 0xFC, 0x00, 0x7F, 0x8F, 0x80, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xC1, 0xFC, 0x3F,
  0x80, 0x7E, 0x3F, 0x80, 0x1F, 0x9F, 0xC0, 0x0F, 0xCF, 0xC0, 0x07, 0xEF,
  0xE0, 0x03, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x01, 0x03, 0xF8, 0x01, 0xC0, 0xFE, 0x01,
  0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFC, 0x02, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0xFC, 0x03, 0xFF, 0xDF, 0x80,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFC, 0x0F,
  0xF0, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xC3, 0xF8, 0x01, 0xF8, 0xFE,
  0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F,
  0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0,
  0x07, 0xF1, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0,
  0x7F, 0x00, 0xFE, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFD, 0xF8, 0x01, 0xFF, 0x3F, 0x00,
  0x02, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x04, 0x00, 0x7F, 0x01, 0x80, 0x0F,
  0xE0, 0x78, 0x07, 0xF8, 0x1F, 0xF7, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x8F, 0xF0, 0x0F, 0xCF, 0xFE, 0x03, 0xF7, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xF0, 0x3F, 0xC3, 0xF8, 0x07, 0xF1,
  0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03,
  0xF1, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0x8F, 0xC0,
  0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x9F,
  0xC0, 0x0F, 0xC7, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F,
  0x1F, 0x80, 0x1F, 0xC7, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xF8, 0xFE, 0x00,
  0x7E, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x01,
  0x8F, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0x0F,
  0xE0, 0x1F, 0xE0, 0xFE, 0x03, 0xFC, 0x0F, 0xC0, 0x7F, 0x80, 0xFC, 0x0F,
  0xF0, 0x0F, 0xC1, 0xFE, 0x00, 0xFC, 0x3F, 0xC0, 0x1F, 0xCF, 0xF8, 0x01,
  0xFD, 0xFE, 0x00, 0x1F, 0xBF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x03, 0xFE, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF0,
  0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xFC,
  0x07, 0xE0, 0x1F, 0xC0, 0x7E, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE,
  0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xCF, 0xC7, 0xE0,
  0x3E, 0xFF, 0x7F, 0x81, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x87, 0xE3, 0xF8, 0xFC, 0x3F, 0x0F, 0xC3, 0xE1, 0xF0, 0x7C,
  0x1F, 0x0F, 0x87, 0xE1, 0xF8, 0xFC, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0x7E,
  0x3F, 0x0F, 0xC3, 0xF1, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0xFC,
  0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC3, 0xF1, 0xF8, 0x7E,
  0x1F, 0x8F, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x07, 0xC7, 0xE1, 0xF8, 0x7E,
  0x3F, 0x0F, 0xC3, 0xF1, 0xF8, 0x7E, 0x1F, 0x8F, 0xC3, 0xF0, 0xFC, 0x7E,
  0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x3E, 0x3F, 0x0F, 0xC3, 0xF0, 0x07, 0xC3,
  0xFC, 0x03, 0xF3, 0xFF, 0x80, 0xFD, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x7F,
  0x1F, 0xC0, 0x1F, 0xC7, 0xE0, 0x07, 0xF1, 0xF8, 0x01, 0xFC, 0x7E, 0x00,
  0x7F, 0x3F, 0x80, 0x1F, 0x8F, 0xE0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC,
  0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x8F, 0xC0, 0x0F, 0xE7, 0xF0, 0x03, 0xF1,
  0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x07,
  0xF1, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0x8F, 0xC0,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0x83, 0xFC,
  0x3F, 0x80, 0xFE, 0x3F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0xDF, 0xC0, 0x07,
  0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x7F, 0x00, 0x1F, 0xBF, 0x80,
  0x1F, 0xDF, 0xC0, 0x0F, 0xE7, 0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC,
  0x0F, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x01, 0xF1, 0xFE,
  0x00, 0x3F, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xC1, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x00,
  0x7E, 0x07, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF0,
  0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xC0,
  0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0xFE,
  0x0F, 0xC0, 0x0F, 0xC1, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0xC1, 0xFE,
  0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x03, 0xFB, 0xFF, 0xC0, 0x3F, 0x9F, 0xF0, 0x03, 0xF0, 0x10, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE3, 0xF0, 0x1F, 0xFC, 0xFC, 0x1F, 0xFF, 0xBF, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x3F,
  0x8F, 0xC0, 0x0F, 0xE7, 0xF0, 0x03, 0xF1, 0xFC, 0x00, 0xFC, 0x7E, 0x00,
  0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x07, 0xF1, 0xF8, 0x01, 0xFC, 0xFE,
  0x00, 0x7E, 0x3F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8,
  0x7E, 0x00, 0xFE, 0x1F, 0xC0, 0x7F, 0x87, 0xF8, 0x3F, 0xC0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xEF, 0xC0, 0x1F,
  0xE7, 0xE0, 0x00, 0xC1, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x20, 0x0F, 0xC3, 0xFF, 0x0F, 0xCF, 0xFE, 0x0F, 0xDF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xF8, 0x04, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0xFF, 0x8F, 0xF0, 0xFE, 0x01, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x38, 0x00, 0x1F, 0x9F, 0x80,
  0x0F, 0xCF, 0xE0, 0x07, 0xE3, 0xF0, 0x07, 0xF1, 0xFE, 0x0F, 0xF8, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x3F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x01, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x1F, 0x80, 0x1F, 0x8F,
  0xC0, 0x0F, 0xCF, 0xE0, 0x07, 0xE7, 0xF0, 0x03, 0xF3, 0xF0, 0x03, 0xF9,
  0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0x3F,
  0x3F, 0x80, 0x3F, 0x9F, 0x80, 0x1F, 0xCF, 0xC0, 0x0F, 0xC7, 0xE0, 0x07,
  0xE3, 0xF0, 0x03, 0xF3, 0xF8, 0x01, 0xF9, 0xFC, 0x01, 0xFC, 0xFC, 0x00,
  0xFE, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x8F, 0xE0,
  0x1F, 0xC7, 0xF0, 0x3F, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFD, 0xF0, 0x3F,
  0xFD, 0xF8, 0x1F, 0xFC, 0xFC, 0x03, 0xFC, 0x7E, 0x00, 0x10, 0x00, 0x00,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xEF, 0xC0, 0x03, 0xF1, 0xF8, 0x01,
  0xFC, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x87, 0xE0, 0x0F, 0xC1, 0xF8,
  0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x00,
  0xFC, 0x0F, 0xC0, 0x1F, 0x07, 0xE0, 0x07, 0xC1, 0xF8, 0x01, 0xF0, 0xFC,
  0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xE7, 0xE0, 0x00, 0xFB,
  0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x03, 0xFF, 0x81, 0xF0, 0x7E, 0xF8,
  0x1F, 0x07, 0xEF, 0x83, 0xF0, 0x7E, 0xF8, 0x3F, 0x07, 0xCF, 0x83, 0xF0,
  0xFC, 0xF8, 0x7F, 0x0F, 0x8F, 0x87, 0xF0, 0xF8, 0xF8, 0x7F, 0x1F, 0x8F,
  0x8F, 0xF1, 0xF0, 0xF8, 0xFF, 0x1F, 0x0F, 0x9E, 0xF3, 0xF0, 0xF9, 0xEF,
  0x3E, 0x0F, 0x9E, 0xF3, 0xE0, 0xFB, 0xCF, 0x7E, 0x0F, 0xBC, 0xF7, 0xC0,
  0xFB, 0xCF, 0x7C, 0x0F, 0xF8, 0xF7, 0xC0, 0xFF, 0x8F, 0xF8, 0x0F, 0xF0,
  0xFF, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xF0,
  0x0F, 0xE0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F,
  0x00, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x07, 0xF0,
  0xFF, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7E, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0xDF, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0xC3,
  0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x3F,
  0x81, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x03,
  0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x1F,
  0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x7F,
  0x00, 0x01, 0xF8, 0x7F, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0xF8, 0xFC,
  0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x4F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x20, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0xE0, 0x07, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x01, 0xFF,
  0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xC0, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x0F,
  0x1F, 0xFE, 0x00, 0xF3, 0xFF, 0xF0, 0x1F, 0x7F, 0xFF, 0xC3, 0xF7, 0xE1,
  0xFF, 0xFE, 0x7C, 0x0F, 0xFF, 0xEF, 0x80, 0x7F, 0xFC, 0xF8, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x08, 0x00,
};

const GFXglyph RobotoMono_SemiBoldItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 30, 0, -1 },
  { 1, 13, 36, 30, 9, -36 },
  { 60, 16, 13, 30, 9, -38 },
  { 86, 30, 36, 30, 0, -36 },
  { 221, 27, 47, 30, 2, -42 },
  { 380, 25, 38, 30, 3, -37 },
  { 499, 28, 38, 30, 1, -37 },
  { 632, 7, 13, 30, 13, -38 },
  { 644, 17, 51, 30, 8, -40 },
  { 753, 17, 52, 30, 4, -40 },
  { 864, 25, 25, 30, 4, -36 },
  { 943, 26, 26, 30, 2, -30 },
  { 1028, 10, 16, 30, 5, -6 },
  { 1048, 21, 6, 30, 6, -19 },
  { 1064, 9, 9, 30, 9, -8 },
  { 1075, 27, 39, 30, 2, -36 },
  { 1207, 25, 38, 30, 3, -37 },
  { 1326, 17, 36, 30, 6, -36 },
  { 1403, 27, 37, 30, 0, -37 },
  { 1528, 27, 38, 30, 1, -37 },
  { 1657, 26, 36, 30, 1, -36 },
  { 1774, 27, 37, 30, 2, -36 },
  { 1899, 24, 38, 30, 2, -37 },
  { 2013, 27, 36, 30, 3, -36 },
  { 2135, 26, 38, 30, 2, -37 },
  { 2259, 23, 37, 30, 4, -37 },
  { 2366, 13, 30, 30, 9, -29 },
  { 2415, 15, 39, 30, 7, -29 },
  { 2489, 23, 24, 30, 4, -28 },
  { 2558, 25, 16, 30, 3, -24 },
  { 2608, 24, 23, 30, 2, -27 },
  { 2677, 23, 37, 30, 6, -37 },
  { 2784, 29, 36, 30, 1, -36 },
  { 2915, 29, 36, 30, -2, -36 },
  { 3046, 29, 36, 30, 1, -36 },
  { 3177, 27, 38, 30, 2, -37 },
  { 3306, 28, 36, 30, 1, -36 },
  { 3432, 30, 36, 30, 1, -36 },
  { 3567, 30, 36, 30, 1, -36 },
  { 3702, 27, 38, 30, 2, -37 },
  { 3831, 30, 36, 30, 0, -36 },
  { 3966, 27, 36, 30, 2, -36 },
  { 4088, 28, 37, 30, 2, -36 },
  { 4218, 32, 36, 30, 1, -36 },
  { 4362, 24, 36, 30, 1, -36 },
  { 4470, 30, 36, 30, 1, -36 },
  { 4605, 30, 36, 30, 0, -36 },
  { 4740, 27, 38, 30, 2, -37 },
  { 4869, 29, 36, 30, 1, -36 },
  { 5000, 27, 43, 30, 2, -37 },
  { 5146, 29, 36, 30, 1, -36 },
  { 5277, 28, 38, 30, 2, -37 },
  { 5410, 29, 36, 30, 4, -36 },
  { 5541, 28, 37, 30, 2, -36 },
  { 5671, 28, 36, 30, 4, -36 },
  { 5797, 29, 36, 30, 3, -36 },
  { 5928, 35, 36, 30, -2, -36 },
  { 6086, 28, 36, 30, 5, -36 },
  { 6212, 30, 36, 30, 0, -36 },
  { 6347, 19, 50, 30, 6, -42 },
  { 6466, 12, 39, 30, 10, -36 },
  { 6525, 19, 50, 30, 6, -42 },
  { 6644, 20, 19, 30, 5, -36 },
  { 6692, 23, 5, 30, 0, 0 },
  { 6707, 9, 7, 30, 14, -37 },
  { 6715, 24, 29, 30, 2, -28 },
  { 6802, 26, 39, 30, 1, -38 },
  { 6929, 24, 29, 30, 3, -28 },
  { 7016, 28, 39, 30, 2, -38 },
  { 7153, 25, 29, 30, 2, -28 },
  { 7244, 28, 39, 30, 4, -39 },
  { 7381, 27, 39, 30, 1, -28 },
  { 7513, 26, 38, 30, 1, -38 },
  { 7637, 22, 37, 30, 3, -37 },
  { 7739, 23, 48, 30, 1, -37 },
  { 7877, 28, 38, 30, 1, -38 },
  { 8010, 23, 38, 30, 2, -38 },
  { 8120, 29, 27, 30, -1, -27 },
  { 8218, 26, 27, 30, 1, -27 },
  { 8306, 25, 29, 30, 2, -28 },
  { 8397, 28, 37, 30, -1, -27 },
  { 8527, 26, 38, 30, 2, -28 },
  { 8651, 24, 28, 30, 5, -28 },
  { 8735, 25, 28, 30, 2, -27 },
  { 8823, 23, 35, 30, 4, -34 },
  { 8924, 25, 28, 30, 3, -27 },
  { 9012, 26, 27, 30, 4, -27 },
  { 9100, 28, 27, 30, 3, -27 },
  { 9195, 30, 27, 30, 0, -27 },
  { 9297, 32, 38, 30, 0, -27 },
  { 9449, 27, 27, 30, 1, -27 },
  { 9541, 20, 49, 30, 7, -40 },
  { 9664, 11, 46, 30, 9, -36 },
  { 9728, 19, 49, 30, 5, -40 },
  { 9845, 28, 11, 30, 0, -20 },
};

const GFXfont RobotoMono_SemiBoldItalic51pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic51pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic51pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC51PT7B_H_
