#ifndef _ROBOTOMONO_SEMIBOLDITALIC38PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x0F,
  0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC1, 0xF0, 0xF8, 0x7C, 0x3C, 0x00, 0x78, 0xF7, 0x0F, 0x70,
  0xE7, 0x0E, 0xF0, 0xEF, 0x1E, 0xE1, 0xEE, 0x1C, 0xE1, 0xCE, 0x1C, 0x00,
  0x1C, 0x38, 0x00, 0x71, 0xE0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x78,
  0xF0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x3C, 0x78, 0x1F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC0, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x0F,
  0x1E, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFE, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0xF0, 0x01,
  0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x78, 0x00, 0xE1, 0xC0, 0x03, 0x87,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0x83,
  0xE1, 0xF0, 0x3E, 0x1F, 0x01, 0xE1, 0xE0, 0x1F, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xCF,
  0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0xF8, 0xFC, 0x0F, 0x87, 0xFF, 0xF8,
  0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x80, 0x07, 0xF8, 0x01, 0xFF,
  0x00, 0x38, 0xF0, 0x87, 0x1E, 0x3D, 0xE3, 0xC7, 0x3C, 0x79, 0xC7, 0x8E,
  0x70, 0x7B, 0xDE, 0x0F, 0xF3, 0x80, 0xFC, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x9F, 0x80, 0xE7,
  0xF8, 0x3D, 0xEF, 0x07, 0x38, 0xF1, 0xCF, 0x1E, 0x79, 0xE3, 0x86, 0x38,
  0x70, 0x07, 0x8E, 0x00, 0xFB, 0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xDF, 0x00, 0x78, 0x78,
  0x07, 0xC3, 0xC0, 0x3C, 0x1E, 0x01, 0xE1, 0xF0, 0x0F, 0x9F, 0x00, 0x3D,
  0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0xC3, 0xE7, 0xFE, 0x1E, 0x7E, 0xF8, 0xF3, 0xE3, 0xEF, 0xBE, 0x1F,
  0x79, 0xF0, 0x7F, 0xCF, 0x83, 0xFC, 0x7C, 0x0F, 0xE3, 0xE0, 0x7E, 0x1F,
  0xDF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xF8, 0xF8, 0x7B, 0xDC,
  0xEF, 0x7B, 0xDC, 0xE7, 0x00, 0x00, 0x10, 0x03, 0x80, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78,
  0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x00, 0x08, 0x00, 0x02, 0x00, 0x18,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x03, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x01,
  0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x0F, 0x00, 0x70, 0x02, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0,
  0x08, 0x38, 0x17, 0x8E, 0x3D, 0xFB, 0xBF, 0xFF, 0xFF, 0xC3, 0xFF, 0xC0,
  0x1E, 0x00, 0x0F, 0x80, 0x07, 0x70, 0x03, 0xDE, 0x01, 0xE3, 0x80, 0xF0,
  0xF0, 0x7C, 0x1E, 0x06, 0x07, 0x01, 0x01, 0x00, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF,
  0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x3C, 0xF9, 0xF3, 0xE7, 0x9F,
  0x3C, 0xF9, 0xE1, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3C, 0xFD, 0xFF, 0xF7, 0xEF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF,
  0xE1, 0xF0, 0x7C, 0x3E, 0x07, 0x8F, 0x80, 0xF9, 0xF0, 0x1F, 0x3C, 0x03,
  0xE7, 0x80, 0xFD, 0xF0, 0x3F, 0xBE, 0x1F, 0xE7, 0xC7, 0xFC, 0xFB, 0xEF,
  0x9E, 0xF9, 0xF3, 0xFC, 0x3E, 0xFF, 0x07, 0xDF, 0x80, 0xF3, 0xE0, 0x3E,
  0x7C, 0x07, 0xCF, 0x80, 0xF8, 0xF0, 0x3E, 0x1F, 0x07, 0xC3, 0xFB, 0xF0,
  0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x30, 0x0F, 0x07,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFE, 0xF9, 0xEC, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F,
  0x83, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xE0, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xFF,
  0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFE, 0xFE, 0x1F, 0x83, 0xE1, 0xF0, 0x1F,
  0x1E, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0xF8,
  0x07, 0xCF, 0x80, 0xF8, 0xFC, 0x1F, 0x87, 0xF7, 0xF0, 0x7F, 0xFE, 0x03,
  0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07,
  0xBE, 0x00, 0xFB, 0xC0, 0x1F, 0x3C, 0x01, 0xE7, 0xC0, 0x3C, 0x7C, 0x07,
  0x87, 0xC0, 0xF8, 0x78, 0x1F, 0x07, 0x81, 0xE0, 0xF8, 0x3C, 0x0F, 0x87,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE7, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xE1, 0xF8,
  0x04, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0xF0, 0x0F, 0x8F, 0x81, 0xF8, 0xF8, 0x1F, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x7C, 0x1F, 0x7F, 0x8F, 0xFF, 0xE7, 0xFF,
  0xF7, 0xF0, 0xFF, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xF9, 0xF0, 0x7C, 0xFF, 0xFC,
  0x3F, 0xFC, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0x83,
  0xE0, 0xF8, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1E, 0x1F, 0x03, 0xE0, 0xF0,
  0x3E, 0x0F, 0x87, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x1F,
  0xFF, 0x03, 0xF0, 0xF8, 0x3E, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7,
  0x80, 0x7C, 0x78, 0x07, 0xC7, 0xC0, 0xFC, 0x7C, 0x0F, 0x87, 0xF7, 0xF8,
  0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xFF,
  0x07, 0xFF, 0x87, 0xF7, 0xE7, 0xE0, 0xF3, 0xE0, 0x7D, 0xE0, 0x3F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xE0, 0xFD, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xEF, 0x07, 0xEF, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xE0, 0x7F, 0xE0, 0x7F,
  0xC0, 0x3F, 0xC0, 0x1F, 0x80, 0x00, 0x0F, 0x0F, 0xC7, 0xE7, 0xF1, 0xF8,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x7E, 0x3F, 0x1F, 0x8F, 0xC3, 0xC0, 0x03, 0xC0, 0x7E, 0x07, 0xF0,
  0x7F, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x01,
  0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0F,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x03, 0xE0, 0x07, 0xF0,
  0x1F, 0xF8, 0x3F, 0xF8, 0xFF, 0xE1, 0xFF, 0x80, 0xFE, 0x00, 0x7C, 0x00,
  0x3F, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xF8, 0x00,
  0xFC, 0x00, 0x1E, 0x00, 0x02, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF,
  0xFF, 0xBF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xC0, 0x18,
  0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x07, 0xF8, 0x07,
  0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0x80, 0x03, 0xC0,
  0x00, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFF,
  0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0x81, 0xC0, 0x70, 0x07, 0x07,
  0x00, 0x18, 0x70, 0xF8, 0xE7, 0x9F, 0xE7, 0x38, 0xFF, 0x39, 0xCE, 0x39,
  0xDC, 0xF1, 0xCE, 0xE7, 0x0C, 0x7E, 0x38, 0x63, 0xF3, 0x87, 0x1B, 0x9C,
  0x38, 0xDC, 0xE1, 0x8E, 0xE7, 0x1C, 0x77, 0x38, 0xE3, 0x39, 0xFF, 0x39,
  0xC7, 0xDF, 0x8E, 0x3C, 0xF8, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x01,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7B, 0xC0, 0x07, 0xDE, 0x00,
  0x3C, 0xF8, 0x03, 0xE3, 0xC0, 0x1E, 0x1E, 0x01, 0xF0, 0xF0, 0x0F, 0x07,
  0x80, 0xF8, 0x3C, 0x07, 0xC1, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0x00, 0x78, 0xF8, 0x03, 0xCF, 0x80, 0x1E,
  0x7C, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3E, 0x0F, 0xFF, 0x00, 0x7F,
  0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xF0, 0x1F, 0x8F, 0x80, 0x7C,
  0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF0, 0x0F, 0x8F, 0x80,
  0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07,
  0x80, 0xFC, 0x7C, 0x03, 0xE3, 0xE0, 0x0F, 0x1F, 0x00, 0x78, 0xF8, 0x03,
  0xC7, 0x80, 0x3E, 0x7C, 0x03, 0xF3, 0xE0, 0x3F, 0x1F, 0xFF, 0xF8, 0xFF,
  0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFE,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xF8, 0x1F, 0x0F, 0x80, 0x78, 0x7C,
  0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0xC7,
  0x80, 0x3C, 0x3E, 0x03, 0xE1, 0xF0, 0x3E, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0x00, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x3E, 0x03,
  0xE1, 0xF0, 0x1F, 0x0F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E,
  0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x78, 0x03, 0xE7, 0xC0, 0x1F,
  0x3E, 0x00, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x78, 0x07, 0xC3, 0xC0,
  0x7E, 0x3E, 0x07, 0xE1, 0xF0, 0x7E, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x03,
  0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0x03, 0xE3,
  0xE0, 0x1E, 0x3E, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x87, 0xFE, 0xF8, 0x7F,
  0xEF, 0x07, 0xFC, 0xF0, 0x7F, 0xCF, 0x00, 0x7C, 0xF0, 0x07, 0xCF, 0x00,
  0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x78, 0x7C, 0x0F, 0x87, 0xFF, 0xF8, 0x3F,
  0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x07, 0xC0, 0x3C, 0x1E, 0x00,
  0xF0, 0x78, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xE0,
  0xF8, 0x07, 0x83, 0xC0, 0x3E, 0x0F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0,
  0x0F, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0x83, 0xC0, 0x1E, 0x0F,
  0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00,
  0xF0, 0x78, 0x03, 0xC1, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80,
  0x7C, 0x3C, 0x07, 0xC1, 0xF0, 0x7E, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00,
  0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x0F, 0x80, 0x7F, 0x0F, 0x80, 0x7E, 0x0F,
  0x80, 0xFC, 0x0F, 0x01, 0xF8, 0x1F, 0x03, 0xF0, 0x1F, 0x07, 0xE0, 0x1F,
  0x0F, 0xC0, 0x1F, 0x1F, 0x80, 0x1E, 0x3F, 0x00, 0x1E, 0x7E, 0x00, 0x3E,
  0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7C,
  0x3F, 0x00, 0x7C, 0x1F, 0x00, 0x78, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xE0, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xF8, 0x07, 0xE0, 0x7E, 0x0F, 0xC1, 0xFC, 0x1F, 0x83, 0xF0,
  0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x7F, 0x83, 0xF8, 0xFF, 0x07,
  0xFB, 0xFE, 0x0F, 0xF7, 0xF8, 0x3F, 0xFE, 0xF0, 0x7D, 0xFD, 0xE0, 0xF3,
  0xF3, 0xC1, 0xE7, 0xEF, 0x83, 0xCF, 0x9F, 0x07, 0x9F, 0x3C, 0x1F, 0x3C,
  0x78, 0x3E, 0x78, 0xF0, 0x78, 0xE3, 0xE0, 0xF0, 0x07, 0xC1, 0xE0, 0x0F,
  0x03, 0xC0, 0x1E, 0x0F, 0x80, 0x3C, 0x1F, 0x00, 0x78, 0x3C, 0x01, 0xF0,
  0x78, 0x03, 0xE0, 0xF0, 0x07, 0x83, 0xE0, 0x0F, 0x00, 0x07, 0xC0, 0x3C,
  0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC3, 0xF8, 0x1F, 0x0F, 0xE0, 0x7C, 0x3F,
  0x81, 0xE0, 0xFE, 0x0F, 0x83, 0xFC, 0x3E, 0x0F, 0xF0, 0xF8, 0x7F, 0xC3,
  0xE1, 0xF7, 0x0F, 0x87, 0xDE, 0x3C, 0x1F, 0x79, 0xF0, 0x78, 0xE7, 0xC1,
  0xE3, 0xDF, 0x0F, 0x8F, 0x7C, 0x3E, 0x3D, 0xF0, 0xF8, 0x77, 0x83, 0xE1,
  0xFE, 0x0F, 0x07, 0xF8, 0x7C, 0x1F, 0xE1, 0xF0, 0x3F, 0x87, 0xC0, 0xFC,
  0x1F, 0x03, 0xF0, 0x7C, 0x0F, 0xC1, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x00,
  0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0x83,
  0xE1, 0xF0, 0x1F, 0x1F, 0x01, 0xF3, 0xE0, 0x0F, 0x3E, 0x00, 0xF3, 0xC0,
  0x0F, 0x7C, 0x00, 0xF7, 0xC0, 0x0F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C,
  0x01, 0xF7, 0x80, 0x1F, 0x78, 0x01, 0xEF, 0x80, 0x3E, 0x78, 0x03, 0xE7,
  0x80, 0x3E, 0x78, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x0F, 0x83, 0xFF, 0xF0,
  0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x7F,
  0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xF8, 0x1F, 0x87, 0x80, 0x7C,
  0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0x80,
  0x3E, 0x3C, 0x03, 0xE3, 0xE0, 0x7F, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07,
  0xFF, 0xF0, 0x3F, 0xFC, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFE,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xF8, 0x3F, 0x0F, 0x80, 0xF8, 0x7C,
  0x03, 0xC7, 0xC0, 0x1E, 0x3E, 0x00, 0xF9, 0xE0, 0x07, 0xDF, 0x00, 0x3E,
  0xF8, 0x01, 0xE7, 0xC0, 0x0F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x00,
  0x3E, 0x78, 0x01, 0xF7, 0xC0, 0x0F, 0x3E, 0x00, 0xF8, 0xF0, 0x07, 0xC7,
  0x80, 0x7C, 0x3E, 0x03, 0xE1, 0xF8, 0x3E, 0x07, 0xFF, 0xE0, 0x3F, 0xFE,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x20, 0x0F, 0xFF, 0x00, 0x7F, 0xFE,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0x7C, 0x7C,
  0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF0, 0x07, 0xCF, 0x80, 0x7C,
  0x7C, 0x07, 0xE3, 0xE0, 0x7E, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF,
  0xC0, 0x7F, 0xFE, 0x03, 0xE0, 0xF0, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07,
  0x81, 0xF0, 0x3C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x07,
  0xC7, 0xC0, 0x3E, 0x3C, 0x01, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xFE, 0x01,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xF8, 0x1F, 0x8F, 0x80, 0x7C, 0x7C, 0x03,
  0xE3, 0xC0, 0x1F, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF9, 0xF0, 0x03, 0xCF, 0x80,
  0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80,
  0xFF, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0x87, 0x80, 0x7C,
  0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0x87, 0xC0,
  0x3C, 0x3C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7,
  0xC0, 0x3C, 0x3E, 0x01, 0xE1, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07,
  0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C,
  0x0F, 0x83, 0xF0, 0x7C, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0,
  0x03, 0xFC, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8,
  0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x81, 0xF8,
  0x7C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x07, 0xC0, 0x7C, 0x3E, 0x03, 0xE3,
  0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF0, 0x07, 0xCF, 0x80, 0x1E, 0x78, 0x00,
  0xF7, 0xC0, 0x07, 0xBE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x38, 0x3D, 0xE1, 0xE1, 0xF7, 0x87, 0x87, 0x9E, 0x1E,
  0x1E, 0x78, 0xF8, 0x79, 0xE3, 0xE3, 0xE7, 0x8F, 0x8F, 0x1E, 0x7E, 0x3C,
  0x79, 0xF9, 0xF1, 0xE7, 0xE7, 0x87, 0x9F, 0x9E, 0x1E, 0xFE, 0x78, 0x7B,
  0xBB, 0xE1, 0xEE, 0xEF, 0x07, 0xFB, 0xBC, 0x1F, 0xCE, 0xF0, 0x7F, 0x3F,
  0x81, 0xFC, 0xFE, 0x07, 0xE3, 0xF8, 0x1F, 0x8F, 0xE0, 0x7E, 0x3F, 0x01,
  0xF8, 0xFC, 0x07, 0xC3, 0xF0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x03, 0xE0,
  0xF8, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x1F, 0x80,
  0xF8, 0x0F, 0x80, 0x7C, 0x0F, 0xC0, 0x3E, 0x07, 0xC0, 0x0F, 0x87, 0xC0,
  0x07, 0xC7, 0xE0, 0x01, 0xE3, 0xE0, 0x00, 0xFB, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0xF9, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x7C,
  0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x7E, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x3F,
  0x00, 0xF8, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xBE,
  0x00, 0xF8, 0xF0, 0x0F, 0x87, 0xC0, 0xFC, 0x3E, 0x07, 0xC1, 0xF0, 0x7C,
  0x07, 0x83, 0xE0, 0x3E, 0x3E, 0x01, 0xF1, 0xE0, 0x07, 0x9F, 0x00, 0x3D,
  0xF0, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x80, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x00,
  0xF0, 0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF8, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xC1, 0xE0, 0xF0, 0x78, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01,
  0xE0, 0x0F, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0xFF, 0x01, 0xCE, 0x07,
  0x9C, 0x1E, 0x3C, 0x3C, 0x78, 0xF0, 0xF1, 0xE0, 0xE7, 0x81, 0xFF, 0x03,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x78,
  0xF0, 0xF0, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x7E, 0x3F,
  0x3F, 0x07, 0xCF, 0x80, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x07, 0xFF, 0xC7,
  0xFF, 0xF3, 0xFF, 0xFD, 0xF8, 0x1E, 0x7C, 0x07, 0xBE, 0x03, 0xEF, 0x80,
  0xFB, 0xE0, 0x7E, 0xFE, 0x7F, 0x9F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0x3E,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xEF, 0xE0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x7E, 0x0F, 0xCF, 0x80, 0xF9,
  0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0x80, 0x7C, 0xF0, 0x0F, 0xBE, 0x01, 0xF7,
  0xC0, 0x3E, 0xF8, 0x07, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x0F, 0x9F,
  0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xBF, 0x8F, 0x81, 0xF7, 0xC0,
  0x7D, 0xF0, 0x1F, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0xFB, 0xE0, 0x3C, 0x7C, 0x1F, 0x1F,
  0xDF, 0x83, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x7F, 0x3E, 0x0F, 0xFB,
  0xE1, 0xFF, 0xFC, 0x3F, 0xBF, 0xC3, 0xE0, 0xFC, 0x7C, 0x07, 0xC7, 0xC0,
  0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x78, 0xF8, 0x07, 0x8F, 0x80, 0xF8, 0xF0,
  0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x81, 0xF0, 0xF8, 0x3F, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xDF, 0x00, 0x03, 0xFC,
  0x01, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0x7E, 0x3E, 0x07, 0xDF, 0x01, 0xF7,
  0xC0, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x21, 0xF0, 0x18, 0x7F, 0xFF,
  0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x03, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0x03,
  0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0,
  0x3C, 0x7C, 0x03, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C,
  0x07, 0xC7, 0xE0, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x80,
  0xFE, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x60, 0x1F, 0x0F, 0x07, 0xE0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE7, 0xE0, 0x7B, 0xFF,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x7E, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F,
  0x3E, 0x03, 0xE7, 0x80, 0x7C, 0xF0, 0x0F, 0xBE, 0x01, 0xE7, 0xC0, 0x3C,
  0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xF3,
  0xE0, 0x1E, 0x7C, 0x07, 0xCF, 0x80, 0xF8, 0x00, 0x1C, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0xC0, 0x07, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x1F, 0xC7, 0xC1, 0xF8, 0x3E, 0x1F, 0x81, 0xE1, 0xF8, 0x1F, 0x1F,
  0x80, 0xF9, 0xF8, 0x07, 0xDF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0x3E, 0x01, 0xF1, 0xF8,
  0x0F, 0x07, 0xC0, 0x78, 0x3F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xE1, 0xF0,
  0x1F, 0x0F, 0x80, 0xFC, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF0, 0x0F, 0x7C, 0xF8, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xDF, 0x1F, 0x3E, 0x3C, 0x78, 0xF8, 0xF1,
  0xE3, 0xE3, 0xC7, 0x8F, 0x1F, 0x3E, 0x3C, 0x7C, 0xF8, 0xF1, 0xE3, 0xC3,
  0xC7, 0x8F, 0x1F, 0x1E, 0x3C, 0x78, 0x78, 0xF1, 0xE3, 0xE7, 0xC7, 0x8F,
  0x9F, 0x1E, 0x3C, 0x78, 0x78, 0xF1, 0xE3, 0xE3, 0xC7, 0x8F, 0x0F, 0x3E,
  0x3C, 0x7C, 0x1E, 0x3F, 0x83, 0xDF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xF3,
  0xF0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3C, 0x03, 0xE7,
  0x80, 0x7D, 0xF0, 0x0F, 0x3E, 0x01, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9E,
  0x01, 0xF3, 0xC0, 0x3E, 0xF8, 0x07, 0x9F, 0x00, 0xF3, 0xE0, 0x3E, 0x7C,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F,
  0xBF, 0x8F, 0x83, 0xE7, 0xC0, 0x7D, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xEF, 0x00, 0xFB,
  0xE0, 0x3E, 0xF8, 0x1F, 0x1F, 0x9F, 0x87, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F,
  0xF0, 0x00, 0x07, 0xDF, 0xC0, 0x3D, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0xFC, 0x1F, 0x07, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F,
  0x00, 0xF8, 0x78, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xE1, 0xF0, 0x1F,
  0x0F, 0x80, 0xF8, 0x7C, 0x0F, 0xC3, 0xE0, 0x7C, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0x7D, 0xFC, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xF3, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F,
  0xCF, 0xE3, 0xE0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF7, 0xC0, 0x3E, 0xF8,
  0x07, 0x9F, 0x00, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0,
  0x1F, 0x3E, 0x03, 0xC7, 0xE0, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFC, 0x0F, 0xEF, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0x1F, 0xC3, 0xDF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xF0, 0x87, 0xE0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0x03, 0xFE, 0x03, 0xFF,
  0xC1, 0xFF, 0xF8, 0xFC, 0x3F, 0x3E, 0x07, 0xCF, 0x00, 0xF3, 0xC0, 0x00,
  0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xEF, 0x00, 0xFB, 0xE0, 0x3E, 0xFC, 0x3F, 0x1F, 0xFF,
  0xC3, 0xFF, 0xE0, 0x3F, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x3C, 0x03, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x3E,
  0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9E, 0x01, 0xF3, 0xC0, 0x3C, 0xF8,
  0x07, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x00, 0xF9, 0xE0,
  0x1E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0,
  0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xBC, 0x0F, 0xCF, 0x80, 0xF8,
  0x03, 0xFF, 0x00, 0xFB, 0xE0, 0x1F, 0x3C, 0x03, 0xC7, 0x80, 0xF8, 0xF0,
  0x1E, 0x1F, 0x07, 0xC1, 0xE0, 0xF0, 0x3C, 0x3E, 0x07, 0x87, 0x80, 0xF1,
  0xF0, 0x1E, 0x3C, 0x01, 0xEF, 0x80, 0x3D, 0xE0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x70, 0xFF, 0x87, 0x87, 0xBC, 0x3C, 0x3D, 0xE1, 0xE3, 0xEF, 0x1F, 0x1E,
  0x78, 0xF8, 0xF3, 0xCF, 0xC7, 0x9E, 0x7E, 0x78, 0xF3, 0xF3, 0xC7, 0xBB,
  0x9E, 0x3D, 0xDD, 0xE1, 0xEE, 0xEF, 0x0F, 0xE7, 0x70, 0x7F, 0x1F, 0x83,
  0xF0, 0xFC, 0x1F, 0x87, 0xC0, 0xFC, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F,
  0x01, 0xF0, 0x78, 0x00, 0x1F, 0x80, 0x7C, 0x3E, 0x03, 0xE0, 0x7C, 0x1F,
  0x01, 0xF0, 0xFC, 0x03, 0xE7, 0xE0, 0x0F, 0xBF, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x80, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFC, 0xF0, 0x03, 0xE3, 0xE0,
  0x1F, 0x07, 0x80, 0xF8, 0x1F, 0x07, 0xC0, 0x3E, 0x3F, 0x00, 0xF8, 0x1F,
  0x00, 0x3F, 0x1F, 0x00, 0x7E, 0x1F, 0x00, 0x7C, 0x0F, 0x00, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0x83, 0xE0, 0x07,
  0x87, 0xC0, 0x07, 0xC7, 0xC0, 0x07, 0xCF, 0x80, 0x03, 0xCF, 0x80, 0x03,
  0xDF, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFE, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFC, 0x00, 0x06, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x80, 0xFC, 0x01, 0xF0,
  0x03, 0xF0, 0x0F, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x0C, 0x00, 0x07,
  0x07, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x70, 0x70,
  0x70, 0x70, 0x70, 0x70, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x04, 0x00,
  0x1C, 0x00, 0x78, 0x02, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3E,
  0x00, 0x78, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x7F, 0x03, 0xF0, 0x1F,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3C,
  0x00, 0xC0, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0x01, 0xDF, 0xFC, 0x1E, 0xFF,
  0xF1, 0xF7, 0x8F, 0xFF, 0x78, 0x1F, 0xFB, 0x80, 0x7F, 0x80, 0x00, 0xF0,
};

const GFXglyph RobotoMono_SemiBoldItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 9, 27, 22, 7, -27 },
  { 32, 12, 10, 22, 7, -29 },
  { 47, 22, 27, 22, 0, -27 },
  { 122, 20, 35, 22, 2, -31 },
  { 210, 19, 27, 22, 2, -27 },
  { 275, 21, 27, 22, 1, -27 },
  { 346, 5, 10, 22, 10, -29 },
  { 353, 13, 39, 22, 6, -30 },
  { 417, 13, 39, 22, 3, -30 },
  { 481, 18, 19, 22, 3, -27 },
  { 524, 19, 19, 22, 2, -22 },
  { 570, 7, 11, 22, 4, -4 },
  { 580, 15, 4, 22, 5, -14 },
  { 588, 7, 6, 22, 6, -6 },
  { 594, 19, 29, 22, 2, -27 },
  { 663, 19, 27, 22, 2, -27 },
  { 728, 12, 27, 22, 5, -27 },
  { 769, 20, 27, 22, 0, -27 },
  { 837, 20, 27, 22, 1, -27 },
  { 905, 20, 27, 22, 0, -27 },
  { 973, 20, 27, 22, 2, -27 },
  { 1041, 17, 27, 22, 2, -27 },
  { 1099, 19, 27, 22, 3, -27 },
  { 1164, 20, 27, 22, 1, -27 },
  { 1232, 17, 27, 22, 3, -27 },
  { 1290, 9, 22, 22, 7, -22 },
  { 1315, 12, 29, 22, 5, -22 },
  { 1359, 17, 18, 22, 3, -21 },
  { 1398, 19, 12, 22, 2, -18 },
  { 1427, 19, 17, 22, 1, -20 },
  { 1468, 16, 27, 22, 5, -27 },
  { 1522, 21, 27, 22, 1, -27 },
  { 1593, 21, 27, 22, -1, -27 },
  { 1664, 21, 27, 22, 1, -27 },
  { 1735, 21, 27, 22, 1, -27 },
  { 1806, 21, 27, 22, 0, -27 },
  { 1877, 22, 27, 22, 1, -27 },
  { 1952, 22, 27, 22, 1, -27 },
  { 2027, 20, 27, 22, 2, -27 },
  { 2095, 22, 27, 22, 0, -27 },
  { 2170, 20, 27, 22, 1, -27 },
  { 2238, 21, 27, 22, 1, -27 },
  { 2309, 24, 27, 22, 1, -27 },
  { 2390, 18, 27, 22, 1, -27 },
  { 2451, 23, 27, 22, 0, -27 },
  { 2529, 22, 27, 22, 0, -27 },
  { 2604, 20, 27, 22, 1, -27 },
  { 2672, 21, 27, 22, 1, -27 },
  { 2743, 21, 32, 22, 1, -27 },
  { 2827, 21, 27, 22, 1, -27 },
  { 2898, 21, 27, 22, 1, -27 },
  { 2969, 21, 27, 22, 3, -27 },
  { 3040, 21, 27, 22, 2, -27 },
  { 3111, 21, 27, 22, 3, -27 },
  { 3182, 22, 27, 22, 2, -27 },
  { 3257, 25, 27, 22, -1, -27 },
  { 3342, 21, 27, 22, 4, -27 },
  { 3413, 23, 27, 22, 0, -27 },
  { 3491, 13, 37, 22, 5, -31 },
  { 3552, 9, 29, 22, 7, -27 },
  { 3585, 13, 37, 22, 5, -31 },
  { 3646, 15, 14, 22, 4, -27 },
  { 3673, 17, 4, 22, 0, 0 },
  { 3682, 7, 5, 22, 10, -27 },
  { 3687, 18, 20, 22, 1, -20 },
  { 3732, 19, 29, 22, 1, -29 },
  { 3801, 18, 21, 22, 2, -21 },
  { 3849, 20, 29, 22, 2, -29 },
  { 3922, 18, 20, 22, 2, -20 },
  { 3967, 21, 29, 22, 3, -29 },
  { 4044, 20, 28, 22, 1, -20 },
  { 4114, 19, 29, 22, 1, -29 },
  { 4183, 17, 28, 22, 2, -28 },
  { 4243, 17, 36, 22, 1, -28 },
  { 4320, 21, 29, 22, 1, -29 },
  { 4397, 17, 29, 22, 2, -29 },
  { 4459, 22, 20, 22, -1, -20 },
  { 4514, 19, 20, 22, 1, -20 },
  { 4562, 18, 21, 22, 2, -21 },
  { 4610, 21, 28, 22, -1, -20 },
  { 4684, 19, 28, 22, 2, -20 },
  { 4751, 18, 20, 22, 3, -20 },
  { 4796, 18, 20, 22, 2, -20 },
  { 4841, 17, 25, 22, 3, -25 },
  { 4895, 19, 20, 22, 2, -20 },
  { 4943, 19, 20, 22, 3, -20 },
  { 4991, 21, 20, 22, 2, -20 },
  { 5044, 22, 20, 22, 0, -20 },
  { 5099, 24, 28, 22, 0, -20 },
  { 5183, 20, 20, 22, 1, -20 },
  { 5233, 15, 37, 22, 5, -30 },
  { 5303, 8, 35, 22, 7, -27 },
  { 5338, 14, 37, 22, 4, -30 },
  { 5403, 21, 8, 22, 0, -15 },
};

const GFXfont RobotoMono_SemiBoldItalic38pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic38pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic38pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC38PT7B_H_
