#ifndef _ROBOTOMONO_SEMIBOLDITALIC25PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x38, 0x70, 0xE1, 0xC3, 0x8E, 0x1C, 0x38, 0x70, 0xE1, 0x80,
  0x00, 0x00, 0x38, 0xF0, 0xE0, 0x73, 0x63, 0x63, 0x63, 0x67, 0xE6, 0xC6,
  0x01, 0x8C, 0x03, 0x38, 0x0E, 0x60, 0x18, 0xC0, 0x33, 0x07, 0xFF, 0xCF,
  0xFF, 0x03, 0x30, 0x0E, 0x60, 0x18, 0xC0, 0x33, 0x07, 0xFF, 0xCF, 0xFF,
  0x83, 0x30, 0x0C, 0x60, 0x18, 0xC0, 0x33, 0x00, 0xC6, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x07, 0xC0, 0xFF, 0x0F, 0xFC, 0xF0, 0xE7, 0x07, 0x38,
  0x39, 0xE0, 0x07, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0E,
  0xE0, 0x77, 0x87, 0x9E, 0x78, 0xFF, 0xC1, 0xF8, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x78, 0x0F, 0xC0, 0xCC, 0x4C, 0xC6, 0xCC, 0xCC, 0xD8, 0xFB, 0x07,
  0x30, 0x06, 0x00, 0xC0, 0x0C, 0x81, 0xBE, 0x37, 0x67, 0x67, 0x66, 0x62,
  0x66, 0x07, 0xE0, 0x3C, 0x03, 0xC0, 0x1F, 0x80, 0xFF, 0x03, 0x9C, 0x0C,
  0x70, 0x71, 0xC0, 0xFE, 0x03, 0xF0, 0x0F, 0x00, 0x7C, 0x33, 0xF9, 0xDE,
  0xE7, 0x71, 0xF9, 0xC7, 0xEF, 0x0F, 0x1E, 0x7C, 0x7F, 0xF0, 0xFC, 0xE0,
  0x76, 0x66, 0x6E, 0xC0, 0x01, 0x03, 0x07, 0x0E, 0x1C, 0x38, 0x38, 0x70,
  0x70, 0x60, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xC0, 0xE0, 0xE0,
  0xE0, 0x60, 0x70, 0x30, 0x18, 0x08, 0x08, 0x0E, 0x03, 0x80, 0xC0, 0x70,
  0x38, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x60, 0x30, 0x38, 0x1C, 0x0E,
  0x07, 0x07, 0x03, 0x81, 0x81, 0xC1, 0xC1, 0xC1, 0xE0, 0xC0, 0x40, 0x00,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x66, 0x7F, 0xFF, 0x3F, 0xC0, 0xE0,
  0x1B, 0x03, 0xB8, 0x71, 0x86, 0x1C, 0x21, 0x00, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x70, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0x3C, 0xE3, 0x8E, 0x39, 0xCE, 0x10, 0xFF, 0xFF,
  0xF0, 0x77, 0xFE, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E,
  0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00,
  0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0x00, 0x0F, 0x81, 0xFC, 0x3F, 0xE7, 0x8E, 0x70, 0x77, 0x07, 0xE0, 0xFE,
  0x3E, 0xE7, 0xEF, 0xEE, 0xF8, 0xEF, 0x0E, 0xE0, 0xEE, 0x1C, 0xE1, 0xCF,
  0x38, 0x7F, 0x83, 0xE0, 0x01, 0x07, 0x3F, 0xFF, 0xF7, 0x8E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x03, 0xE0,
  0x7F, 0x87, 0xFE, 0x78, 0x73, 0x83, 0x9C, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0F, 0xFE,
  0xFF, 0xF7, 0xFF, 0x80, 0x07, 0xC0, 0xFF, 0x0F, 0xFC, 0x70, 0xE7, 0x87,
  0x80, 0x38, 0x01, 0xC0, 0x3C, 0x0F, 0xC0, 0x7E, 0x00, 0x78, 0x01, 0xC0,
  0x0E, 0x70, 0x73, 0x83, 0x9E, 0x7C, 0x7F, 0xC1, 0xF8, 0x00, 0x00, 0x38,
  0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x1D, 0xC1, 0xCE, 0x1C,
  0x71, 0xC7, 0x0E, 0x38, 0xE1, 0xCF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x0F, 0xF8, 0xFF, 0xC7, 0xFE, 0x38, 0x01, 0x80,
  0x1C, 0x00, 0xEE, 0x07, 0xF8, 0x7F, 0xE0, 0x87, 0x00, 0x1C, 0x00, 0xE0,
  0x07, 0x70, 0x73, 0x83, 0x8E, 0x3C, 0x7F, 0xC1, 0xF8, 0x00, 0x00, 0xE0,
  0x7E, 0x0F, 0xE1, 0xE0, 0x3C, 0x03, 0x80, 0x73, 0x87, 0xFC, 0x7F, 0xEF,
  0x0E, 0xF0, 0xFE, 0x07, 0xE0, 0x7E, 0x0E, 0x70, 0xE7, 0x9C, 0x3F, 0xC1,
  0xF0, 0xFF, 0xFF, 0xFF, 0xBF, 0xFC, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1E, 0x00,
  0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x00, 0x07, 0xC0, 0x7F, 0x07, 0xFC,
  0x78, 0xE3, 0x87, 0x9C, 0x38, 0xE1, 0xC7, 0x9C, 0x1F, 0xC1, 0xFE, 0x1E,
  0x79, 0xE1, 0xCE, 0x0E, 0x70, 0x73, 0x83, 0x9E, 0x7C, 0x7F, 0xC1, 0xFC,
  0x00, 0x0F, 0x87, 0xF9, 0xFF, 0x38, 0x7F, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFE, 0x7D, 0xFF, 0x9F, 0xE0, 0x1C, 0x07, 0x01, 0xE3, 0xF8, 0x7E,
  0x0F, 0x00, 0x1C, 0x7C, 0xF8, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC3,
  0xCF, 0x8E, 0x00, 0x0E, 0x0F, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x70, 0xE0, 0x40, 0x00, 0x20,
  0x0C, 0x0F, 0x87, 0xF7, 0xF1, 0xF8, 0x38, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0x00, 0x40, 0x3F, 0xFB, 0xFF, 0xDF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xDF, 0xFE, 0x30, 0x03, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xF0,
  0x0F, 0x07, 0xE3, 0xF8, 0xFE, 0x0F, 0x00, 0xC0, 0x00, 0x1F, 0x87, 0xF9,
  0xFF, 0xF8, 0x7E, 0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x07, 0x81, 0xE0, 0x70,
  0x0E, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x01, 0x80,
  0x1F, 0xC1, 0xC3, 0x0E, 0x06, 0x33, 0xD9, 0x9F, 0x26, 0xEC, 0xB3, 0x32,
  0xD8, 0xCB, 0x62, 0x6D, 0x99, 0xA6, 0x64, 0x9F, 0xB3, 0x3B, 0x8C, 0x00,
  0x38, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00,
  0x7C, 0x01, 0xF0, 0x0E, 0xC0, 0x3B, 0x81, 0xCE, 0x07, 0x38, 0x38, 0xE0,
  0xE3, 0x87, 0xFE, 0x1F, 0xF8, 0xFF, 0xE3, 0x81, 0xDE, 0x07, 0x70, 0x1F,
  0xC0, 0x70, 0x1F, 0xE0, 0x7F, 0xE1, 0xFF, 0xC7, 0x07, 0x1C, 0x1C, 0x70,
  0x73, 0x81, 0xCE, 0x1E, 0x3F, 0xF0, 0xFF, 0xC3, 0x83, 0x9E, 0x0E, 0x70,
  0x39, 0xC0, 0xE7, 0x07, 0x9F, 0xFC, 0x7F, 0xF3, 0xFF, 0x00, 0x07, 0xC0,
  0x7F, 0x87, 0xFE, 0x70, 0x77, 0x83, 0xB8, 0x1D, 0xC0, 0x0E, 0x00, 0xF0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x07, 0x70, 0x3B, 0xC3, 0x8F, 0x3C,
  0x7F, 0xC0, 0xFC, 0x00, 0x1F, 0x80, 0x7F, 0x81, 0xFF, 0x07, 0x1E, 0x1C,
  0x3C, 0xF0, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x83, 0xDE,
  0x0E, 0x70, 0x39, 0xC1, 0xC7, 0x0F, 0x1F, 0xF8, 0x7F, 0xC3, 0xFC, 0x00,
  0x1F, 0xFC, 0xFF, 0xF3, 0xFF, 0xCE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x1C, 0x04, 0x7F, 0xE1, 0xFF, 0x87, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80,
  0x0E, 0x00, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x80, 0x1F, 0xFC, 0xFF, 0xF3,
  0xFF, 0xCE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x7F, 0xF1,
  0xFF, 0xC7, 0xFE, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0x07, 0xC0, 0x7F, 0x87, 0xFE, 0x78, 0x73, 0x83,
  0xB8, 0x1D, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x1F, 0xF8, 0xFD, 0xC0, 0xEE,
  0x07, 0x70, 0x3B, 0xC1, 0xCF, 0x3E, 0x3F, 0xE0, 0xFC, 0x00, 0x1C, 0x0E,
  0x38, 0x3C, 0x70, 0x70, 0xE0, 0xE1, 0xC1, 0xC7, 0x03, 0x8E, 0x07, 0x1C,
  0x1C, 0x3F, 0xF8, 0x7F, 0xF0, 0xE0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x0E,
  0x1C, 0x1C, 0x38, 0x38, 0xF0, 0x71, 0xC0, 0xE0, 0x1F, 0xF8, 0xFF, 0xC7,
  0xFE, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x1F, 0xFC, 0xFF, 0xC7,
  0xFE, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0xF3, 0x83, 0x8E, 0x0E, 0x3C, 0xF0, 0x7F, 0xC0, 0xFC, 0x00, 0x1E, 0x0F,
  0x1C, 0x1E, 0x1C, 0x3C, 0x1C, 0x78, 0x1C, 0x70, 0x1C, 0xF0, 0x39, 0xE0,
  0x3B, 0xC0, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x7D, 0xE0, 0x78, 0xE0,
  0x70, 0xE0, 0x70, 0xF0, 0x70, 0x70, 0x70, 0x78, 0xF0, 0x38, 0x1C, 0x07,
  0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E,
  0x1E, 0x3C, 0x3C, 0x78, 0xF8, 0xF1, 0xE1, 0xF7, 0xC7, 0xEF, 0x8E, 0xFF,
  0x1D, 0xEE, 0x3B, 0xDC, 0x77, 0x30, 0xCE, 0xE3, 0x99, 0xC7, 0x03, 0x8E,
  0x07, 0x1C, 0x0E, 0x38, 0x18, 0x60, 0x71, 0xC0, 0xE0, 0x1C, 0x0E, 0x3C,
  0x3C, 0x78, 0x70, 0xF0, 0xE1, 0xF1, 0xC7, 0xE3, 0x8E, 0xC7, 0x1D, 0x9C,
  0x3B, 0xB8, 0x77, 0x70, 0xE6, 0xE3, 0x8D, 0xC7, 0x1F, 0x8E, 0x3E, 0x1C,
  0x3C, 0x38, 0x78, 0xF0, 0xF1, 0xC1, 0xE0, 0x07, 0xC0, 0x7F, 0x07, 0xFC,
  0x70, 0xF7, 0x83, 0xB8, 0x1D, 0xC0, 0xEE, 0x07, 0xF0, 0x3F, 0x01, 0xF8,
  0x1F, 0xC0, 0xEE, 0x07, 0x70, 0x7B, 0xC3, 0x8F, 0x7C, 0x7F, 0xC1, 0xF8,
  0x00, 0x1F, 0xC0, 0xFF, 0xC3, 0xFF, 0x8E, 0x0E, 0x38, 0x3C, 0xE0, 0xF3,
  0x83, 0x9E, 0x0E, 0x70, 0xF9, 0xFF, 0xC7, 0xFC, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x07, 0xC0, 0x7F,
  0x07, 0xFC, 0x70, 0xF7, 0x83, 0xB8, 0x1D, 0xC0, 0xEE, 0x07, 0xF0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0xEE, 0x07, 0x70, 0x3B, 0xC3, 0x8F, 0x7C, 0x7F,
  0xC0, 0xFE, 0x00, 0x78, 0x01, 0xE0, 0x04, 0x00, 0x1F, 0xE0, 0x7F, 0xE1,
  0xFF, 0xC7, 0x07, 0x1C, 0x1C, 0x70, 0x73, 0xC1, 0xCE, 0x0F, 0x38, 0x78,
  0xFF, 0xC3, 0xFC, 0x0E, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0F, 0x1C, 0x1C,
  0x70, 0x73, 0xC1, 0xE0, 0x07, 0xE0, 0x7F, 0xC3, 0xFF, 0x8E, 0x0E, 0x38,
  0x38, 0xE0, 0x13, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x1F, 0x00,
  0x1C, 0x00, 0x73, 0x81, 0xCE, 0x07, 0x3E, 0x7C, 0x7F, 0xE0, 0x7E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x38, 0x1C, 0xE0, 0x73,
  0x83, 0x8E, 0x0E, 0x38, 0x39, 0xE0, 0xE7, 0x03, 0x9C, 0x1E, 0x70, 0x71,
  0xC1, 0xC7, 0x07, 0x3C, 0x1C, 0xE0, 0x73, 0x83, 0x8F, 0x0E, 0x1E, 0xF8,
  0x7F, 0xC0, 0xFC, 0x00, 0xF0, 0x3F, 0xC0, 0xEF, 0x07, 0x9C, 0x1C, 0x70,
  0xF1, 0xC3, 0x87, 0x0E, 0x1C, 0x70, 0x71, 0xC1, 0xCF, 0x03, 0xB8, 0x0E,
  0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0x70, 0x00,
  0xE3, 0x1F, 0x9C, 0x7E, 0x73, 0xB9, 0xCE, 0xEF, 0x3B, 0xBC, 0xCE, 0xF7,
  0x3B, 0xDC, 0xFB, 0x73, 0x6F, 0x8D, 0xBE, 0x3C, 0xF8, 0xF3, 0xC3, 0xCF,
  0x0F, 0x3C, 0x38, 0xF0, 0xE3, 0x83, 0x8E, 0x00, 0x1E, 0x07, 0x87, 0x07,
  0x83, 0xC3, 0x80, 0xE3, 0xC0, 0x73, 0xC0, 0x3D, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0xF7, 0x00,
  0xF3, 0x80, 0x71, 0xE0, 0x78, 0x70, 0x78, 0x3C, 0x78, 0x1E, 0x00, 0xF0,
  0x3D, 0xC0, 0xE7, 0x07, 0x9C, 0x1C, 0x38, 0xE0, 0xE7, 0x83, 0x9C, 0x0E,
  0xF0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0xFF,
  0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3F,
  0xFC, 0xFF, 0xF9, 0xFF, 0xE0, 0x0F, 0x87, 0xC3, 0xE3, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0x91, 0xF0, 0xF8, 0x00, 0xE3, 0x8E,
  0x38, 0xE1, 0x87, 0x1C, 0x71, 0xC7, 0x0C, 0x38, 0xE3, 0x8E, 0x38, 0x61,
  0xC7, 0x0F, 0x87, 0xC7, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x71, 0xF0, 0xF8, 0x00, 0x06, 0x07, 0x83, 0xC3, 0xE1, 0xB1,
  0xDD, 0xCE, 0xE3, 0xE1, 0xE0, 0xC0, 0xFF, 0xFF, 0xFC, 0xE7, 0x30, 0x1F,
  0xC3, 0xFE, 0x78, 0xF7, 0x07, 0x00, 0x71, 0xFE, 0x7F, 0xEF, 0x0E, 0xE0,
  0xEE, 0x0E, 0xF3, 0xEF, 0xFE, 0x7E, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x3F, 0xE3, 0xFE, 0x7C, 0xF7, 0x07, 0x70, 0x77,
  0x07, 0x70, 0x7F, 0x07, 0xE0, 0xFE, 0x0E, 0xF9, 0xEF, 0xFC, 0xEF, 0x80,
  0x0F, 0xC3, 0xFE, 0x38, 0xF7, 0x07, 0x70, 0x7F, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0F, 0x0E, 0x79, 0xE7, 0xFC, 0x1F, 0x80, 0x00, 0x1C, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE1, 0xFF, 0x8F, 0xFC, 0x78, 0xF1,
  0xC1, 0xC7, 0x07, 0x3C, 0x1C, 0xE0, 0xF3, 0x83, 0x8E, 0x0E, 0x3C, 0x38,
  0x7B, 0xE1, 0xFF, 0x83, 0xEE, 0x00, 0x0F, 0xC1, 0xFE, 0x3C, 0xF7, 0x07,
  0x70, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0F, 0x04, 0x79, 0xE3, 0xFE,
  0x1F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x78, 0x83, 0xC0, 0x0E, 0x00, 0x38,
  0x0F, 0xFF, 0x3F, 0xF8, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0x0F, 0xDC, 0x7F, 0xF1, 0xC7, 0x8E, 0x0E, 0x38, 0x39, 0xE0, 0xE7, 0x03,
  0x9C, 0x1E, 0x70, 0x71, 0xE1, 0xC3, 0xDF, 0x0F, 0xFC, 0x1F, 0x70, 0x03,
  0xC4, 0x0E, 0x1C, 0xF8, 0xFF, 0xC0, 0xFC, 0x00, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x77, 0xC7, 0x7F, 0x3C, 0x79, 0xC1,
  0xCE, 0x0E, 0x70, 0x73, 0x83, 0xBC, 0x1D, 0xC1, 0xEE, 0x0E, 0x70, 0x73,
  0x83, 0xBC, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x00, 0x00, 0x7F, 0x0F,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC3,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x3C, 0x03, 0x80, 0x00, 0x00, 0x3F,
  0x87, 0xF0, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01,
  0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x81, 0xE1, 0xFC, 0x3E, 0x00,
  0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE1, 0xE7,
  0x1E, 0x71, 0xE3, 0x9E, 0x1F, 0xC0, 0xFC, 0x07, 0xF0, 0x7F, 0xC3, 0xCE,
  0x1C, 0x78, 0xE1, 0xC7, 0x0F, 0x38, 0x3C, 0x1F, 0xC3, 0xF8, 0x7F, 0x00,
  0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xF8,
  0xFF, 0xF7, 0xB9, 0xDC, 0xE7, 0x73, 0x9D, 0xCE, 0x77, 0x31, 0x98, 0xCE,
  0xE7, 0x3B, 0x9C, 0xEE, 0x73, 0xB9, 0xCE, 0xE6, 0x70, 0x1D, 0xF1, 0xFF,
  0xCF, 0x9E, 0x70, 0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xEF, 0x07, 0x70, 0x7B,
  0x83, 0x9C, 0x1C, 0xE0, 0xEF, 0x07, 0x00, 0x0F, 0xC3, 0xFE, 0x38, 0xF7,
  0x07, 0x70, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFF, 0x0E, 0x79, 0xE7,
  0xFC, 0x3F, 0x00, 0x1F, 0xF0, 0xFF, 0x8F, 0x1E, 0x70, 0x73, 0x83, 0x9C,
  0x1C, 0xE0, 0xEF, 0x07, 0x70, 0x7B, 0x83, 0x9E, 0x3C, 0xFF, 0xC7, 0x7C,
  0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x1F, 0xB9, 0xFF,
  0x9E, 0x3C, 0xE0, 0xE7, 0x07, 0x78, 0x3B, 0x81, 0xDC, 0x1C, 0xE0, 0xE7,
  0x87, 0x1C, 0xF8, 0xFF, 0xC3, 0xEE, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x1E, 0x00, 0x39, 0xF3, 0xFF, 0x3F, 0xE3, 0xC0, 0x38, 0x03, 0x80,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x00, 0x1F,
  0xE3, 0xFF, 0x38, 0x77, 0x07, 0x78, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x00,
  0xEE, 0x0E, 0xF0, 0xE7, 0xFC, 0x3F, 0x80, 0x0E, 0x01, 0xC0, 0x38, 0x7F,
  0xFF, 0xFE, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03,
  0x80, 0x78, 0x87, 0xF0, 0x7E, 0x38, 0x39, 0xC1, 0xDC, 0x1C, 0xE0, 0xE7,
  0x07, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0xF0, 0xE3, 0x87, 0x1E, 0xF8, 0xFF,
  0xC3, 0xEE, 0x00, 0xE0, 0x7F, 0x07, 0xB8, 0x38, 0xE1, 0xC7, 0x1C, 0x38,
  0xE1, 0xCE, 0x06, 0x70, 0x37, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x01, 0xC0,
  0x00, 0xE3, 0x1F, 0x8C, 0x6E, 0x73, 0xB9, 0xCE, 0xEF, 0x33, 0xBD, 0xCE,
  0xF7, 0x3E, 0x58, 0xF9, 0x63, 0xE7, 0x8F, 0x1C, 0x3C, 0x70, 0xE1, 0xC0,
  0x3C, 0x1E, 0x38, 0x70, 0x39, 0xE0, 0x77, 0x80, 0x7E, 0x00, 0xF8, 0x01,
  0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x39, 0xC0, 0xF3, 0x83, 0xC3, 0x8F, 0x07,
  0x80, 0x38, 0x0E, 0x70, 0x38, 0xF0, 0xF0, 0xE1, 0xC1, 0xC7, 0x83, 0x8E,
  0x07, 0x38, 0x07, 0x70, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x3F,
  0xFC, 0xFF, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xFF, 0x9F, 0xFC, 0xFF, 0xF0, 0x00, 0x81,
  0xC1, 0xE1, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x0E, 0x1F, 0x0E,
  0x07, 0x80, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xF0,
  0x38, 0x0C, 0x30, 0xC6, 0x18, 0x61, 0x86, 0x18, 0xE3, 0x0C, 0x30, 0xC3,
  0x0C, 0x61, 0x86, 0x18, 0x61, 0x8E, 0x00, 0x0C, 0x03, 0x80, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x18, 0x07, 0x01, 0xC0, 0x3C, 0x0F, 0x07, 0xC3,
  0x80, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x1C, 0x0E, 0x00,
  0x3C, 0x01, 0xFC, 0x77, 0xF9, 0xB8, 0xFE, 0x41, 0xF0,
};

const GFXglyph RobotoMono_SemiBoldItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 7, 18, 15, 4, -18 },
  { 17, 8, 7, 15, 4, -19 },
  { 24, 15, 18, 15, 0, -18 },
  { 58, 13, 24, 15, 1, -21 },
  { 97, 12, 18, 15, 2, -18 },
  { 124, 14, 18, 15, 0, -18 },
  { 156, 4, 7, 15, 6, -19 },
  { 160, 8, 26, 15, 4, -20 },
  { 186, 9, 26, 15, 2, -20 },
  { 216, 12, 13, 15, 2, -18 },
  { 236, 12, 13, 15, 1, -15 },
  { 256, 6, 8, 15, 2, -3 },
  { 262, 10, 2, 15, 3, -9 },
  { 265, 5, 4, 15, 4, -4 },
  { 268, 13, 20, 15, 1, -18 },
  { 301, 12, 18, 15, 2, -18 },
  { 328, 8, 18, 15, 3, -18 },
  { 346, 13, 18, 15, 0, -18 },
  { 376, 13, 18, 15, 1, -18 },
  { 406, 13, 18, 15, 0, -18 },
  { 436, 13, 18, 15, 1, -18 },
  { 466, 12, 18, 15, 1, -18 },
  { 493, 13, 18, 15, 2, -18 },
  { 523, 13, 18, 15, 1, -18 },
  { 553, 11, 18, 15, 2, -18 },
  { 578, 7, 14, 15, 4, -14 },
  { 591, 8, 19, 15, 3, -14 },
  { 610, 11, 12, 15, 2, -14 },
  { 627, 13, 8, 15, 1, -12 },
  { 640, 12, 11, 15, 1, -13 },
  { 657, 11, 18, 15, 3, -18 },
  { 682, 14, 18, 15, 1, -18 },
  { 714, 14, 18, 15, -1, -18 },
  { 746, 14, 18, 15, 0, -18 },
  { 778, 13, 18, 15, 1, -18 },
  { 808, 14, 18, 15, 0, -18 },
  { 840, 14, 18, 15, 1, -18 },
  { 872, 14, 18, 15, 1, -18 },
  { 904, 13, 18, 15, 1, -18 },
  { 934, 15, 18, 15, 0, -18 },
  { 968, 13, 18, 15, 1, -18 },
  { 998, 14, 18, 15, 1, -18 },
  { 1030, 16, 18, 15, 0, -18 },
  { 1066, 11, 18, 15, 1, -18 },
  { 1091, 15, 18, 15, 0, -18 },
  { 1125, 15, 18, 15, 0, -18 },
  { 1159, 13, 18, 15, 1, -18 },
  { 1189, 14, 18, 15, 1, -18 },
  { 1221, 13, 21, 15, 1, -18 },
  { 1256, 14, 18, 15, 0, -18 },
  { 1288, 14, 18, 15, 1, -18 },
  { 1320, 14, 18, 15, 2, -18 },
  { 1352, 14, 18, 15, 1, -18 },
  { 1384, 14, 18, 15, 2, -18 },
  { 1416, 14, 18, 15, 2, -18 },
  { 1448, 17, 18, 15, -1, -18 },
  { 1487, 14, 18, 15, 2, -18 },
  { 1519, 15, 18, 15, 0, -18 },
  { 1553, 9, 25, 15, 3, -21 },
  { 1582, 6, 20, 15, 5, -18 },
  { 1597, 9, 25, 15, 3, -21 },
  { 1626, 9, 10, 15, 3, -18 },
  { 1638, 11, 2, 15, 0, 0 },
  { 1641, 4, 3, 15, 7, -18 },
  { 1643, 12, 13, 15, 1, -13 },
  { 1663, 12, 19, 15, 1, -19 },
  { 1692, 12, 13, 15, 1, -13 },
  { 1712, 14, 19, 15, 1, -19 },
  { 1746, 12, 13, 15, 1, -13 },
  { 1766, 14, 19, 15, 2, -19 },
  { 1800, 14, 18, 15, 0, -13 },
  { 1832, 13, 19, 15, 0, -19 },
  { 1863, 11, 18, 15, 1, -18 },
  { 1888, 11, 23, 15, 1, -18 },
  { 1920, 13, 19, 15, 1, -19 },
  { 1951, 11, 19, 15, 1, -19 },
  { 1978, 14, 13, 15, 0, -13 },
  { 2001, 13, 13, 15, 0, -13 },
  { 2023, 12, 13, 15, 1, -13 },
  { 2043, 13, 18, 15, 0, -13 },
  { 2073, 13, 18, 15, 1, -13 },
  { 2103, 12, 13, 15, 2, -13 },
  { 2123, 12, 13, 15, 1, -13 },
  { 2143, 11, 16, 15, 2, -16 },
  { 2165, 13, 13, 15, 1, -13 },
  { 2187, 13, 13, 15, 2, -13 },
  { 2209, 14, 13, 15, 1, -13 },
  { 2232, 15, 13, 15, 0, -13 },
  { 2257, 15, 18, 15, 0, -13 },
  { 2291, 14, 13, 15, 0, -13 },
  { 2314, 9, 24, 15, 4, -20 },
  { 2341, 6, 23, 15, 4, -18 },
  { 2359, 10, 23, 15, 2, -19 },
  { 2388, 14, 5, 15, 0, -10 },
};

const GFXfont RobotoMono_SemiBoldItalic25pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic25pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic25pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC25PT7B_H_
