#ifndef _ROBOTOMONO_SEMIBOLDITALIC24PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0xC6, 0x38, 0xE3, 0x8E, 0x38, 0xC7, 0x00, 0x00, 0x06,
  0x3C, 0xE0, 0x63, 0x67, 0x66, 0x66, 0xC6, 0xC6, 0x01, 0x98, 0x0C, 0x60,
  0x33, 0x80, 0xCC, 0x06, 0x30, 0xFF, 0xF3, 0xFF, 0xC3, 0x18, 0x0C, 0xC0,
  0x33, 0x0F, 0xFF, 0x3F, 0xFC, 0x19, 0x80, 0xC6, 0x03, 0x30, 0x0C, 0xC0,
  0x67, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x0F, 0xC1, 0xFF, 0x0E, 0x38,
  0xE1, 0xC7, 0x07, 0x38, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0x70, 0x03, 0x9C, 0x1C, 0xE0, 0xE3, 0x8F, 0x1F, 0xF0, 0x7F, 0x00, 0xC0,
  0x06, 0x00, 0x3C, 0x07, 0xE0, 0x66, 0x26, 0x66, 0xE6, 0xC7, 0xD8, 0x79,
  0x80, 0x30, 0x06, 0x00, 0x60, 0x0D, 0xE1, 0xBF, 0x33, 0x37, 0x73, 0x27,
  0x30, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x3F, 0x80, 0xE6, 0x07, 0x1C, 0x1C,
  0x60, 0x73, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x77, 0xB9, 0x9C,
  0xEE, 0x71, 0xF3, 0xC7, 0xC7, 0x1E, 0x1F, 0xFC, 0x3F, 0x78, 0x6D, 0xFD,
  0x80, 0x02, 0x07, 0x0E, 0x1C, 0x18, 0x38, 0x70, 0x70, 0x60, 0xE0, 0xE0,
  0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0x60, 0x60, 0x38,
  0x10, 0x08, 0x1C, 0x0C, 0x06, 0x06, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x06, 0x0E, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x70, 0xE0,
  0xC0, 0x07, 0x00, 0xE0, 0x18, 0x23, 0x1F, 0x6E, 0xFF, 0xC3, 0x80, 0xF0,
  0x3B, 0x0E, 0x71, 0x86, 0x10, 0x80, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x0F, 0xFF, 0xFF, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0,
  0x39, 0xCE, 0x77, 0x3B, 0x88, 0xFF, 0xFF, 0xEF, 0xF8, 0x6F, 0xFF, 0x00,
  0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07,
  0x00, 0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70,
  0x0E, 0x00, 0x0F, 0xC1, 0xFE, 0x1C, 0xF3, 0x87, 0x38, 0x77, 0x07, 0x70,
  0xF7, 0x3F, 0x77, 0x77, 0xC6, 0x78, 0xEE, 0x0E, 0xE0, 0xE7, 0x1C, 0x73,
  0xC7, 0xF8, 0x1F, 0x00, 0x03, 0x1F, 0xFE, 0xFE, 0xCE, 0x0E, 0x0E, 0x0E,
  0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x07, 0xE0, 0xFF,
  0x87, 0x1C, 0x70, 0xF3, 0x83, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1F, 0xFE, 0xFF,
  0xE0, 0x0F, 0xC1, 0xFE, 0x3C, 0xF7, 0x87, 0x00, 0x70, 0x07, 0x00, 0xE0,
  0xFC, 0x0F, 0x80, 0x3C, 0x00, 0xE0, 0x0E, 0xE0, 0xEE, 0x1E, 0xF3, 0xC7,
  0xF8, 0x3F, 0x00, 0x00, 0x78, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x03,
  0xB8, 0x3B, 0x83, 0x9C, 0x18, 0xE1, 0xC7, 0x1C, 0x39, 0xFF, 0xFF, 0xFF,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1F, 0xF8, 0xFF, 0x87, 0xFC,
  0x30, 0x03, 0x80, 0x1C, 0x00, 0xFE, 0x0F, 0xF8, 0x79, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xCE, 0x0E, 0x70, 0x73, 0xCF, 0x0F, 0xF0, 0x3F, 0x00, 0x03,
  0xC0, 0xF8, 0x7E, 0x0E, 0x03, 0x80, 0xE0, 0x1F, 0xF3, 0xFE, 0xF9, 0xFE,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC3, 0xDC, 0xF3, 0xFC, 0x1F, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x07,
  0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0,
  0x00, 0x0F, 0xC1, 0xFE, 0x3C, 0xF3, 0x87, 0x38, 0x73, 0x87, 0x38, 0xE1,
  0xFC, 0x1F, 0x87, 0xFC, 0x70, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xF3, 0xC7,
  0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xF9, 0xE7, 0x78, 0x6E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x0F, 0xF1, 0xCF, 0xF9, 0xFF, 0x00, 0xE0, 0x38, 0x0E, 0x0F, 0xC3,
  0xE0, 0x78, 0x00, 0x18, 0xF3, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x07, 0x3C,
  0xF1, 0xC0, 0x0E, 0x1E, 0x1F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x38, 0x38, 0x38, 0x70, 0x70, 0xE0, 0x40, 0x00, 0x20, 0x3C,
  0x1F, 0x1F, 0xCF, 0xC1, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xF0, 0x02,
  0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0xFF, 0xE0,
  0x20, 0x07, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xC1, 0xF9, 0xFC, 0xFE,
  0x1E, 0x03, 0x00, 0x00, 0x3F, 0x9F, 0xFF, 0x1F, 0x87, 0x01, 0xC0, 0x70,
  0x3C, 0x1E, 0x0F, 0x07, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x03, 0x81, 0xE0,
  0x30, 0x00, 0x03, 0xC0, 0x7F, 0x06, 0x0C, 0x60, 0x36, 0x7D, 0xB7, 0x6F,
  0x33, 0x7B, 0x13, 0xD9, 0x9C, 0xCC, 0xA6, 0x6D, 0x37, 0x49, 0xFE, 0x60,
  0x03, 0x80, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x1F, 0x00,
  0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x77, 0x01, 0xCC, 0x0E, 0x30, 0x38, 0xE1,
  0xC3, 0x87, 0xFE, 0x3F, 0xF8, 0xE0, 0xE7, 0x83, 0x9C, 0x0E, 0xF0, 0x3C,
  0x1F, 0xE0, 0x7F, 0xE1, 0xC7, 0xC7, 0x07, 0x1C, 0x1C, 0xE0, 0x73, 0x83,
  0x8F, 0xFC, 0x3F, 0xE0, 0xE3, 0xC7, 0x03, 0x9C, 0x0E, 0x70, 0x39, 0xC1,
  0xE7, 0x1F, 0x1F, 0xF8, 0xFF, 0x80, 0x0F, 0xC0, 0xFF, 0x8F, 0x1C, 0x70,
  0xF7, 0x03, 0xB8, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x2E, 0x0E, 0x70, 0x71, 0xC7, 0x0F, 0xF8, 0x3F, 0x00, 0x1F, 0xC0,
  0xFF, 0x07, 0x7C, 0x38, 0xF3, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x07, 0x38,
  0x39, 0xC1, 0xDC, 0x0E, 0xE0, 0xE7, 0x07, 0x38, 0x71, 0xDF, 0x8F, 0xF8,
  0xFF, 0x00, 0x3F, 0xF9, 0xFF, 0xCE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01,
  0xC0, 0x0F, 0xFC, 0x7F, 0xE3, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1F, 0xFC, 0xFF, 0xE0, 0x3F, 0xFC, 0xFF, 0xE3, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87,
  0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x0F, 0xE0, 0xFF, 0x8F, 0x1C, 0x70, 0xF7, 0x03, 0xB8, 0x01, 0xC0, 0x1C,
  0x00, 0xE3, 0xF7, 0x1F, 0xB8, 0xFD, 0xC0, 0xEE, 0x0E, 0x70, 0x71, 0xC7,
  0x8F, 0xFC, 0x3F, 0x80, 0x1C, 0x1C, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0x38,
  0x38, 0xE0, 0xE3, 0x83, 0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xC7, 0x07, 0x1C,
  0x1C, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0x38, 0x18, 0xE0, 0xE0, 0x1F, 0xF8,
  0xFF, 0x88, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x1F, 0xF8,
  0xFF, 0xC0, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xCE, 0x0E, 0x70,
  0xF3, 0xCF, 0x0F, 0xF0, 0x3F, 0x00, 0x1C, 0x1F, 0x1C, 0x1C, 0x1C, 0x38,
  0x1C, 0x70, 0x1C, 0xF0, 0x39, 0xE0, 0x3B, 0xC0, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0xC0, 0x7D, 0xC0, 0x79, 0xC0, 0x70, 0xE0, 0x70, 0xE0, 0x70, 0xF0,
  0x70, 0x70, 0xE0, 0x78, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0xFF, 0xFF, 0xE0, 0x1E, 0x3C, 0x78, 0xF1, 0xE7, 0xC7, 0x9F, 0x3E,
  0x7C, 0xFB, 0x63, 0xED, 0x8E, 0xEE, 0x33, 0xB8, 0xCE, 0xE7, 0x33, 0x9C,
  0xCC, 0x70, 0x71, 0xC1, 0xC6, 0x07, 0x18, 0x1C, 0xE0, 0x70, 0x1C, 0x1C,
  0x78, 0x71, 0xE1, 0xC7, 0x87, 0x3E, 0x38, 0xFC, 0xE3, 0xF3, 0x8E, 0xCE,
  0x3B, 0x38, 0xEF, 0xC7, 0x1F, 0x1C, 0x7C, 0x71, 0xF1, 0xC7, 0xC7, 0x0F,
  0x38, 0x38, 0xE0, 0xE0, 0x0F, 0xC0, 0xFF, 0x0F, 0x3C, 0x70, 0xE7, 0x07,
  0x38, 0x1D, 0xC1, 0xDC, 0x0E, 0xE0, 0x77, 0x03, 0xB8, 0x1D, 0xC0, 0xEE,
  0x0E, 0x70, 0x71, 0xCF, 0x0F, 0xF0, 0x3F, 0x00, 0x3F, 0xC1, 0xFF, 0x8E,
  0x3C, 0x70, 0x73, 0x83, 0x9C, 0x1D, 0xC0, 0xEE, 0x0E, 0x7F, 0xF3, 0xFE,
  0x1F, 0x80, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x00,
  0x0F, 0xC0, 0xFF, 0x0F, 0x3C, 0x70, 0xE7, 0x03, 0xB8, 0x1D, 0xC0, 0xFC,
  0x0F, 0xE0, 0x77, 0x03, 0xB8, 0x1D, 0xC0, 0xEE, 0x0E, 0x70, 0x71, 0xCF,
  0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0x80, 0x1F, 0xE0, 0x7F,
  0xE1, 0xC7, 0x87, 0x07, 0x1C, 0x1C, 0xE0, 0x73, 0x83, 0x8E, 0x1E, 0x3F,
  0xF0, 0xFF, 0x83, 0xFC, 0x1C, 0x78, 0x70, 0xE1, 0xC3, 0x87, 0x0F, 0x1C,
  0x1C, 0xE0, 0x70, 0x0F, 0xE0, 0xFF, 0x8F, 0x1C, 0x70, 0x77, 0x03, 0xBC,
  0x00, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x38, 0x00, 0xEE, 0x07,
  0x70, 0x7B, 0xC7, 0x8F, 0xF8, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0,
  0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x00, 0x38,
  0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x77, 0x07, 0x38, 0x39, 0xC1, 0xCE, 0x0E,
  0x70, 0x73, 0x83, 0xB8, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0xF1, 0xCF, 0x0F,
  0xF0, 0x3F, 0x00, 0xE0, 0x3F, 0x03, 0xBC, 0x1C, 0xE1, 0xE7, 0x0E, 0x38,
  0xF1, 0xC7, 0x0E, 0x38, 0x73, 0x83, 0x9C, 0x0D, 0xC0, 0x6E, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x00, 0xE7, 0x3F, 0x39, 0xF9, 0xCF,
  0xDE, 0xEC, 0xF7, 0x67, 0xBB, 0x7D, 0x9B, 0x7C, 0xDB, 0xE6, 0xDF, 0x3C,
  0xF1, 0xE7, 0x8F, 0x3C, 0x71, 0xC3, 0x8E, 0x1C, 0x70, 0xC3, 0x80, 0x1E,
  0x0F, 0x0E, 0x0E, 0x0E, 0x1C, 0x07, 0x3C, 0x07, 0x38, 0x07, 0x70, 0x03,
  0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E,
  0x70, 0x1C, 0x70, 0x3C, 0x78, 0x78, 0x38, 0xF0, 0x3C, 0xF0, 0x3D, 0xC1,
  0xE7, 0x07, 0x1C, 0x38, 0x39, 0xE0, 0xE7, 0x03, 0xB8, 0x0E, 0xE0, 0x1F,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x00, 0x1F, 0xFC, 0xFF, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x3C, 0x01, 0xE0, 0x07, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x0F, 0x8F, 0x87,
  0xC3, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0xC3, 0xE1, 0xF0,
  0xE1, 0x87, 0x1C, 0x71, 0xC3, 0x0C, 0x38, 0xE3, 0x8E, 0x18, 0x61, 0xC7,
  0x1C, 0x70, 0x1F, 0x8F, 0x87, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x83, 0x87, 0xC3, 0xE1, 0xF0, 0x0E, 0x07, 0x07, 0x83, 0xE3, 0xB1, 0x99,
  0x8D, 0xC7, 0xC1, 0x80, 0xFF, 0xFF, 0xFC, 0xF1, 0x86, 0x0F, 0x87, 0xF8,
  0xE7, 0xB8, 0x70, 0x0E, 0x1F, 0xDF, 0xFF, 0x87, 0xE0, 0xFC, 0x3B, 0x8F,
  0x7F, 0xE7, 0xDC, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xB8,
  0x3F, 0xE7, 0xFE, 0x70, 0xE7, 0x07, 0x70, 0x77, 0x07, 0xE0, 0xEE, 0x0E,
  0xE0, 0xEF, 0x3C, 0xFF, 0xCD, 0xF0, 0x0F, 0x81, 0xFC, 0x3F, 0xE7, 0x0E,
  0x70, 0x7E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x0E, 0x71, 0xC7, 0xF8,
  0x3F, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x07, 0xB8,
  0xFF, 0xC7, 0xFE, 0x70, 0xF3, 0x87, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x70,
  0x73, 0x83, 0x8E, 0x78, 0x7F, 0xC1, 0xFE, 0x00, 0x07, 0x81, 0xFC, 0x3F,
  0xE7, 0x86, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xE0, 0x0F, 0x04, 0x79,
  0xE7, 0xFC, 0x1F, 0x80, 0x00, 0x20, 0x1F, 0xC1, 0xFE, 0x1E, 0x00, 0xE0,
  0x07, 0x03, 0xFF, 0x9F, 0xFC, 0xFF, 0xE0, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x07,
  0x98, 0x7F, 0xC7, 0xFE, 0x70, 0x73, 0x83, 0xB8, 0x39, 0xC1, 0xCE, 0x0E,
  0x70, 0x73, 0x83, 0x8E, 0x7C, 0x7F, 0xC1, 0xFE, 0x00, 0x71, 0x07, 0x9E,
  0x78, 0x7F, 0x81, 0xF0, 0x00, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0C, 0xF0, 0xEF, 0xC7, 0xFE, 0x38, 0x79, 0xC1, 0xCE, 0x0E, 0x70,
  0xE7, 0x07, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x77, 0x87, 0x00, 0x01,
  0x80, 0x78, 0x0F, 0x00, 0xC0, 0x00, 0x7F, 0x0F, 0xE1, 0xFC, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70, 0xFF, 0xFF, 0xF8,
  0x00, 0x80, 0x38, 0x07, 0x80, 0x40, 0x00, 0x3F, 0x87, 0xF0, 0xFC, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x38, 0x07, 0x09, 0xE1, 0xF8, 0x3E, 0x00, 0x0E, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0xF3, 0x87, 0x8E, 0x3C, 0x39, 0xC0,
  0xEE, 0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0x81, 0xEF, 0x07, 0x1C, 0x1C, 0x78,
  0x70, 0xE3, 0xC3, 0xC0, 0x1F, 0xC3, 0xF8, 0x7F, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03,
  0x80, 0x70, 0xFF, 0xFF, 0xFC, 0x37, 0x31, 0xFF, 0xDF, 0xFE, 0xE7, 0x37,
  0x39, 0xB9, 0x9D, 0xDC, 0xEC, 0xE7, 0xE7, 0x3F, 0x39, 0xB9, 0x8D, 0xCC,
  0xEC, 0xE7, 0x00, 0x19, 0xE1, 0xDF, 0x8F, 0xFC, 0x70, 0xF3, 0x83, 0x9C,
  0x1C, 0xE1, 0xCE, 0x0E, 0x70, 0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xEF, 0x0E,
  0x00, 0x0F, 0x81, 0xFC, 0x3F, 0xE7, 0x0E, 0x70, 0x7E, 0x07, 0xE0, 0x7E,
  0x0E, 0xE0, 0xEE, 0x0E, 0x71, 0xC7, 0xF8, 0x3F, 0x00, 0x19, 0xC1, 0xFF,
  0x8F, 0xFC, 0x70, 0xE3, 0x87, 0x9C, 0x1C, 0xE0, 0xEE, 0x0E, 0x70, 0x73,
  0x83, 0x9E, 0x78, 0xFF, 0xC7, 0xF8, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x0F, 0x73, 0xFF, 0x3F, 0xF7, 0x0F, 0x70, 0x6E, 0x0E,
  0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0x73, 0xC7, 0xFC, 0x3F, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x39, 0xF3, 0xBE, 0x3F, 0xE3, 0xC0,
  0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00,
  0xE0, 0x00, 0x0F, 0x83, 0xFE, 0x3C, 0xE7, 0x07, 0x70, 0x03, 0xC0, 0x3F,
  0x80, 0x7C, 0x00, 0xEE, 0x0E, 0xF1, 0xE7, 0xFC, 0x3F, 0x80, 0x0E, 0x01,
  0xC0, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xC7, 0x00, 0xE0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x79, 0x0F, 0xE0, 0xFC, 0x38, 0x73, 0x87, 0x70,
  0x77, 0x07, 0x70, 0x77, 0x06, 0x70, 0xE7, 0x0E, 0xE0, 0xEE, 0x0E, 0x73,
  0xE7, 0xFC, 0x3C, 0xC0, 0xE0, 0x7E, 0x0E, 0xE0, 0xE6, 0x1C, 0x61, 0xC7,
  0x38, 0x73, 0x87, 0x70, 0x37, 0x03, 0x60, 0x3E, 0x03, 0xC0, 0x3C, 0x00,
  0xE3, 0x1F, 0x39, 0xF9, 0xCF, 0xCE, 0x6E, 0xF7, 0x77, 0xBB, 0xAD, 0x9F,
  0x6C, 0xFB, 0xE7, 0x9E, 0x3C, 0xF1, 0xE7, 0x8E, 0x38, 0x00, 0x38, 0x1C,
  0x70, 0xE1, 0xC7, 0x03, 0xBC, 0x0F, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0xC0, 0x77, 0x03, 0x8E, 0x1E, 0x38, 0xF0, 0x70, 0x38, 0x1E, 0x70,
  0x38, 0xE0, 0xF1, 0xC1, 0xC1, 0xC7, 0x03, 0x8E, 0x07, 0x38, 0x06, 0xF0,
  0x0D, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x00, 0xC0, 0xF0, 0x30, 0x1C, 0x06, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x07, 0x03, 0xC1, 0xC0, 0xF0, 0x0E, 0x01, 0xC0,
  0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0x80, 0xC0, 0x0C, 0x61,
  0x86, 0x18, 0x61, 0x8C, 0x30, 0xC3, 0x0C, 0x30, 0x86, 0x18, 0x61, 0x86,
  0x18, 0xC3, 0x00, 0x08, 0x07, 0x00, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x38, 0x0E, 0x01, 0x80, 0x7C, 0x0E, 0x07, 0x83, 0x81, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0x80, 0xE0, 0x38, 0x3C, 0x0E, 0x00, 0x18, 0x03, 0xF0, 0xDF,
  0xC7, 0xC7, 0xFC, 0x1F, 0x00, 0x20,
};

const GFXglyph RobotoMono_SemiBoldItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 6, 17, 14, 4, -17 },
  { 14, 8, 6, 14, 4, -18 },
  { 20, 14, 17, 14, 0, -17 },
  { 50, 13, 22, 14, 1, -20 },
  { 86, 12, 17, 14, 1, -17 },
  { 112, 14, 17, 14, 0, -17 },
  { 142, 3, 6, 14, 6, -18 },
  { 145, 8, 24, 14, 4, -19 },
  { 169, 8, 24, 14, 2, -19 },
  { 193, 11, 12, 14, 2, -17 },
  { 210, 12, 12, 14, 1, -14 },
  { 228, 5, 8, 14, 2, -3 },
  { 233, 10, 3, 14, 3, -9 },
  { 237, 4, 4, 14, 4, -4 },
  { 239, 12, 18, 14, 1, -17 },
  { 266, 12, 17, 14, 1, -17 },
  { 292, 8, 17, 14, 3, -17 },
  { 309, 13, 17, 14, 0, -17 },
  { 337, 12, 17, 14, 1, -17 },
  { 363, 13, 17, 14, 0, -17 },
  { 391, 13, 17, 14, 1, -17 },
  { 419, 11, 17, 14, 1, -17 },
  { 443, 12, 17, 14, 2, -17 },
  { 469, 12, 17, 14, 1, -17 },
  { 495, 11, 17, 14, 2, -17 },
  { 519, 6, 14, 14, 4, -14 },
  { 530, 8, 19, 14, 3, -14 },
  { 549, 11, 11, 14, 2, -13 },
  { 565, 12, 7, 14, 1, -11 },
  { 576, 11, 11, 14, 1, -13 },
  { 592, 10, 17, 14, 3, -17 },
  { 614, 13, 17, 14, 1, -17 },
  { 642, 14, 17, 14, -1, -17 },
  { 672, 14, 17, 14, 0, -17 },
  { 702, 13, 17, 14, 1, -17 },
  { 730, 13, 17, 14, 0, -17 },
  { 758, 13, 17, 14, 1, -17 },
  { 786, 14, 17, 14, 1, -17 },
  { 816, 13, 17, 14, 1, -17 },
  { 844, 14, 17, 14, 0, -17 },
  { 874, 13, 17, 14, 1, -17 },
  { 902, 13, 17, 14, 1, -17 },
  { 930, 16, 17, 14, 0, -17 },
  { 964, 11, 17, 14, 1, -17 },
  { 988, 14, 17, 14, 0, -17 },
  { 1018, 14, 17, 14, 0, -17 },
  { 1048, 13, 17, 14, 1, -17 },
  { 1076, 13, 17, 14, 1, -17 },
  { 1104, 13, 20, 14, 1, -17 },
  { 1137, 14, 17, 14, 0, -17 },
  { 1167, 13, 17, 14, 1, -17 },
  { 1195, 13, 17, 14, 2, -17 },
  { 1223, 13, 17, 14, 1, -17 },
  { 1251, 13, 17, 14, 2, -17 },
  { 1279, 13, 17, 14, 2, -17 },
  { 1307, 16, 17, 14, -1, -17 },
  { 1341, 14, 17, 14, 2, -17 },
  { 1371, 14, 17, 14, 0, -17 },
  { 1401, 9, 24, 14, 3, -20 },
  { 1428, 6, 18, 14, 4, -17 },
  { 1442, 9, 24, 14, 3, -20 },
  { 1469, 9, 9, 14, 3, -17 },
  { 1480, 11, 2, 14, 0, 0 },
  { 1483, 5, 3, 14, 6, -17 },
  { 1485, 11, 13, 14, 1, -13 },
  { 1503, 12, 18, 14, 1, -18 },
  { 1530, 12, 13, 14, 1, -13 },
  { 1550, 13, 18, 14, 1, -18 },
  { 1580, 12, 13, 14, 1, -13 },
  { 1600, 13, 19, 14, 2, -19 },
  { 1631, 13, 18, 14, 0, -13 },
  { 1661, 13, 18, 14, 0, -18 },
  { 1691, 11, 18, 14, 1, -18 },
  { 1716, 11, 23, 14, 1, -18 },
  { 1748, 14, 18, 14, 0, -18 },
  { 1780, 11, 18, 14, 1, -18 },
  { 1805, 13, 13, 14, 0, -13 },
  { 1827, 13, 13, 14, 0, -13 },
  { 1849, 12, 13, 14, 1, -13 },
  { 1869, 13, 18, 14, 0, -13 },
  { 1899, 12, 18, 14, 1, -13 },
  { 1926, 12, 13, 14, 2, -13 },
  { 1946, 12, 13, 14, 1, -13 },
  { 1966, 11, 16, 14, 2, -16 },
  { 1988, 12, 13, 14, 1, -13 },
  { 2008, 12, 13, 14, 2, -13 },
  { 2028, 13, 13, 14, 1, -13 },
  { 2050, 14, 13, 14, 0, -13 },
  { 2073, 15, 18, 14, 0, -13 },
  { 2107, 13, 13, 14, 0, -13 },
  { 2129, 10, 23, 14, 3, -19 },
  { 2158, 6, 22, 14, 4, -17 },
  { 2175, 10, 23, 14, 2, -19 },
  { 2204, 13, 6, 14, 0, -10 },
};

const GFXfont RobotoMono_SemiBoldItalic24pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic24pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic24pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC24PT7B_H_
