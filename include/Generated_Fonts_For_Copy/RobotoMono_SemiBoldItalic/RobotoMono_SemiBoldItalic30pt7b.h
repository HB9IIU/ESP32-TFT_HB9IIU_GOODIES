#ifndef _ROBOTOMONO_SEMIBOLDITALIC30PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x3C, 0x3C, 0x3C,
  0x38, 0x38, 0x38, 0x00, 0x00, 0x00, 0x70, 0xF8, 0xF8, 0x70, 0x71, 0xDC,
  0x77, 0x19, 0xC6, 0x63, 0x98, 0xEE, 0x3B, 0x8C, 0x00, 0xE3, 0x80, 0x38,
  0xC0, 0x0C, 0x70, 0x07, 0x18, 0x01, 0xC6, 0x00, 0x63, 0x81, 0xFF, 0xFC,
  0xFF, 0xFE, 0x03, 0x1C, 0x01, 0xC6, 0x00, 0x63, 0x80, 0x18, 0xE0, 0x0E,
  0x30, 0x3F, 0xFF, 0x8F, 0xFF, 0xE0, 0x71, 0x80, 0x18, 0xE0, 0x06, 0x38,
  0x03, 0x8C, 0x00, 0xC7, 0x00, 0x71, 0x80, 0x00, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x70, 0x03, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x1E, 0x0F,
  0x1E, 0x0F, 0x1C, 0x0F, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x70, 0x1E, 0xF0, 0x1E,
  0x78, 0x1C, 0x78, 0x3C, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xE0, 0x03, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x1C, 0x01, 0xF8, 0x07, 0xF0, 0x39, 0xC4, 0xE7,
  0x1B, 0x1C, 0xCE, 0x77, 0x3F, 0x98, 0x7E, 0xC0, 0xE7, 0x00, 0x38, 0x00,
  0xC0, 0x07, 0x00, 0x3B, 0xE0, 0xDF, 0xC6, 0x77, 0x3B, 0x8D, 0xCE, 0x32,
  0x39, 0xC0, 0xE7, 0x03, 0xF8, 0x07, 0xC0, 0x00, 0x60, 0x01, 0xFC, 0x01,
  0xFF, 0x00, 0xF7, 0x80, 0xF1, 0xC0, 0x78, 0xE0, 0x38, 0x70, 0x1E, 0x78,
  0x0F, 0xF8, 0x03, 0xF8, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x39, 0xEF,
  0x3D, 0xE3, 0x9C, 0xF1, 0xFE, 0x70, 0x7F, 0x38, 0x3F, 0x1E, 0x1F, 0x0F,
  0xFF, 0xC3, 0xFF, 0xE0, 0xFE, 0x78, 0x76, 0xEE, 0xEE, 0xCC, 0x00, 0x80,
  0x70, 0x3C, 0x1C, 0x0F, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x01,
  0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x3C, 0x06, 0x00,
  0x80, 0x04, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x0E, 0x03,
  0xC0, 0x70, 0x1C, 0x0F, 0x00, 0xC0, 0x10, 0x00, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0C, 0x07, 0x18, 0xEF, 0xB7, 0xFF, 0xFF, 0x83, 0xF0, 0x07,
  0x80, 0x1F, 0x80, 0x73, 0x81, 0xE7, 0x07, 0x87, 0x06, 0x0C, 0x00, 0x10,
  0x00, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78,
  0x1F, 0xFF, 0xBF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x3C, 0xF3, 0xCE, 0x79, 0xCF,
  0x38, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x77, 0xFF, 0xF7, 0x80, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x1F,
  0xC1, 0xFF, 0x87, 0xDF, 0x3C, 0x3C, 0xE0, 0x77, 0x81, 0xDE, 0x07, 0x78,
  0x7D, 0xC3, 0xFF, 0x3F, 0xFD, 0xEF, 0xFE, 0x3F, 0xF0, 0xEF, 0x03, 0xB8,
  0x1E, 0xE0, 0x7B, 0xC1, 0xCF, 0x0F, 0x1F, 0xF8, 0x7F, 0xC0, 0x7E, 0x00,
  0x01, 0x83, 0xE7, 0xFB, 0xFE, 0xFF, 0xB1, 0xE0, 0x70, 0x1C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0,
  0x70, 0x3C, 0x00, 0x00, 0xE0, 0x03, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x1E,
  0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0x00,
  0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFB, 0xF3, 0xC1, 0xE7, 0x83, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x80,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0xE0, 0x3D, 0xE0, 0x7B, 0xC1, 0xE3, 0xFF,
  0x87, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xDC, 0x03, 0x9C, 0x07, 0x3C, 0x0E,
  0x3C, 0x1E, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x07,
  0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x1F, 0xE0, 0x3F, 0xF8, 0x3F, 0xF8, 0x3C, 0x7C, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0x78, 0x78, 0x7F,
  0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x00, 0xF8, 0x0F, 0xE0, 0x7F, 0x83, 0xE0,
  0x1F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x7C, 0x7F, 0xF9, 0xFF, 0xE7, 0xC3,
  0xDE, 0x0F, 0x70, 0x3F, 0xC0, 0x7F, 0x03, 0xDC, 0x0F, 0x70, 0x3D, 0xE1,
  0xE3, 0xFF, 0x0F, 0xFC, 0x0F, 0xC0, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x00, 0xC0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFD, 0xF1, 0xE1, 0xE3, 0x83, 0xCF,
  0x03, 0x9E, 0x0F, 0x1C, 0x1E, 0x3E, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFF,
  0x8F, 0x07, 0x9C, 0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x7B, 0xE1, 0xE3,
  0xFF, 0xC3, 0xFF, 0x03, 0xF8, 0x00, 0x03, 0x80, 0x3F, 0x81, 0xFF, 0x0F,
  0xBE, 0x78, 0x39, 0xE0, 0xF7, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xDE, 0x3E, 0x7F, 0xF8, 0xFE, 0xE1, 0xF7, 0x80, 0x1C, 0x00, 0xF0,
  0x07, 0x80, 0x7C, 0x0F, 0xE0, 0x7F, 0x01, 0xF0, 0x00, 0x0C, 0x1E, 0x3F,
  0x1F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x78, 0xFC,
  0xF8, 0x78, 0x07, 0x07, 0xC3, 0xE1, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x78, 0x3C, 0x1E, 0x0E, 0x0F,
  0x07, 0x07, 0x01, 0x00, 0x00, 0x0C, 0x00, 0xF0, 0x1F, 0xC1, 0xFE, 0x3F,
  0xE1, 0xFC, 0x0F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x00,
  0x7C, 0x00, 0x70, 0x00, 0x40, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xE0, 0x30,
  0x00, 0xF0, 0x03, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF0, 0x03, 0xC0,
  0x3F, 0x07, 0xFC, 0xFF, 0x87, 0xF8, 0x1F, 0x00, 0xE0, 0x02, 0x00, 0x00,
  0x07, 0x01, 0xFF, 0x1F, 0xFD, 0xFB, 0xEF, 0x07, 0xF8, 0x3C, 0x01, 0xE0,
  0x1E, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x78, 0x07, 0xC0, 0x1C, 0x00,
  0x01, 0xF8, 0x07, 0xFC, 0x0F, 0x0E, 0x1C, 0x07, 0x38, 0xE3, 0x31, 0xFB,
  0x73, 0xB3, 0x67, 0x33, 0xE6, 0x33, 0xEE, 0x33, 0xCC, 0x73, 0xCC, 0x63,
  0xCC, 0x66, 0xCC, 0xE6, 0xCF, 0xFC, 0xCF, 0x7C, 0xC0, 0x10, 0xE0, 0x00,
  0x70, 0x40, 0x3F, 0xC0, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0x9C, 0x03,
  0xCE, 0x01, 0xC7, 0x01, 0xE3, 0x80, 0xE1, 0xC0, 0xF0, 0xF0, 0x7F, 0xF8,
  0x7F, 0xFC, 0x3F, 0xFE, 0x3C, 0x0F, 0x1E, 0x03, 0x9E, 0x01, 0xCF, 0x00,
  0xFF, 0x00, 0x78, 0x0F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xE3, 0xC0, 0xF1,
  0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1C, 0x1F, 0x1F, 0xFE,
  0x0F, 0xFF, 0x07, 0x87, 0xC3, 0xC0, 0xF1, 0xC0, 0x78, 0xE0, 0x3C, 0xF0,
  0x1E, 0x78, 0x0F, 0x3C, 0x1F, 0x1F, 0xFF, 0x8F, 0xFF, 0x0F, 0xFE, 0x00,
  0x00, 0xE0, 0x03, 0xFC, 0x0F, 0xFE, 0x1F, 0xBE, 0x1E, 0x0F, 0x3C, 0x0F,
  0x38, 0x0F, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x1E, 0xF0, 0x1C, 0x70, 0x3C,
  0x78, 0x7C, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x0F, 0xF8, 0x07, 0xFE,
  0x03, 0xFF, 0x83, 0xC3, 0xE1, 0xE0, 0xF0, 0xF0, 0x38, 0x78, 0x1E, 0x38,
  0x0F, 0x1C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xE3, 0xC0, 0xF1,
  0xC0, 0x79, 0xE0, 0x38, 0xF0, 0x3C, 0x78, 0x3C, 0x3C, 0x7E, 0x1F, 0xFE,
  0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3,
  0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0xFC,
  0x1F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F,
  0xFF, 0x80, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xC0, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0xFE, 0x0F,
  0xFF, 0x0F, 0xFF, 0x87, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xE0, 0x03, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C,
  0x0F, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0xFE, 0xF0,
  0xFE, 0xF0, 0xFE, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0x78, 0x1C, 0x78,
  0x3C, 0x3F, 0xFC, 0x3F, 0xF8, 0x0F, 0xE0, 0x0F, 0x03, 0xC3, 0x80, 0xE1,
  0xE0, 0x38, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xC0, 0x78, 0x70,
  0x1C, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x38, 0x0E,
  0x0E, 0x03, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0x87,
  0x01, 0xC1, 0xC0, 0x70, 0xF0, 0x3C, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F,
  0xFE, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x7F, 0xF8, 0xFF, 0xF8, 0xFF,
  0xF0, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF1, 0xE0, 0x78, 0xF0,
  0x3C, 0x7C, 0x3C, 0x1F, 0xFC, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0x03,
  0xF0, 0xF0, 0x7C, 0x0E, 0x0F, 0x81, 0xE1, 0xF0, 0x1E, 0x1E, 0x01, 0xE3,
  0xC0, 0x1E, 0x78, 0x01, 0xEF, 0x80, 0x1D, 0xF0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xE7, 0x80, 0x38, 0x78, 0x07,
  0x83, 0xC0, 0x78, 0x3C, 0x07, 0x83, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xE0,
  0xF0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x87, 0xC3, 0xE3, 0xF0, 0xF8, 0xFC, 0x7E,
  0x3E, 0x1F, 0x9F, 0x87, 0x67, 0xE1, 0xDB, 0xB8, 0x76, 0xFE, 0x1D, 0xF7,
  0x8F, 0x7D, 0xC3, 0xDE, 0x70, 0xE7, 0x9C, 0x39, 0xCF, 0x0E, 0x73, 0xC7,
  0x80, 0xE1, 0xE0, 0x38, 0x78, 0x0E, 0x1C, 0x07, 0x87, 0x01, 0xE1, 0xC0,
  0x78, 0xF0, 0x1C, 0x00, 0x0F, 0x03, 0xC3, 0xC0, 0xE1, 0xF0, 0x78, 0x7E,
  0x1E, 0x1F, 0x87, 0x87, 0xE1, 0xE1, 0xF8, 0x78, 0x77, 0x1C, 0x3D, 0xCF,
  0x0F, 0x73, 0xC3, 0xCE, 0xF0, 0xF3, 0xBC, 0x3C, 0xEE, 0x0E, 0x3B, 0x87,
  0x87, 0xE1, 0xE1, 0xF8, 0x78, 0x7E, 0x1E, 0x1F, 0x87, 0x03, 0xC1, 0xC0,
  0xF0, 0xF0, 0x3C, 0x00, 0x00, 0xC0, 0x07, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE,
  0x1E, 0x1E, 0x3C, 0x0F, 0x38, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F,
  0x70, 0x0F, 0x70, 0x0F, 0xF0, 0x0E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E,
  0xF0, 0x3C, 0x70, 0x3C, 0x78, 0x78, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0,
  0x1F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0x81, 0xE1, 0xC0, 0x71, 0xE0,
  0x3C, 0xF0, 0x1C, 0x78, 0x1E, 0x3C, 0x0F, 0x1C, 0x1F, 0x0F, 0xFF, 0x8F,
  0xFF, 0x87, 0xFF, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x07,
  0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x1E, 0x1E, 0x3C, 0x0F, 0x38, 0x0F, 0x78,
  0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x70, 0x0F, 0x70, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1C, 0x70, 0x3C, 0x78, 0x78, 0x7F,
  0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x18, 0x00,
  0x10, 0x0F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xE1, 0xC0, 0xF1, 0xE0, 0x78,
  0xF0, 0x1C, 0x78, 0x1E, 0x3C, 0x0F, 0x1C, 0x0F, 0x9E, 0x0F, 0x8F, 0xFF,
  0x87, 0xFF, 0x83, 0xFF, 0x81, 0xE3, 0xC0, 0xE1, 0xE0, 0xF0, 0x78, 0x78,
  0x3C, 0x3C, 0x1E, 0x1E, 0x07, 0x8E, 0x03, 0xCF, 0x01, 0xE0, 0x00, 0xE0,
  0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xBF, 0x3E, 0x0F, 0x3C, 0x07, 0x3C, 0x07,
  0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0x7C, 0x00, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0x78, 0x3C,
  0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0x1E, 0x07, 0x8E, 0x03, 0x87, 0x01, 0xC7, 0x81, 0xE3,
  0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x70, 0x1C, 0x38, 0x0E, 0x3C, 0x0F,
  0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0x80, 0xE3, 0xC0, 0x70, 0xE0,
  0x78, 0x78, 0x3C, 0x3C, 0x3C, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFC, 0x00,
  0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78,
  0xF0, 0x78, 0x70, 0xF0, 0x70, 0xF0, 0x78, 0xE0, 0x79, 0xE0, 0x79, 0xE0,
  0x7B, 0xC0, 0x7B, 0xC0, 0x3B, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0xF1, 0xC7, 0xF8, 0xE3, 0xFC, 0xF1,
  0xDE, 0x78, 0xEF, 0x3C, 0xF7, 0x9E, 0x73, 0xDF, 0x39, 0xEF, 0xBC, 0xE7,
  0xDE, 0x77, 0xEE, 0x3B, 0xF7, 0x1D, 0xBF, 0x8F, 0xDF, 0x87, 0xEF, 0xC3,
  0xE7, 0xE1, 0xF3, 0xF0, 0xF9, 0xF0, 0x78, 0xF8, 0x3C, 0x7C, 0x1E, 0x3C,
  0x0F, 0x1E, 0x00, 0x0F, 0x01, 0xF0, 0x78, 0x3E, 0x07, 0x83, 0xC0, 0x78,
  0x78, 0x03, 0xCF, 0x80, 0x3C, 0xF0, 0x03, 0xDE, 0x00, 0x1F, 0xE0, 0x01,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x7F, 0xC0, 0x07, 0xBC, 0x00, 0xF1, 0xE0, 0x1F, 0x1E, 0x01, 0xE1, 0xE0,
  0x3C, 0x0F, 0x07, 0xC0, 0xF0, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0xF0, 0x1E,
  0x70, 0x3E, 0x78, 0x3C, 0x78, 0x78, 0x38, 0x78, 0x38, 0xF0, 0x3C, 0xE0,
  0x3D, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF,
  0xFE, 0x00, 0x0F, 0xC3, 0xF0, 0xFC, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xF0, 0xFC, 0x3F, 0x00, 0xE1, 0xC3, 0x87, 0x8F, 0x0E, 0x1C, 0x38, 0x70,
  0xF1, 0xE1, 0xC3, 0x87, 0x0E, 0x1E, 0x3C, 0x38, 0x70, 0xE1, 0xC3, 0xC7,
  0x80, 0x0F, 0xC3, 0xF0, 0xFC, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC3, 0xF0,
  0xFC, 0x3F, 0x00, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0xEC, 0x0E, 0xC1, 0xCE,
  0x1C, 0xE3, 0x8E, 0x38, 0x67, 0x07, 0xF0, 0x70, 0xFF, 0xFB, 0xFF, 0xEF,
  0xFF, 0x80, 0xF1, 0xC3, 0x8F, 0x07, 0xE0, 0x7F, 0xE3, 0xFF, 0xCF, 0x0F,
  0x38, 0x1C, 0x00, 0xF0, 0x7F, 0xC7, 0xFF, 0x7F, 0xFD, 0xE0, 0xFF, 0x03,
  0xBC, 0x0E, 0xF0, 0xFB, 0xFF, 0xE7, 0xFF, 0x8F, 0xDE, 0x0E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0xF8,
  0x3F, 0xF8, 0x7F, 0xF8, 0xF8, 0xF1, 0xE0, 0xF7, 0x81, 0xEF, 0x03, 0xDE,
  0x07, 0xBC, 0x0F, 0x70, 0x1C, 0xE0, 0x7B, 0xC0, 0xF7, 0xC3, 0xCF, 0xFF,
  0x9F, 0xFE, 0x39, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xF1,
  0xE3, 0xC1, 0xEF, 0x03, 0xDE, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x01,
  0xC0, 0x03, 0x81, 0xE7, 0x87, 0x87, 0xFF, 0x0F, 0xFC, 0x0F, 0xE0, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x0F, 0x9C, 0x1F, 0xFE, 0x0F, 0xFF, 0x0F, 0x0F, 0x8F, 0x03,
  0xC7, 0x81, 0xE3, 0xC0, 0xE1, 0xC0, 0x70, 0xE0, 0x78, 0xF0, 0x3C, 0x78,
  0x1E, 0x1C, 0x0F, 0x0F, 0x0F, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x7D, 0xE0,
  0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xF1, 0xE3, 0xC1, 0xEF, 0x03, 0xDE,
  0x07, 0xBF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x87, 0x83,
  0x87, 0xFF, 0x8F, 0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFE,
  0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0xFF, 0xFC, 0xFF, 0xF8,
  0xFF, 0xF8, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x03, 0xE7, 0x83, 0xFF, 0x83, 0xFF, 0xC3, 0xE3,
  0xE3, 0xE0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x70, 0x1C, 0x38, 0x0E, 0x3C,
  0x0F, 0x1E, 0x07, 0x87, 0x03, 0xC3, 0xC3, 0xE1, 0xFF, 0xE0, 0x7F, 0xF0,
  0x1F, 0x78, 0x00, 0x3C, 0x10, 0x1E, 0x1C, 0x1E, 0x1F, 0xFE, 0x07, 0xFE,
  0x00, 0xFE, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0,
  0x03, 0x80, 0x0F, 0x00, 0x1E, 0x7C, 0x3F, 0xFC, 0x7F, 0xF8, 0xF8, 0xF9,
  0xC0, 0xF7, 0x81, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0E, 0x70, 0x1C, 0xE0,
  0x7B, 0xC0, 0xF7, 0x81, 0xEF, 0x03, 0xDE, 0x07, 0x38, 0x1E, 0x00, 0x00,
  0x70, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x07,
  0xF8, 0x1F, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x1F, 0xFF, 0x7F, 0xFB,
  0xFF, 0xE0, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x87, 0xFC, 0x3F, 0xC1, 0xF8, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x3C, 0x1F, 0x3C, 0x3E, 0x3C, 0x7C, 0x38, 0xF8, 0x39, 0xF0,
  0x7B, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x79, 0xE0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x78, 0xF0, 0x78, 0xE0, 0x3C, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x7F, 0xFD, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xCF, 0x1F, 0xFF, 0x8F, 0xFF, 0xE7, 0x3C, 0xF3,
  0x9E, 0x7B, 0xCF, 0x39, 0xE7, 0x1C, 0xE3, 0x8E, 0x71, 0xC7, 0x38, 0xE7,
  0x9C, 0xF3, 0xDE, 0x79, 0xCF, 0x38, 0xE7, 0x1C, 0x73, 0x8E, 0x39, 0xC7,
  0x3C, 0x3C, 0xF8, 0x77, 0xF8, 0xFF, 0xF1, 0xF1, 0xF3, 0x81, 0xEF, 0x03,
  0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1C, 0xE0, 0x79, 0xC0, 0xF7, 0x81, 0xEF,
  0x03, 0xDE, 0x07, 0xBC, 0x0E, 0x70, 0x3C, 0x07, 0xF0, 0x1F, 0xF0, 0x7F,
  0xF1, 0xE1, 0xE7, 0x81, 0xEF, 0x03, 0xDC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0xF3, 0x81, 0xE7, 0x87, 0x8F, 0xFF, 0x0F, 0xFC, 0x0F,
  0xE0, 0x1E, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x1E, 0x1E, 0x1C, 0x0F, 0x3C,
  0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x38, 0x0E, 0x38, 0x1E, 0x78,
  0x1E, 0x7C, 0x3C, 0x7F, 0xFC, 0x7F, 0xF8, 0x73, 0xF0, 0x70, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x07, 0xCF, 0x1F,
  0xEE, 0x1F, 0xFE, 0x3E, 0x3E, 0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x70,
  0x1C, 0x70, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0x70, 0x3C, 0x78, 0x78, 0x7F,
  0xF8, 0x3F, 0xF8, 0x1F, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x3C, 0xFC, 0xF7, 0xF3, 0xFF, 0x8F, 0xFE,
  0x3E, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0x07, 0xF0, 0x1F,
  0xF8, 0x7F, 0xF1, 0xE0, 0xF3, 0x81, 0xE7, 0x80, 0x0F, 0xC0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x03, 0xF8, 0x00, 0xF7, 0x81, 0xEF, 0x03, 0xCF, 0xFF, 0x0F,
  0xFC, 0x0F, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE3, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xFF, 0x07, 0xF8, 0x1F, 0xC0,
  0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x73, 0xC1, 0xE7, 0x03, 0xCE, 0x07, 0xBC,
  0x0F, 0x78, 0x1C, 0xF0, 0x39, 0xE0, 0xF3, 0x81, 0xE7, 0x83, 0xCF, 0x0F,
  0x9F, 0xFE, 0x1F, 0xDC, 0x1F, 0x38, 0xF0, 0x1F, 0x70, 0x1E, 0x70, 0x3C,
  0x70, 0x3C, 0x78, 0x38, 0x78, 0x78, 0x38, 0x70, 0x38, 0xF0, 0x38, 0xE0,
  0x3D, 0xE0, 0x1D, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00,
  0x0E, 0x00, 0xE3, 0x87, 0xE3, 0x8F, 0xE3, 0x8E, 0xE7, 0x8E, 0xE7, 0x9E,
  0xE7, 0x9C, 0xEF, 0x9C, 0xED, 0xB8, 0xED, 0xB8, 0xF9, 0xB8, 0xF9, 0xF0,
  0xF9, 0xF0, 0xF1, 0xF0, 0xF1, 0xE0, 0xF1, 0xE0, 0xE1, 0xE0, 0x1E, 0x07,
  0xC7, 0x83, 0xE0, 0xF0, 0xF0, 0x3C, 0x78, 0x07, 0xBC, 0x01, 0xFE, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3D,
  0xE0, 0x1E, 0x38, 0x0F, 0x0F, 0x07, 0x81, 0xC3, 0xE0, 0x78, 0x3C, 0x03,
  0xE7, 0x80, 0x78, 0x78, 0x1E, 0x0F, 0x07, 0xC1, 0xE0, 0xF0, 0x3C, 0x3C,
  0x03, 0x87, 0x80, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xEF, 0x00, 0x1D, 0xC0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xF1, 0xFF, 0xF9, 0xFF,
  0xFC, 0x00, 0x70, 0x1F, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x7E, 0x0F, 0x80, 0xF8, 0x07,
  0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x0E, 0x1C, 0x38, 0x60, 0xC1,
  0x87, 0x0E, 0x1C, 0x30, 0x60, 0xC1, 0x87, 0x0E, 0x1C, 0x30, 0x60, 0xC3,
  0x87, 0x0E, 0x18, 0x30, 0x60, 0xC3, 0x80, 0x0E, 0x01, 0xE0, 0x1C, 0x03,
  0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0,
  0x3E, 0x03, 0xC0, 0xF8, 0x3E, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x38, 0x07, 0x00, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0x70, 0x00, 0x1E, 0x00,
  0x1F, 0xC1, 0xDF, 0xF1, 0xCE, 0x7F, 0xEE, 0x0F, 0xE1, 0x03, 0xE0,
};

const GFXglyph RobotoMono_SemiBoldItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 8, 21, 18, 5, -21 },
  { 22, 10, 8, 18, 5, -23 },
  { 32, 18, 21, 18, 0, -21 },
  { 80, 16, 28, 18, 1, -25 },
  { 136, 14, 22, 18, 2, -22 },
  { 175, 17, 22, 18, 0, -22 },
  { 222, 4, 8, 18, 8, -23 },
  { 226, 10, 31, 18, 5, -24 },
  { 265, 11, 31, 18, 2, -24 },
  { 308, 15, 15, 18, 2, -21 },
  { 337, 15, 16, 18, 1, -18 },
  { 367, 6, 9, 18, 3, -3 },
  { 374, 12, 3, 18, 4, -11 },
  { 379, 5, 5, 18, 5, -5 },
  { 383, 16, 23, 18, 1, -21 },
  { 429, 14, 22, 18, 2, -22 },
  { 468, 10, 21, 18, 4, -21 },
  { 495, 16, 22, 18, 0, -22 },
  { 539, 15, 22, 18, 1, -22 },
  { 581, 16, 21, 18, 0, -21 },
  { 623, 16, 21, 18, 1, -21 },
  { 665, 14, 21, 18, 1, -21 },
  { 702, 16, 21, 18, 2, -21 },
  { 744, 15, 22, 18, 1, -22 },
  { 786, 14, 22, 18, 2, -22 },
  { 825, 8, 17, 18, 5, -17 },
  { 842, 9, 23, 18, 4, -17 },
  { 868, 14, 14, 18, 2, -16 },
  { 893, 14, 10, 18, 2, -14 },
  { 911, 14, 14, 18, 1, -16 },
  { 936, 13, 22, 18, 4, -22 },
  { 972, 16, 21, 18, 1, -21 },
  { 1014, 17, 21, 18, -1, -21 },
  { 1059, 17, 21, 18, 0, -21 },
  { 1104, 16, 22, 18, 1, -22 },
  { 1148, 17, 21, 18, 0, -21 },
  { 1193, 17, 21, 18, 1, -21 },
  { 1238, 17, 21, 18, 1, -21 },
  { 1283, 16, 22, 18, 1, -22 },
  { 1327, 18, 21, 18, 0, -21 },
  { 1375, 16, 21, 18, 1, -21 },
  { 1417, 17, 21, 18, 1, -21 },
  { 1462, 20, 21, 18, 0, -21 },
  { 1515, 14, 21, 18, 1, -21 },
  { 1552, 18, 21, 18, 0, -21 },
  { 1600, 18, 21, 18, 0, -21 },
  { 1648, 16, 22, 18, 1, -22 },
  { 1692, 17, 21, 18, 1, -21 },
  { 1737, 16, 26, 18, 1, -22 },
  { 1789, 17, 21, 18, 0, -21 },
  { 1834, 16, 22, 18, 1, -22 },
  { 1878, 17, 21, 18, 2, -21 },
  { 1923, 17, 21, 18, 1, -21 },
  { 1968, 16, 21, 18, 3, -21 },
  { 2010, 17, 21, 18, 2, -21 },
  { 2055, 20, 21, 18, -1, -21 },
  { 2108, 16, 21, 18, 3, -21 },
  { 2150, 18, 21, 18, 0, -21 },
  { 2198, 10, 30, 18, 4, -25 },
  { 2236, 7, 23, 18, 6, -21 },
  { 2257, 10, 30, 18, 4, -25 },
  { 2295, 12, 11, 18, 3, -21 },
  { 2312, 14, 3, 18, 0, 0 },
  { 2318, 6, 4, 18, 8, -22 },
  { 2321, 14, 16, 18, 1, -16 },
  { 2349, 15, 23, 18, 1, -23 },
  { 2393, 15, 16, 18, 1, -16 },
  { 2423, 17, 23, 18, 1, -23 },
  { 2472, 15, 16, 18, 1, -16 },
  { 2502, 16, 23, 18, 3, -23 },
  { 2548, 17, 22, 18, 0, -16 },
  { 2595, 15, 23, 18, 1, -23 },
  { 2639, 14, 22, 18, 1, -22 },
  { 2678, 13, 28, 18, 1, -22 },
  { 2724, 16, 23, 18, 1, -23 },
  { 2770, 14, 23, 18, 1, -23 },
  { 2811, 17, 16, 18, 0, -16 },
  { 2845, 15, 16, 18, 1, -16 },
  { 2875, 15, 16, 18, 1, -16 },
  { 2905, 16, 22, 18, 0, -16 },
  { 2949, 16, 22, 18, 1, -16 },
  { 2993, 14, 16, 18, 3, -16 },
  { 3021, 15, 16, 18, 1, -16 },
  { 3051, 13, 20, 18, 3, -20 },
  { 3084, 15, 16, 18, 2, -16 },
  { 3114, 16, 16, 18, 2, -16 },
  { 3146, 16, 16, 18, 2, -16 },
  { 3178, 18, 16, 18, 0, -16 },
  { 3214, 19, 22, 18, 0, -16 },
  { 3267, 17, 16, 18, 0, -16 },
  { 3301, 12, 28, 18, 4, -23 },
  { 3343, 7, 27, 18, 5, -21 },
  { 3367, 11, 28, 18, 3, -23 },
  { 3406, 17, 6, 18, 0, -12 },
};

const GFXfont RobotoMono_SemiBoldItalic30pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic30pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic30pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC30PT7B_H_
