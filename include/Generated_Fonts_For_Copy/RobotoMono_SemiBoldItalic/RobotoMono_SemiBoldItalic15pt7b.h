#ifndef _ROBOTOMONO_SEMIBOLDITALIC15PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xB0, 0x1B, 0x00, 0xD9, 0x9B, 0x0D, 0x04, 0x82, 0xCF,
  0xF7, 0xF8, 0xB0, 0x91, 0xFE, 0x2C, 0x24, 0x16, 0x00, 0x0C, 0x1C, 0x3E,
  0x66, 0x63, 0x60, 0x38, 0x0C, 0x06, 0xC6, 0xCC, 0x78, 0x20, 0x20, 0x61,
  0xA2, 0x5D, 0xE6, 0x82, 0x0D, 0x1F, 0x52, 0xA4, 0x70, 0x0C, 0x0F, 0x0C,
  0x86, 0xC3, 0xC1, 0xC1, 0xE6, 0x9E, 0xCF, 0x77, 0x1E, 0xC0, 0xEA, 0x08,
  0xCC, 0x46, 0x31, 0x18, 0xC6, 0x30, 0x84, 0x30, 0x80, 0x20, 0x86, 0x10,
  0x84, 0x21, 0x18, 0xC6, 0x63, 0x33, 0x00, 0x08, 0x11, 0x6F, 0xF1, 0x85,
  0x1B, 0x24, 0x18, 0x30, 0x67, 0xFF, 0xE6, 0x0C, 0x18, 0x32, 0x66, 0xC0,
  0xFC, 0xF0, 0x02, 0x0C, 0x10, 0x61, 0x83, 0x0C, 0x18, 0x60, 0xC3, 0x06,
  0x00, 0x1C, 0x7D, 0x9A, 0x3C, 0xFB, 0xF9, 0xE3, 0xCD, 0x99, 0xE0, 0x0B,
  0xFD, 0x63, 0x18, 0xC6, 0x23, 0x18, 0x1C, 0x3F, 0x63, 0x63, 0x06, 0x06,
  0x0C, 0x38, 0x70, 0xFE, 0xFE, 0x1E, 0x3F, 0x73, 0x03, 0x07, 0x1C, 0x06,
  0x02, 0xC6, 0x6E, 0x7C, 0x03, 0x07, 0x0E, 0x1E, 0x16, 0x36, 0x66, 0xFF,
  0xFF, 0x0C, 0x0C, 0x3F, 0x3E, 0x60, 0x60, 0x7C, 0xFC, 0x06, 0x06, 0xC4,
  0xCC, 0x78, 0x0C, 0x79, 0xC3, 0x0F, 0xDD, 0xB1, 0xE3, 0xCD, 0x99, 0xE0,
  0x7F, 0xFF, 0x06, 0x04, 0x0C, 0x18, 0x18, 0x30, 0x20, 0x60, 0xC0, 0x1C,
  0xFD, 0x9B, 0x36, 0x67, 0x33, 0x62, 0xC5, 0x99, 0xE0, 0x38, 0xF9, 0x9E,
  0x3C, 0x78, 0xDF, 0x96, 0x0C, 0xF1, 0x80, 0x6C, 0x00, 0x36, 0x39, 0x80,
  0x00, 0x01, 0x8C, 0x66, 0x20, 0x02, 0x3D, 0xE6, 0x07, 0x83, 0x81, 0x00,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x41, 0xE0, 0x70, 0x77, 0xDC, 0x20, 0x00,
  0x3B, 0xFC, 0xC3, 0x0C, 0xE3, 0x18, 0x01, 0x86, 0x00, 0x04, 0x0D, 0x88,
  0x49, 0xD5, 0x2A, 0xAB, 0xD5, 0x7A, 0xD6, 0x20, 0x0F, 0x00, 0x02, 0x03,
  0x81, 0xC1, 0xE0, 0xB0, 0xD8, 0x64, 0x7E, 0x3F, 0xB0, 0xF8, 0x60, 0x3E,
  0x1F, 0x8C, 0x64, 0x36, 0x33, 0xF1, 0x8C, 0xC6, 0x63, 0x7F, 0x3F, 0x00,
  0x1C, 0x7E, 0x62, 0xC3, 0xC0, 0xC0, 0xC0, 0x80, 0xC6, 0xCC, 0x78, 0x3C,
  0x3E, 0x33, 0x63, 0x63, 0x63, 0x63, 0x63, 0x46, 0xFE, 0xF8, 0x3F, 0x9F,
  0xCC, 0x06, 0x06, 0x13, 0xF1, 0x80, 0xC0, 0x60, 0x3F, 0x3F, 0x80, 0x3F,
  0x9F, 0xCC, 0x06, 0x06, 0x03, 0xF9, 0xF8, 0xC0, 0x60, 0x20, 0x30, 0x00,
  0x1C, 0x7E, 0x62, 0xC3, 0xC0, 0xC0, 0xDE, 0xC6, 0xC6, 0xEE, 0x7C, 0x31,
  0x98, 0xC8, 0x4C, 0x66, 0x33, 0xF9, 0x8C, 0xC6, 0x42, 0x63, 0x31, 0x80,
  0x7E, 0xFC, 0x60, 0xC1, 0x82, 0x0C, 0x18, 0x31, 0xFB, 0xF0, 0x03, 0x03,
  0x02, 0x06, 0x06, 0x06, 0x06, 0x06, 0x8C, 0xDC, 0x78, 0x31, 0xCC, 0xE3,
  0x30, 0x98, 0x6C, 0x1F, 0x07, 0xC1, 0xB0, 0x66, 0x31, 0x8C, 0x30, 0x30,
  0x60, 0xC1, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xFF, 0xF8, 0x31, 0x99, 0xCE,
  0xEF, 0xE7, 0xD3, 0x79, 0xAC, 0x96, 0x43, 0x61, 0x31, 0x80, 0x31, 0x98,
  0xCC, 0x4F, 0x67, 0xB3, 0x59, 0xAC, 0xDE, 0x46, 0x63, 0x31, 0x80, 0x1C,
  0xFD, 0x9E, 0x1C, 0x38, 0xF1, 0xC3, 0xC7, 0xB9, 0xE0, 0x3E, 0x1F, 0x8C,
  0x66, 0x36, 0x1B, 0xF9, 0xF8, 0xC0, 0x60, 0x20, 0x30, 0x00, 0x1C, 0x7E,
  0x66, 0xC2, 0xC3, 0xC6, 0xC6, 0x86, 0xC6, 0xDC, 0x78, 0x0E, 0x04, 0x3E,
  0x1F, 0x8C, 0x64, 0x36, 0x33, 0xF9, 0xF0, 0xCC, 0x66, 0x63, 0x30, 0xC0,
  0x0E, 0x1F, 0x8C, 0x64, 0x03, 0x00, 0xF0, 0x1C, 0x06, 0xC3, 0x33, 0x8F,
  0x80, 0xFF, 0xFF, 0x86, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x00, 0x63, 0x63, 0x43, 0xC2, 0xC6, 0xC6, 0xC6, 0xC6, 0xC4, 0xDC,
  0x78, 0xC3, 0xC3, 0x46, 0x66, 0x66, 0x6C, 0x6C, 0x78, 0x78, 0x30, 0x30,
  0xC9, 0xED, 0xB6, 0xDB, 0x6F, 0xA7, 0x73, 0xB9, 0xD8, 0xCC, 0x66, 0x33,
  0x00, 0x71, 0xCC, 0x63, 0x30, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0xD0, 0x66,
  0x19, 0x8C, 0x30, 0xC3, 0xB1, 0x99, 0x8C, 0xC2, 0xC1, 0xC0, 0xE0, 0x60,
  0x30, 0x18, 0x0C, 0x00, 0x3F, 0xBF, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x60,
  0x60, 0x60, 0x7F, 0xBF, 0x80, 0x39, 0x8C, 0x46, 0x31, 0x8C, 0x62, 0x31,
  0x8C, 0x70, 0x9B, 0x64, 0x9B, 0x6C, 0x90, 0x38, 0xC6, 0x31, 0x18, 0xC6,
  0x31, 0x8C, 0x46, 0x70, 0x11, 0x8E, 0xFC, 0xC4, 0xFE, 0xCC, 0x3E, 0x36,
  0x43, 0x3E, 0x66, 0xC6, 0x6E, 0x7E, 0x30, 0x30, 0x30, 0x2E, 0x77, 0x63,
  0x63, 0x63, 0x62, 0x66, 0xDC, 0x3C, 0xDF, 0x1E, 0x0C, 0x18, 0xB3, 0x3C,
  0x03, 0x03, 0x06, 0x3E, 0x6E, 0xC6, 0xC6, 0xC4, 0xCC, 0xDC, 0x7C, 0x3C,
  0xDF, 0x1F, 0xFF, 0xF8, 0x3B, 0x3C, 0x02, 0x0F, 0x18, 0x18, 0xFE, 0x30,
  0x30, 0x30, 0x30, 0x20, 0x60, 0x60, 0x1F, 0x37, 0x63, 0x63, 0x63, 0x62,
  0x66, 0x3E, 0x06, 0xCC, 0x78, 0x30, 0x30, 0x30, 0x2E, 0x7F, 0x63, 0x63,
  0x63, 0x62, 0x46, 0xC6, 0x0C, 0x30, 0x1E, 0x78, 0x61, 0x84, 0x33, 0xFF,
  0xC0, 0x06, 0x0C, 0x00, 0xF3, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x20, 0xC1,
  0x9E, 0x00, 0x30, 0x18, 0x0C, 0x04, 0x76, 0x63, 0x61, 0xE0, 0xF8, 0x6C,
  0x23, 0x31, 0xC0, 0x7C, 0x31, 0x86, 0x18, 0x61, 0x84, 0x33, 0xFF, 0xC0,
  0x7B, 0x7F, 0x49, 0x4B, 0xDB, 0xDB, 0xDB, 0xD2, 0x2E, 0x7F, 0x63, 0x63,
  0x63, 0x62, 0x46, 0xC6, 0x3C, 0xDF, 0x1E, 0x3C, 0x78, 0xF3, 0x3C, 0x2E,
  0x77, 0x63, 0x63, 0x63, 0x62, 0x66, 0xDC, 0xC0, 0xC0, 0xC0, 0x3E, 0xDF,
  0x1E, 0x3C, 0x59, 0xB7, 0x3E, 0x0C, 0x18, 0x60, 0x2E, 0xFD, 0xC3, 0x06,
  0x0C, 0x10, 0x60, 0x3C, 0xCF, 0x03, 0x83, 0xD0, 0xF3, 0x3C, 0x18, 0x63,
  0xF9, 0x83, 0x06, 0x08, 0x30, 0x34, 0x78, 0x67, 0x8F, 0x1E, 0x3C, 0x78,
  0xB7, 0x3E, 0xC3, 0xC6, 0x44, 0x6C, 0x68, 0x78, 0x30, 0x30, 0xDB, 0x9B,
  0xBA, 0xBE, 0xAC, 0xCC, 0xCC, 0xC8, 0x63, 0x99, 0x87, 0x83, 0x81, 0xC1,
  0xE1, 0x99, 0x8E, 0x61, 0xB1, 0x8C, 0xC6, 0xC3, 0x61, 0xE0, 0x60, 0x30,
  0x30, 0x38, 0x38, 0x00, 0x7F, 0x7F, 0x06, 0x0C, 0x18, 0x30, 0x7F, 0xFE,
  0x04, 0x61, 0x84, 0x10, 0xC3, 0x30, 0x60, 0x82, 0x18, 0x20, 0xC1, 0x00,
  0x25, 0xA4, 0x92, 0xDA, 0x49, 0x00, 0x10, 0xE1, 0x86, 0x18, 0x61, 0x83,
  0x18, 0xC3, 0x0C, 0x21, 0x88, 0x00, 0x71, 0xFB, 0x8E,
};

const GFXglyph RobotoMono_SemiBoldItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 11, 9, 3, -11 },
  { 6, 4, 4, 9, 3, -11 },
  { 8, 9, 11, 9, 0, -11 },
  { 21, 8, 14, 9, 1, -12 },
  { 35, 7, 11, 9, 1, -11 },
  { 45, 9, 11, 9, 0, -11 },
  { 58, 2, 4, 9, 4, -11 },
  { 59, 5, 15, 9, 2, -12 },
  { 69, 5, 15, 9, 1, -12 },
  { 79, 7, 8, 9, 1, -11 },
  { 86, 7, 8, 9, 1, -9 },
  { 93, 4, 5, 9, 1, -2 },
  { 96, 6, 1, 9, 2, -5 },
  { 97, 2, 2, 9, 3, -2 },
  { 98, 7, 12, 9, 1, -11 },
  { 109, 7, 11, 9, 1, -11 },
  { 119, 5, 11, 9, 2, -11 },
  { 126, 8, 11, 9, 0, -11 },
  { 137, 8, 11, 9, 0, -11 },
  { 148, 8, 11, 9, 0, -11 },
  { 159, 8, 11, 9, 1, -11 },
  { 170, 7, 11, 9, 1, -11 },
  { 180, 8, 11, 9, 1, -11 },
  { 191, 7, 11, 9, 1, -11 },
  { 201, 7, 11, 9, 1, -11 },
  { 211, 3, 8, 9, 3, -8 },
  { 214, 5, 11, 9, 2, -8 },
  { 221, 7, 7, 9, 1, -8 },
  { 228, 7, 5, 9, 1, -7 },
  { 233, 7, 7, 9, 1, -8 },
  { 240, 6, 11, 9, 2, -11 },
  { 249, 9, 11, 9, 0, -11 },
  { 262, 9, 11, 9, -1, -11 },
  { 275, 9, 11, 9, 0, -11 },
  { 288, 8, 11, 9, 1, -11 },
  { 299, 8, 11, 9, 0, -11 },
  { 310, 9, 11, 9, 0, -11 },
  { 323, 9, 11, 9, 0, -11 },
  { 336, 8, 11, 9, 1, -11 },
  { 347, 9, 11, 9, 0, -11 },
  { 360, 7, 11, 9, 1, -11 },
  { 370, 8, 11, 9, 1, -11 },
  { 381, 10, 11, 9, 0, -11 },
  { 395, 7, 11, 9, 0, -11 },
  { 405, 9, 11, 9, 0, -11 },
  { 418, 9, 11, 9, 0, -11 },
  { 431, 7, 11, 9, 1, -11 },
  { 441, 9, 11, 9, 0, -11 },
  { 454, 8, 13, 9, 1, -11 },
  { 467, 9, 11, 9, 0, -11 },
  { 480, 9, 11, 9, 0, -11 },
  { 493, 9, 11, 9, 1, -11 },
  { 506, 8, 11, 9, 1, -11 },
  { 517, 8, 11, 9, 1, -11 },
  { 528, 9, 11, 9, 1, -11 },
  { 541, 10, 11, 9, 0, -11 },
  { 555, 9, 11, 9, 1, -11 },
  { 568, 9, 11, 9, 0, -11 },
  { 581, 5, 14, 9, 2, -12 },
  { 590, 3, 12, 9, 3, -11 },
  { 595, 5, 14, 9, 2, -12 },
  { 604, 5, 6, 9, 2, -11 },
  { 608, 7, 1, 9, 0, 0 },
  { 609, 3, 2, 9, 4, -11 },
  { 610, 8, 8, 9, 0, -8 },
  { 618, 8, 11, 9, 0, -11 },
  { 629, 7, 8, 9, 1, -8 },
  { 636, 8, 11, 9, 1, -11 },
  { 647, 7, 8, 9, 1, -8 },
  { 654, 8, 12, 9, 1, -12 },
  { 666, 8, 11, 9, 0, -8 },
  { 677, 8, 11, 9, 0, -11 },
  { 688, 6, 11, 9, 1, -11 },
  { 697, 7, 14, 9, 0, -11 },
  { 710, 9, 11, 9, 0, -11 },
  { 723, 6, 11, 9, 1, -11 },
  { 732, 8, 8, 9, 0, -8 },
  { 740, 8, 8, 9, 0, -8 },
  { 748, 7, 8, 9, 1, -8 },
  { 755, 8, 11, 9, 0, -8 },
  { 766, 7, 11, 9, 1, -8 },
  { 776, 7, 8, 9, 1, -8 },
  { 783, 7, 8, 9, 1, -8 },
  { 790, 7, 10, 9, 1, -10 },
  { 799, 7, 8, 9, 1, -8 },
  { 806, 8, 8, 9, 1, -8 },
  { 814, 8, 8, 9, 1, -8 },
  { 822, 9, 8, 9, 0, -8 },
  { 831, 9, 11, 9, 0, -8 },
  { 844, 8, 8, 9, 0, -8 },
  { 852, 6, 15, 9, 2, -12 },
  { 864, 3, 14, 9, 3, -11 },
  { 870, 6, 15, 9, 1, -12 },
  { 882, 8, 3, 9, 0, -6 },
};

const GFXfont RobotoMono_SemiBoldItalic15pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic15pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC15PT7B_H_
