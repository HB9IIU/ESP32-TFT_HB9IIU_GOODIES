#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/RobotoMono_SemiBoldItalic
// Headers: 67

#include "RobotoMono_SemiBoldItalic6pt7b.h"
#include "RobotoMono_SemiBoldItalic7pt7b.h"
#include "RobotoMono_SemiBoldItalic8pt7b.h"
#include "RobotoMono_SemiBoldItalic9pt7b.h"
#include "RobotoMono_SemiBoldItalic10pt7b.h"
#include "RobotoMono_SemiBoldItalic11pt7b.h"
#include "RobotoMono_SemiBoldItalic12pt7b.h"
#include "RobotoMono_SemiBoldItalic13pt7b.h"
#include "RobotoMono_SemiBoldItalic14pt7b.h"
#include "RobotoMono_SemiBoldItalic15pt7b.h"
#include "RobotoMono_SemiBoldItalic16pt7b.h"
#include "RobotoMono_SemiBoldItalic17pt7b.h"
#include "RobotoMono_SemiBoldItalic18pt7b.h"
#include "RobotoMono_SemiBoldItalic19pt7b.h"
#include "RobotoMono_SemiBoldItalic20pt7b.h"
#include "RobotoMono_SemiBoldItalic21pt7b.h"
#include "RobotoMono_SemiBoldItalic22pt7b.h"
#include "RobotoMono_SemiBoldItalic23pt7b.h"
#include "RobotoMono_SemiBoldItalic24pt7b.h"
#include "RobotoMono_SemiBoldItalic25pt7b.h"
#include "RobotoMono_SemiBoldItalic26pt7b.h"
#include "RobotoMono_SemiBoldItalic27pt7b.h"
#include "RobotoMono_SemiBoldItalic28pt7b.h"
#include "RobotoMono_SemiBoldItalic29pt7b.h"
#include "RobotoMono_SemiBoldItalic30pt7b.h"
#include "RobotoMono_SemiBoldItalic31pt7b.h"
#include "RobotoMono_SemiBoldItalic32pt7b.h"
#include "RobotoMono_SemiBoldItalic33pt7b.h"
#include "RobotoMono_SemiBoldItalic34pt7b.h"
#include "RobotoMono_SemiBoldItalic35pt7b.h"
#include "RobotoMono_SemiBoldItalic36pt7b.h"
#include "RobotoMono_SemiBoldItalic37pt7b.h"
#include "RobotoMono_SemiBoldItalic38pt7b.h"
#include "RobotoMono_SemiBoldItalic39pt7b.h"
#include "RobotoMono_SemiBoldItalic40pt7b.h"
#include "RobotoMono_SemiBoldItalic41pt7b.h"
#include "RobotoMono_SemiBoldItalic42pt7b.h"
#include "RobotoMono_SemiBoldItalic43pt7b.h"
#include "RobotoMono_SemiBoldItalic44pt7b.h"
#include "RobotoMono_SemiBoldItalic45pt7b.h"
#include "RobotoMono_SemiBoldItalic46pt7b.h"
#include "RobotoMono_SemiBoldItalic47pt7b.h"
#include "RobotoMono_SemiBoldItalic48pt7b.h"
#include "RobotoMono_SemiBoldItalic49pt7b.h"
#include "RobotoMono_SemiBoldItalic50pt7b.h"
#include "RobotoMono_SemiBoldItalic51pt7b.h"
#include "RobotoMono_SemiBoldItalic52pt7b.h"
#include "RobotoMono_SemiBoldItalic53pt7b.h"
#include "RobotoMono_SemiBoldItalic54pt7b.h"
#include "RobotoMono_SemiBoldItalic55pt7b.h"
#include "RobotoMono_SemiBoldItalic56pt7b.h"
#include "RobotoMono_SemiBoldItalic57pt7b.h"
#include "RobotoMono_SemiBoldItalic58pt7b.h"
#include "RobotoMono_SemiBoldItalic59pt7b.h"
#include "RobotoMono_SemiBoldItalic60pt7b.h"
#include "RobotoMono_SemiBoldItalic61pt7b.h"
#include "RobotoMono_SemiBoldItalic62pt7b.h"
#include "RobotoMono_SemiBoldItalic63pt7b.h"
#include "RobotoMono_SemiBoldItalic64pt7b.h"
#include "RobotoMono_SemiBoldItalic65pt7b.h"
#include "RobotoMono_SemiBoldItalic66pt7b.h"
#include "RobotoMono_SemiBoldItalic67pt7b.h"
#include "RobotoMono_SemiBoldItalic68pt7b.h"
#include "RobotoMono_SemiBoldItalic69pt7b.h"
#include "RobotoMono_SemiBoldItalic70pt7b.h"
#include "RobotoMono_SemiBoldItalic71pt7b.h"
#include "RobotoMono_SemiBoldItalic72pt7b.h"
