#ifndef _ROBOTOMONO_SEMIBOLDITALIC45PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xC0, 0x7C, 0x3D, 0xF0,
  0xF7, 0x83, 0xDE, 0x0F, 0x78, 0x79, 0xE1, 0xE7, 0x07, 0xBC, 0x1E, 0xF0,
  0x7B, 0xC1, 0xCF, 0x0F, 0x38, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x01, 0xC1,
  0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0E, 0x0F, 0x00, 0x07,
  0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x3C, 0x03,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xC0, 0x3C, 0x1C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0x83, 0xC0, 0x01, 0xE0,
  0xE0, 0x00, 0x78, 0x78, 0x00, 0x1C, 0x1E, 0x01, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0x1E, 0x1E, 0x00,
  0x07, 0x07, 0x80, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x38, 0x3C,
  0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC1, 0xC0, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0x7E, 0x0F,
  0xC0, 0x7E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3F, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0xFC,
  0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7E,
  0x03, 0xF8, 0x7F, 0x8F, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0x8F, 0x00, 0x78, 0x78, 0x33,
  0xC3, 0xC3, 0xDE, 0x1E, 0x3C, 0xF0, 0xF1, 0xE7, 0x87, 0x9E, 0x3C, 0x79,
  0xE1, 0xFF, 0xCE, 0x07, 0xFC, 0xF0, 0x1F, 0xCF, 0x00, 0x10, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC3,
  0x00, 0x3C, 0xFE, 0x01, 0xCF, 0xF8, 0x1E, 0xFF, 0xE1, 0xE7, 0x8F, 0x0E,
  0x78, 0x78, 0xF3, 0xC3, 0xCF, 0x1E, 0x1E, 0x70, 0xF0, 0xF0, 0x87, 0x87,
  0x80, 0x3E, 0x7C, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0x8F, 0x80, 0x0F, 0x83, 0xE0, 0x0F, 0xC1, 0xF0,
  0x07, 0xC0, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0x3E, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x47, 0xFF, 0x03, 0xC7, 0xFF,
  0xC3, 0xE3, 0xF3, 0xE1, 0xF3, 0xF1, 0xF8, 0xFB, 0xF0, 0x7E, 0xF9, 0xF8,
  0x3F, 0xFC, 0xFC, 0x0F, 0xFE, 0x7E, 0x07, 0xFE, 0x3F, 0x01, 0xFE, 0x1F,
  0x80, 0xFE, 0x0F, 0xE1, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFD, 0xF8, 0x0F, 0xF8, 0x7E, 0x00, 0x3C, 0xF3, 0xCF, 0x7D, 0xE7,
  0x9E, 0x79, 0xE7, 0x3C, 0x00, 0x02, 0x00, 0x1C, 0x00, 0x78, 0x03, 0xF0,
  0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E,
  0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0x20, 0x00, 0x01, 0x00, 0x03, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x0E, 0x00, 0x18, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x01, 0x81, 0xE0, 0x6F, 0x0F, 0x0F, 0x7E, 0x73, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F,
  0xF0, 0x01, 0xF7, 0x80, 0x0F, 0x1E, 0x00, 0xF8, 0xF8, 0x0F, 0x83, 0xC0,
  0xF8, 0x1F, 0x03, 0x80, 0xF0, 0x0C, 0x03, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x0F, 0x87, 0xC3, 0xE1, 0xF1, 0xF8, 0xF8, 0x7C, 0x3E, 0x3E,
  0x1F, 0x1F, 0x1F, 0x07, 0x00, 0x80, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF,
  0xFF, 0x7F, 0xFF, 0xE0, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFC,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0x8F, 0xC1, 0xF8, 0x1F, 0x87,
  0xC0, 0x3E, 0x3F, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x9F, 0x80,
  0x3E, 0x7E, 0x03, 0xF9, 0xF8, 0x1F, 0xE7, 0xC1, 0xFF, 0x9F, 0x0F, 0xFE,
  0x7C, 0x7D, 0xFB, 0xF7, 0xE7, 0xEF, 0xFE, 0x1F, 0x3F, 0xF0, 0x7C, 0xFF,
  0x01, 0xF3, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0x3E, 0x00, 0xFC, 0xF8, 0x03,
  0xE3, 0xE0, 0x1F, 0x8F, 0x80, 0x7C, 0x3F, 0x03, 0xF0, 0x7E, 0x1F, 0x81,
  0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x3C, 0x03, 0xF8, 0x3F, 0xF3, 0xFF, 0xEF,
  0xFF, 0xDF, 0xFF, 0x3F, 0xBE, 0x78, 0x7D, 0x81, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0,
  0x07, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x07, 0xF9, 0xFE, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x3F, 0x0F,
  0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x07, 0xF0, 0xFE, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3E, 0x1F,
  0x80, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0xFC,
  0x00, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x7F,
  0x0F, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x7C, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF8, 0x07,
  0xE1, 0xF8, 0x07, 0xC1, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x3E,
  0x01, 0xF0, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x3F, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x0F, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0xF8,
  0x01, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0x7F,
  0x0F, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x7F,
  0x03, 0xEF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xF8, 0xFE, 0x7F,
  0x03, 0xF3, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3E, 0xFC, 0x03, 0xF3, 0xE0,
  0x1F, 0x9F, 0x81, 0xF8, 0xFE, 0x3F, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0x1F, 0xC1, 0xF8, 0x1F, 0x83, 0xE0, 0x1F,
  0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0x7C, 0x3F, 0x00, 0xF8, 0x7E, 0x03, 0xF0,
  0xFC, 0x07, 0xC0, 0xFC, 0x1F, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFC, 0x1F, 0x83, 0xF0,
  0x1F, 0x87, 0xC0, 0x1F, 0x1F, 0x80, 0x3E, 0x3F, 0x00, 0x7C, 0x7C, 0x00,
  0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0xC7, 0xF8, 0xFF,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFC,
  0x7F, 0x1F, 0x81, 0xF8, 0xFC, 0x07, 0xCF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB,
  0xE0, 0x0F, 0xDF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xBE, 0x00,
  0xFD, 0xF0, 0x07, 0xEF, 0xC0, 0x7E, 0x7F, 0x0F, 0xF1, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xBE, 0x00, 0x63, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x7F,
  0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC1, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x1F, 0xC3, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x3F, 0x0F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF0, 0x7E, 0x00, 0x01,
  0xF0, 0x07, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0,
  0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x70, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFF,
  0x00, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0x80, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x00, 0x18, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC,
  0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x3E, 0x00, 0x01, 0xC0,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xFE,
  0x1F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFE, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x3E, 0x01, 0xE0, 0x3E, 0x00, 0x78, 0x1E, 0x00, 0x1C, 0x1E, 0x1F,
  0x8F, 0x1E, 0x1F, 0xF3, 0x8E, 0x1F, 0xF1, 0xCF, 0x1F, 0x38, 0xE7, 0x1E,
  0x1C, 0x77, 0x8F, 0x0E, 0x3B, 0xCF, 0x0E, 0x1D, 0xC7, 0x87, 0x0E, 0xE3,
  0x83, 0x8E, 0xF1, 0xC1, 0xC7, 0x79, 0xE1, 0xE3, 0xBC, 0xF0, 0xE1, 0xDC,
  0x78, 0x71, 0xCE, 0x3C, 0x78, 0xE7, 0x1E, 0x7C, 0xE3, 0xC7, 0xFF, 0xF1,
  0xE3, 0xF7, 0xF0, 0xF0, 0xF1, 0xF0, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x60, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x07, 0xEF,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F,
  0x8F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xFC, 0x3E, 0x00,
  0x3E, 0x0F, 0xC0, 0x1F, 0x81, 0xF0, 0x07, 0xC0, 0x7C, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x83, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x3F,
  0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xE7, 0xE0, 0x00, 0xFB, 0xF8, 0x00, 0x3F,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x7E, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80,
  0x3F, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xC3, 0xF0,
  0x07, 0xE1, 0xF8, 0x07, 0xE0, 0xFF, 0x3F, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xC0, 0x3F, 0x07,
  0xC0, 0x0F, 0xC3, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF1, 0xF8, 0x00, 0xF8,
  0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x7F,
  0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xF1, 0xFE, 0x0F, 0xC0,
  0x7E, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3E, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01,
  0xF0, 0x7E, 0x03, 0xF0, 0x7F, 0x0F, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x3F, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0x80, 0x7E, 0x07,
  0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0,
  0xFC, 0x01, 0xF8, 0x7C, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x3F, 0x00, 0x3F,
  0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x07,
  0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00,
  0xFC, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0xFC, 0x1F, 0x81, 0xFE, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x81, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xF1, 0xFE, 0x0F, 0xC0, 0x7E,
  0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xFE, 0xFC, 0x1F, 0xFC,
  0xFC, 0x1F, 0xFC, 0xFC, 0x1F, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC,
  0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0x7C, 0x01, 0xF8,
  0x7E, 0x01, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x00,
  0xF8, 0x0F, 0x80, 0x1F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F,
  0xC0, 0x1F, 0x81, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x0F, 0xC0, 0x0F,
  0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC0, 0xF8,
  0x01, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0xF8, 0x0F, 0x80,
  0x1F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81,
  0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x81, 0xF8, 0x03,
  0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xF8, 0x01, 0xF0, 0x1F,
  0x00, 0x3E, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x03,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0xF8,
  0x01, 0xF0, 0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0xFF,
  0x1F, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xE0, 0x07, 0xF8, 0x3F, 0x00, 0x7F, 0x01, 0xF0, 0x07,
  0xF0, 0x0F, 0x80, 0x7F, 0x00, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x00,
  0x3F, 0x03, 0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0x83, 0xF8, 0x00, 0x7C,
  0x3F, 0x80, 0x07, 0xE3, 0xF8, 0x00, 0x3F, 0x3F, 0x80, 0x01, 0xFB, 0xF8,
  0x00, 0x0F, 0xBF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F,
  0xBF, 0x80, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x01, 0xF8, 0x1F,
  0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xE0, 0x1F, 0x80,
  0x1F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0xC0, 0x7E,
  0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0x3F, 0xE3,
  0xFE, 0x07, 0xFC, 0xF7, 0xC1, 0xF7, 0x9F, 0xF0, 0x3E, 0xF7, 0xBE, 0x07,
  0xDE, 0xF7, 0xC0, 0xFB, 0xFE, 0xF8, 0x1F, 0x7F, 0x9F, 0x03, 0xEF, 0xF7,
  0xE0, 0xF8, 0xFC, 0xF8, 0x1F, 0x1F, 0x9F, 0x03, 0xE3, 0xE3, 0xE0, 0x7C,
  0x7C, 0x7C, 0x0F, 0x8F, 0x0F, 0x83, 0xF1, 0xE3, 0xF0, 0x7E, 0x38, 0x7C,
  0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0,
  0x0F, 0xC1, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0,
  0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x07, 0xE0, 0x7E, 0x00, 0xF8, 0x0F, 0xC0, 0x3F, 0x03, 0xF8, 0x07, 0xE0,
  0x7F, 0x80, 0xFC, 0x0F, 0xF0, 0x1F, 0x81, 0xFE, 0x03, 0xE0, 0x3F, 0xC0,
  0x7C, 0x0F, 0xFC, 0x1F, 0x81, 0xFF, 0x83, 0xF0, 0x3F, 0xF0, 0x7E, 0x07,
  0xFF, 0x0F, 0xC0, 0xFB, 0xE1, 0xF0, 0x1F, 0x3C, 0x3E, 0x07, 0xE7, 0x8F,
  0xC0, 0xFC, 0xF9, 0xF8, 0x1F, 0x9F, 0x3F, 0x03, 0xF1, 0xE7, 0xC0, 0x7C,
  0x3C, 0xF8, 0x0F, 0x87, 0xFF, 0x03, 0xF0, 0xFF, 0xE0, 0x7E, 0x0F, 0xFC,
  0x0F, 0xC1, 0xFF, 0x81, 0xF8, 0x3F, 0xE0, 0x3E, 0x03, 0xFC, 0x07, 0xC0,
  0x7F, 0x81, 0xF8, 0x0F, 0xF0, 0x3F, 0x01, 0xFE, 0x07, 0xE0, 0x1F, 0xC0,
  0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0x3F,
  0xC1, 0xF8, 0x1F, 0x87, 0xE0, 0x1F, 0x8F, 0x80, 0x3F, 0x3F, 0x00, 0x3E,
  0x7C, 0x00, 0x7D, 0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xF7, 0xE0, 0x03, 0xEF,
  0x80, 0x07, 0xDF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x0F, 0xDF, 0x00,
  0x1F, 0xBE, 0x00, 0x3E, 0x7C, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x07,
  0xE1, 0xF8, 0x1F, 0x83, 0xF8, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3E, 0x01,
  0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0x87, 0xE0,
  0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC,
  0x01, 0xF8, 0x7E, 0x01, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xF1,
  0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x80, 0x7E, 0x1F, 0x00, 0x7E, 0x3F, 0x00,
  0x3E, 0x3E, 0x00, 0x3E, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00,
  0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xF8, 0x00, 0x7C, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0xF8, 0xFC, 0x01,
  0xF8, 0xFC, 0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x7F, 0x9F, 0xE0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x40, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7E, 0x01, 0xF8, 0x3F,
  0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x0F, 0xC7,
  0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xF8,
  0x7C, 0x03, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3F,
  0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x3E, 0x01,
  0xF8, 0x1F, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0,
  0x0F, 0xC3, 0xF0, 0x03, 0xF1, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0x8F, 0xF0,
  0x7F, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x0F,
  0x87, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0x7C,
  0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x07, 0xF0, 0x7F, 0x83,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x1F, 0x87,
  0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xF0, 0x03, 0xE1, 0xF8, 0x03, 0xF0,
  0xFC, 0x01, 0xF8, 0x7C, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E,
  0x1F, 0x80, 0x1F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xE0, 0x07,
  0xE1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00,
  0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x07, 0xC0,
  0x0F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC,
  0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xE3, 0xFC, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0x7E, 0x01,
  0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x03,
  0xF0, 0x7E, 0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F,
  0xC0, 0x3E, 0x0F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x3F, 0x3F,
  0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x1E, 0x0F, 0xDF, 0x0F, 0x83, 0xE7, 0xC3,
  0xE0, 0xF9, 0xF0, 0xF8, 0x7E, 0x7C, 0x3E, 0x1F, 0x1F, 0x1F, 0x87, 0xC7,
  0xC7, 0xE1, 0xF1, 0xE1, 0xF8, 0xF8, 0xF8, 0xFE, 0x3E, 0x3E, 0x3F, 0x8F,
  0x8F, 0x8F, 0xE3, 0xE3, 0xE7, 0xF9, 0xF0, 0xF9, 0xFE, 0x7C, 0x3E, 0x7F,
  0x9F, 0x0F, 0x9D, 0xEF, 0x83, 0xEF, 0x7B, 0xE0, 0xFB, 0xDE, 0xF8, 0x3E,
  0xF7, 0xBE, 0x0F, 0xF9, 0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0x9F, 0xF0,
  0x3F, 0xC7, 0xF8, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0xFE, 0x1F,
  0xE0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0xFC,
  0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xE0, 0x7E, 0x00,
  0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x7F, 0x00,
  0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7C, 0x7F, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3F,
  0x9F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x83,
  0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0x80, 0x7E,
  0x01, 0xFC, 0x00, 0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xE0,
  0xFC, 0x00, 0x3F, 0xBE, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0xCF, 0xC0, 0x0F,
  0xC3, 0xE0, 0x0F, 0xC1, 0xF0, 0x0F, 0xE0, 0xFC, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x1F, 0x03, 0xF0, 0x0F, 0x83, 0xF0, 0x07, 0xE3, 0xF0, 0x01, 0xF1,
  0xF8, 0x00, 0xF9, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F,
  0xF8, 0x00, 0xF8, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x01,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x80, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xE0,
  0x1F, 0xF0, 0x0F, 0x78, 0x0F, 0xBC, 0x07, 0x9E, 0x07, 0xCF, 0x83, 0xC3,
  0xC3, 0xE1, 0xE3, 0xE0, 0xF1, 0xF0, 0x7D, 0xF0, 0x1E, 0xF0, 0x0F, 0xF8,
  0x07, 0x80, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3E, 0x1F, 0x87, 0xC1, 0xF0, 0x78, 0x1E, 0x00, 0x7F, 0x80, 0x0F,
  0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xC1, 0xF8, 0x7E, 0x03,
  0xF1, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x3B, 0xF0,
  0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFE, 0x07, 0xE7, 0xE0,
  0x1F, 0x9F, 0x80, 0x7E, 0x7C, 0x01, 0xF3, 0xF0, 0x07, 0xC7, 0xC0, 0x7F,
  0x1F, 0x83, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03,
  0xFC, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x3F, 0x00, 0x7D, 0xFF,
  0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFE, 0xFF, 0x0F, 0xE0, 0x7E,
  0x1F, 0x80, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF9, 0xF8, 0x03, 0xF3,
  0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E,
  0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xE3, 0xF0, 0x0F, 0xC7, 0xF0,
  0x3F, 0x8F, 0xF0, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFD, 0xFF,
  0xC1, 0xF1, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFE,
  0x03, 0xFF, 0xFC, 0x1F, 0xE7, 0xF8, 0x7E, 0x07, 0xE3, 0xF0, 0x0F, 0x8F,
  0x80, 0x3E, 0x7E, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x01, 0xF1, 0xF0, 0x0F, 0xC7, 0xE0, 0x7E, 0x1F, 0xC3, 0xF8, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x7E, 0x03, 0xFF,
  0x7E, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xE7, 0xFC, 0x3F, 0x81,
  0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x7C, 0x00,
  0xF8, 0x7C, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01,
  0xF0, 0xFC, 0x01, 0xF0, 0xFC, 0x01, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03,
  0xF0, 0x7E, 0x07, 0xF0, 0x7F, 0x1F, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFB, 0xE0, 0x0F, 0xF3, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFF,
  0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xE7, 0xF8, 0x7E, 0x07, 0xE3,
  0xF0, 0x0F, 0x8F, 0x80, 0x1F, 0x7E, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x01, 0x07, 0xE0, 0x1E, 0x1F,
  0xE1, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF,
  0x1F, 0x01, 0xFF, 0xBF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xF3,
  0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00,
  0x7E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0x7E, 0x00,
  0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xF8, 0x7E, 0x00,
  0xF8, 0x7E, 0x01, 0xF8, 0x3F, 0x03, 0xF8, 0x3F, 0x87, 0xF8, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFD, 0xF0, 0x07, 0xF9, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x20, 0x07, 0xE0, 0x70, 0x0F, 0xE0, 0xFC, 0x3F,
  0xC0, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0x7C, 0xFF, 0x80,
  0xFB, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFE, 0xFF, 0x0F, 0xE0, 0x7F, 0x1F,
  0x80, 0x7E, 0x3E, 0x00, 0xFC, 0x7C, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0,
  0x07, 0xC7, 0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x7E, 0x3E, 0x00,
  0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xE3, 0xF0, 0x07, 0xC7, 0xC0, 0x0F,
  0x8F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF1,
  0xF0, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF,
  0xE0, 0x07, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x0F, 0xE1, 0xF0, 0x0F, 0xE0, 0xF8, 0x1F, 0xE0,
  0xFC, 0x1F, 0xE0, 0x7E, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0, 0x1F, 0x9F, 0xC0,
  0x0F, 0x9F, 0xC0, 0x07, 0xDF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xBF,
  0x00, 0x3F, 0x8F, 0xC0, 0x1F, 0x87, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xC0,
  0xFE, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC,
  0x03, 0xF8, 0x7E, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x9F, 0x1F, 0x03, 0xEF,
  0xEF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xDF, 0xEF, 0xC3,
  0xE3, 0xF1, 0xF1, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x1F, 0x1F, 0x0F, 0x87,
  0xC7, 0xC3, 0xE3, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F,
  0x0F, 0x8F, 0x87, 0xC3, 0xE3, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C, 0x7E, 0x3E,
  0x1F, 0x1F, 0x0F, 0x8F, 0x87, 0xC7, 0xC3, 0xE1, 0xF1, 0xF0, 0xF8, 0x7C,
  0x7C, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0xC7, 0xC3, 0xC3, 0xE3, 0xF1, 0xF0,
  0xF8, 0x0F, 0x8F, 0xE0, 0x1F, 0x3F, 0xF0, 0x3E, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE1, 0xFF, 0xBF, 0xC3, 0xF8, 0x1F, 0xC7, 0xE0, 0x1F, 0x8F, 0x80, 0x3F,
  0x1F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF1, 0xF8, 0x03, 0xE3,
  0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x8F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E,
  0x00, 0xF8, 0xFC, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0xCF, 0xC0,
  0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7C, 0x7E, 0x00, 0xF8, 0x00, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xE7, 0xF8,
  0xFE, 0x07, 0xE3, 0xF0, 0x0F, 0x9F, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03,
  0xEF, 0x80, 0x0F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x0F, 0xC7,
  0xE0, 0x7F, 0x1F, 0xC3, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE3, 0xF0, 0x01, 0xF7,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xDF, 0xF0, 0x3F,
  0x81, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x87,
  0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0,
  0x7C, 0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3E,
  0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x3F, 0x83, 0xFC, 0x3F, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC0, 0xFD, 0xFF, 0x80, 0x7E, 0x7F, 0x80, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x3E, 0x07, 0xFE, 0xFC, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE1, 0xFE, 0x7F, 0xC7, 0xF0, 0x3F, 0x8F, 0xC0, 0x3F, 0x3F,
  0x00, 0x7C, 0x7E, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x07, 0xE7, 0xE0,
  0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3E, 0x3F, 0x00, 0x7C, 0x7E, 0x00,
  0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE1, 0xF8, 0x1F, 0xC3, 0xF8, 0xFF,
  0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFE, 0xF8, 0x07, 0xFB, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x0F, 0x87, 0xF8, 0x7C, 0xFF, 0xC3, 0xEF, 0xFE, 0x1F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x0F, 0xFE, 0x38, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x1F, 0xC1, 0xF8, 0xFC, 0x03, 0xF3, 0xF0, 0x0F,
  0xCF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00,
  0xFC, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0xC0, 0x1F, 0x3F, 0x81, 0xFC,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x18, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x80,
  0x1F, 0xF8, 0x3F, 0x00, 0xFC, 0xF8, 0x03, 0xF3, 0xE0, 0x0F, 0xCF, 0x80,
  0x3F, 0x7E, 0x00, 0xF9, 0xF8, 0x03, 0xE7, 0xE0, 0x1F, 0x9F, 0x00, 0x7E,
  0x7C, 0x01, 0xF9, 0xF0, 0x07, 0xCF, 0xC0, 0x1F, 0x3F, 0x00, 0x7C, 0xFC,
  0x03, 0xF3, 0xE0, 0x0F, 0xCF, 0x80, 0x3F, 0x3E, 0x00, 0xF8, 0xF8, 0x03,
  0xE3, 0xE0, 0x1F, 0x8F, 0xC0, 0xFE, 0x3F, 0x8F, 0xF8, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0x03, 0xFF, 0x7C, 0x07, 0xF1, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x7E, 0xF8, 0x00, 0xFD, 0xF0, 0x03, 0xF3, 0xE0, 0x07, 0xE7, 0xE0,
  0x1F, 0x87, 0xC0, 0x3E, 0x0F, 0x80, 0xFC, 0x1F, 0x01, 0xF0, 0x3E, 0x07,
  0xE0, 0x7C, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8,
  0x03, 0xE3, 0xE0, 0x03, 0xC7, 0xC0, 0x07, 0x9F, 0x00, 0x0F, 0xBE, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x3C, 0x1F, 0xF0,
  0x7C, 0x1F, 0xF0, 0x7C, 0x3E, 0xF0, 0x7C, 0x3E, 0xF0, 0xFC, 0x3E, 0xF0,
  0xFC, 0x7C, 0xF0, 0xFC, 0x7C, 0xF1, 0xFC, 0x7C, 0xF1, 0xFC, 0xF8, 0xF3,
  0xFC, 0xF8, 0xF3, 0xFC, 0xF8, 0xF3, 0xBC, 0xF0, 0xF7, 0xBD, 0xF0, 0xF7,
  0x1D, 0xE0, 0xF7, 0x1D, 0xE0, 0xFF, 0x1F, 0xE0, 0xFE, 0x1F, 0xC0, 0xFE,
  0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xF8,
  0x1F, 0x80, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0xC0, 0x0F, 0xE0,
  0xF8, 0x03, 0xF8, 0x1F, 0x80, 0xFE, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x07,
  0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0xFE, 0x7C, 0x00, 0x3F, 0x8F, 0xC0,
  0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x1F, 0x80,
  0x3F, 0x07, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xF1, 0xF8, 0x00, 0x7E,
  0x0F, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0xFC,
  0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x7E,
  0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x1F, 0x80, 0x03,
  0xF1, 0xF8, 0x00, 0x1F, 0x3F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x7E,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x01, 0xFF,
  0x00, 0x7F, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x03, 0xFE, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0x80, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x07,
  0xF8, 0x03, 0xFE, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x06, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xF8, 0x03, 0xCF, 0xFE, 0x01, 0xE7, 0xFF, 0x81, 0xF7, 0xFF,
  0xF1, 0xF3, 0xC1, 0xFF, 0xFB, 0xE0, 0x7F, 0xF9, 0xE0, 0x1F, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x30, 0x00,
};

const GFXglyph RobotoMono_SemiBoldItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 11, 32, 26, 8, -32 },
  { 45, 14, 12, 26, 8, -34 },
  { 66, 26, 32, 26, 0, -32 },
  { 170, 24, 42, 26, 2, -37 },
  { 296, 21, 33, 26, 3, -33 },
  { 383, 25, 33, 26, 1, -33 },
  { 487, 6, 12, 26, 11, -34 },
  { 496, 15, 46, 26, 7, -36 },
  { 583, 15, 46, 26, 4, -36 },
  { 670, 21, 22, 26, 4, -32 },
  { 728, 22, 24, 26, 2, -27 },
  { 794, 9, 14, 26, 4, -5 },
  { 810, 19, 4, 26, 5, -16 },
  { 820, 7, 7, 26, 8, -7 },
  { 827, 23, 35, 26, 2, -32 },
  { 928, 22, 34, 26, 3, -33 },
  { 1022, 15, 32, 26, 5, -32 },
  { 1082, 24, 32, 26, 0, -32 },
  { 1178, 24, 32, 26, 1, -32 },
  { 1274, 24, 32, 26, 0, -32 },
  { 1370, 24, 33, 26, 2, -32 },
  { 1469, 21, 33, 26, 2, -32 },
  { 1556, 23, 32, 26, 3, -32 },
  { 1648, 23, 32, 26, 2, -32 },
  { 1740, 21, 32, 26, 3, -32 },
  { 1824, 11, 25, 26, 8, -25 },
  { 1859, 14, 34, 26, 6, -25 },
  { 1919, 21, 20, 26, 3, -24 },
  { 1972, 23, 14, 26, 2, -21 },
  { 2013, 21, 21, 26, 2, -24 },
  { 2069, 19, 33, 26, 6, -33 },
  { 2148, 25, 32, 26, 1, -32 },
  { 2248, 26, 32, 26, -2, -32 },
  { 2352, 25, 32, 26, 1, -32 },
  { 2452, 24, 34, 26, 2, -33 },
  { 2554, 25, 32, 26, 0, -32 },
  { 2654, 26, 32, 26, 1, -32 },
  { 2758, 26, 32, 26, 1, -32 },
  { 2862, 24, 32, 26, 2, -32 },
  { 2958, 27, 32, 26, 0, -32 },
  { 3066, 23, 32, 26, 2, -32 },
  { 3158, 24, 32, 26, 2, -32 },
  { 3254, 29, 32, 26, 1, -32 },
  { 3370, 21, 32, 26, 1, -32 },
  { 3454, 27, 32, 26, 0, -32 },
  { 3562, 27, 32, 26, 0, -32 },
  { 3670, 23, 32, 26, 2, -32 },
  { 3762, 25, 32, 26, 1, -32 },
  { 3862, 24, 38, 26, 2, -32 },
  { 3976, 25, 32, 26, 1, -32 },
  { 4076, 25, 32, 26, 1, -32 },
  { 4176, 26, 32, 26, 3, -32 },
  { 4280, 25, 33, 26, 2, -32 },
  { 4384, 24, 32, 26, 4, -32 },
  { 4480, 26, 32, 26, 3, -32 },
  { 4584, 30, 32, 26, -1, -32 },
  { 4704, 25, 32, 26, 4, -32 },
  { 4804, 27, 32, 26, 0, -32 },
  { 4912, 17, 44, 26, 5, -37 },
  { 5006, 11, 35, 26, 8, -32 },
  { 5055, 17, 44, 26, 5, -37 },
  { 5149, 17, 17, 26, 5, -32 },
  { 5186, 20, 4, 26, 0, 0 },
  { 5196, 9, 7, 26, 12, -33 },
  { 5204, 22, 24, 26, 1, -24 },
  { 5270, 23, 34, 26, 1, -34 },
  { 5368, 22, 25, 26, 2, -24 },
  { 5437, 24, 34, 26, 2, -34 },
  { 5539, 22, 24, 26, 2, -24 },
  { 5605, 24, 35, 26, 4, -35 },
  { 5710, 24, 33, 26, 1, -24 },
  { 5809, 23, 34, 26, 1, -34 },
  { 5907, 20, 33, 26, 2, -33 },
  { 5990, 21, 43, 26, 1, -33 },
  { 6103, 25, 34, 26, 1, -34 },
  { 6210, 20, 34, 26, 2, -34 },
  { 6295, 26, 24, 26, -1, -24 },
  { 6373, 23, 24, 26, 1, -24 },
  { 6442, 22, 25, 26, 2, -24 },
  { 6511, 25, 33, 26, -1, -24 },
  { 6615, 23, 33, 26, 2, -24 },
  { 6710, 21, 24, 26, 4, -24 },
  { 6773, 22, 24, 26, 2, -24 },
  { 6839, 20, 30, 26, 4, -30 },
  { 6914, 22, 25, 26, 3, -24 },
  { 6983, 23, 24, 26, 3, -24 },
  { 7052, 24, 24, 26, 3, -24 },
  { 7124, 27, 24, 26, 0, -24 },
  { 7205, 28, 34, 26, 0, -24 },
  { 7324, 24, 24, 26, 1, -24 },
  { 7396, 18, 43, 26, 6, -35 },
  { 7493, 10, 41, 26, 8, -32 },
  { 7545, 18, 43, 26, 4, -35 },
  { 7642, 25, 10, 26, 0, -18 },
};

const GFXfont RobotoMono_SemiBoldItalic45pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic45pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic45pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC45PT7B_H_
