#ifndef _ROBOTOMONO_SEMIBOLDITALIC35PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x7C, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x03, 0xC3, 0xE1, 0xF0, 0x70, 0x00, 0x78, 0xEE, 0x1D, 0xC3, 0xB8, 0xF7,
  0x1C, 0xE3, 0xB8, 0x77, 0x0E, 0xE1, 0xC0, 0x00, 0x38, 0xF0, 0x01, 0xC7,
  0x00, 0x1C, 0x38, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x70, 0xE0, 0x03,
  0x8E, 0x03, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0x71, 0xC0,
  0x07, 0x0E, 0x00, 0x38, 0xE0, 0x01, 0x87, 0x00, 0x1C, 0x38, 0x0F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x03, 0x8E, 0x00, 0x38, 0x70, 0x01,
  0xC7, 0x00, 0x0E, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x1C, 0x00, 0x78, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x01, 0xFC,
  0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0x7E, 0x1F, 0x07, 0x87, 0x81, 0xF3,
  0xE0, 0x7C, 0xF8, 0x0F, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF8, 0x1F, 0x3F, 0x1F, 0x87,
  0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x1E, 0xE0, 0x0E, 0x38,
  0x4E, 0x1C, 0x77, 0x0E, 0x73, 0x8E, 0x71, 0xE7, 0x38, 0x7F, 0xB8, 0x3F,
  0xB8, 0x03, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x30,
  0x0E, 0xFE, 0x0E, 0x7F, 0x07, 0x73, 0xC7, 0x38, 0xE7, 0x1C, 0x73, 0x9C,
  0x38, 0x8F, 0x1C, 0x03, 0x9C, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xEF, 0x80, 0xF0, 0xF0, 0x1E, 0x1E,
  0x03, 0xC3, 0xC0, 0x78, 0xF0, 0x0F, 0x3E, 0x01, 0xFF, 0x80, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xC3, 0xCF, 0xF8, 0x7B, 0xEF, 0x8E,
  0xF8, 0xFB, 0xDE, 0x1F, 0xFB, 0xC1, 0xFE, 0x78, 0x1F, 0xCF, 0x03, 0xF1,
  0xF1, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xC7, 0xC0, 0x7B, 0x9C,
  0xEF, 0x73, 0x9C, 0xE0, 0x00, 0x10, 0x07, 0x00, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x78, 0x03,
  0x80, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x20, 0x04, 0x00,
  0x60, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0,
  0x38, 0x07, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x00, 0xE0, 0x08, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0C, 0x03, 0x0E, 0x19, 0xE7, 0x3D, 0xFF, 0xFF, 0x3F, 0xFF, 0x01,
  0xF8, 0x01, 0xF0, 0x01, 0xFC, 0x01, 0xEE, 0x01, 0xE3, 0x81, 0xE1, 0xE0,
  0xF0, 0x70, 0x30, 0x30, 0x00, 0x10, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x81, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xC0, 0x78, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0x20, 0x7F,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x31, 0xEF, 0xFF, 0xFD, 0xE0, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xF3, 0xE1, 0xE0, 0xF9, 0xF0,
  0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x7C, 0x0F, 0xBE, 0x0F, 0xDE, 0x1F, 0xEF,
  0x1F, 0xF7, 0xBE, 0xF3, 0xFE, 0x7B, 0xFC, 0x3D, 0xFC, 0x1E, 0xF8, 0x1F,
  0x78, 0x0F, 0xBC, 0x07, 0x9E, 0x03, 0xC7, 0x83, 0xC3, 0xE3, 0xE1, 0xFF,
  0xE0, 0x7F, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x30, 0x0F, 0x07, 0xE3, 0xFE,
  0x7F, 0xE7, 0xFE, 0xF1, 0xE8, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0xFE, 0x00, 0xFF,
  0xC0, 0x7F, 0xF8, 0x3F, 0x3F, 0x1F, 0x07, 0xC7, 0x80, 0xF1, 0xE0, 0x3C,
  0xF8, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8,
  0x7E, 0x3E, 0x1F, 0x07, 0xC7, 0x80, 0xF3, 0xE0, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xCF, 0x00, 0xF3,
  0xC0, 0x3C, 0xF8, 0x1F, 0x1F, 0x1F, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xDE, 0x01, 0xE7, 0x80, 0xF3,
  0xE0, 0x3C, 0xF0, 0x1E, 0x3C, 0x0F, 0x0F, 0x07, 0x83, 0xC3, 0xC1, 0xF0,
  0xF0, 0x7C, 0x7F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x1F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xC0,
  0xFF, 0xF8, 0x7C, 0x3E, 0x02, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xCF, 0x01, 0xF3, 0xC0, 0x78, 0xF0, 0x3E, 0x3F, 0x1F,
  0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0xFE,
  0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x7C, 0x60, 0x7B, 0xF8, 0x7F, 0xFC, 0xFF, 0xFE, 0xFE, 0x3E, 0xF8, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x1E,
  0xF8, 0x3E, 0x7C, 0x7C, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0, 0x3F, 0xFF,
  0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xC0,
  0x7F, 0xF8, 0x3F, 0x3E, 0x0F, 0x07, 0xC7, 0xC0, 0xF1, 0xE0, 0x3C, 0x78,
  0x1F, 0x1E, 0x07, 0x87, 0xC3, 0xE0, 0xFF, 0xF0, 0x1F, 0xF8, 0x07, 0xFC,
  0x07, 0xFF, 0x83, 0xE1, 0xF1, 0xF0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xCF,
  0x80, 0xF3, 0xE0, 0x3C, 0x78, 0x1F, 0x1F, 0x1F, 0x87, 0xFF, 0xE0, 0xFF,
  0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3E, 0x7E,
  0x7C, 0x1E, 0x78, 0x1E, 0xF8, 0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1E,
  0xF0, 0x1E, 0xF0, 0x1E, 0xF8, 0x3E, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC,
  0x0F, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xF0, 0x7F, 0xE0,
  0x7F, 0xC0, 0x7F, 0x00, 0x7C, 0x00, 0x06, 0x0F, 0x87, 0xE3, 0xF1, 0xF8,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0xF8,
  0xFC, 0x7E, 0x3F, 0x0F, 0x00, 0x01, 0x01, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0,
  0x38, 0x04, 0x00, 0x00, 0x00, 0x80, 0x03, 0x80, 0x07, 0xC0, 0x1F, 0xE0,
  0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x7F, 0x80,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xE0, 0x00, 0xF0, 0x00,
  0x18, 0x3F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF,
  0x80, 0x10, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0xFF,
  0x87, 0xFF, 0x07, 0xFC, 0x03, 0xF8, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x07,
  0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7E, 0x7E, 0x7C, 0x1E, 0xF8, 0x1F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xC0, 0xE0, 0xE0,
  0x0C, 0x38, 0x21, 0xC6, 0x3F, 0x99, 0xCF, 0xF3, 0x71, 0xCE, 0x6E, 0x71,
  0x8D, 0x8C, 0x31, 0xF3, 0x8E, 0x3E, 0x71, 0xCF, 0xCE, 0x31, 0xB9, 0x86,
  0x36, 0x31, 0xC6, 0xC7, 0x39, 0x98, 0xFF, 0xF3, 0x9F, 0x7C, 0x70, 0xC6,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x9C, 0x00, 0xFF, 0x80, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x3E,
  0xF0, 0x07, 0x9E, 0x01, 0xF1, 0xC0, 0x3C, 0x3C, 0x0F, 0x87, 0x81, 0xE0,
  0xF0, 0x7C, 0x1E, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF,
  0xF3, 0xE0, 0x3E, 0x78, 0x03, 0xDF, 0x00, 0x7B, 0xC0, 0x0F, 0xF8, 0x01,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F,
  0x01, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x1F, 0x01, 0xF1,
  0xF0, 0x3E, 0x1E, 0x0F, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xFC,
  0x3E, 0x07, 0xC3, 0xE0, 0x3E, 0x3C, 0x03, 0xE3, 0xC0, 0x3E, 0x3C, 0x03,
  0xE7, 0xC0, 0x3C, 0x7C, 0x07, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF,
  0xE0, 0xFF, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x07,
  0xE7, 0xE1, 0xF0, 0x3C, 0x3C, 0x07, 0xCF, 0x80, 0x79, 0xE0, 0x0F, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0xF1, 0xE0,
  0x1E, 0x3C, 0x07, 0xC7, 0xC1, 0xF0, 0xFC, 0x7E, 0x0F, 0xFF, 0x80, 0xFF,
  0xE0, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0xFF, 0xFC, 0x0F, 0x07, 0xC0, 0xF0, 0x3E, 0x0F, 0x01, 0xE1, 0xF0, 0x1E,
  0x1F, 0x01, 0xE1, 0xE0, 0x1F, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x01,
  0xE3, 0xE0, 0x1E, 0x3E, 0x01, 0xE3, 0xC0, 0x3E, 0x3C, 0x03, 0xC3, 0xC0,
  0x7C, 0x3C, 0x07, 0xC7, 0xC0, 0xF8, 0x7C, 0x1F, 0x07, 0xFF, 0xE0, 0x7F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xFF, 0x83, 0xFF,
  0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFF, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0xE7, 0xE1, 0xF0,
  0x3C, 0x3C, 0x07, 0xCF, 0x80, 0x79, 0xE0, 0x0F, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x83, 0xFC, 0xF0, 0xFF, 0x9E, 0x1F,
  0xF3, 0xC3, 0xFE, 0xF8, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03,
  0xC7, 0xC0, 0xF8, 0x7E, 0x7F, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xF8,
  0x00, 0x07, 0x80, 0xF8, 0x7C, 0x07, 0x83, 0xE0, 0x3C, 0x1E, 0x01, 0xE0,
  0xF0, 0x0F, 0x07, 0x80, 0xF8, 0x3C, 0x07, 0xC3, 0xE0, 0x3C, 0x1E, 0x01,
  0xE0, 0xF0, 0x0F, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x3E,
  0x1F, 0x01, 0xE0, 0xF8, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC1, 0xE0,
  0x3E, 0x0F, 0x01, 0xF0, 0xF8, 0x0F, 0x00, 0x07, 0xFF, 0xE1, 0xFF, 0xFC,
  0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0xFF, 0xFC, 0x1F,
  0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0xF8, 0x0F, 0x0F, 0x81, 0xF0, 0x78, 0x1F, 0x07,
  0xE7, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x07, 0x80,
  0x7E, 0x0F, 0x01, 0xF8, 0x3E, 0x07, 0xE0, 0x7C, 0x1F, 0x80, 0xF0, 0x7E,
  0x01, 0xE0, 0xF8, 0x03, 0xC3, 0xE0, 0x07, 0x8F, 0x80, 0x1F, 0x3E, 0x00,
  0x3E, 0xF8, 0x00, 0x7B, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0x9F, 0x00, 0x3E, 0x3E, 0x00, 0x78,
  0x3C, 0x00, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0x01,
  0xF0, 0x1E, 0x01, 0xF0, 0x3C, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0xFE, 0x1F, 0x87, 0xE0, 0xFC,
  0x3F, 0x07, 0xF3, 0xF8, 0x3B, 0x9F, 0xC3, 0xDD, 0xFE, 0x1E, 0xEE, 0xF0,
  0xF7, 0xF7, 0x07, 0xBF, 0x78, 0x3D, 0xFB, 0xC1, 0xEF, 0x9E, 0x1E, 0x7C,
  0xF0, 0xF3, 0xC7, 0x87, 0x8E, 0x78, 0x3C, 0x63, 0xC1, 0xE0, 0x1E, 0x0F,
  0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x7C, 0x3C, 0x03, 0xC1, 0xE0, 0x1E,
  0x0F, 0x00, 0xF0, 0xF8, 0x07, 0x80, 0x07, 0x80, 0xF8, 0x7C, 0x07, 0x83,
  0xF0, 0x3C, 0x1F, 0x81, 0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xF8, 0x3F, 0x87,
  0xC3, 0xFC, 0x3C, 0x1F, 0xE1, 0xE0, 0xF7, 0x0F, 0x07, 0xBC, 0xF8, 0x3D,
  0xE7, 0xC3, 0xE7, 0x3C, 0x1F, 0x39, 0xE0, 0xF9, 0xEF, 0x07, 0x87, 0x78,
  0x3C, 0x3F, 0xC1, 0xE1, 0xFE, 0x1F, 0x0F, 0xE0, 0xF8, 0x3F, 0x07, 0x81,
  0xF8, 0x3C, 0x0F, 0xC1, 0xE0, 0x7E, 0x0F, 0x01, 0xF0, 0xF8, 0x0F, 0x00,
  0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xF0, 0x7C,
  0x3C, 0x07, 0x8F, 0x80, 0xF9, 0xE0, 0x1F, 0x3C, 0x03, 0xEF, 0x80, 0x7D,
  0xE0, 0x0F, 0xBC, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0xBE, 0x00, 0xF7,
  0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xF1, 0xE0, 0x3E, 0x3C, 0x07, 0x87,
  0xC1, 0xF0, 0xFC, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0x03,
  0xE1, 0xF0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0,
  0x1E, 0x3E, 0x03, 0xE3, 0xE0, 0x7C, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F,
  0xFE, 0x07, 0xFF, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF,
  0xE1, 0xF0, 0x7C, 0x3C, 0x07, 0x8F, 0x80, 0xF9, 0xE0, 0x1F, 0x3C, 0x03,
  0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xBC, 0x01, 0xF7, 0x80, 0x3C, 0xF0, 0x07,
  0x9E, 0x00, 0xF7, 0xC0, 0x1E, 0xF8, 0x07, 0xDF, 0x00, 0xF3, 0xE0, 0x1E,
  0x3C, 0x07, 0xC7, 0xC1, 0xF0, 0xFC, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x00, 0x60,
  0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xE0, 0x3E,
  0x3C, 0x07, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x3E, 0x01, 0xE7, 0xC0, 0x7C,
  0xF0, 0x1F, 0x1E, 0x07, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0xF8, 0x3C, 0x0F, 0x0F,
  0x81, 0xF1, 0xF0, 0x3E, 0x3C, 0x03, 0xC7, 0x80, 0x7C, 0xF0, 0x0F, 0x80,
  0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x07, 0xE7, 0xE1, 0xF0, 0x3E,
  0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0x9E, 0x00, 0xFB, 0xC0, 0x1F, 0x7C, 0x03, 0xC7,
  0x80, 0xF8, 0xFC, 0x7F, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C,
  0x78, 0x07, 0x8F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0x8F, 0x00, 0xF1,
  0xE0, 0x1E, 0x3C, 0x07, 0xC7, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xC7,
  0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x03, 0xE3, 0xC0, 0x7C, 0x78, 0x0F, 0x0F,
  0x83, 0xE1, 0xF9, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x00,
  0xF8, 0x03, 0xFF, 0x00, 0x7B, 0xE0, 0x1F, 0x7C, 0x03, 0xE7, 0x80, 0xF8,
  0xF0, 0x1F, 0x1E, 0x03, 0xC3, 0xC0, 0xF8, 0x7C, 0x1E, 0x0F, 0x87, 0xC1,
  0xF0, 0xF0, 0x1E, 0x3E, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x3E, 0x01,
  0xE7, 0x80, 0x3D, 0xF0, 0x07, 0xBC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x70, 0xF7, 0x8F, 0x0F, 0x78, 0xF0, 0xF7, 0x8F, 0x1E, 0x79, 0xF1,
  0xE7, 0x9F, 0x1E, 0x79, 0xF3, 0xC7, 0x9F, 0x3C, 0x73, 0xF3, 0xC7, 0x3F,
  0x3C, 0x73, 0xF7, 0x87, 0x77, 0x78, 0x77, 0x77, 0x87, 0x77, 0x70, 0x7F,
  0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xE0, 0xFC, 0x7E, 0x0F,
  0xC7, 0xE0, 0xFC, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0,
  0xF0, 0x78, 0x00, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xF0,
  0x1E, 0x07, 0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x3C, 0x00, 0x78, 0xF8, 0x00,
  0xFB, 0xE0, 0x00, 0xF7, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x80, 0x03, 0xEF, 0x00, 0x0F, 0x9E, 0x00, 0x1F, 0x3E, 0x00, 0x7C, 0x3C,
  0x01, 0xF0, 0x7C, 0x07, 0xE0, 0xF8, 0x0F, 0x80, 0xF0, 0x3E, 0x01, 0xF0,
  0xFC, 0x03, 0xE0, 0xF8, 0x03, 0xF7, 0x80, 0x3E, 0x78, 0x07, 0xC7, 0xC0,
  0x7C, 0x3C, 0x0F, 0x83, 0xC1, 0xF0, 0x3C, 0x1F, 0x03, 0xE3, 0xE0, 0x1E,
  0x3C, 0x01, 0xE7, 0xC0, 0x1E, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0x80,
  0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0x78, 0x03, 0xC0, 0x1E, 0x01,
  0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x3F, 0xC0, 0xE0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0x70, 0x78, 0x78, 0x78, 0x78, 0x78, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x0F, 0x0F, 0x0F,
  0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F,
  0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0x80, 0x01, 0xE0, 0x0F,
  0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF8, 0x39, 0xC3, 0xCE, 0x3C, 0x71,
  0xE3, 0xDE, 0x1E, 0xE0, 0x7F, 0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xF8, 0x78, 0xF0, 0xF0, 0x01, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xC3,
  0xFF, 0xE3, 0xE0, 0xF9, 0xE0, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x0F, 0xFF,
  0x0F, 0xFF, 0x9F, 0xE3, 0xCF, 0x81, 0xEF, 0x81, 0xF7, 0xC0, 0xFB, 0xE0,
  0x79, 0xF8, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x07, 0xE7, 0xC0, 0x0F, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x3C, 0xF0, 0x1E, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xE1, 0xF3,
  0xE0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x7C, 0x07, 0xBE, 0x03,
  0xDE, 0x01, 0xEF, 0x01, 0xF7, 0x80, 0xF3, 0xE0, 0xFB, 0xF8, 0xF9, 0xFF,
  0xFC, 0xF7, 0xFC, 0x79, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x1F, 0xFE,
  0x3F, 0xFE, 0x3E, 0x1F, 0x7C, 0x0F, 0x78, 0x0F, 0xF8, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x1E, 0xF8, 0x3E,
  0x7C, 0x7C, 0x7F, 0xFC, 0x3F, 0xF8, 0x1F, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x1E, 0x3C, 0x0F, 0xF7, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0x0F,
  0xC7, 0xC0, 0xF0, 0xF0, 0x1E, 0x3E, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x1F,
  0x1E, 0x03, 0xE3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xF0, 0x7C,
  0x3F, 0x3F, 0x83, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xF7, 0x80, 0x01, 0xF0,
  0x03, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE3, 0xE1, 0xF3, 0xE0, 0x79, 0xE0,
  0x3D, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xDE, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x30, 0xFC, 0x7C, 0x7F, 0xFE, 0x1F, 0xFE,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xE0, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x80, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE3, 0x01, 0xFE,
  0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0x0F, 0xCF, 0x81, 0xF3, 0xC0, 0x79,
  0xF0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0xF9, 0xE0, 0x3E, 0x78,
  0x0F, 0x1E, 0x03, 0xC7, 0xC1, 0xF1, 0xF9, 0xFC, 0x3F, 0xFF, 0x07, 0xFF,
  0xC0, 0xFD, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x18, 0x0F, 0x0F, 0x0F, 0xC3,
  0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xF0, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0xF0, 0x1E, 0xFF, 0x07, 0xFF, 0xE3, 0xFF, 0xF8, 0xFC, 0x3E, 0x3C, 0x07,
  0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x7C, 0x07, 0x9E, 0x01, 0xE7,
  0x80, 0xF9, 0xE0, 0x3E, 0x78, 0x0F, 0x3E, 0x03, 0xCF, 0x80, 0xF3, 0xC0,
  0x3C, 0xF0, 0x1F, 0x3C, 0x07, 0xC0, 0x00, 0x30, 0x00, 0xF0, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x04, 0x1F, 0xF0, 0x3F,
  0xE0, 0xFF, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF,
  0x00, 0x30, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x01, 0x1E, 0x07,
  0xC3, 0xC1, 0xF0, 0xF8, 0x7C, 0x1F, 0x3F, 0x03, 0xCF, 0xC0, 0x7B, 0xF0,
  0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFB, 0xE0,
  0x3E, 0x7C, 0x07, 0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0x81, 0xF0,
  0xF0, 0x1F, 0x1E, 0x03, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0x83,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0C, 0xE1, 0x81, 0xDF, 0x7E, 0x3F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x3C, 0x79, 0xE3, 0xC7, 0x8E, 0x3C, 0x71, 0xE3,
  0x8F, 0x1E, 0x78, 0xF1, 0xE7, 0x8F, 0x1E, 0x78, 0xF1, 0xE7, 0x8F, 0x1C,
  0x78, 0xE3, 0xCF, 0x1E, 0x3C, 0xF1, 0xE3, 0xCF, 0x1E, 0x3C, 0xF1, 0xE3,
  0xCF, 0x1E, 0x78, 0xF3, 0xC7, 0x80, 0x1E, 0x3C, 0x07, 0xBF, 0xC1, 0xFF,
  0xF8, 0xFF, 0xFE, 0x3F, 0x0F, 0x8F, 0x81, 0xE3, 0xC0, 0x78, 0xF0, 0x1E,
  0x7C, 0x07, 0x9F, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x3E, 0x78, 0x0F, 0x9E,
  0x03, 0xCF, 0x80, 0xF3, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x07, 0xCF, 0x01,
  0xF0, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0x0F,
  0x8F, 0x81, 0xE7, 0xC0, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE7,
  0x80, 0x79, 0xE0, 0x1E, 0x78, 0x0F, 0x9E, 0x03, 0xC7, 0xC1, 0xF1, 0xF8,
  0xF8, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0x9E, 0x00, 0xF7,
  0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xF0, 0xFC, 0x3E, 0x1F, 0x03, 0xC3, 0xC0,
  0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE3, 0xE0, 0x3C, 0x7C, 0x07, 0x8F, 0x00,
  0xF1, 0xE0, 0x3E, 0x3C, 0x07, 0x87, 0x81, 0xF1, 0xFC, 0x7C, 0x3F, 0xFF,
  0x87, 0xBF, 0xE0, 0xF3, 0xF0, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x07, 0xFB, 0xC7, 0xFF, 0xE7, 0xFF, 0xF7, 0xE1, 0xFB, 0xE0, 0x79, 0xE0,
  0x3D, 0xF0, 0x1E, 0xF0, 0x0F, 0x78, 0x0F, 0xBC, 0x07, 0xDE, 0x03, 0xCF,
  0x01, 0xE7, 0x80, 0xF3, 0xE0, 0xF9, 0xF9, 0xFC, 0x7F, 0xFC, 0x3F, 0xFE,
  0x07, 0xEF, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x0F, 0x3F, 0xC7, 0xBF,
  0xC3, 0xFF, 0xE1, 0xFF, 0xF1, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0x7E, 0x3E, 0x07, 0x8F, 0x01,
  0xF3, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xE0,
  0x01, 0xFC, 0x00, 0x0F, 0x3E, 0x03, 0xC7, 0x80, 0xF1, 0xF0, 0x7C, 0x3F,
  0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x88, 0x1F, 0xFC,
  0x0F, 0xFC, 0x07, 0xF8, 0x3C, 0x07, 0xCF, 0x01, 0xE3, 0xC0, 0x79, 0xF0,
  0x3E, 0x7C, 0x0F, 0x9E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F,
  0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xC0, 0x78, 0xF0, 0x1E, 0x3E, 0x0F, 0x8F,
  0xCF, 0xE1, 0xFF, 0xF8, 0x7F, 0xDE, 0x0F, 0xCF, 0x00, 0xB0, 0x00, 0x78,
  0x07, 0xFC, 0x03, 0xDE, 0x03, 0xEF, 0x81, 0xE3, 0xC1, 0xF1, 0xE0, 0xF0,
  0xF0, 0x78, 0x78, 0x78, 0x1C, 0x3C, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xDE,
  0x01, 0xEF, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0xE1, 0xFE, 0x3C, 0x7B, 0xC7, 0x8F, 0x78, 0xF1, 0xEF,
  0x3E, 0x39, 0xE7, 0xCF, 0x3D, 0xF9, 0xE7, 0xBF, 0x38, 0xE6, 0xEF, 0x1D,
  0xDD, 0xE3, 0xB9, 0xB8, 0x76, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xF8, 0x3E,
  0x1F, 0x07, 0xC3, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x00, 0x1F, 0x01, 0xF8,
  0x7C, 0x1F, 0x01, 0xE1, 0xF0, 0x0F, 0x9F, 0x00, 0x3C, 0xF8, 0x01, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xCF, 0x00, 0x7C, 0x7C,
  0x07, 0xC1, 0xF0, 0x7C, 0x07, 0x87, 0xC0, 0x3E, 0x00, 0x3E, 0x00, 0xFC,
  0x78, 0x03, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x3C,
  0x1F, 0x00, 0xF0, 0x78, 0x03, 0xE3, 0xE0, 0x07, 0x8F, 0x00, 0x1E, 0x7C,
  0x00, 0x79, 0xE0, 0x00, 0xEF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xF1,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xC7, 0xFF,
  0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF8, 0x00, 0x38, 0x01, 0xF0, 0x0F, 0x00,
  0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x03, 0xF0, 0x3F, 0x00, 0xF8, 0x03,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xF8,
  0x01, 0xE0, 0x03, 0x80, 0x07, 0x07, 0x07, 0x06, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x30, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0,
  0x07, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7C, 0x07, 0xF0, 0x3E, 0x01, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0x80, 0x1E, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x00, 0xE0, 0x00, 0x1F, 0x00,
  0x07, 0xF8, 0x1D, 0xFF, 0x83, 0xBF, 0xFC, 0xFF, 0x0F, 0xFD, 0xC0, 0xFF,
  0x80, 0x07, 0xE0,
};

const GFXglyph RobotoMono_SemiBoldItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 9, 25, 21, 6, -25 },
  { 30, 11, 9, 21, 6, -26 },
  { 43, 21, 25, 21, 0, -25 },
  { 109, 18, 33, 21, 2, -29 },
  { 184, 17, 25, 21, 2, -25 },
  { 238, 19, 25, 21, 1, -25 },
  { 298, 5, 9, 21, 9, -26 },
  { 304, 12, 36, 21, 5, -28 },
  { 358, 12, 36, 21, 3, -28 },
  { 412, 17, 18, 21, 3, -25 },
  { 451, 17, 19, 21, 2, -21 },
  { 492, 8, 11, 21, 3, -4 },
  { 503, 14, 4, 21, 4, -13 },
  { 510, 6, 6, 21, 6, -6 },
  { 515, 18, 27, 21, 2, -25 },
  { 576, 17, 25, 21, 2, -25 },
  { 630, 12, 25, 21, 4, -25 },
  { 668, 18, 25, 21, 0, -25 },
  { 725, 18, 25, 21, 1, -25 },
  { 782, 18, 25, 21, 0, -25 },
  { 839, 18, 25, 21, 2, -25 },
  { 896, 16, 25, 21, 2, -25 },
  { 946, 18, 25, 21, 2, -25 },
  { 1003, 18, 25, 21, 1, -25 },
  { 1060, 16, 25, 21, 3, -25 },
  { 1110, 9, 20, 21, 6, -20 },
  { 1133, 10, 27, 21, 5, -20 },
  { 1167, 17, 16, 21, 2, -19 },
  { 1201, 17, 11, 21, 2, -16 },
  { 1225, 17, 16, 21, 1, -19 },
  { 1259, 16, 25, 21, 4, -25 },
  { 1309, 19, 25, 21, 1, -25 },
  { 1369, 19, 25, 21, -1, -25 },
  { 1429, 20, 25, 21, 0, -25 },
  { 1492, 19, 25, 21, 1, -25 },
  { 1552, 20, 25, 21, 0, -25 },
  { 1615, 20, 25, 21, 1, -25 },
  { 1678, 20, 25, 21, 1, -25 },
  { 1741, 19, 25, 21, 1, -25 },
  { 1801, 21, 25, 21, 0, -25 },
  { 1867, 19, 25, 21, 1, -25 },
  { 1927, 20, 25, 21, 1, -25 },
  { 1990, 23, 25, 21, 0, -25 },
  { 2062, 16, 25, 21, 1, -25 },
  { 2112, 21, 25, 21, 0, -25 },
  { 2178, 21, 25, 21, 0, -25 },
  { 2244, 19, 25, 21, 1, -25 },
  { 2304, 20, 25, 21, 1, -25 },
  { 2367, 19, 29, 21, 1, -25 },
  { 2436, 19, 25, 21, 1, -25 },
  { 2496, 19, 25, 21, 1, -25 },
  { 2556, 19, 25, 21, 3, -25 },
  { 2616, 19, 25, 21, 2, -25 },
  { 2676, 19, 25, 21, 3, -25 },
  { 2736, 20, 25, 21, 2, -25 },
  { 2799, 23, 25, 21, -1, -25 },
  { 2871, 20, 25, 21, 3, -25 },
  { 2934, 21, 25, 21, 0, -25 },
  { 3000, 13, 35, 21, 4, -29 },
  { 3057, 8, 27, 21, 7, -25 },
  { 3084, 13, 35, 21, 4, -29 },
  { 3141, 13, 13, 21, 4, -25 },
  { 3163, 16, 3, 21, 0, 0 },
  { 3169, 7, 4, 21, 9, -25 },
  { 3173, 17, 19, 21, 1, -19 },
  { 3214, 17, 26, 21, 1, -26 },
  { 3270, 16, 19, 21, 2, -19 },
  { 3308, 19, 26, 21, 2, -26 },
  { 3370, 17, 19, 21, 2, -19 },
  { 3411, 19, 27, 21, 3, -27 },
  { 3476, 18, 26, 21, 1, -19 },
  { 3535, 18, 26, 21, 1, -26 },
  { 3594, 15, 26, 21, 2, -26 },
  { 3643, 16, 34, 21, 1, -26 },
  { 3711, 19, 26, 21, 1, -26 },
  { 3773, 15, 26, 21, 2, -26 },
  { 3822, 20, 19, 21, 0, -19 },
  { 3870, 18, 19, 21, 1, -19 },
  { 3913, 18, 19, 21, 1, -19 },
  { 3956, 19, 26, 21, -1, -19 },
  { 4018, 17, 26, 21, 2, -19 },
  { 4074, 17, 19, 21, 3, -19 },
  { 4115, 18, 19, 21, 1, -19 },
  { 4158, 16, 23, 21, 3, -23 },
  { 4204, 18, 18, 21, 2, -18 },
  { 4245, 17, 19, 21, 3, -19 },
  { 4286, 19, 18, 21, 2, -18 },
  { 4329, 21, 18, 21, 0, -18 },
  { 4377, 22, 26, 21, 0, -18 },
  { 4449, 20, 18, 21, 0, -18 },
  { 4494, 14, 33, 21, 5, -27 },
  { 4552, 8, 32, 21, 6, -25 },
  { 4584, 14, 33, 21, 3, -27 },
  { 4642, 19, 7, 21, 0, -14 },
};

const GFXfont RobotoMono_SemiBoldItalic35pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic35pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic35pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC35PT7B_H_
