#ifndef _ROBOTOMONO_SEMIBOLDITALIC23PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x63, 0x8E, 0x38, 0xE3, 0x0C, 0x71, 0xC0, 0x00, 0x03, 0x8E,
  0x38, 0x66, 0xCF, 0x1E, 0x3C, 0xD9, 0x80, 0x03, 0x98, 0x0C, 0xC0, 0x33,
  0x01, 0x88, 0x3F, 0xFC, 0xFF, 0xE0, 0xC4, 0x03, 0x30, 0x0C, 0xC0, 0x66,
  0x0F, 0xFF, 0x06, 0x60, 0x33, 0x00, 0xCC, 0x02, 0x30, 0x19, 0x80, 0x01,
  0x80, 0x18, 0x01, 0x80, 0xFE, 0x1F, 0xE3, 0x87, 0x38, 0x73, 0x87, 0x38,
  0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xE0, 0x0E, 0xE0, 0xEE, 0x0E, 0x71,
  0xC7, 0xFC, 0x3F, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x0F, 0x81, 0x98, 0x33,
  0x3C, 0x6C, 0xDB, 0x1F, 0x61, 0x98, 0x06, 0x00, 0x80, 0x37, 0x0D, 0xF3,
  0x66, 0xEC, 0xC9, 0x98, 0x3F, 0x03, 0xC0, 0x01, 0x80, 0x3E, 0x03, 0xF8,
  0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x77, 0x01, 0xF0, 0x0E, 0x01, 0xF8, 0xDF,
  0xCE, 0xE7, 0x76, 0x3F, 0x70, 0xF1, 0xC7, 0x8F, 0xFC, 0x3F, 0x70, 0x7F,
  0x6D, 0x80, 0x02, 0x1C, 0x70, 0xC3, 0x86, 0x1C, 0x30, 0xE1, 0xC3, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x03, 0x06, 0x06, 0x04, 0x00, 0x18,
  0x1C, 0x0C, 0x0E, 0x06, 0x06, 0x06, 0x07, 0x07, 0x07, 0x07, 0x06, 0x06,
  0x06, 0x0E, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x70, 0xE0, 0xC0, 0x06, 0x00,
  0xC0, 0x18, 0x33, 0x3F, 0xFE, 0x7F, 0x07, 0x81, 0xF0, 0x73, 0x1C, 0x70,
  0x84, 0x00, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x61, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x00, 0x39, 0xCE, 0x67, 0x33, 0x80,
  0xFF, 0xFF, 0xC0, 0x6F, 0xFE, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x01,
  0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18,
  0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x00, 0xFC, 0x1F, 0xE3,
  0x8E, 0x38, 0x67, 0x07, 0x70, 0xE7, 0x3E, 0x77, 0xE7, 0xEE, 0x78, 0xEF,
  0x0E, 0xE0, 0xC6, 0x1C, 0x73, 0xC7, 0xF8, 0x3F, 0x00, 0x06, 0x7F, 0xFF,
  0x78, 0xE1, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xC3, 0x87, 0x0E, 0x1C, 0x01,
  0x80, 0xFE, 0x1F, 0xF3, 0x87, 0x38, 0x73, 0x07, 0x00, 0x70, 0x0E, 0x01,
  0xC0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0xFE, 0xFF,
  0xE0, 0x03, 0x01, 0xFC, 0x3F, 0xE3, 0x8E, 0x70, 0x60, 0x0E, 0x00, 0xE0,
  0x3C, 0x0F, 0x80, 0xFC, 0x01, 0xC0, 0x0C, 0x00, 0xCE, 0x1C, 0xE3, 0xCF,
  0xF8, 0x3F, 0x00, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x3E, 0x07, 0xE0, 0xEE,
  0x0C, 0xE1, 0x8E, 0x38, 0xC7, 0x1C, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x1C,
  0x01, 0x80, 0x38, 0x1F, 0xF1, 0xFF, 0x18, 0x03, 0x80, 0x38, 0x03, 0x70,
  0x7F, 0xC7, 0xFC, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0xE1, 0xCF, 0x3C,
  0x7F, 0x83, 0xF0, 0x07, 0xC1, 0xF8, 0x78, 0x1C, 0x03, 0x00, 0xEE, 0x1B,
  0xF3, 0xDE, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x1C, 0xE7, 0x9F, 0xE1,
  0xF8, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x38,
  0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x3C, 0x07, 0x00, 0x03,
  0x00, 0xFC, 0x1F, 0xE3, 0x8E, 0x38, 0x63, 0x06, 0x38, 0xE3, 0xFC, 0x1F,
  0x83, 0xFC, 0x71, 0xCE, 0x0C, 0xE0, 0xCE, 0x1C, 0xF3, 0xC7, 0xF8, 0x3F,
  0x00, 0x04, 0x0F, 0xE7, 0xF9, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xFF, 0xF7, 0xF8, 0x6E, 0x03, 0x81, 0xC1, 0xE1, 0xF0, 0xF0, 0x00, 0x18,
  0xF3, 0xCE, 0x00, 0x00, 0x00, 0x01, 0x8F, 0x3C, 0xF0, 0x0C, 0x3C, 0x78,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE1, 0xC3, 0x06, 0x1C, 0x30, 0xE0,
  0x00, 0xC1, 0xF1, 0xFD, 0xF8, 0xF0, 0x3C, 0x07, 0xC0, 0x7E, 0x07, 0x80,
  0x60, 0x7F, 0xF7, 0xFE, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0xFF, 0xEF,
  0xFC, 0x30, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x1E, 0x07, 0xC7, 0xF7, 0xF0,
  0xF8, 0x18, 0x00, 0x0C, 0x0F, 0xE7, 0xFB, 0x87, 0xE1, 0xC0, 0x70, 0x38,
  0x1E, 0x0F, 0x07, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x03, 0x01, 0xC0, 0x70,
  0x00, 0x07, 0xC1, 0xEE, 0x30, 0x32, 0x3B, 0x6F, 0xDC, 0xC9, 0xD9, 0x9D,
  0x9B, 0x99, 0xB9, 0x12, 0x9B, 0x29, 0xDC, 0xC8, 0x8C, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x03, 0xB8, 0x1D,
  0xC1, 0xCE, 0x0E, 0x70, 0xE3, 0x87, 0xFC, 0x7F, 0xE3, 0x83, 0xB8, 0x1D,
  0xC0, 0xFE, 0x07, 0x1F, 0xF0, 0xFF, 0xC7, 0x0E, 0x30, 0x73, 0x83, 0x9C,
  0x1C, 0xE3, 0xC7, 0xF8, 0x3F, 0xF3, 0x83, 0x9C, 0x0C, 0xE0, 0xE7, 0x07,
  0x38, 0xF9, 0xFF, 0x9F, 0xF0, 0x03, 0x00, 0xFC, 0x1F, 0xE3, 0x87, 0x70,
  0x77, 0x07, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0xEE, 0x0E, 0x71, 0xC7, 0xF8, 0x3F, 0x00, 0x1F, 0xC0, 0xFF, 0x06, 0x3C,
  0x70, 0xE3, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x07, 0x30, 0x3B, 0x83, 0x9C,
  0x1C, 0xE0, 0xE7, 0x0E, 0x39, 0xE1, 0xFE, 0x1F, 0xC0, 0x1F, 0xFC, 0x7F,
  0xE1, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xFF, 0x0F, 0xF8, 0x3F,
  0xE0, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0xFE, 0x3F,
  0xF8, 0x3F, 0xF9, 0xFF, 0xCE, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0,
  0x0F, 0xFC, 0x7F, 0xC3, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0x03, 0x00, 0xFC, 0x1F, 0xE3, 0x87, 0x70, 0x77, 0x07,
  0x70, 0x0E, 0x00, 0xE0, 0x1E, 0x3E, 0xE3, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E,
  0x71, 0xE7, 0xFC, 0x3F, 0x80, 0x1C, 0x1C, 0x70, 0xE1, 0x83, 0x8E, 0x0E,
  0x38, 0x38, 0xE0, 0xE3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF1, 0xC1, 0xC7, 0x07,
  0x1C, 0x1C, 0x70, 0x61, 0x83, 0x8E, 0x0E, 0x38, 0x38, 0x1F, 0xF3, 0xFF,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC4, 0xFF, 0x8F, 0xF8, 0x00, 0x38, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x39, 0xC1, 0xCE, 0x1C, 0x71, 0xE1, 0xFE, 0x07, 0xC0, 0x1C,
  0x1E, 0x38, 0x70, 0x71, 0xC0, 0xC7, 0x83, 0x9E, 0x07, 0x78, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xE7, 0x03, 0x8E, 0x07, 0x0E, 0x0E,
  0x1C, 0x18, 0x3C, 0x70, 0x38, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFF,
  0xFF, 0x1E, 0x3C, 0x79, 0xF1, 0xE7, 0x8F, 0xBE, 0x3E, 0xF8, 0xFF, 0xE3,
  0x7B, 0x8D, 0xEC, 0x37, 0x31, 0xCD, 0xC7, 0x27, 0x1C, 0x1C, 0x70, 0x71,
  0x81, 0x86, 0x06, 0x38, 0x38, 0x1C, 0x1C, 0x70, 0xE1, 0xE3, 0x8F, 0x8E,
  0x3E, 0x38, 0xF8, 0xE3, 0xF7, 0x0E, 0xDC, 0x33, 0x71, 0xCD, 0xC7, 0x3F,
  0x1C, 0x7C, 0x71, 0xE1, 0xC7, 0x8E, 0x0E, 0x38, 0x38, 0x03, 0x00, 0xFC,
  0x1F, 0xE3, 0x8E, 0x70, 0x77, 0x07, 0x60, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x6E, 0x0E, 0xE0, 0xEE, 0x1C, 0x73, 0xC7, 0xF8, 0x3F, 0x00, 0x3F,
  0xC1, 0xFF, 0x8E, 0x1C, 0x70, 0xE3, 0x03, 0x38, 0x39, 0xC1, 0xCE, 0x3C,
  0x7F, 0xC3, 0xFC, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18,
  0x00, 0x03, 0x00, 0xFC, 0x1F, 0xE3, 0x8F, 0x70, 0x77, 0x07, 0x60, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0E, 0xE0, 0xEE, 0x1C, 0x73, 0xC7,
  0xF8, 0x3F, 0x80, 0x1C, 0x00, 0xE0, 0x08, 0x1F, 0xE0, 0xFF, 0x87, 0x0E,
  0x30, 0x73, 0x83, 0x9C, 0x1C, 0xE1, 0xE7, 0xFE, 0x3F, 0xE3, 0xFE, 0x1C,
  0x70, 0xE3, 0x87, 0x0E, 0x38, 0x71, 0x83, 0x9C, 0x0E, 0x03, 0x01, 0xFE,
  0x3F, 0xF3, 0x87, 0x70, 0x77, 0x00, 0x38, 0x03, 0xE0, 0x1F, 0x80, 0x7C,
  0x01, 0xE0, 0x0E, 0xE0, 0xEE, 0x0E, 0xF1, 0xE7, 0xFC, 0x3F, 0x80, 0xFF,
  0xFF, 0xFF, 0x83, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x39, 0xC3, 0x8C, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x39, 0xC1,
  0x8E, 0x1C, 0x60, 0xE7, 0x07, 0x38, 0x39, 0xC1, 0xCE, 0x1C, 0x39, 0xE1,
  0xFE, 0x07, 0xE0, 0xE0, 0x7F, 0x03, 0xB8, 0x38, 0xC1, 0xC7, 0x1C, 0x38,
  0xE1, 0xCE, 0x0E, 0x70, 0x73, 0x03, 0xB8, 0x1D, 0xC0, 0x7C, 0x03, 0xE0,
  0x1E, 0x00, 0xF0, 0x07, 0x00, 0x73, 0x1D, 0x8C, 0xE6, 0x73, 0x99, 0xCE,
  0x67, 0x31, 0xBD, 0xC6, 0xF7, 0x1B, 0xD8, 0x7B, 0x61, 0xEF, 0x87, 0xBE,
  0x1E, 0xF0, 0x73, 0xC1, 0xCF, 0x07, 0x38, 0x38, 0xE0, 0x1E, 0x0F, 0x0E,
  0x1C, 0x0E, 0x3C, 0x07, 0x38, 0x07, 0x70, 0x07, 0xF0, 0x03, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0x70, 0x38,
  0x70, 0x78, 0x70, 0xF0, 0x38, 0xE0, 0x7B, 0x83, 0x9C, 0x38, 0xE3, 0x83,
  0x1C, 0x1D, 0xC0, 0xEC, 0x07, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0xFF, 0x3F, 0xF8, 0x1F,
  0x1F, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x38, 0x38, 0x30, 0x30, 0x70,
  0x70, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xF8, 0xF8, 0xF8, 0xE1, 0x86,
  0x18, 0x71, 0xC7, 0x0C, 0x30, 0xE3, 0x8E, 0x38, 0x61, 0x87, 0x1C, 0x1F,
  0x1F, 0x07, 0x07, 0x06, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0x38, 0xF8, 0xF8, 0xF8, 0x07, 0x07,
  0x83, 0xC3, 0xE1, 0xB9, 0x8D, 0xC7, 0xC3, 0xFF, 0xFF, 0xF0, 0xE3, 0x8C,
  0x70, 0x1F, 0x87, 0xF9, 0xC3, 0x80, 0x70, 0x0E, 0x7F, 0x9E, 0x77, 0x0E,
  0xE1, 0xDC, 0x7B, 0xFF, 0x3E, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x18, 0x03, 0xBE, 0x3F, 0xE3, 0xC7, 0x38, 0x73, 0x87, 0x30, 0x77, 0x07,
  0x70, 0x77, 0x0E, 0x79, 0xE7, 0xFC, 0xEF, 0x80, 0x1F, 0x87, 0xF9, 0xE3,
  0xB8, 0x76, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE1, 0xCE, 0x39, 0xFE, 0x1F,
  0x80, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x0F, 0xB8, 0xFF,
  0x8F, 0x1C, 0x70, 0xE7, 0x07, 0x38, 0x39, 0xC1, 0x8E, 0x1C, 0x70, 0xE3,
  0xCF, 0x0F, 0xF8, 0x3D, 0xC0, 0x1F, 0x87, 0xF9, 0xE3, 0xB8, 0x7E, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x8E, 0x39, 0xFF, 0x1F, 0x80, 0x01, 0xF0,
  0x7F, 0x07, 0xF0, 0xE0, 0x0E, 0x01, 0xC0, 0xFF, 0xEF, 0xFC, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07,
  0x00, 0x0F, 0xB8, 0xFF, 0xCF, 0x1C, 0x70, 0xE7, 0x07, 0x38, 0x39, 0xC1,
  0xCE, 0x0C, 0x70, 0xE1, 0xCF, 0x0F, 0xF8, 0x3D, 0xC0, 0x0E, 0x20, 0xE3,
  0xFF, 0x0F, 0xF0, 0x1E, 0x00, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18,
  0x03, 0xBE, 0x3F, 0xF3, 0xC7, 0x38, 0x73, 0x87, 0x30, 0x77, 0x07, 0x70,
  0x77, 0x06, 0x70, 0xE7, 0x0E, 0xE0, 0xE0, 0x01, 0x80, 0xE0, 0x38, 0x00,
  0x00, 0x0F, 0xE3, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03,
  0x80, 0xE3, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x00, 0x00,
  0x1F, 0x83, 0xF0, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x2F, 0x07, 0xE1, 0xF0, 0x00,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x3C, 0xE3, 0xC7,
  0x38, 0x3B, 0x81, 0xF8, 0x0F, 0xC0, 0xFF, 0x07, 0xB8, 0x38, 0xE1, 0xC7,
  0x0E, 0x1C, 0xE0, 0xF0, 0x1F, 0x87, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xE3, 0xFF,
  0xFF, 0xC0, 0x37, 0x71, 0xFF, 0xDC, 0xEE, 0xE6, 0x77, 0x73, 0xB3, 0x99,
  0x9C, 0xDC, 0xEE, 0xE6, 0x77, 0x33, 0xBB, 0x9D, 0x9C, 0xC0, 0x3B, 0xE3,
  0xFF, 0x3C, 0x73, 0x87, 0x38, 0x73, 0x07, 0x70, 0x77, 0x07, 0x70, 0x67,
  0x0E, 0x70, 0xEE, 0x0E, 0x1F, 0x87, 0xF9, 0xE3, 0xB8, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE1, 0xDE, 0x79, 0xFE, 0x1F, 0x80, 0x3B, 0xE3, 0xFE,
  0x3C, 0x73, 0x87, 0x38, 0x73, 0x07, 0x70, 0x77, 0x07, 0x70, 0xE7, 0x9E,
  0x7F, 0xC6, 0xF8, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x1F,
  0x73, 0xFE, 0x78, 0xE7, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x1C, 0xE1,
  0xCF, 0x3C, 0x7F, 0xC3, 0xDC, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x3B, 0xE7, 0xFC, 0xFB, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x60, 0x1C, 0x03, 0x80, 0x70, 0x00, 0x1F, 0xC7, 0xFD, 0xC3, 0xB8, 0x77,
  0x80, 0x7E, 0x03, 0xF0, 0x0E, 0xE0, 0xDC, 0x39, 0xFF, 0x1F, 0x80, 0x0C,
  0x07, 0x01, 0xC3, 0xFF, 0xFF, 0xC6, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x8F, 0xE1, 0xF8, 0x30, 0x77, 0x07, 0x70, 0x67, 0x0E,
  0x70, 0xE7, 0x0E, 0x60, 0xEE, 0x0C, 0xE1, 0xC7, 0x3C, 0x7F, 0xC3, 0xDC,
  0xE0, 0xFC, 0x1F, 0x87, 0x30, 0xC6, 0x38, 0xC6, 0x1D, 0xC3, 0xB0, 0x3E,
  0x07, 0x80, 0xF0, 0x1C, 0x00, 0xE6, 0x3F, 0x39, 0xB9, 0xDD, 0xDE, 0xEE,
  0xF6, 0x75, 0xB3, 0xEF, 0x9F, 0x78, 0xF3, 0xC7, 0x9C, 0x38, 0xE1, 0xC7,
  0x00, 0x38, 0x3C, 0x71, 0xC1, 0xCE, 0x03, 0xF8, 0x0F, 0xC0, 0x1E, 0x00,
  0xF8, 0x03, 0xE0, 0x1D, 0xC0, 0xE7, 0x07, 0x0E, 0x3C, 0x3C, 0x38, 0x1C,
  0xE0, 0xE3, 0x83, 0x86, 0x1C, 0x1C, 0xE0, 0x73, 0x81, 0xDC, 0x03, 0x70,
  0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x0B, 0x80,
  0x3E, 0x00, 0xE0, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x9F, 0xF9, 0xFF, 0xC0,
  0x01, 0x81, 0xC1, 0xC0, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x3C,
  0x1E, 0x03, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x1C, 0x0E, 0x03, 0x01, 0xC0,
  0x60, 0x18, 0xC6, 0x31, 0x18, 0xC6, 0x31, 0x88, 0xC6, 0x31, 0x8C, 0x62,
  0x31, 0x8C, 0x00, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x03, 0x01, 0xE0, 0xF0, 0xE0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x0E,
  0x06, 0x0F, 0x06, 0x00, 0x3C, 0x13, 0xF1, 0xF9, 0xFD, 0x87, 0xE0, 0x0C,
  0x00,
};

const GFXglyph RobotoMono_SemiBoldItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 6, 16, 14, 4, -16 },
  { 13, 7, 6, 14, 4, -17 },
  { 19, 14, 16, 14, 0, -16 },
  { 47, 12, 21, 14, 1, -19 },
  { 79, 11, 17, 14, 1, -17 },
  { 103, 13, 17, 14, 0, -17 },
  { 131, 3, 6, 14, 6, -17 },
  { 134, 7, 23, 14, 4, -18 },
  { 155, 8, 23, 14, 2, -18 },
  { 178, 11, 11, 14, 2, -16 },
  { 194, 11, 12, 14, 1, -14 },
  { 211, 5, 7, 14, 2, -3 },
  { 216, 9, 2, 14, 3, -8 },
  { 219, 4, 4, 14, 4, -4 },
  { 221, 12, 17, 14, 1, -16 },
  { 247, 12, 17, 14, 1, -17 },
  { 273, 7, 16, 14, 3, -16 },
  { 287, 12, 17, 14, 0, -17 },
  { 313, 12, 17, 14, 1, -17 },
  { 339, 12, 16, 14, 0, -16 },
  { 363, 12, 16, 14, 1, -16 },
  { 387, 11, 16, 14, 1, -16 },
  { 409, 11, 16, 14, 2, -16 },
  { 431, 12, 17, 14, 1, -17 },
  { 457, 10, 17, 14, 2, -17 },
  { 479, 6, 13, 14, 4, -13 },
  { 489, 7, 17, 14, 3, -13 },
  { 504, 10, 10, 14, 2, -12 },
  { 517, 12, 8, 14, 1, -11 },
  { 529, 11, 10, 14, 1, -12 },
  { 543, 10, 17, 14, 3, -17 },
  { 565, 12, 16, 14, 1, -16 },
  { 589, 13, 16, 14, -1, -16 },
  { 615, 13, 16, 14, 0, -16 },
  { 641, 12, 17, 14, 1, -17 },
  { 667, 13, 16, 14, 0, -16 },
  { 693, 14, 16, 14, 0, -16 },
  { 721, 13, 16, 14, 1, -16 },
  { 747, 12, 17, 14, 1, -17 },
  { 773, 14, 16, 14, 0, -16 },
  { 801, 12, 16, 14, 1, -16 },
  { 825, 13, 16, 14, 1, -16 },
  { 851, 15, 16, 14, 0, -16 },
  { 881, 10, 16, 14, 1, -16 },
  { 901, 14, 16, 14, 0, -16 },
  { 929, 14, 16, 14, 0, -16 },
  { 957, 12, 17, 14, 1, -17 },
  { 983, 13, 16, 14, 1, -16 },
  { 1009, 12, 20, 14, 1, -17 },
  { 1039, 13, 16, 14, 0, -16 },
  { 1065, 12, 17, 14, 1, -17 },
  { 1091, 13, 16, 14, 2, -16 },
  { 1117, 13, 16, 14, 1, -16 },
  { 1143, 13, 16, 14, 2, -16 },
  { 1169, 14, 16, 14, 1, -16 },
  { 1197, 16, 16, 14, -1, -16 },
  { 1229, 13, 16, 14, 2, -16 },
  { 1255, 14, 16, 14, 0, -16 },
  { 1283, 8, 23, 14, 3, -19 },
  { 1306, 6, 17, 14, 4, -16 },
  { 1319, 8, 23, 14, 3, -19 },
  { 1342, 9, 8, 14, 2, -16 },
  { 1351, 10, 2, 14, 0, 0 },
  { 1354, 5, 4, 14, 6, -17 },
  { 1357, 11, 12, 14, 1, -12 },
  { 1374, 12, 17, 14, 0, -17 },
  { 1400, 11, 12, 14, 1, -12 },
  { 1417, 13, 17, 14, 1, -17 },
  { 1445, 11, 12, 14, 1, -12 },
  { 1462, 12, 18, 14, 2, -18 },
  { 1489, 13, 17, 14, 0, -12 },
  { 1517, 12, 17, 14, 0, -17 },
  { 1543, 10, 17, 14, 1, -17 },
  { 1565, 11, 22, 14, 0, -17 },
  { 1596, 13, 17, 14, 0, -17 },
  { 1624, 10, 17, 14, 1, -17 },
  { 1646, 13, 12, 14, 0, -12 },
  { 1666, 12, 12, 14, 0, -12 },
  { 1684, 11, 12, 14, 1, -12 },
  { 1701, 12, 17, 14, 0, -12 },
  { 1727, 12, 17, 14, 1, -12 },
  { 1753, 11, 12, 14, 2, -12 },
  { 1770, 11, 12, 14, 1, -12 },
  { 1787, 10, 15, 14, 2, -15 },
  { 1806, 12, 12, 14, 1, -12 },
  { 1824, 11, 12, 14, 2, -12 },
  { 1841, 13, 12, 14, 1, -12 },
  { 1861, 14, 12, 14, 0, -12 },
  { 1882, 14, 17, 14, 0, -12 },
  { 1912, 13, 12, 14, 0, -12 },
  { 1932, 9, 22, 14, 3, -18 },
  { 1957, 5, 21, 14, 4, -16 },
  { 1971, 9, 22, 14, 2, -18 },
  { 1996, 13, 5, 14, 0, -9 },
};

const GFXfont RobotoMono_SemiBoldItalic23pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic23pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic23pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC23PT7B_H_
