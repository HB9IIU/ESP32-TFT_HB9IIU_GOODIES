#ifndef _ROBOTOMONO_SEMIBOLDITALIC21PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCC, 0x63, 0x39, 0xCC, 0x63, 0x00, 0x0C, 0x73, 0x00, 0xCF,
  0x3C, 0xF3, 0xCE, 0x20, 0x03, 0x30, 0x26, 0x06, 0x60, 0x66, 0x3F, 0xF3,
  0xFF, 0x0C, 0x80, 0x98, 0x19, 0x8F, 0xFE, 0xFF, 0xE3, 0x30, 0x32, 0x06,
  0x60, 0x66, 0x00, 0x03, 0x00, 0x60, 0x3E, 0x0F, 0xE3, 0x8E, 0x61, 0xCC,
  0x39, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xEE, 0x1D, 0xC3, 0xB8, 0x73,
  0xFC, 0x3F, 0x01, 0x00, 0x60, 0x00, 0x38, 0x1B, 0x0C, 0xCF, 0x36, 0xCD,
  0x1E, 0xC0, 0x60, 0x10, 0x0C, 0x06, 0xF3, 0x6C, 0x99, 0x64, 0xC1, 0xB0,
  0x78, 0x07, 0x80, 0xFC, 0x1C, 0xC1, 0x8C, 0x19, 0xC1, 0xF8, 0x1F, 0x01,
  0xE0, 0x3E, 0x37, 0x77, 0x63, 0x6E, 0x3E, 0x61, 0xC7, 0xFC, 0x3E, 0xE0,
  0x6D, 0xBD, 0x80, 0x02, 0x0C, 0x38, 0xE1, 0x86, 0x0C, 0x38, 0x60, 0xC1,
  0x87, 0x0E, 0x18, 0x30, 0x60, 0x60, 0xC1, 0x81, 0x83, 0x02, 0x00, 0x10,
  0x30, 0x60, 0x60, 0xC1, 0x83, 0x83, 0x06, 0x1C, 0x38, 0x70, 0xC1, 0x87,
  0x0C, 0x18, 0x61, 0xC3, 0x0C, 0x10, 0x00, 0x0E, 0x03, 0x00, 0xC3, 0x33,
  0xFF, 0xCF, 0xC1, 0xC0, 0xD8, 0x66, 0x30, 0xC0, 0x20, 0x06, 0x01, 0x80,
  0xE0, 0x38, 0xFF, 0xFF, 0xF0, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x37,
  0x76, 0xEC, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x18, 0x07, 0x00,
  0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0x03,
  0x00, 0xE0, 0x18, 0x07, 0x00, 0x0F, 0x87, 0xF3, 0x9C, 0xC3, 0x70, 0xDC,
  0x76, 0x3D, 0xBF, 0xF9, 0xFC, 0x7E, 0x1F, 0x86, 0x63, 0x9F, 0xC3, 0xE0,
  0x03, 0x1E, 0x7E, 0x7E, 0x8E, 0x0E, 0x0C, 0x0C, 0x0C, 0x1C, 0x1C, 0x1C,
  0x18, 0x18, 0x38, 0x0F, 0x83, 0xF8, 0xE3, 0x98, 0x77, 0x0E, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xFF, 0xBF, 0xF0,
  0x1F, 0x8F, 0xF7, 0x1D, 0xC3, 0x00, 0xC0, 0x70, 0xF8, 0x7C, 0x07, 0x80,
  0x60, 0x1B, 0x06, 0xE3, 0xBF, 0xC7, 0xE0, 0x00, 0xE0, 0x3C, 0x0F, 0x81,
  0xE0, 0x6C, 0x1B, 0x87, 0x71, 0xCE, 0x31, 0x8C, 0x33, 0xFF, 0xFF, 0xF0,
  0x38, 0x07, 0x00, 0xC0, 0x1F, 0xE3, 0xFC, 0xE0, 0x18, 0x03, 0x00, 0x7C,
  0x1F, 0xE3, 0x9C, 0x01, 0xC0, 0x38, 0x07, 0x70, 0xCE, 0x38, 0xFE, 0x0F,
  0x80, 0x03, 0x83, 0xE1, 0xE0, 0xE0, 0x70, 0x1B, 0xC7, 0xFB, 0xCE, 0xE1,
  0xF8, 0x7E, 0x1F, 0x86, 0xE3, 0x9F, 0xC3, 0xE0, 0x7F, 0xEF, 0xFC, 0x03,
  0x80, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x0C,
  0x03, 0x80, 0xE0, 0x3C, 0x00, 0x0F, 0x8F, 0xF3, 0x9D, 0xC3, 0x70, 0xCC,
  0x73, 0xF8, 0xFC, 0x73, 0xB8, 0x6E, 0x1B, 0x86, 0xE3, 0xBF, 0xC3, 0xE0,
  0x3E, 0x3F, 0x9C, 0xFC, 0x7C, 0x1E, 0x0F, 0x0F, 0xC7, 0xFF, 0xBD, 0x81,
  0xC0, 0xC1, 0xE7, 0xE3, 0xC0, 0x3B, 0xCE, 0x00, 0x00, 0x00, 0x07, 0x39,
  0xC0, 0x1C, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x1C, 0x71, 0x8E,
  0x30, 0x00, 0xC0, 0xF1, 0xF9, 0xF0, 0x60, 0x3E, 0x03, 0xF0, 0x1E, 0x01,
  0x80, 0x7F, 0xEF, 0xF9, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xBF, 0xE0, 0x60,
  0x1E, 0x03, 0xF0, 0x3F, 0x01, 0xC3, 0xE7, 0xE3, 0xE0, 0xC0, 0x00, 0x3E,
  0x3F, 0xB8, 0xF8, 0x70, 0x38, 0x38, 0x38, 0x38, 0x38, 0x18, 0x0C, 0x00,
  0x06, 0x03, 0x81, 0xC0, 0x03, 0xC0, 0xFE, 0x18, 0x33, 0x3B, 0x27, 0xD6,
  0xC9, 0x6C, 0x94, 0x9B, 0x59, 0xBD, 0x92, 0x4F, 0xE4, 0xDC, 0x60, 0x03,
  0xB0, 0x1F, 0x00, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x07, 0xE0, 0x6E,
  0x0E, 0xE0, 0xC6, 0x1C, 0x61, 0xFE, 0x3F, 0xE3, 0xFF, 0x70, 0x77, 0x07,
  0xE0, 0x70, 0x1F, 0xC1, 0xFE, 0x38, 0x73, 0x87, 0x38, 0x73, 0x87, 0x3F,
  0xE3, 0xFC, 0x70, 0xE7, 0x06, 0x70, 0x67, 0x0E, 0x61, 0xE7, 0xFC, 0xFF,
  0x00, 0x0F, 0x83, 0xF8, 0xE3, 0xB8, 0x76, 0x0F, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x18, 0x03, 0x07, 0x70, 0xEE, 0x38, 0xFE, 0x0F, 0x80, 0x1F, 0x01,
  0xFC, 0x39, 0xE3, 0x86, 0x38, 0x73, 0x87, 0x30, 0x73, 0x07, 0x70, 0x67,
  0x0E, 0x70, 0xE6, 0x1C, 0x63, 0xCF, 0xF8, 0xFE, 0x00, 0x1F, 0xF8, 0xFF,
  0x86, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xFF, 0x87, 0xF8, 0x30, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x1F, 0xF8,
  0xFF, 0x86, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xFC, 0x3F,
  0xC3, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x00, 0x0F,
  0x83, 0xF8, 0xE3, 0xB8, 0x76, 0x0F, 0xC0, 0x38, 0x07, 0x3E, 0xE7, 0xDC,
  0x1B, 0x87, 0x70, 0xEE, 0x1C, 0xFF, 0x0F, 0xC0, 0x18, 0x31, 0x83, 0x38,
  0x73, 0x87, 0x38, 0x73, 0x06, 0x3F, 0xE7, 0xFE, 0x70, 0xE7, 0x0E, 0x70,
  0xE6, 0x0C, 0x60, 0xCE, 0x1C, 0xE1, 0xC0, 0x3F, 0xE7, 0xFC, 0x18, 0x03,
  0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01,
  0xC1, 0xFF, 0x3F, 0xC0, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0x80, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x60, 0xCE, 0x39, 0xFE, 0x1F,
  0x80, 0x1C, 0x3C, 0x61, 0xC3, 0x8F, 0x0E, 0x78, 0x3B, 0xC0, 0xEE, 0x03,
  0x70, 0x0F, 0xC0, 0x7F, 0x01, 0xEE, 0x07, 0x38, 0x1C, 0x70, 0x61, 0xC1,
  0x83, 0x8E, 0x0E, 0x00, 0x38, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x81, 0xC0,
  0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0xFF, 0xFE, 0x1C, 0x78, 0xE3,
  0x8F, 0x3C, 0x79, 0xE3, 0x5B, 0x1B, 0xF8, 0xDD, 0xC6, 0xEC, 0x76, 0x63,
  0xB3, 0x18, 0x38, 0xC1, 0xC6, 0x0C, 0x70, 0x63, 0x83, 0x00, 0x18, 0x31,
  0xC7, 0x3C, 0x73, 0xC7, 0x3E, 0x73, 0x66, 0x36, 0x67, 0x6E, 0x73, 0xE7,
  0x3E, 0x73, 0xE6, 0x3C, 0x61, 0xCE, 0x1C, 0xE1, 0xC0, 0x0F, 0x87, 0xF8,
  0xE7, 0x38, 0x76, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xD8, 0x1B, 0x07,
  0x70, 0xEE, 0x38, 0xFE, 0x0F, 0x80, 0x1F, 0xC1, 0xFE, 0x18, 0x73, 0x83,
  0x38, 0x33, 0x87, 0x38, 0x73, 0xFE, 0x3F, 0xC7, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x06, 0x00, 0xE0, 0x00, 0x0F, 0x83, 0xF8, 0xE7, 0x38, 0x76, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x1B, 0x07, 0x70, 0xEE, 0x38, 0xFE,
  0x0F, 0xC0, 0x1C, 0x01, 0xC0, 0x20, 0x1F, 0xC1, 0xFE, 0x38, 0xF3, 0x87,
  0x38, 0x73, 0x87, 0x30, 0xE3, 0xFE, 0x7F, 0x87, 0x38, 0x71, 0x87, 0x1C,
  0x61, 0xC6, 0x0C, 0xE0, 0xE0, 0x0F, 0x87, 0xF8, 0xE3, 0xB8, 0x37, 0x00,
  0xE0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x3B, 0x03, 0x60, 0xEE, 0x1C, 0xFF,
  0x0F, 0xC0, 0x7F, 0xF7, 0xFF, 0x86, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18,
  0x00, 0x30, 0x66, 0x0D, 0xC3, 0xB8, 0x77, 0x0E, 0xC1, 0xD8, 0x33, 0x06,
  0xE1, 0xDC, 0x3B, 0x87, 0x70, 0xCE, 0x38, 0xFE, 0x0F, 0x80, 0xE0, 0xFC,
  0x1F, 0x87, 0x70, 0xEE, 0x38, 0xC7, 0x18, 0xC3, 0x38, 0x66, 0x0F, 0xC1,
  0xF8, 0x3E, 0x03, 0xC0, 0x70, 0x0E, 0x00, 0x66, 0x36, 0x63, 0x66, 0x76,
  0xE6, 0x6E, 0x66, 0xEE, 0x6A, 0xC7, 0xAC, 0x7A, 0xCF, 0x3C, 0xF3, 0x8F,
  0x38, 0xF3, 0x8E, 0x30, 0xE3, 0x00, 0x1C, 0x1C, 0x30, 0xE0, 0xE3, 0x83,
  0x9C, 0x06, 0xE0, 0x1F, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3F, 0x00,
  0xEC, 0x07, 0x38, 0x38, 0xE1, 0xE1, 0x8F, 0x07, 0x00, 0xE0, 0xFE, 0x0E,
  0x61, 0xC7, 0x18, 0x73, 0x83, 0x70, 0x36, 0x03, 0xE0, 0x3C, 0x01, 0xC0,
  0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x00, 0x3F, 0xF9, 0xFF, 0x80,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x07, 0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x1E, 0x7C, 0xE1,
  0xC3, 0x86, 0x0C, 0x18, 0x70, 0xE1, 0xC3, 0x06, 0x0C, 0x38, 0x70, 0xE1,
  0xC3, 0xC7, 0x80, 0xC6, 0x38, 0xC6, 0x31, 0x8E, 0x71, 0x8C, 0x63, 0x1C,
  0xE3, 0x0F, 0x1F, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C,
  0x0C, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x78, 0xF8, 0x06, 0x0E, 0x1E,
  0x1E, 0x33, 0x33, 0x63, 0xE3, 0xFF, 0xFF, 0xE0, 0xE6, 0x30, 0x1F, 0x1F,
  0xE7, 0x1C, 0x07, 0x1F, 0xDF, 0xEE, 0x1B, 0x0E, 0xC3, 0xBF, 0xE7, 0xF8,
  0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x7F, 0x8F, 0xF1, 0xC7, 0x30,
  0xE6, 0x1D, 0xC3, 0xB8, 0x77, 0x0C, 0xE3, 0x9F, 0xE7, 0x78, 0x1F, 0x0F,
  0xE7, 0x1D, 0x83, 0xE0, 0x38, 0x0E, 0x03, 0x86, 0xE3, 0x9F, 0xC3, 0xE0,
  0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x3D, 0x8F, 0xF3, 0x8E, 0x61,
  0xDC, 0x3B, 0x87, 0x70, 0xCE, 0x19, 0xC7, 0x1F, 0xE3, 0xFC, 0x1F, 0x0F,
  0xE7, 0x1D, 0x83, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE1, 0x9F, 0xE3, 0xF0,
  0x07, 0xE1, 0xFC, 0x38, 0x0E, 0x01, 0xC1, 0xFF, 0xBF, 0xE0, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x0F, 0x71,
  0xFE, 0x38, 0xE3, 0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0C, 0x71, 0xC3,
  0xFC, 0x1F, 0xC0, 0x1C, 0x43, 0x8F, 0xF8, 0x7E, 0x00, 0x1C, 0x03, 0x00,
  0x60, 0x0C, 0x03, 0x80, 0x77, 0x8F, 0xF9, 0xC7, 0x30, 0xE6, 0x1D, 0xC3,
  0xB8, 0x77, 0x0C, 0xC1, 0x98, 0x37, 0x0E, 0x03, 0x03, 0x80, 0x00, 0x03,
  0xF1, 0xF0, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0x80, 0xC7, 0xFF, 0xFE,
  0x01, 0xC0, 0x70, 0x00, 0x00, 0x0F, 0x83, 0xE1, 0x38, 0x0E, 0x03, 0x80,
  0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x1F, 0x87, 0xC2,
  0x80, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x8F, 0x39, 0xC3,
  0x38, 0x37, 0x03, 0xE0, 0x7F, 0x07, 0xF0, 0x73, 0x86, 0x38, 0x61, 0xCE,
  0x1E, 0x1F, 0x9F, 0x80, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x07,
  0x03, 0x81, 0xC0, 0xC0, 0x63, 0xFF, 0xFF, 0x3E, 0xE7, 0xFF, 0x77, 0x76,
  0x67, 0x66, 0x66, 0x66, 0xE6, 0x6E, 0xE6, 0xEE, 0xEC, 0xCE, 0xCC, 0xC0,
  0x3F, 0xC7, 0xFC, 0xE3, 0x98, 0x73, 0x0E, 0xE1, 0xDC, 0x3B, 0x86, 0x60,
  0xCC, 0x1B, 0x87, 0x00, 0x1F, 0x0F, 0xE7, 0x1F, 0x87, 0xE1, 0xF8, 0x7C,
  0x1F, 0x87, 0xE3, 0x9F, 0xC3, 0xE0, 0x3F, 0xC7, 0xF8, 0xE3, 0x98, 0x73,
  0x0E, 0xE1, 0xDC, 0x3B, 0x86, 0x71, 0xCF, 0xF1, 0xBC, 0x70, 0x0E, 0x01,
  0xC0, 0x30, 0x00, 0x1E, 0xE7, 0xF9, 0xC7, 0x30, 0xEE, 0x1D, 0xC3, 0xB8,
  0x67, 0x0C, 0xE3, 0x8F, 0xF1, 0xFE, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0,
  0x37, 0xCF, 0xE7, 0xC9, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x00, 0x1F, 0x8F, 0xF7, 0x1D, 0x80, 0x7C, 0x0F, 0xC0, 0x7B, 0x06,
  0xE1, 0x9F, 0xE3, 0xF0, 0x1C, 0x0E, 0x06, 0x1F, 0xFF, 0xF9, 0xC0, 0xE0,
  0x60, 0x30, 0x18, 0x1C, 0x0E, 0x03, 0xF0, 0xF8, 0x70, 0xEE, 0x19, 0xC3,
  0x30, 0xE6, 0x1D, 0xC3, 0xB8, 0x77, 0x0C, 0xE3, 0x8F, 0xF1, 0xFE, 0x00,
  0xC1, 0xF0, 0x6E, 0x3B, 0x8C, 0x67, 0x19, 0x86, 0xE1, 0xB0, 0x6C, 0x0E,
  0x03, 0x80, 0xE6, 0x7C, 0xE6, 0xCE, 0xEC, 0xEC, 0xDE, 0xCD, 0xEC, 0xD7,
  0x8F, 0x78, 0xE7, 0x8E, 0x70, 0xE7, 0x00, 0x38, 0x71, 0x8E, 0x1D, 0xC0,
  0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF8, 0x39, 0x87, 0x1C, 0xE0, 0xE0,
  0x70, 0x39, 0xC3, 0x8E, 0x18, 0x71, 0xC1, 0x9C, 0x0C, 0xE0, 0x7E, 0x03,
  0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0x80, 0x7C, 0x03, 0xC0,
  0x08, 0x00, 0x3F, 0xF3, 0xFE, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0x06, 0x0C, 0x0C, 0x1C,
  0x1C, 0x1C, 0x18, 0x38, 0xE0, 0xF0, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x18, 0x08, 0x13, 0x33, 0x33, 0x22, 0x66, 0x66, 0x44, 0xCC, 0xCC,
  0x80, 0x18, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0E, 0x07, 0x0F,
  0x1C, 0x18, 0x38, 0x38, 0x38, 0x30, 0x70, 0xE0, 0x80, 0x7C, 0x37, 0xE6,
  0xC7, 0xE0, 0x3C,
};

const GFXglyph RobotoMono_SemiBoldItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 5, 15, 12, 4, -15 },
  { 11, 6, 6, 12, 4, -16 },
  { 16, 12, 15, 12, 0, -15 },
  { 39, 11, 19, 12, 1, -17 },
  { 66, 10, 15, 12, 1, -15 },
  { 85, 12, 15, 12, 0, -15 },
  { 108, 3, 6, 12, 5, -16 },
  { 111, 7, 22, 12, 3, -17 },
  { 131, 7, 22, 12, 2, -17 },
  { 151, 10, 11, 12, 2, -15 },
  { 165, 10, 11, 12, 1, -12 },
  { 179, 4, 6, 12, 2, -2 },
  { 182, 8, 3, 12, 3, -8 },
  { 185, 3, 3, 12, 4, -3 },
  { 187, 11, 16, 12, 1, -15 },
  { 209, 10, 15, 12, 1, -15 },
  { 228, 8, 15, 12, 2, -15 },
  { 243, 11, 15, 12, 0, -15 },
  { 264, 10, 15, 12, 1, -15 },
  { 283, 11, 15, 12, 0, -15 },
  { 304, 11, 15, 12, 1, -15 },
  { 325, 10, 15, 12, 1, -15 },
  { 344, 11, 15, 12, 1, -15 },
  { 365, 10, 15, 12, 1, -15 },
  { 384, 9, 15, 12, 2, -15 },
  { 401, 5, 12, 12, 4, -12 },
  { 409, 6, 16, 12, 3, -12 },
  { 421, 10, 9, 12, 1, -11 },
  { 433, 11, 7, 12, 1, -10 },
  { 443, 10, 9, 12, 1, -11 },
  { 455, 9, 15, 12, 3, -15 },
  { 472, 12, 15, 12, 0, -15 },
  { 495, 12, 15, 12, -1, -15 },
  { 518, 12, 15, 12, 0, -15 },
  { 541, 11, 15, 12, 1, -15 },
  { 562, 12, 15, 12, 0, -15 },
  { 585, 13, 15, 12, 0, -15 },
  { 610, 13, 15, 12, 0, -15 },
  { 635, 11, 15, 12, 1, -15 },
  { 656, 12, 15, 12, 0, -15 },
  { 679, 11, 15, 12, 1, -15 },
  { 700, 11, 15, 12, 1, -15 },
  { 721, 14, 15, 12, 0, -15 },
  { 748, 9, 15, 12, 1, -15 },
  { 765, 13, 15, 12, 0, -15 },
  { 790, 12, 15, 12, 0, -15 },
  { 813, 11, 15, 12, 1, -15 },
  { 834, 12, 15, 12, 0, -15 },
  { 857, 11, 18, 12, 1, -15 },
  { 882, 12, 15, 12, 0, -15 },
  { 905, 11, 15, 12, 1, -15 },
  { 926, 12, 15, 12, 1, -15 },
  { 949, 11, 15, 12, 1, -15 },
  { 970, 11, 15, 12, 2, -15 },
  { 991, 12, 15, 12, 1, -15 },
  { 1014, 14, 15, 12, -1, -15 },
  { 1041, 12, 15, 12, 2, -15 },
  { 1064, 13, 15, 12, 0, -15 },
  { 1089, 7, 20, 12, 3, -17 },
  { 1107, 5, 16, 12, 4, -15 },
  { 1117, 8, 20, 12, 2, -17 },
  { 1137, 8, 8, 12, 2, -15 },
  { 1145, 10, 2, 12, 0, 0 },
  { 1148, 4, 3, 12, 6, -15 },
  { 1150, 10, 11, 12, 1, -11 },
  { 1164, 11, 16, 12, 0, -16 },
  { 1186, 10, 11, 12, 1, -11 },
  { 1200, 11, 16, 12, 1, -16 },
  { 1222, 10, 11, 12, 1, -11 },
  { 1236, 11, 16, 12, 2, -16 },
  { 1258, 12, 15, 12, 0, -11 },
  { 1281, 11, 16, 12, 0, -16 },
  { 1303, 9, 15, 12, 1, -15 },
  { 1320, 10, 20, 12, 0, -15 },
  { 1345, 12, 16, 12, 0, -16 },
  { 1369, 9, 16, 12, 1, -16 },
  { 1387, 12, 11, 12, 0, -11 },
  { 1404, 11, 11, 12, 0, -11 },
  { 1420, 10, 11, 12, 1, -11 },
  { 1434, 11, 15, 12, 0, -11 },
  { 1455, 11, 15, 12, 1, -11 },
  { 1476, 10, 11, 12, 2, -11 },
  { 1490, 10, 11, 12, 1, -11 },
  { 1504, 9, 14, 12, 2, -14 },
  { 1520, 11, 11, 12, 1, -11 },
  { 1536, 10, 11, 12, 2, -11 },
  { 1550, 12, 11, 12, 1, -11 },
  { 1567, 12, 11, 12, 0, -11 },
  { 1584, 13, 16, 12, 0, -11 },
  { 1610, 12, 11, 12, 0, -11 },
  { 1627, 8, 20, 12, 3, -16 },
  { 1647, 4, 19, 12, 4, -15 },
  { 1657, 8, 20, 12, 2, -16 },
  { 1677, 12, 4, 12, 0, -8 },
};

const GFXfont RobotoMono_SemiBoldItalic21pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic21pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic21pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC21PT7B_H_
