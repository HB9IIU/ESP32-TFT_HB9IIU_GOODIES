#ifndef _ROBOTOMONO_SEMIBOLDITALIC40PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0xFC, 0x3F, 0x0F, 0xC1, 0xE0,
  0x78, 0x7B, 0xC3, 0xDE, 0x1C, 0xF1, 0xE7, 0x0F, 0x38, 0x7B, 0xC3, 0x9E,
  0x1C, 0xE0, 0xE7, 0x0F, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x1C, 0x3C, 0x00,
  0x1C, 0x38, 0x00, 0x3C, 0x38, 0x00, 0x38, 0x78, 0x00, 0x38, 0x70, 0x00,
  0x78, 0x70, 0x00, 0x70, 0xF1, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x01, 0xE1, 0xC0, 0x01, 0xE3, 0xC0, 0x01, 0xC3, 0x80, 0x03,
  0xC3, 0x80, 0x03, 0x87, 0x80, 0x03, 0x87, 0x00, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x0F, 0x0E, 0x00, 0x0E, 0x1E, 0x00, 0x0E,
  0x1C, 0x00, 0x1E, 0x1C, 0x00, 0x1C, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x3C,
  0x38, 0x00, 0x38, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0xFF, 0xFC, 0x0F, 0xE7, 0xF0, 0x7C, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x01,
  0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0,
  0x1F, 0x3E, 0x00, 0xF9, 0xF8, 0x0F, 0x87, 0xC0, 0xFC, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFC, 0x00,
  0x3F, 0xE0, 0x07, 0x9E, 0x00, 0x70, 0xE0, 0x87, 0x0E, 0x1E, 0x70, 0xE3,
  0xCF, 0x0E, 0x38, 0x71, 0xE7, 0x07, 0xBE, 0xF0, 0x7F, 0xCE, 0x03, 0xF9,
  0xC0, 0x06, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0xF8, 0x03, 0x9F, 0xE0, 0x7B, 0xFE, 0x0F, 0x78, 0xE0,
  0xE7, 0x8F, 0x1C, 0x70, 0xF3, 0xC7, 0x0F, 0x18, 0x70, 0xE0, 0x07, 0x0E,
  0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xE7, 0xC0, 0x1F, 0x0F,
  0x00, 0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x87, 0xC0, 0x1E, 0x3E, 0x00,
  0x79, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xFC, 0x1F, 0x3F, 0xF8, 0x7C, 0xFB, 0xE1, 0xE7, 0xC7, 0xC7,
  0xBF, 0x1F, 0xBE, 0xF8, 0x3F, 0xF3, 0xE0, 0xFF, 0xCF, 0x81, 0xFE, 0x3E,
  0x03, 0xF0, 0xFC, 0x1F, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x1F, 0xF1, 0xF0, 0x3D, 0xE7, 0x9E, 0x79, 0xC7, 0x3C, 0xF3, 0xC0,
  0x00, 0x08, 0x00, 0x60, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3C,
  0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x02, 0x00,
  0x02, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00,
  0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x00,
  0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x00, 0x40, 0x00,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x60, 0xE0, 0xDF, 0x1C, 0x7B, 0xFB, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xF0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x1E, 0x70, 0x07, 0xCF, 0x01,
  0xF0, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xE0, 0x60, 0x30, 0x00, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x1F, 0x1F, 0x1E, 0x1E, 0x3E, 0x3E, 0x3C, 0x7C,
  0x78, 0xF8, 0xF0, 0x20, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7D, 0xFB, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xC7, 0xE0,
  0xF8, 0x3E, 0x1F, 0x01, 0xE1, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F,
  0x3E, 0x03, 0xF3, 0xE0, 0xFF, 0x7C, 0x1F, 0xE7, 0xC7, 0xFE, 0x7C, 0xFB,
  0xE7, 0xDF, 0x3E, 0x7F, 0xC3, 0xE7, 0xF8, 0x3E, 0x7E, 0x03, 0xCF, 0xC0,
  0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0x78, 0x0F, 0x87, 0xC0, 0xF8, 0x7C,
  0x1F, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x00,
  0x00, 0x38, 0x0F, 0xC3, 0xFE, 0x7F, 0xFF, 0xFF, 0x7F, 0xFB, 0xE7, 0xDC,
  0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0x3F, 0x07,
  0xC0, 0xFC, 0x7E, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0xFE, 0x3F, 0x0F, 0xC0, 0xF8, 0x7C, 0x03, 0xE3, 0xE0, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x01,
  0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x7C, 0x01,
  0xF3, 0xE0, 0x1F, 0x9F, 0x00, 0xF8, 0x7C, 0x0F, 0xC3, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0xC0, 0x0F, 0xBC, 0x00, 0x7B, 0xE0, 0x07, 0x9F, 0x00, 0x7C,
  0xF8, 0x07, 0xC7, 0xC0, 0x7C, 0x3E, 0x03, 0xC1, 0xE0, 0x3C, 0x1F, 0x03,
  0xE0, 0xF8, 0x3E, 0x07, 0xC1, 0xE0, 0x3E, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF1, 0x80,
  0x07, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0x9F, 0xE0, 0x30,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x3E, 0x1F, 0x83,
  0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0x80, 0x0F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x81,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE7,
  0xC1, 0xF7, 0xFC, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xF1, 0xFF, 0xF8, 0x1F,
  0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3E, 0x7C, 0x1F, 0x9F, 0xFF, 0xC3, 0xFF,
  0xE0, 0x7F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x7E, 0x3F, 0x07, 0xE0, 0xF8, 0x3E, 0x03, 0xE1, 0xF0,
  0x1F, 0x0F, 0x00, 0xF8, 0x78, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x07, 0xC0,
  0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xDF,
  0xC1, 0xF8, 0x3E, 0x1F, 0x80, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E,
  0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0xF8, 0x7E, 0x0F, 0xC3, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xF8, 0x01,
  0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0x9F, 0x8F, 0x83, 0xF7, 0xC0,
  0x7D, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFD, 0xF8, 0xFF, 0x7F, 0xFF, 0x8F,
  0xFF, 0xE1, 0xFE, 0xF8, 0x1E, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x87, 0xF1, 0xFC, 0x7F, 0x1F, 0xC3, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x1F, 0x8F, 0xE3, 0xF8, 0xFE, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0xFE,
  0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01,
  0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0xE1,
  0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x03,
  0x80, 0x00, 0x20, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x7F,
  0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x18, 0x00, 0x07,
  0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x03, 0xFF, 0x03,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xE0, 0x00, 0xF0,
  0x00, 0x10, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF,
  0xF7, 0xF3, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0xF0, 0x1E, 0x07, 0x80, 0x38, 0x38, 0x00, 0x71, 0xE3,
  0xF1, 0xC7, 0x1F, 0xE7, 0x38, 0xFF, 0x9C, 0xE7, 0x8E, 0x77, 0x1C, 0x39,
  0xDC, 0xF0, 0xC7, 0x73, 0x87, 0x1F, 0x8E, 0x1C, 0x7E, 0x38, 0x71, 0xB9,
  0xE1, 0x8E, 0xE7, 0x8E, 0x3B, 0x9E, 0x38, 0xCE, 0x39, 0xE7, 0x38, 0xFF,
  0xF8, 0xE3, 0xFF, 0xE3, 0x87, 0x1E, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x7C, 0x08, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0x78, 0x00, 0x7D, 0xE0,
  0x01, 0xE7, 0x80, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x01, 0xF1, 0xF0, 0x07,
  0xC7, 0xC0, 0x3E, 0x0F, 0x00, 0xF8, 0x3C, 0x07, 0xC0, 0xF0, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3,
  0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x7E, 0x00, 0x79, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x1F, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x83, 0xFF, 0xFE, 0x0F, 0x80, 0xFC, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7,
  0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x03, 0xE1, 0xF0, 0x1F, 0x8F, 0x83,
  0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0x81, 0xFC,
  0x3E, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x1F, 0x00, 0x3C, 0x7C,
  0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x3F, 0x3E, 0x03, 0xF8, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x00, 0x3E, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFC, 0x7F, 0x0F, 0xC0,
  0xF8, 0xFC, 0x07, 0xE7, 0xC0, 0x1F, 0x7E, 0x00, 0xFB, 0xE0, 0x07, 0xDF,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x1F, 0x1F, 0x01, 0xF8,
  0x7C, 0x1F, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF,
  0xFC, 0x07, 0xC1, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0xC3, 0xE0, 0x1F,
  0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F,
  0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x3E, 0x00,
  0xFC, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x7E, 0x3E, 0x01, 0xF0,
  0xF8, 0x0F, 0xC7, 0xC0, 0x7E, 0x1F, 0x07, 0xF0, 0x7F, 0xFF, 0x81, 0xFF,
  0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF0, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0xFE, 0x7F, 0x0F, 0xC0, 0xF8, 0x7C, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00,
  0xFB, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x07, 0xFE, 0xF8, 0x3F, 0xF7, 0xC1, 0xFF,
  0x3E, 0x10, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0,
  0x1F, 0x9F, 0x80, 0xF8, 0x7C, 0x0F, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x3E,
  0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E,
  0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x00, 0x7C,
  0x1F, 0x00, 0x7C, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF0,
  0x3E, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x7C, 0x01, 0xF0,
  0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xE0,
  0x7C, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0x83,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0xFC, 0x1F,
  0x01, 0xF0, 0x3F, 0x07, 0xE0, 0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0x87, 0xC0, 0x3F, 0x03,
  0xE0, 0x3F, 0x81, 0xF0, 0x3F, 0x80, 0xF8, 0x3F, 0x80, 0xF8, 0x1F, 0x80,
  0x7C, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x1F, 0x1F, 0x80, 0x0F, 0x9F, 0x80,
  0x07, 0xDF, 0x80, 0x07, 0xDF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xBE, 0x00, 0x3F, 0x9F,
  0x80, 0x1F, 0x87, 0xC0, 0x0F, 0x83, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0,
  0x7E, 0x01, 0xF0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xE0, 0x7C,
  0x01, 0xF0, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0x7F, 0xFF, 0xE0, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0xFF, 0x07, 0xF0, 0xFE, 0x07, 0xF1, 0xFE, 0x0F, 0xF1, 0xFE, 0x0F, 0xF1,
  0xFE, 0x0F, 0x73, 0xFE, 0x0F, 0x73, 0xFE, 0x0F, 0x77, 0xBC, 0x1F, 0x77,
  0xBC, 0x1F, 0x7F, 0x3C, 0x1F, 0x7F, 0x7C, 0x1E, 0x7E, 0x7C, 0x1E, 0x7E,
  0x78, 0x1E, 0x3C, 0x78, 0x3E, 0x3C, 0x78, 0x3E, 0x38, 0xF8, 0x3E, 0x38,
  0xF8, 0x3E, 0x00, 0xF8, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x7C, 0x01,
  0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0x78, 0x01,
  0xE0, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x3F, 0x07, 0xE0, 0x3E, 0x07, 0xE0,
  0x3E, 0x07, 0xE0, 0x3E, 0x0F, 0xF0, 0x3E, 0x0F, 0xF0, 0x3E, 0x0F, 0xF0,
  0x7C, 0x0F, 0xF0, 0x7C, 0x0F, 0xF8, 0x7C, 0x0F, 0xF8, 0x7C, 0x1F, 0x78,
  0x7C, 0x1F, 0x78, 0xFC, 0x1F, 0x3C, 0xF8, 0x1F, 0x3C, 0xF8, 0x1F, 0x3C,
  0xF8, 0x1F, 0x3C, 0xF8, 0x3E, 0x1E, 0xF8, 0x3E, 0x1F, 0xF0, 0x3E, 0x1F,
  0xF0, 0x3E, 0x0F, 0xF0, 0x3E, 0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x7C, 0x0F,
  0xF0, 0x7C, 0x07, 0xE0, 0x7C, 0x07, 0xE0, 0x7C, 0x07, 0xE0, 0x7C, 0x07,
  0xE0, 0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0xFE, 0xFE, 0x0F, 0xC1, 0xF8, 0xFC, 0x07, 0xC7, 0xC0,
  0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x07, 0x9F, 0x00, 0x3E, 0xF8, 0x03, 0xEF,
  0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01,
  0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C,
  0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x01, 0xF0, 0x7C, 0x1F, 0x83, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xF8, 0x0F, 0xC1,
  0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E,
  0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x07, 0xE1, 0xF0, 0x1F, 0x87, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xF7, 0xF0, 0x3F, 0x07, 0xE1, 0xF8,
  0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x07,
  0xCF, 0x80, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F,
  0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00,
  0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x3E, 0x1F, 0x01, 0xF8,
  0x3E, 0x0F, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x0F, 0x80, 0xFC, 0x3E, 0x01, 0xF1, 0xF0, 0x07, 0xC7,
  0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80,
  0x7E, 0x3E, 0x03, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3F, 0x07, 0xC0, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07,
  0xE3, 0xE0, 0x1F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xF3, 0xF8, 0x3F,
  0x03, 0xF1, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0xC0, 0x1F,
  0x1F, 0x00, 0xFC, 0x7E, 0x07, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x03,
  0xFF, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x7C, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0,
  0x3E, 0x1E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x7C,
  0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C,
  0x01, 0xF1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0xF8, 0x03,
  0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3,
  0xE0, 0x1F, 0x0F, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0x7F, 0xFF, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0xFD, 0xF0, 0x03,
  0xE7, 0xC0, 0x1F, 0x9F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x0F, 0xC7,
  0xC0, 0x3E, 0x0F, 0x81, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x3F, 0x03, 0xE0,
  0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE3, 0xE0,
  0x07, 0x8F, 0x80, 0x1E, 0x3E, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0xF8, 0x78, 0x3F, 0xE1, 0xE1, 0xFF, 0x8F, 0x87, 0xFE, 0x3E, 0x1E, 0xF8,
  0xF8, 0xFB, 0xE3, 0xE3, 0xEF, 0x9F, 0x8F, 0x3C, 0x7E, 0x3C, 0xF1, 0xF9,
  0xF3, 0xCF, 0xE7, 0xCF, 0x3F, 0x9E, 0x3C, 0xEE, 0x78, 0xF7, 0xBB, 0xE3,
  0xDE, 0xEF, 0x0F, 0x73, 0xBC, 0x3D, 0xCF, 0xF0, 0xFF, 0x3F, 0xC3, 0xF8,
  0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x03, 0xF0, 0xFC,
  0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x0F,
  0x83, 0xE0, 0x3C, 0x0F, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x03, 0xF0,
  0x0F, 0x80, 0x7C, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x07, 0xE0, 0x03, 0xE0,
  0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0xF9, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF9, 0xF0,
  0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0xFC,
  0x0F, 0x80, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x01, 0xF8, 0x03, 0xE0,
  0x7E, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xE7, 0xC0, 0x3F,
  0x1F, 0x00, 0xF8, 0x7C, 0x07, 0xE1, 0xF0, 0x1F, 0x03, 0xE0, 0xF8, 0x0F,
  0x87, 0xE0, 0x3E, 0x1F, 0x00, 0x78, 0xFC, 0x01, 0xF3, 0xE0, 0x07, 0xDF,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3F, 0xE0,
  0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x00, 0xF8, 0x1E, 0x07, 0x81, 0xF0, 0x7C,
  0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x83, 0xE0, 0xF8, 0x1E, 0x07, 0x81,
  0xE0, 0x7C, 0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0xF8, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1F, 0x07, 0xC0, 0xF0, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC1, 0xFF, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x3F, 0xE0, 0xFF,
  0x83, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x03, 0xFC, 0x03, 0xBC, 0x07, 0xBC, 0x0F, 0x1C, 0x0F, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x3C, 0x1E, 0x7C, 0x0E, 0x78, 0x0F, 0xF8, 0x0F, 0x7F,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF1, 0xF1, 0xE1,
  0xE1, 0xC0, 0x00, 0x10, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1,
  0xFC, 0xFE, 0x3E, 0x07, 0xCF, 0xC0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x3F, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xF8, 0x3E, 0xFC, 0x0F, 0x9F,
  0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x83, 0xF9, 0xFF, 0xFF, 0x3F,
  0xFF, 0xE3, 0xFF, 0x7C, 0x3F, 0xCF, 0x80, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x04, 0x01, 0xF3, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE1, 0xF8, 0x3F, 0x1F, 0x01, 0xF3, 0xE0, 0x1F, 0x3E,
  0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x7C, 0x01, 0xF7,
  0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x07, 0xE7, 0xE0, 0xFC,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFB, 0xFF, 0x0F, 0x9F, 0xC0, 0x00, 0x30,
  0x00, 0x7F, 0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xFC, 0x7E, 0x0F,
  0x8F, 0x80, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xFF, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x3E,
  0xF8, 0x0F, 0x8F, 0x83, 0xF1, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x41, 0xF0, 0x1F, 0xE7, 0xC0, 0xFF, 0xDF, 0x07, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C,
  0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07,
  0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xE0, 0xF8, 0x0F, 0x83,
  0xF0, 0x7E, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F,
  0x3C, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1,
  0xFF, 0xFC, 0x7E, 0x0F, 0xCF, 0x80, 0xFB, 0xE0, 0x1F, 0x7C, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x03, 0x0F, 0xC0, 0xF1, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFE, 0x08, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x07, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x0F, 0xF7, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xC1,
  0xF8, 0xFC, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF3, 0xE0, 0x0F, 0x9F,
  0x00, 0x7C, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F,
  0x8F, 0x80, 0x7C, 0x7C, 0x07, 0xE1, 0xF0, 0x7E, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xF3, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x20, 0x1F, 0x83, 0x81, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x1F, 0x04, 0x01, 0xF3, 0xF8, 0x1F, 0x7F, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF1, 0xF8, 0x3F, 0x3F, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0,
  0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x7C, 0x01, 0xE7, 0xC0, 0x3E, 0x7C,
  0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0x80, 0x3E, 0xF8, 0x07, 0xCF,
  0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x5F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x01, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80,
  0x0E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x07, 0xF1, 0xF0, 0x3F, 0x07, 0xC1, 0xF8,
  0x1F, 0x0F, 0xC0, 0x7C, 0x7E, 0x01, 0xE3, 0xF0, 0x0F, 0x9F, 0x80, 0x3E,
  0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xFC,
  0x01, 0xFD, 0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0x0F, 0xC0, 0x7C, 0x1F, 0x01,
  0xF0, 0x7E, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xF0, 0xF8, 0x07, 0xC3, 0xE0,
  0x1F, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x00, 0x08,
  0x10, 0x1E, 0xFC, 0xF8, 0x3F, 0xFB, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xE3, 0xE3, 0xE3, 0xC7, 0xC7, 0x87, 0x8F, 0x8F, 0x0F, 0x1E, 0x1E, 0x3E,
  0x3C, 0x7C, 0x7C, 0xF8, 0xF8, 0xF9, 0xF1, 0xF1, 0xE3, 0xE3, 0xC3, 0xC7,
  0x87, 0x87, 0x8F, 0x0F, 0x1F, 0x1E, 0x3E, 0x3E, 0x7C, 0x7C, 0x7C, 0xF8,
  0xF8, 0xF1, 0xF1, 0xE1, 0xE3, 0xC3, 0xC3, 0xC7, 0x87, 0x8F, 0x9F, 0x1F,
  0x1F, 0x00, 0x00, 0x06, 0x01, 0xF3, 0xFC, 0x1F, 0x7F, 0xE1, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF1, 0xF8, 0x3F, 0x3F, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01,
  0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x7C, 0x03, 0xE7, 0xC0,
  0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0x80, 0x3E, 0xF8,
  0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0x00, 0x20, 0x00,
  0x7F, 0xC0, 0x1F, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x7E, 0x0F, 0x9F,
  0x80, 0xFB, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8,
  0x0F, 0xCF, 0x83, 0xF1, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0x00, 0x1F, 0x7F, 0x80, 0x7F, 0xFF, 0x01, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0xC3, 0xE0, 0x1F,
  0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x1F,
  0x00, 0x7C, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x01,
  0xF0, 0x7E, 0x0F, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3E, 0xFF, 0xC0,
  0xF9, 0xFC, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x7F, 0x9F, 0x0F, 0xFD, 0xF1, 0xFF, 0xFF, 0x3F,
  0xFF, 0xE3, 0xF0, 0x7E, 0x7E, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xEF,
  0x80, 0x3E, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C,
  0xF8, 0x07, 0xCF, 0x80, 0x78, 0xF8, 0x0F, 0x8F, 0xC1, 0xF8, 0x7F, 0xFF,
  0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFC, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x02, 0x03, 0xE7, 0xFC, 0x7D, 0xFF, 0x0F,
  0x7F, 0xE1, 0xFF, 0xFC, 0x7F, 0xF7, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x7F, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xF8, 0xFE, 0x7C, 0x07, 0xCF,
  0x80, 0xF9, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF7, 0x80, 0x3E, 0xF8,
  0x07, 0xDF, 0x01, 0xFB, 0xF8, 0xFE, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x1F,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x02, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xC0,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x07,
  0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3,
  0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E,
  0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xC7, 0xC0, 0x7C, 0xF8, 0x07,
  0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0xC0, 0xFC, 0x7C, 0x1F, 0x87, 0xFF,
  0xF8, 0x7F, 0xF7, 0x83, 0xFE, 0xF8, 0x1F, 0xCF, 0x80, 0xF8, 0x01, 0xFF,
  0x80, 0x3E, 0x78, 0x03, 0xE7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0xF8,
  0x7C, 0x0F, 0x83, 0xC1, 0xF0, 0x3C, 0x1F, 0x03, 0xE1, 0xE0, 0x3E, 0x3E,
  0x01, 0xE3, 0xC0, 0x1E, 0x7C, 0x01, 0xE7, 0x80, 0x1E, 0xF8, 0x01, 0xEF,
  0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x78, 0x7F, 0xE1, 0xE1, 0xFF, 0x8F, 0x87, 0xBE, 0x3E,
  0x3E, 0xF8, 0xF8, 0xF3, 0xC7, 0xE3, 0xCF, 0x1F, 0x8F, 0x3C, 0x7E, 0x78,
  0xF3, 0xB9, 0xE3, 0xCE, 0xE7, 0x8F, 0x3B, 0xBC, 0x3D, 0xCE, 0xF0, 0xF7,
  0x3B, 0xC3, 0xFC, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFC, 0x3F,
  0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x00,
  0x0F, 0x80, 0x7F, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x07, 0xE1, 0xF8,
  0x03, 0xE3, 0xF0, 0x01, 0xF7, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xEF, 0x80, 0x0F, 0xCF, 0x80,
  0x0F, 0x87, 0xC0, 0x1F, 0x07, 0xE0, 0x3F, 0x03, 0xE0, 0x7E, 0x03, 0xF0,
  0xFC, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x8F, 0x80, 0x1F, 0x87, 0xE0, 0x0F,
  0x81, 0xF0, 0x0F, 0xC0, 0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x07,
  0xE0, 0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xF0, 0x03, 0xE1, 0xF0, 0x00, 0xF1,
  0xF0, 0x00, 0x78, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x00, 0x00, 0x0E, 0x00,
  0x7C, 0x01, 0xF8, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x81, 0xFE, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x30, 0x00, 0x03, 0x83, 0xC1,
  0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x78, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x78, 0x3C,
  0x1C, 0x00, 0x03, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x1F, 0xE0, 0x7E, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x1C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x80, 0x73, 0xFF, 0x03, 0xDF, 0xFE,
  0x0F, 0x78, 0xFF, 0xFB, 0xC0, 0xFF, 0xEF, 0x01, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0x80,
};

const GFXglyph RobotoMono_SemiBoldItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 10, 28, 23, 7, -28 },
  { 36, 13, 10, 23, 7, -30 },
  { 53, 24, 28, 23, 0, -28 },
  { 137, 21, 37, 23, 2, -33 },
  { 235, 20, 29, 23, 2, -29 },
  { 308, 22, 29, 23, 1, -29 },
  { 388, 6, 10, 23, 10, -30 },
  { 396, 14, 41, 23, 6, -32 },
  { 468, 14, 41, 23, 3, -32 },
  { 540, 19, 19, 23, 3, -28 },
  { 586, 20, 21, 23, 2, -24 },
  { 639, 8, 13, 23, 4, -5 },
  { 652, 16, 5, 23, 5, -15 },
  { 662, 7, 6, 23, 7, -6 },
  { 668, 20, 30, 23, 2, -28 },
  { 743, 20, 29, 23, 2, -29 },
  { 816, 13, 28, 23, 5, -28 },
  { 862, 21, 29, 23, 0, -29 },
  { 939, 21, 29, 23, 1, -29 },
  { 1016, 21, 28, 23, 0, -28 },
  { 1090, 21, 28, 23, 2, -28 },
  { 1164, 18, 29, 23, 2, -29 },
  { 1230, 20, 28, 23, 3, -28 },
  { 1300, 21, 29, 23, 1, -29 },
  { 1377, 18, 29, 23, 3, -29 },
  { 1443, 10, 22, 23, 7, -22 },
  { 1471, 13, 30, 23, 5, -22 },
  { 1520, 18, 19, 23, 3, -22 },
  { 1563, 20, 12, 23, 2, -18 },
  { 1593, 19, 18, 23, 2, -21 },
  { 1636, 17, 29, 23, 5, -29 },
  { 1698, 22, 28, 23, 1, -28 },
  { 1775, 22, 28, 23, -1, -28 },
  { 1852, 22, 28, 23, 1, -28 },
  { 1929, 21, 29, 23, 2, -29 },
  { 2006, 22, 28, 23, 0, -28 },
  { 2083, 23, 28, 23, 1, -28 },
  { 2164, 23, 28, 23, 1, -28 },
  { 2245, 21, 29, 23, 2, -29 },
  { 2322, 24, 28, 23, 0, -28 },
  { 2406, 21, 28, 23, 2, -28 },
  { 2480, 23, 28, 23, 1, -28 },
  { 2561, 25, 28, 23, 1, -28 },
  { 2649, 19, 28, 23, 1, -28 },
  { 2716, 24, 28, 23, 0, -28 },
  { 2800, 24, 28, 23, 0, -28 },
  { 2884, 21, 29, 23, 2, -29 },
  { 2961, 23, 28, 23, 1, -28 },
  { 3042, 22, 34, 23, 1, -29 },
  { 3136, 22, 28, 23, 1, -28 },
  { 3213, 22, 29, 23, 1, -29 },
  { 3293, 23, 28, 23, 3, -28 },
  { 3374, 22, 28, 23, 2, -28 },
  { 3451, 22, 28, 23, 3, -28 },
  { 3528, 22, 28, 23, 3, -28 },
  { 3605, 27, 28, 23, -1, -28 },
  { 3700, 22, 28, 23, 4, -28 },
  { 3777, 24, 28, 23, 0, -28 },
  { 3861, 14, 39, 23, 5, -33 },
  { 3930, 10, 30, 23, 7, -28 },
  { 3968, 14, 39, 23, 5, -33 },
  { 4037, 16, 15, 23, 4, -28 },
  { 4067, 18, 4, 23, 0, 0 },
  { 4076, 7, 6, 23, 11, -29 },
  { 4082, 19, 22, 23, 1, -22 },
  { 4135, 20, 30, 23, 1, -30 },
  { 4210, 19, 22, 23, 2, -22 },
  { 4263, 22, 30, 23, 2, -30 },
  { 4346, 19, 22, 23, 2, -22 },
  { 4399, 22, 31, 23, 3, -31 },
  { 4485, 21, 30, 23, 1, -22 },
  { 4564, 20, 30, 23, 1, -30 },
  { 4639, 18, 29, 23, 2, -29 },
  { 4705, 18, 38, 23, 1, -29 },
  { 4791, 22, 30, 23, 1, -30 },
  { 4874, 18, 30, 23, 2, -30 },
  { 4942, 23, 22, 23, -1, -22 },
  { 5006, 20, 22, 23, 1, -22 },
  { 5061, 19, 22, 23, 2, -22 },
  { 5114, 22, 30, 23, -1, -22 },
  { 5197, 20, 30, 23, 2, -22 },
  { 5272, 19, 22, 23, 4, -22 },
  { 5325, 19, 22, 23, 2, -22 },
  { 5378, 19, 26, 23, 3, -26 },
  { 5440, 20, 21, 23, 2, -21 },
  { 5493, 20, 21, 23, 3, -21 },
  { 5546, 22, 21, 23, 2, -21 },
  { 5604, 24, 21, 23, 0, -21 },
  { 5667, 25, 30, 23, 0, -21 },
  { 5761, 21, 21, 23, 1, -21 },
  { 5817, 15, 38, 23, 6, -31 },
  { 5889, 9, 36, 23, 7, -28 },
  { 5930, 15, 38, 23, 4, -31 },
  { 6002, 22, 9, 23, 0, -16 },
};

const GFXfont RobotoMono_SemiBoldItalic40pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic40pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic40pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC40PT7B_H_
