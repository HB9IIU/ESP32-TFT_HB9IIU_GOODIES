#ifndef _ROBOTOMONO_SEMIBOLDITALIC66PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x7F, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0x7E, 0x00, 0x08,
  0x00, 0x1F, 0x81, 0xFC, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E,
  0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0xFC, 0x3F,
  0x03, 0xF0, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xF8, 0x7E, 0x03,
  0xE1, 0xF0, 0x1F, 0x87, 0xC0, 0x7E, 0x1F, 0x01, 0xF8, 0xFC, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00,
  0x1F, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xC7, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x03, 0xFE,
  0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xF0, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0x7F, 0x81, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x04, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01,
  0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x1F,
  0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x20, 0x7E, 0x0F, 0xC0,
  0x70, 0xFC, 0x0F, 0xC0, 0x7C, 0xFC, 0x0F, 0xC0, 0xF8, 0xFC, 0x0F, 0xC1,
  0xF8, 0xFC, 0x0F, 0xC3, 0xF0, 0xFC, 0x0F, 0xC3, 0xE0, 0xFC, 0x0F, 0x87,
  0xE0, 0xFC, 0x1F, 0x8F, 0xC0, 0xFE, 0x3F, 0x8F, 0x80, 0x7F, 0xFF, 0x1F,
  0x00, 0x7F, 0xFF, 0x3F, 0x00, 0x3F, 0xFE, 0x3E, 0x00, 0x1F, 0xF8, 0x7C,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x07,
  0xE0, 0x00, 0x3E, 0x3F, 0xF8, 0x00, 0x7E, 0x7F, 0xFC, 0x00, 0xFC, 0xFF,
  0xFC, 0x00, 0xF8, 0xFF, 0xFE, 0x01, 0xF9, 0xFC, 0x7E, 0x03, 0xF1, 0xF8,
  0x3F, 0x03, 0xE3, 0xF0, 0x3F, 0x07, 0xC3, 0xF0, 0x3F, 0x0F, 0xC3, 0xF0,
  0x3F, 0x1F, 0x83, 0xF0, 0x3F, 0x1F, 0x03, 0xE0, 0x3F, 0x07, 0x03, 0xE0,
  0x3E, 0x02, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF8,
  0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x80,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00,
  0xFF, 0x0F, 0xF8, 0x00, 0x03, 0xF9, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xC0, 0xFF, 0xFE,
  0x01, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xE0, 0xFF, 0xFF, 0xC0, 0x7F, 0x0F,
  0xF9, 0xFF, 0x03, 0xF8, 0xFF, 0x87, 0xFC, 0x3F, 0xC7, 0xFC, 0x1F, 0xE1,
  0xFC, 0x7F, 0xC0, 0xFF, 0x9F, 0xE3, 0xFC, 0x03, 0xFD, 0xFE, 0x1F, 0xE0,
  0x1F, 0xFF, 0xF1, 0xFF, 0x00, 0x7F, 0xFF, 0x0F, 0xF8, 0x03, 0xFF, 0xF8,
  0x7F, 0xC0, 0x0F, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xF0, 0x01,
  0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x7F, 0xC0, 0x1F, 0xFF, 0xE3, 0xFE, 0x00, 0x3F,
  0xFC, 0x0F, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0x8F, 0xC7,
  0xE3, 0xF3, 0xF9, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xF8, 0x7C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x18,
  0x01, 0xF0, 0x06, 0x1E, 0x01, 0xF0, 0x1E, 0x3F, 0x81, 0xE0, 0x7E, 0x3F,
  0xE1, 0xE3, 0xFF, 0x7F, 0xFB, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7E, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x03,
  0xF8, 0x7E, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x1F,
  0xE0, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x07,
  0x00, 0x1F, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0,
  0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0x07, 0x00, 0x08, 0x00, 0x7F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0x06, 0x03, 0xFC,
  0x7F, 0xE7, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xE7, 0xFC,
  0x3F, 0x80, 0x60, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x07, 0xFC,
  0x03, 0xFC, 0x03, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF8, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF,
  0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0xFF,
  0x3F, 0xC0, 0x03, 0xFF, 0x3F, 0xC0, 0x07, 0xFF, 0x3F, 0xC0, 0x1F, 0xFF,
  0x3F, 0xC0, 0x3F, 0xFE, 0x3F, 0xC0, 0xFF, 0xFE, 0x7F, 0xC1, 0xFF, 0xFE,
  0x7F, 0x87, 0xFD, 0xFE, 0x7F, 0x8F, 0xF1, 0xFE, 0x7F, 0xBF, 0xE3, 0xFE,
  0x7F, 0xFF, 0x83, 0xFC, 0x7F, 0xFF, 0x03, 0xFC, 0x7F, 0xFE, 0x03, 0xFC,
  0xFF, 0xF8, 0x03, 0xFC, 0xFF, 0xF0, 0x03, 0xFC, 0xFF, 0xC0, 0x03, 0xFC,
  0xFF, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0,
  0x7F, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xE0, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x3F, 0xE3, 0xFC, 0xFC, 0x0F, 0xF3, 0xC0, 0x3F, 0xC8, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xF0, 0x7F,
  0x80, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x0F, 0xF8,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x0F, 0xFE, 0x03, 0xFE,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x1F,
  0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x03,
  0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00,
  0x3F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x1F, 0xC7,
  0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x03, 0xFC,
  0x3F, 0xC0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x03,
  0xF8, 0x07, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xE0, 0x03, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0xF8, 0x00, 0x00, 0xFE, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xE0,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xF0, 0x1F,
  0xE0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xF0,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x3F, 0xCF, 0xFF, 0x00, 0xFF, 0x3F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFC, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x0F, 0xF9,
  0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0xFF,
  0x00, 0x03, 0xFD, 0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xF7, 0xFC,
  0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFF, 0x1F, 0xF0,
  0x07, 0xFC, 0x1F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x0F,
  0xFE, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xE0, 0x3F, 0xE0,
  0x07, 0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x1F, 0xF0,
  0x07, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xF8,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x01, 0xFE, 0x1F,
  0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF8,
  0x7F, 0x80, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xE3, 0xFE, 0x00,
  0x7F, 0x9F, 0xF0, 0x00, 0xFE, 0x7F, 0xC0, 0x03, 0xFD, 0xFE, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0x9F, 0xE0,
  0x03, 0xFE, 0x7F, 0xC0, 0x1F, 0xF9, 0xFF, 0x81, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFE, 0xFF, 0x00, 0xFF, 0xE7, 0xF8, 0x00, 0x7C, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x30, 0x01, 0xFC,
  0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x07, 0xFF,
  0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFC, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0,
  0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xC0, 0x3F, 0x80,
  0x0C, 0x00, 0x00, 0x02, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x08, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x06, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0x0F, 0xFE, 0x7F, 0xE0, 0x1F, 0xFB,
  0xFE, 0x00, 0x7F, 0xDF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3C,
  0x07, 0xE0, 0x7F, 0xE1, 0xF0, 0x7E, 0x0F, 0xFF, 0x8F, 0x83, 0xE0, 0xFF,
  0xFC, 0x7C, 0x3F, 0x0F, 0xFF, 0xE3, 0xE1, 0xF0, 0xFE, 0x1F, 0x1F, 0x1F,
  0x87, 0xE0, 0xF0, 0xF8, 0xF8, 0x7E, 0x07, 0x87, 0xC7, 0xC3, 0xE0, 0x7C,
  0x3E, 0x7C, 0x3F, 0x03, 0xE1, 0xF3, 0xE1, 0xF0, 0x1E, 0x0F, 0x9F, 0x0F,
  0x80, 0xF0, 0x7D, 0xF8, 0xFC, 0x0F, 0x83, 0xCF, 0x87, 0xC0, 0x7C, 0x1E,
  0x7C, 0x3E, 0x03, 0xE0, 0xF3, 0xE1, 0xF0, 0x1E, 0x0F, 0x9F, 0x0F, 0x81,
  0xF0, 0x78, 0xF8, 0x7C, 0x0F, 0x83, 0xC7, 0xC3, 0xE0, 0x7C, 0x1E, 0x3C,
  0x1F, 0x07, 0xC1, 0xE3, 0xE0, 0xF8, 0x3E, 0x0F, 0x1F, 0x07, 0xC3, 0xF0,
  0xF0, 0x7C, 0x3F, 0xFF, 0xDF, 0x83, 0xE1, 0xFF, 0xFF, 0xF8, 0x1F, 0x07,
  0xFD, 0xFF, 0x80, 0xF8, 0x3F, 0xC7, 0xF8, 0x07, 0xC0, 0x78, 0x1F, 0x80,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x70, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x00, 0x7F, 0xBF, 0x80, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x3F, 0xCF,
  0xE0, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x00,
  0xFF, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x83, 0xF8,
  0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x03, 0xFC,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x83,
  0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00,
  0x7F, 0x8F, 0xF8, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x1F, 0xE7, 0xFC,
  0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0,
  0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x01, 0xFF,
  0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xC1, 0xFF, 0x00,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07,
  0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFE,
  0x1F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xF8, 0x3F,
  0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x03, 0xFE,
  0x3F, 0xC0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00,
  0xFF, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF8,
  0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x07,
  0xF8, 0x1F, 0xE0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0,
  0x1F, 0xF8, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xE0,
  0x3F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x01, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFF, 0x07,
  0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x01, 0xFE, 0x1F,
  0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0xC3, 0xFE, 0x00,
  0x07, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x0F, 0xF8, 0x3F,
  0xC0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x1F, 0xFC, 0x07, 0xF8, 0x07,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0x07, 0xF9, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xFF, 0x9F, 0xF0, 0x0F,
  0xFF, 0xF3, 0xFC, 0x01, 0xFF, 0xFE, 0x7F, 0x80, 0x7F, 0xFF, 0xCF, 0xF0,
  0x0F, 0xFF, 0xF1, 0xFE, 0x01, 0xFF, 0xFE, 0x3F, 0xC0, 0x3F, 0xFF, 0xC7,
  0xF8, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x3F,
  0xE3, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0x80,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0xC0,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x3F, 0xE0, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x3F,
  0xC0, 0x00, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x3F, 0xE0,
  0x3F, 0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xC1, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x7F, 0xE0, 0x00, 0x01, 0xFE,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x9F, 0xF8, 0x00, 0x00, 0x1F, 0xEF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x7F, 0xC0,
  0x00, 0x07, 0xFF, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0x80, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x1F,
  0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x07,
  0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xFF, 0x87, 0xFF, 0xE0, 0x1F, 0xFF, 0x0F,
  0xDF, 0xC0, 0x3F, 0xFE, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x7F, 0xFE, 0x01,
  0xFE, 0xF8, 0xFD, 0xFC, 0x03, 0xFD, 0xF3, 0xFB, 0xF8, 0x07, 0xF3, 0xE7,
  0xE7, 0xF0, 0x0F, 0xE7, 0xDF, 0xDF, 0xE0, 0x1F, 0xCF, 0xFF, 0x3F, 0xC0,
  0x7F, 0x9F, 0xFE, 0x7F, 0x00, 0xFF, 0x3F, 0xF8, 0xFE, 0x01, 0xFE, 0x7F,
  0xF1, 0xFC, 0x03, 0xF8, 0xFF, 0xC7, 0xF8, 0x07, 0xF1, 0xFF, 0x8F, 0xF0,
  0x0F, 0xE1, 0xFE, 0x1F, 0xC0, 0x3F, 0xC3, 0xFC, 0x3F, 0x80, 0x7F, 0x87,
  0xF0, 0x7F, 0x00, 0xFF, 0x0F, 0xE1, 0xFE, 0x01, 0xFC, 0x1F, 0x83, 0xFC,
  0x03, 0xF8, 0x3F, 0x07, 0xF8, 0x07, 0xF0, 0x7C, 0x0F, 0xE0, 0x1F, 0xE0,
  0xF8, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x01, 0xFE,
  0x01, 0xFF, 0x80, 0x07, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xFC,
  0x00, 0x7F, 0x80, 0xFF, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xF0,
  0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xF8,
  0x03, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xC0,
  0x7F, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xF8, 0x07, 0xFB, 0xF0,
  0x1F, 0xE0, 0x1F, 0xEF, 0xC0, 0x7F, 0x80, 0x7F, 0xBF, 0x83, 0xFE, 0x03,
  0xFE, 0xFE, 0x0F, 0xF8, 0x0F, 0xF1, 0xF8, 0x3F, 0xC0, 0x3F, 0xC7, 0xF0,
  0xFF, 0x00, 0xFF, 0x1F, 0xC3, 0xFC, 0x03, 0xFC, 0x7F, 0x0F, 0xF0, 0x0F,
  0xF0, 0xFC, 0x7F, 0xC0, 0x7F, 0xC3, 0xF9, 0xFE, 0x01, 0xFE, 0x0F, 0xE7,
  0xF8, 0x07, 0xF8, 0x1F, 0x9F, 0xE0, 0x1F, 0xE0, 0x7E, 0x7F, 0x80, 0x7F,
  0x81, 0xFF, 0xFE, 0x03, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xFF,
  0xC0, 0x3F, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFC,
  0x03, 0xFF, 0xF0, 0x0F, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xFF,
  0x01, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xE0,
  0x03, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xF8,
  0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x00,
  0x07, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xBF, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xF8,
  0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x0F,
  0xF1, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0x3F, 0xC0, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x03, 0xFD, 0xFE, 0x00,
  0x00, 0xFF, 0x7F, 0x80, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x07, 0xFD, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xBF,
  0xE0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00,
  0x7F, 0xCF, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x00,
  0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF8, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xF0,
  0x1F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xFC, 0x1F,
  0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x07, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0xE0,
  0x3F, 0xC0, 0x1F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xF0, 0x18, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x3F, 0xE0, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0xC0,
  0x03, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x1F, 0xE3, 0xFE, 0x00,
  0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x01, 0xFE, 0x3F,
  0xC0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0x03, 0xFC, 0x7F, 0x80, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x03, 0xFC, 0x7F,
  0x80, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x87, 0xF8, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F,
  0xC0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8,
  0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0xFE, 0x01, 0xFE, 0x00,
  0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x03, 0xFE, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x07, 0xFC,
  0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0x80, 0x07, 0xFE, 0x07, 0xFC, 0x00,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xF0,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x03, 0xFC, 0x03, 0xFE, 0x00,
  0x1F, 0xE0, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x1F,
  0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x7F, 0x80, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xE0,
  0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFE, 0x1F, 0xFE, 0x03, 0xFF,
  0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x8F,
  0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x0F,
  0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xE0,
  0x03, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x00, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFF, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x07, 0xF8, 0x3F,
  0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xFC, 0x00,
  0x0F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x7F,
  0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE,
  0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x3F, 0xC0, 0xFF, 0x80, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x7F,
  0x80, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xF8,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x03, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x07, 0xFC, 0xFF,
  0x80, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x00, 0xFF,
  0x87, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFF, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x7F,
  0xC0, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x0F,
  0xE3, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x00, 0xFF, 0x7F, 0x80, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0xFE, 0x03, 0xFD, 0xFE, 0x03, 0xF8, 0x0F, 0xF7, 0xF8,
  0x0F, 0xC0, 0x3F, 0x9F, 0xE0, 0x7F, 0x01, 0xFE, 0x7F, 0x81, 0xFC, 0x07,
  0xF9, 0xFE, 0x07, 0xF0, 0x1F, 0xC7, 0xF8, 0x3F, 0xC0, 0x7F, 0x1F, 0xE0,
  0xFF, 0x03, 0xFC, 0x7F, 0x83, 0xFC, 0x0F, 0xF1, 0xFE, 0x0F, 0xF0, 0x3F,
  0x87, 0xF0, 0x7F, 0xC1, 0xFE, 0x1F, 0xC1, 0xFF, 0x07, 0xF8, 0x7F, 0x07,
  0xFC, 0x1F, 0xC1, 0xFC, 0x3F, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0xC3, 0xFC,
  0x1F, 0xC3, 0xFF, 0x0F, 0xF0, 0x7F, 0x1F, 0xFC, 0x3F, 0x81, 0xFC, 0x7F,
  0xF0, 0xFE, 0x07, 0xF1, 0xFF, 0xC7, 0xF8, 0x1F, 0xC7, 0xDF, 0x1F, 0xC0,
  0x7F, 0x3F, 0x7C, 0x7F, 0x01, 0xFC, 0xFD, 0xF3, 0xFC, 0x07, 0xF3, 0xE7,
  0xCF, 0xF0, 0x1F, 0xDF, 0x9F, 0x3F, 0x80, 0x7F, 0x7E, 0x7C, 0xFE, 0x01,
  0xFD, 0xF1, 0xF7, 0xF8, 0x07, 0xFF, 0xC7, 0xDF, 0xC0, 0x1F, 0xFF, 0x1F,
  0x7F, 0x00, 0x7F, 0xFC, 0x7D, 0xFC, 0x01, 0xFF, 0xE1, 0xFF, 0xF0, 0x07,
  0xFF, 0x87, 0xFF, 0x80, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x7F,
  0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x1F,
  0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x81, 0xFF,
  0x80, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x7F, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0x81, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC7,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xCF, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x0F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xE0, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFB, 0xFC, 0x00, 0x01,
  0xFF, 0x9F, 0xE0, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0xC7, 0xFC,
  0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x3F,
  0xC3, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0xE0, 0x00, 0x07, 0xF9, 0xFE, 0x00,
  0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x3F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x07,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xEF, 0xE0, 0x03, 0xF1, 0xF8, 0x01,
  0xFC, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x87, 0xE0, 0x1F, 0xC0, 0xFC,
  0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x7F, 0x00,
  0xFE, 0x1F, 0xC0, 0x1F, 0x8F, 0xE0, 0x07, 0xE7, 0xF0, 0x01, 0xF9, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x0F, 0xF8,
  0x7F, 0x83, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F,
  0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xF8, 0x03, 0xFC, 0x3F,
  0xE0, 0x03, 0xFC, 0x7F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0xFF,
  0x80, 0x07, 0xFC, 0xFF, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF,
  0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x3F, 0xF8, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF7, 0xF8, 0x0F, 0xFF, 0xC7, 0xF8, 0x03, 0xFF, 0x07, 0xF8, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x20, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x03,
  0xFC, 0xFF, 0xF8, 0x00, 0xFF, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xF1, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x07, 0xF8, 0x3F, 0xC0,
  0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x1F, 0xF0, 0xFF,
  0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFE,
  0x1F, 0xE0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFE, 0x0F, 0xF8, 0x00,
  0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFE,
  0xFF, 0xFF, 0x80, 0x7F, 0x1F, 0xFF, 0x80, 0x3F, 0xC1, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x0F, 0xFC,
  0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE,
  0x3F, 0xE0, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0xFE,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF8,
  0x7F, 0x80, 0x07, 0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F, 0xF0,
  0x3F, 0xF0, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x87, 0xF8, 0x00, 0x7F, 0xFC, 0x7F,
  0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xF1, 0xFF, 0xF0, 0x1F,
  0xF8, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x0F, 0xF8,
  0x07, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x0F,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0xFF, 0x00, 0x07, 0xFF, 0xCF, 0xF0,
  0x00, 0x3F, 0xF0, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFE, 0x1F, 0xF8,
  0x01, 0xFE, 0x1F, 0xF0, 0x00, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0,
  0x00, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x40, 0x7F, 0xC0,
  0x01, 0xE0, 0x3F, 0xE0, 0x03, 0xF0, 0x3F, 0xF8, 0x1F, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xF0,
  0x02, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0x00, 0x1F, 0xFF, 0x8F, 0xE0,
  0x03, 0xFF, 0xFD, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFC, 0x3F, 0xFE, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xC0,
  0xFF, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x07,
  0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xE0,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xE0,
  0x01, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC1, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xF3, 0xFC, 0x00,
  0x07, 0xFE, 0x3F, 0xC0, 0x00, 0x0F, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x80, 0x00, 0xFF, 0x80, 0x1C, 0x00,
  0x1F, 0xF0, 0x03, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x10, 0x00, 0x0F,
  0xF0, 0x7F, 0xC0, 0x03, 0xFC, 0x7F, 0xFC, 0x00, 0xFF, 0x3F, 0xFF, 0x80,
  0x3F, 0xDF, 0xFF, 0xF0, 0x0F, 0xEF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xF8, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x01,
  0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x80,
  0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x01, 0xFE, 0x1F,
  0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF8,
  0x7F, 0x80, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x1F, 0xE1, 0xFF, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xF8,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07,
  0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xE0, 0x07, 0xFF, 0x00, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xE0,
  0x03, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0x07,
  0xFE, 0x00, 0x07, 0xF8, 0x7F, 0xE0, 0x00, 0x3F, 0xC7, 0xFE, 0x00, 0x03,
  0xFE, 0x7F, 0xE0, 0x00, 0x1F, 0xE7, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xCF,
  0xF8, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07,
  0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xF8,
  0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xF0,
  0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x03, 0xFF, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x10, 0x01, 0x00, 0x0F, 0xE3, 0xF8, 0x3F, 0x80, 0x3F, 0xBF, 0xF3,
  0xFF, 0x00, 0xFE, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0x3F, 0xF9,
  0xFF, 0x07, 0xF8, 0x7F, 0xC3, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x07, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0x03,
  0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xF8,
  0x1F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x1F,
  0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFF,
  0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07,
  0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF8,
  0x7F, 0x83, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x3F,
  0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC1,
  0xFC, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFC,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0x00, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x3F,
  0x87, 0xFF, 0xC0, 0x0F, 0xE3, 0xFF, 0xF8, 0x03, 0xFB, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x0F, 0xFE,
  0x07, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x07,
  0xFC, 0x1F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0x7F, 0x87, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF8, 0x7F,
  0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFE, 0x1F, 0xE0,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x07, 0xFE, 0x1F,
  0xF0, 0x03, 0xFE, 0x3F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x3F,
  0xC0, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0xFF,
  0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFE, 0xFF,
  0x00, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x07, 0xF8, 0x7F,
  0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xF0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xF1, 0xFF, 0x80,
  0x00, 0xFF, 0x3F, 0xFE, 0x00, 0x0F, 0xEF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x03, 0xFE,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFE, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x3F,
  0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE,
  0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x7F,
  0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xFC,
  0x0F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xFC, 0x01,
  0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0xFF, 0xFF, 0x00,
  0x1F, 0xE7, 0xFF, 0xE0, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x3C,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x1F, 0xC0, 0x1F, 0xFF, 0x8F, 0xE0, 0x3F, 0xFF, 0xEF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x0F, 0xF8, 0x00,
  0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x3F, 0xE3, 0xFC, 0x00,
  0x1F, 0xE3, 0xFE, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0xE0,
  0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF,
  0x80, 0x07, 0xF8, 0x7F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x0F,
  0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xF7, 0xF8, 0x01, 0xFF, 0xF3, 0xFC, 0x00, 0x7F, 0xF3, 0xFC,
  0x00, 0x03, 0xC1, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x07,
  0xF8, 0x3F, 0xFC, 0x0F, 0xE1, 0xFF, 0xF8, 0x1F, 0xC7, 0xFF, 0xF0, 0x7F,
  0x9F, 0xFF, 0xC0, 0xFF, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x10, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFC, 0x03, 0xFE, 0x0F,
  0xF0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFF,
  0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x07, 0xF8, 0x7F,
  0xC0, 0x1F, 0xF8, 0x7F, 0xFD, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x07, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x7F,
  0xC7, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x03,
  0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x3F, 0xE3, 0xFC, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFF, 0x1F, 0xE0,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF8, 0x7F,
  0x80, 0x07, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFE, 0x07,
  0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xDF, 0xC0, 0x1F, 0xFF, 0xCF, 0xE0, 0x07, 0xFF, 0xC7, 0xF0,
  0x01, 0xFF, 0x87, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x0F, 0xF1, 0xFE, 0x00,
  0x07, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x87, 0xF8,
  0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0x80, 0x07, 0xF8, 0x0F,
  0xF0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x03, 0xF8, 0x1F,
  0xC0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE1,
  0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00,
  0x3F, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x01, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0x00, 0xFE, 0xFE,
  0x03, 0xF0, 0x0F, 0xEF, 0xE0, 0x3F, 0x01, 0xFE, 0xFE, 0x07, 0xF0, 0x1F,
  0xCF, 0xE0, 0x7F, 0x01, 0xFC, 0xFE, 0x07, 0xF0, 0x3F, 0xCF, 0xE0, 0xFF,
  0x03, 0xF8, 0xFE, 0x0F, 0xF0, 0x3F, 0x8F, 0xE1, 0xFF, 0x87, 0xF0, 0xFE,
  0x1F, 0xF8, 0x7F, 0x0F, 0xE1, 0xFF, 0x87, 0xF0, 0xFE, 0x3E, 0xF8, 0xFE,
  0x0F, 0xC3, 0xEF, 0x8F, 0xE0, 0xFC, 0x3E, 0xF8, 0xFE, 0x0F, 0xC7, 0xCF,
  0x8F, 0xC0, 0xFC, 0x7C, 0xF9, 0xFC, 0x0F, 0xC7, 0xCF, 0x9F, 0xC0, 0xFC,
  0xF8, 0xF9, 0xF8, 0x0F, 0xCF, 0x8F, 0xBF, 0x80, 0xFD, 0xF8, 0xFB, 0xF8,
  0x0F, 0xDF, 0x0F, 0xBF, 0x00, 0xFD, 0xF0, 0xFF, 0xF0, 0x0F, 0xFE, 0x0F,
  0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF,
  0xC0, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xF0, 0x0F,
  0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x03, 0xFC, 0x00,
  0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xF0,
  0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0xC0, 0x00, 0x3F, 0xE1, 0xFF, 0x00,
  0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xCF, 0xF0, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x3F,
  0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0x83, 0xFC, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x00,
  0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0x80, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00,
  0x00, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x02, 0x7F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x0E, 0x43, 0xFF, 0xF8, 0x00,
  0x7C, 0x3F, 0xFF, 0xE0, 0x07, 0xE3, 0xFF, 0xFF, 0x80, 0x3F, 0x1F, 0xFF,
  0xFE, 0x03, 0xF9, 0xFF, 0xFF, 0xFC, 0x7F, 0x8F, 0xE0, 0x7F, 0xFF, 0xFC,
  0x7E, 0x00, 0xFF, 0xFF, 0xE3, 0xF0, 0x03, 0xFF, 0xFE, 0x3F, 0x00, 0x0F,
  0xFF, 0xE0, 0x38, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00,
};

const GFXglyph RobotoMono_SemiBoldItalic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 39, 0, -1 },
  { 1, 16, 48, 39, 12, -47 },
  { 97, 22, 17, 39, 11, -50 },
  { 144, 39, 47, 39, 0, -47 },
  { 374, 35, 61, 39, 3, -54 },
  { 641, 32, 49, 39, 4, -48 },
  { 837, 37, 49, 39, 1, -48 },
  { 1064, 9, 18, 39, 17, -50 },
  { 1085, 22, 67, 39, 10, -52 },
  { 1270, 23, 67, 39, 5, -52 },
  { 1463, 32, 33, 39, 5, -47 },
  { 1595, 33, 34, 39, 3, -39 },
  { 1736, 14, 21, 39, 6, -8 },
  { 1773, 27, 7, 39, 8, -24 },
  { 1797, 12, 12, 39, 11, -11 },
  { 1815, 34, 51, 39, 3, -47 },
  { 2032, 32, 49, 39, 4, -48 },
  { 2228, 22, 47, 39, 8, -47 },
  { 2358, 35, 48, 39, 0, -48 },
  { 2568, 34, 49, 39, 2, -48 },
  { 2777, 34, 47, 39, 1, -47 },
  { 2977, 35, 48, 39, 3, -47 },
  { 3187, 31, 48, 39, 3, -47 },
  { 3373, 35, 47, 39, 4, -47 },
  { 3579, 34, 49, 39, 2, -48 },
  { 3788, 30, 48, 39, 5, -48 },
  { 3968, 16, 39, 39, 12, -38 },
  { 4046, 20, 51, 39, 9, -38 },
  { 4174, 30, 31, 39, 5, -36 },
  { 4291, 33, 20, 39, 3, -30 },
  { 4374, 31, 30, 39, 3, -35 },
  { 4491, 29, 48, 39, 8, -48 },
  { 4665, 37, 47, 39, 1, -47 },
  { 4883, 37, 47, 39, -2, -47 },
  { 5101, 37, 47, 39, 1, -47 },
  { 5319, 35, 49, 39, 3, -48 },
  { 5534, 36, 47, 39, 1, -47 },
  { 5746, 39, 47, 39, 1, -47 },
  { 5976, 38, 47, 39, 2, -47 },
  { 6200, 35, 49, 39, 3, -48 },
  { 6415, 38, 47, 39, 1, -47 },
  { 6639, 34, 47, 39, 3, -47 },
  { 6839, 37, 48, 39, 2, -47 },
  { 7061, 42, 47, 39, 1, -47 },
  { 7308, 31, 47, 39, 2, -47 },
  { 7491, 39, 47, 39, 1, -47 },
  { 7721, 38, 47, 39, 1, -47 },
  { 7945, 34, 49, 39, 3, -48 },
  { 8154, 37, 47, 39, 2, -47 },
  { 8372, 36, 56, 39, 2, -48 },
  { 8624, 37, 47, 39, 1, -47 },
  { 8842, 36, 49, 39, 2, -48 },
  { 9063, 37, 47, 39, 5, -47 },
  { 9281, 36, 48, 39, 3, -47 },
  { 9497, 36, 47, 39, 6, -47 },
  { 9709, 38, 47, 39, 4, -47 },
  { 9933, 44, 47, 39, -2, -47 },
  { 10192, 37, 47, 39, 6, -47 },
  { 10410, 39, 47, 39, 0, -47 },
  { 10640, 24, 65, 39, 8, -54 },
  { 10835, 16, 51, 39, 12, -47 },
  { 10937, 24, 65, 39, 8, -54 },
  { 11132, 26, 25, 39, 7, -47 },
  { 11214, 30, 7, 39, 0, 0 },
  { 11241, 12, 9, 39, 18, -48 },
  { 11255, 32, 37, 39, 2, -36 },
  { 11403, 34, 51, 39, 1, -50 },
  { 11620, 32, 37, 39, 3, -36 },
  { 11768, 36, 51, 39, 3, -50 },
  { 11998, 32, 37, 39, 3, -36 },
  { 12146, 35, 51, 39, 6, -51 },
  { 12370, 36, 50, 39, 1, -36 },
  { 12595, 34, 50, 39, 1, -50 },
  { 12808, 29, 48, 39, 3, -48 },
  { 12982, 31, 62, 39, 1, -48 },
  { 13223, 37, 50, 39, 1, -50 },
  { 13455, 30, 50, 39, 3, -50 },
  { 13643, 38, 36, 39, -1, -36 },
  { 13814, 34, 36, 39, 1, -36 },
  { 13967, 32, 37, 39, 3, -36 },
  { 14115, 36, 49, 39, -1, -36 },
  { 14336, 33, 49, 39, 3, -36 },
  { 14539, 31, 36, 39, 6, -36 },
  { 14679, 32, 37, 39, 3, -36 },
  { 14827, 30, 44, 39, 6, -43 },
  { 14992, 33, 36, 39, 4, -35 },
  { 15141, 34, 35, 39, 5, -35 },
  { 15290, 36, 35, 39, 4, -35 },
  { 15448, 39, 35, 39, 0, -35 },
  { 15619, 41, 49, 39, 0, -35 },
  { 15871, 36, 35, 39, 1, -35 },
  { 16029, 26, 64, 39, 9, -52 },
  { 16237, 14, 60, 39, 12, -47 },
  { 16342, 26, 63, 39, 6, -51 },
  { 16547, 37, 14, 39, 0, -26 },
};

const GFXfont RobotoMono_SemiBoldItalic66pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic66pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic66pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC66PT7B_H_
