#ifndef _ROBOTOMONO_SEMIBOLDITALIC52PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x0F, 0xC0, 0xFE, 0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x07,
  0xC0, 0x00, 0x3E, 0x0F, 0x9F, 0x07, 0x8F, 0x07, 0xCF, 0x83, 0xE7, 0xC1,
  0xF3, 0xE0, 0xF9, 0xF0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x1F, 0x3E,
  0x0F, 0x9E, 0x07, 0x8F, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x03,
  0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x3C,
  0x1F, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x7C, 0x1E,
  0x08, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x7C, 0x1E, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xE0, 0x00,
  0x0F, 0x07, 0xC0, 0x00, 0x1E, 0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0xF0,
  0x7C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x0F, 0x07,
  0xC0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x7C,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xC1, 0xFE,
  0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xE0, 0x7E,
  0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8,
  0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x1F, 0xF0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xE1, 0xE0,
  0x41, 0xE0, 0xF0, 0x39, 0xF0, 0x78, 0x3E, 0xF8, 0x3C, 0x3E, 0x7C, 0x1E,
  0x1E, 0x3E, 0x0F, 0x1E, 0x1F, 0x0F, 0x9F, 0x07, 0xCF, 0x8F, 0x03, 0xFF,
  0xCF, 0x00, 0xFF, 0xCF, 0x80, 0x3F, 0xCF, 0x80, 0x07, 0x87, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xE1, 0xE0, 0x01, 0xE3, 0xFC, 0x01, 0xE7, 0xFF,
  0x01, 0xF3, 0xFF, 0x80, 0xF3, 0xE3, 0xE0, 0xF1, 0xE1, 0xF0, 0xF9, 0xF0,
  0x78, 0x78, 0xF8, 0x3C, 0x78, 0x7C, 0x1E, 0x7C, 0x3C, 0x1F, 0x04, 0x1F,
  0x0F, 0x80, 0x0F, 0x87, 0x80, 0x07, 0xE7, 0xC0, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x07,
  0xE0, 0x01, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x0F, 0xC0,
  0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x1F,
  0x87, 0xFF, 0xC0, 0xF8, 0x7F, 0xFE, 0x07, 0xC7, 0xF3, 0xF8, 0x7E, 0x7F,
  0x8F, 0xE3, 0xF3, 0xF8, 0x7F, 0x3F, 0x1F, 0x81, 0xFD, 0xF9, 0xFC, 0x0F,
  0xFF, 0xCF, 0xE0, 0x3F, 0xFC, 0x7F, 0x00, 0xFF, 0xC3, 0xF8, 0x07, 0xFE,
  0x1F, 0xC0, 0x1F, 0xE0, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xF9, 0xFC, 0x03, 0xFF,
  0x0F, 0xF0, 0x01, 0x80, 0x00, 0x00, 0x3E, 0x7C, 0xF9, 0xF7, 0xCF, 0x9F,
  0x3E, 0x7C, 0xF1, 0xE7, 0xCF, 0x80, 0x00, 0x01, 0x80, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x60, 0x1E, 0x02, 0x3C, 0x1E, 0x07, 0xBF, 0x8F,
  0x1F, 0xDF, 0xF7, 0xBF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x01, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xF7, 0xC0, 0x01, 0xF9, 0xF0, 0x01, 0xF8, 0xF8, 0x01, 0xF8, 0x3E, 0x01,
  0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0xC0, 0x3C, 0x03, 0xC0, 0x0C, 0x01, 0xC0,
  0x02, 0x00, 0x40, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3F,
  0x07, 0xE1, 0xF8, 0x1E, 0x00, 0x80, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0x3F, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x08, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xC0, 0x7F, 0x0F,
  0xC0, 0x1F, 0x8F, 0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF3,
  0xF8, 0x01, 0xF9, 0xF8, 0x01, 0xFC, 0xFC, 0x01, 0xFE, 0x7E, 0x03, 0xFF,
  0x3F, 0x03, 0xFF, 0xBF, 0x87, 0xFF, 0xDF, 0xC7, 0xFF, 0xEF, 0xC7, 0xE7,
  0xE7, 0xEF, 0xE3, 0xF3, 0xFF, 0xC1, 0xF9, 0xFF, 0xC1, 0xFD, 0xFF, 0x80,
  0xFE, 0xFF, 0x80, 0x7F, 0x7F, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80,
  0x0F, 0xCF, 0xC0, 0x0F, 0xE7, 0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xF0, 0xFC,
  0x03, 0xF0, 0x7F, 0x07, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x01, 0xE0, 0x03, 0xF8, 0x07, 0xFE, 0x0F, 0xFF, 0x8F,
  0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFC, 0x7F, 0xBF, 0x1F, 0x0F, 0xCE, 0x03,
  0xF2, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0x07, 0xF8,
  0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x07, 0xE1, 0xFC, 0x00, 0xFC, 0x3F, 0x00,
  0x1F, 0x87, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFE, 0x07, 0xF8, 0x3F, 0x80, 0x7F,
  0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC,
  0x00, 0x7E, 0x1F, 0x80, 0x1F, 0xC3, 0xF8, 0x07, 0xF8, 0x7F, 0x81, 0xFE,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0xFC, 0xFC,
  0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0xC0, 0x0F, 0xC7, 0xF0, 0x07, 0xE1,
  0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x3F,
  0x03, 0xF8, 0x1F, 0x80, 0xFE, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC1,
  0xF8, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFD, 0xFE, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x1F, 0xC0, 0xFF, 0x00, 0x38, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xF0,
  0xFE, 0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF8,
  0x3F, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x30, 0x00, 0xFC, 0xFF, 0x80, 0xFE, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xF0, 0x3F, 0xCF, 0xF0,
  0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC,
  0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF,
  0xC0, 0x0F, 0xE7, 0xE0, 0x07, 0xF3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8,
  0x7F, 0x07, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x7F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xA0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0,
  0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F,
  0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0xC3, 0xF0, 0x07, 0xE0, 0xFE, 0x03, 0xF8,
  0x1F, 0xC1, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xFC,
  0x0F, 0xE0, 0xFE, 0x01, 0xF8, 0x7F, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xCF,
  0xE0, 0x03, 0xF3, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F,
  0xCF, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0x7F, 0x83, 0xFE, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x1F, 0xC1, 0xFC, 0x3F, 0x80, 0xFE, 0x7F, 0x00, 0x7E, 0x7F, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0x87, 0xFE, 0x7F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFD, 0xFC, 0x03, 0xF1, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0x3F, 0x83, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xC0,
  0xFC, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x81,
  0xFE, 0x0F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0xFF, 0x03, 0xF0, 0x04,
  0x00, 0x00, 0x7C, 0x00, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F,
  0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x78, 0x00, 0x10, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F,
  0xFE, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x10, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x08,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xF0, 0x7F, 0xBF, 0x80,
  0x7F, 0x7F, 0x00, 0xFF, 0xFC, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x7E, 0x00, 0xFC,
  0x00, 0xF0, 0x0F, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x07, 0x81, 0xF8,
  0x70, 0x7C, 0x3F, 0xE3, 0xC3, 0xC3, 0xFF, 0x9E, 0x3C, 0x3F, 0xF8, 0xF1,
  0xE3, 0xE1, 0xC7, 0x9E, 0x1E, 0x1E, 0x3C, 0xF1, 0xE0, 0xF1, 0xE7, 0x8F,
  0x07, 0x8F, 0x78, 0xF8, 0x38, 0x7B, 0xC7, 0x83, 0xC3, 0x9E, 0x3C, 0x1E,
  0x1C, 0xF1, 0xE0, 0xF0, 0xEF, 0x1F, 0x07, 0x0F, 0x78, 0xF0, 0x78, 0x7B,
  0xC7, 0x83, 0xC3, 0x9E, 0x3C, 0x1E, 0x3C, 0xF1, 0xF1, 0xF1, 0xC7, 0x87,
  0xFF, 0x9E, 0x3C, 0x3F, 0xFF, 0xE1, 0xE1, 0xFC, 0xFE, 0x07, 0x87, 0xC3,
  0xE0, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E,
  0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x87, 0xC0, 0x01, 0xF8, 0x3F,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00,
  0x7E, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xC3,
  0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0xFE, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xF8, 0x3F, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0,
  0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x03,
  0xF8, 0x3F, 0x00, 0x3F, 0x83, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x07, 0xF0, 0x01,
  0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF8,
  0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xF8,
  0x01, 0xFF, 0x0F, 0xC0, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x07, 0xF8,
  0x1F, 0xC0, 0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xE1, 0xFC, 0x00, 0x7E,
  0x1F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF3, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xCF,
  0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x87, 0xE0, 0x03, 0xF0, 0x7E, 0x00,
  0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80,
  0x7F, 0x1F, 0xF8, 0x07, 0xE0, 0x3F, 0xC0, 0x7E, 0x01, 0xFE, 0x07, 0xE0,
  0x0F, 0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F,
  0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xFC,
  0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xF8, 0x00, 0x7F, 0x1F, 0x80, 0x07,
  0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x07, 0xE3, 0xF8, 0x00, 0x7E, 0x3F,
  0x80, 0x0F, 0xE3, 0xF0, 0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x01,
  0xFC, 0x7F, 0x00, 0x1F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x07,
  0xE0, 0x0F, 0xF0, 0x7E, 0x03, 0xFE, 0x07, 0xE1, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0,
  0x07, 0xE1, 0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x07, 0xF1, 0xF8, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x3F, 0xFC, 0x7E, 0x03, 0xFF, 0xCF, 0xE0, 0x7F, 0xFC, 0xFE,
  0x07, 0xFF, 0xCF, 0xE0, 0x7F, 0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01,
  0xF8, 0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x87,
  0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x1F,
  0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x80, 0xFC,
  0x00, 0x7F, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x01, 0xF8, 0x0F, 0xE0,
  0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0x7E, 0x00,
  0x3F, 0x80, 0xFC, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x00, 0xFC,
  0x07, 0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x0F, 0xC0,
  0x7F, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03,
  0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x3F,
  0x80, 0x0F, 0xC0, 0x7F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0xFE, 0x03, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x08, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x07,
  0xF0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x80,
  0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0xFF, 0x81, 0xF8, 0x00, 0xFF, 0x80, 0xFC, 0x00, 0x7F, 0x80, 0x7E,
  0x00, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x1F,
  0xC0, 0x7F, 0x80, 0x0F, 0xC0, 0x7F, 0x80, 0x07, 0xE0, 0x7F, 0x80, 0x03,
  0xF0, 0x7F, 0x80, 0x03, 0xF8, 0x7F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x00,
  0xFC, 0x3F, 0xC0, 0x00, 0x7E, 0x3F, 0xC0, 0x00, 0x3F, 0x3F, 0xC0, 0x00,
  0x3F, 0xBF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xDF, 0xC0, 0x00, 0x7F, 0xC7, 0xF0,
  0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xC0, 0x7F,
  0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x07,
  0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xF0, 0x1F, 0xC0,
  0x03, 0xF8, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F,
  0xC0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xE1, 0xFF, 0x81, 0xFF, 0x87, 0xFE, 0x07, 0xFE, 0x3F,
  0xF8, 0x3F, 0xF8, 0xFF, 0xE0, 0xFF, 0xE7, 0xDF, 0x03, 0xFF, 0x9F, 0x7C,
  0x0F, 0xDE, 0xFB, 0xF0, 0x3E, 0x7B, 0xEF, 0xC1, 0xF9, 0xFF, 0x3F, 0x07,
  0xE7, 0xFC, 0xFC, 0x1F, 0x9F, 0xE3, 0xE0, 0x7E, 0x7F, 0x9F, 0x81, 0xF9,
  0xFC, 0x7E, 0x07, 0xE7, 0xF1, 0xF8, 0x3F, 0x1F, 0xC7, 0xE0, 0xFC, 0x3E,
  0x1F, 0x83, 0xF0, 0xF8, 0xFC, 0x0F, 0xC3, 0xC3, 0xF0, 0x3F, 0x0F, 0x0F,
  0xC0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0,
  0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F,
  0x80, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x0F, 0xC0,
  0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0xFE, 0x03, 0xF8, 0x01, 0xF8, 0x0F, 0xF0, 0x03, 0xF0, 0x1F, 0xE0,
  0x07, 0xE0, 0x3F, 0xC0, 0x1F, 0xC0, 0x7F, 0xC0, 0x3F, 0x80, 0xFF, 0x80,
  0x7F, 0x01, 0xFF, 0x00, 0xFC, 0x07, 0xFF, 0x01, 0xF8, 0x0F, 0xFE, 0x07,
  0xF0, 0x1F, 0xFC, 0x0F, 0xE0, 0x3F, 0xF8, 0x1F, 0xC0, 0x7F, 0xF8, 0x3F,
  0x00, 0xFD, 0xF0, 0x7E, 0x03, 0xFB, 0xE0, 0xFC, 0x07, 0xF7, 0xC3, 0xF8,
  0x0F, 0xEF, 0xC7, 0xF0, 0x1F, 0x8F, 0x8F, 0xE0, 0x3F, 0x1F, 0x1F, 0x80,
  0x7E, 0x3E, 0x3F, 0x01, 0xFC, 0x3E, 0x7E, 0x03, 0xF8, 0x7D, 0xFC, 0x07,
  0xF0, 0xFB, 0xF8, 0x0F, 0xC1, 0xF7, 0xF0, 0x1F, 0x81, 0xFF, 0xC0, 0x7F,
  0x03, 0xFF, 0x80, 0xFE, 0x07, 0xFF, 0x01, 0xFC, 0x0F, 0xFE, 0x03, 0xF0,
  0x0F, 0xFC, 0x07, 0xE0, 0x1F, 0xF8, 0x0F, 0xC0, 0x3F, 0xE0, 0x3F, 0x80,
  0x7F, 0xC0, 0x7F, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0xFF, 0x01, 0xF8, 0x01,
  0xFE, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x7F, 0x80,
  0xFE, 0x0F, 0xE0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x1F, 0x9F,
  0xC0, 0x03, 0xF3, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x01,
  0xFB, 0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFD, 0xF8,
  0x00, 0x3F, 0xBF, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xBF, 0x80, 0x03, 0xF7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xDF, 0xC0,
  0x03, 0xFB, 0xF8, 0x00, 0x7E, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF0,
  0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0x3F, 0x83,
  0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x7F, 0xC0, 0x3F, 0x00, 0x7F,
  0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0,
  0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xF8, 0x3F,
  0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xF0, 0x01, 0xFC, 0x0F, 0xC0,
  0x0F, 0xF0, 0x3F, 0x00, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x0F, 0xE0, 0x0F,
  0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x3F,
  0x80, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE7, 0xF0, 0x00,
  0x7E, 0x7F, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0xFE, 0x7E, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00,
  0x0F, 0xCF, 0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xFC,
  0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0,
  0x03, 0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x83, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xF8, 0x1F,
  0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x03, 0xF8,
  0x3F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE,
  0x00, 0x3F, 0x87, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0xC1, 0xF8, 0x01,
  0xFE, 0x1F, 0xC0, 0x1F, 0xE0, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xF0, 0x3F, 0x00, 0x3F, 0x01, 0xFC, 0x01, 0xF8, 0x0F,
  0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0,
  0x3F, 0x80, 0x3F, 0x01, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0x7E,
  0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00,
  0x7F, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x0F, 0xE0,
  0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x03, 0xF1, 0xFC, 0x00, 0x3F,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x1F, 0xCF,
  0xC0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xF0, 0x07, 0xF8, 0x7F, 0x80,
  0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x08, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0xC1, 0xF8, 0x00,
  0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8,
  0x3F, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xE0, 0xFE,
  0x00, 0x3F, 0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0xC1, 0xF8, 0x00,
  0xFE, 0x0F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x07, 0xF0, 0x01, 0xF8,
  0x3F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xF0, 0x7E,
  0x00, 0x3F, 0x87, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xC1, 0xFC, 0x00,
  0x7E, 0x0F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x83, 0xF0, 0x01, 0xFC,
  0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xF0, 0x3F,
  0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFB,
  0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xFC, 0xFE, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x07,
  0xF0, 0x3F, 0x00, 0x3F, 0x81, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0xC0,
  0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE,
  0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x1F,
  0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xF8, 0x7F, 0x00,
  0x0F, 0xE3, 0xF0, 0x00, 0x3F, 0x3F, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x0F,
  0xDF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x07, 0xC0, 0xFD, 0xF8, 0x1F, 0x03, 0xF7, 0xE0, 0xFC, 0x1F, 0x9F, 0x83,
  0xF0, 0x7E, 0x7E, 0x0F, 0xC1, 0xF9, 0xF8, 0x7F, 0x07, 0xC7, 0xE1, 0xFC,
  0x3F, 0x1F, 0x87, 0xF0, 0xFC, 0x7E, 0x1F, 0xC3, 0xF1, 0xF8, 0xFF, 0x1F,
  0x87, 0xE3, 0xFC, 0x7E, 0x1F, 0x8F, 0xF1, 0xF8, 0x7E, 0x7F, 0xC7, 0xC1,
  0xF9, 0xFF, 0x3F, 0x07, 0xE7, 0xFC, 0xFC, 0x1F, 0x3F, 0xF3, 0xF0, 0x7C,
  0xFF, 0xCF, 0x81, 0xF3, 0xDF, 0x7E, 0x07, 0xCF, 0x7D, 0xF8, 0x1F, 0x7D,
  0xF7, 0xC0, 0x7D, 0xE7, 0xFF, 0x01, 0xF7, 0x9F, 0xFC, 0x07, 0xFE, 0x7F,
  0xF0, 0x1F, 0xF9, 0xFF, 0x80, 0x7F, 0xC7, 0xFE, 0x01, 0xFF, 0x1F, 0xF8,
  0x07, 0xFC, 0x7F, 0xC0, 0x1F, 0xE1, 0xFF, 0x00, 0x7F, 0x87, 0xFC, 0x01,
  0xFE, 0x1F, 0xF0, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0xFF,
  0x07, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x0F, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F,
  0x80, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03, 0xF0,
  0xFE, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00,
  0xFD, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xBF, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x80,
  0x7F, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0x9F, 0x80, 0x03, 0xF8, 0xFE,
  0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC0, 0xFC, 0x01,
  0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x00, 0xFC, 0x07, 0xF0,
  0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x07,
  0xE3, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x10, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x07,
  0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x03, 0xE7, 0x80, 0x7E, 0x7C, 0x07, 0xC7, 0xC0, 0xFC,
  0x7C, 0x0F, 0x87, 0xC1, 0xF0, 0x3C, 0x1F, 0x03, 0xE3, 0xE0, 0x3E, 0x7E,
  0x03, 0xE7, 0xC0, 0x3E, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFE, 0x1F, 0x87, 0xF0, 0xFC, 0x1F, 0x03, 0xE0, 0xFC, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0xFF, 0x07, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0x80,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xC0, 0xFC, 0x7F,
  0x80, 0x7E, 0x7F, 0x00, 0x3F, 0x3F, 0x80, 0x1F, 0x9F, 0x80, 0x1F, 0xCF,
  0xC0, 0x0F, 0xE7, 0xE0, 0x0F, 0xE3, 0xF8, 0x1F, 0xF1, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0x3F, 0x01, 0xFF, 0x1F,
  0xC0, 0x18, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xEF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFC, 0xFF, 0x83,
  0xFC, 0x0F, 0xF0, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x0F,
  0xC7, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80,
  0x0F, 0xCF, 0xE0, 0x03, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F,
  0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE,
  0x7F, 0x80, 0x7F, 0x1F, 0xF0, 0x7F, 0xC7, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0x3F, 0xFC, 0x0F, 0xC3, 0xFE, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0xF3, 0xFE, 0x3F, 0xC0, 0x7F, 0x3F,
  0x80, 0x7F, 0x7F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0xFC, 0xFE, 0x00, 0xFC, 0xFE, 0x01, 0xFC, 0x7F, 0x03, 0xF8, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7E, 0x1F,
  0xC0, 0x1F, 0xFC, 0xFC, 0x01, 0xFF, 0xF7, 0xE0, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0xF9, 0xFF, 0xC0, 0xFF, 0x03, 0xFE, 0x07, 0xF0,
  0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x1F,
  0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x03,
  0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0xFE, 0x0F, 0xE0,
  0x07, 0xF0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x7E, 0x00, 0x1F,
  0xF3, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xFE,
  0x3F, 0xC1, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0x8F,
  0xE0, 0x07, 0xE7, 0xF0, 0x00, 0xFD, 0xFC, 0x00, 0x7F, 0x7F, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x08, 0x1F, 0xE0, 0x0F, 0x03, 0xFC, 0x07, 0xC0, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0x06, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x08, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x82, 0x00, 0x07, 0xFE, 0x3F, 0x01, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xC7, 0xFE, 0x0F, 0xF0,
  0x1F, 0xE0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0xFC,
  0x3F, 0x80, 0x0F, 0xC3, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0xC3, 0xF0,
  0x01, 0xFC, 0x3F, 0x00, 0x1F, 0xC3, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F,
  0x87, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x83, 0xF0, 0x03, 0xF8, 0x3F,
  0x80, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x7E, 0x00,
  0x3F, 0xE7, 0xE0, 0x00, 0x20, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x10, 0x00,
  0xFE, 0x03, 0x00, 0x1F, 0xC0, 0x78, 0x03, 0xFC, 0x0F, 0xF1, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x7E,
  0x7F, 0xE0, 0x1F, 0xDF, 0xFE, 0x03, 0xF7, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x0F, 0xFE, 0xFF, 0xC1, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x0F, 0xE0,
  0x07, 0xE1, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0,
  0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE, 0x00,
  0x7F, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x1F,
  0xC0, 0x07, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xC0, 0x07,
  0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x8F, 0xE0, 0x07, 0xF1, 0xFC,
  0x00, 0xFE, 0x3F, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x41, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x10, 0x7E, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0x3F, 0x80, 0xFF,
  0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xC0, 0xFF, 0x00, 0x7E, 0x1F, 0xF0, 0x03,
  0xF1, 0xFF, 0x00, 0x3F, 0x9F, 0xF0, 0x01, 0xFD, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x03,
  0xFE, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFC, 0x1F, 0xE0, 0x0F, 0xE0,
  0x7F, 0x00, 0x7F, 0x03, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F,
  0x80, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0x00, 0xE7, 0xC1, 0xE0, 0x1F, 0x3F, 0x9F, 0xC0, 0x7D, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xDF, 0xF7, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x7E,
  0x0F, 0x83, 0xF1, 0xF8, 0x7E, 0x0F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x8F, 0xC1, 0xF0,
  0x7E, 0x3F, 0x0F, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0xC3, 0xF1, 0xF8, 0x3E, 0x0F, 0xC7,
  0xE1, 0xF8, 0x3E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xC1, 0xF8, 0x7E, 0x3F, 0x07, 0xC1, 0xF8, 0x00, 0xE1,
  0xF8, 0x00, 0xF8, 0xFF, 0xC0, 0x3F, 0x3F, 0xFC, 0x07, 0xEF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFC, 0x1F, 0xF9, 0xFF, 0x83, 0xFC, 0x07, 0xF0, 0x7F, 0x00,
  0xFE, 0x1F, 0xC0, 0x0F, 0xC3, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F,
  0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x8F, 0xE0, 0x07,
  0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC,
  0x00, 0x7E, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7F,
  0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x1F, 0xC0,
  0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x03, 0xFE, 0x7F, 0xC1, 0xFE, 0x07, 0xF8, 0xFF, 0x00, 0xFE, 0x3F,
  0x80, 0x1F, 0x8F, 0xC0, 0x07, 0xE7, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0x7E,
  0x7E, 0x00, 0x1F, 0xBF, 0x80, 0x07, 0xEF, 0xE0, 0x01, 0xFB, 0xF8, 0x00,
  0x7E, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xF3, 0xF8,
  0x01, 0xFC, 0x7E, 0x00, 0x7F, 0x1F, 0xC0, 0x3F, 0x87, 0xF8, 0x1F, 0xC0,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0xFC, 0x00,
  0x1F, 0xBF, 0xF0, 0x03, 0xF7, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x3F, 0xF3, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x7F,
  0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x07, 0xF0, 0x03, 0xF0, 0x7E,
  0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0xE0, 0x03,
  0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7E, 0x0F,
  0xC0, 0x07, 0xE0, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC1, 0xFE, 0x01,
  0xFC, 0x1F, 0xF0, 0x7F, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x3F, 0xBF, 0xFC, 0x03, 0xF9, 0xFF, 0x00, 0x3F, 0x81,
  0x80, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x20, 0x3F, 0xF8, 0xF8, 0x0F, 0xFF, 0xBF, 0x03,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xF1, 0xFF, 0x87, 0xF8, 0x0F,
  0xF0, 0xFE, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0x87, 0xE0, 0x03, 0xF1, 0xFC,
  0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0x7E,
  0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7F, 0x1F, 0xC0,
  0x0F, 0xE1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0,
  0xFE, 0x01, 0xFC, 0x1F, 0xE0, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFB, 0xF0, 0x03, 0xFE, 0x7E, 0x00,
  0x04, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x0F, 0xC3, 0xFF, 0x0F, 0xCF, 0xFF, 0x0F, 0xDF,
  0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xF8, 0x1F, 0xE1, 0xFC, 0x01, 0xF8,
  0x7E, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0xC7, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x80, 0x1F,
  0xC7, 0xF0, 0x0F, 0xE1, 0xFF, 0x0F, 0xF8, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x81, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF8, 0x08, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x1F, 0x80, 0x1F,
  0xC7, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x80,
  0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0xFE, 0x7F,
  0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xC7, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xFC,
  0x7E, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xE3, 0xF8, 0x01,
  0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8,
  0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x3F, 0xC1, 0xFF, 0x07, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFE, 0xFC, 0x07, 0xFF, 0x3E, 0x00, 0xFF, 0x1F,
  0x80, 0x02, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xE0,
  0x01, 0xF9, 0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0xC7,
  0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x7F,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x1F, 0x03, 0xF0, 0x07, 0xC1,
  0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x03,
  0xE3, 0xE0, 0x00, 0xF9, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x0F, 0x03, 0xFF, 0xC1, 0xF0, 0x3F, 0xFC, 0x1F, 0x03, 0xEF, 0xC3, 0xF0,
  0x7E, 0xF8, 0x3F, 0x07, 0xEF, 0x83, 0xF0, 0x7C, 0xF8, 0x7F, 0x0F, 0xCF,
  0x87, 0xF0, 0xFC, 0xF8, 0x7F, 0x0F, 0x8F, 0x8F, 0xF1, 0xF8, 0xF8, 0xF7,
  0x1F, 0x8F, 0x9F, 0x71, 0xF0, 0xF9, 0xE7, 0x3F, 0x0F, 0x9E, 0x73, 0xE0,
  0xFB, 0xC7, 0x3E, 0x0F, 0xBC, 0x73, 0xE0, 0xFB, 0xC7, 0x7C, 0x0F, 0xF8,
  0x77, 0xC0, 0xFF, 0x87, 0x7C, 0x0F, 0xF8, 0x7F, 0x80, 0xFF, 0x07, 0xF8,
  0x0F, 0xF0, 0x7F, 0x80, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE,
  0x07, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x01, 0xFE, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xC0,
  0x7F, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x1F, 0x87, 0xF8, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x8F, 0xE0, 0x01, 0xFE, 0x0F, 0xE0, 0x07,
  0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0xFE,
  0x00, 0x3F, 0x83, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x0F,
  0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xE0, 0x01, 0xFC, 0x07,
  0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x03,
  0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x03,
  0xF8, 0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x01,
  0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00,
  0xFD, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x3F, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0,
  0x00, 0x01, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x04, 0x07, 0xFF, 0x80, 0x3E, 0x7F, 0xFE, 0x01, 0xF3, 0xFF, 0xF8, 0x1F,
  0x3F, 0xFF, 0xF1, 0xF9, 0xF0, 0x7F, 0xFF, 0xCF, 0x00, 0xFF, 0xFC, 0xF8,
  0x03, 0xFF, 0xC1, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
};

const GFXglyph RobotoMono_SemiBoldItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 13, 37, 31, 9, -37 },
  { 62, 17, 13, 31, 9, -39 },
  { 90, 31, 37, 31, 0, -37 },
  { 234, 28, 48, 31, 2, -43 },
  { 402, 25, 39, 31, 3, -38 },
  { 524, 29, 39, 31, 1, -38 },
  { 666, 7, 13, 31, 13, -39 },
  { 678, 18, 53, 31, 8, -41 },
  { 798, 18, 53, 31, 4, -41 },
  { 918, 25, 26, 31, 4, -37 },
  { 1000, 26, 27, 31, 2, -31 },
  { 1088, 11, 16, 31, 5, -6 },
  { 1110, 21, 5, 31, 6, -19 },
  { 1124, 9, 9, 31, 9, -8 },
  { 1135, 27, 40, 31, 2, -37 },
  { 1270, 25, 39, 31, 3, -38 },
  { 1392, 18, 37, 31, 6, -37 },
  { 1476, 27, 38, 31, 0, -38 },
  { 1605, 27, 39, 31, 1, -38 },
  { 1737, 26, 37, 31, 1, -37 },
  { 1858, 28, 38, 31, 2, -37 },
  { 1991, 25, 38, 31, 2, -37 },
  { 2110, 26, 37, 31, 4, -37 },
  { 2231, 26, 39, 31, 2, -38 },
  { 2358, 24, 38, 31, 4, -38 },
  { 2472, 13, 30, 31, 9, -29 },
  { 2521, 16, 39, 31, 7, -29 },
  { 2599, 24, 24, 31, 4, -28 },
  { 2671, 26, 16, 31, 3, -24 },
  { 2723, 25, 24, 31, 2, -28 },
  { 2798, 23, 38, 31, 6, -38 },
  { 2908, 29, 37, 31, 1, -37 },
  { 3043, 29, 37, 31, -2, -37 },
  { 3178, 29, 37, 31, 1, -37 },
  { 3313, 28, 39, 31, 2, -38 },
  { 3450, 28, 37, 31, 1, -37 },
  { 3580, 30, 37, 31, 1, -37 },
  { 3719, 30, 37, 31, 1, -37 },
  { 3858, 28, 39, 31, 2, -38 },
  { 3995, 31, 37, 31, 0, -37 },
  { 4139, 27, 37, 31, 2, -37 },
  { 4264, 29, 38, 31, 2, -37 },
  { 4402, 33, 37, 31, 1, -37 },
  { 4555, 25, 37, 31, 1, -37 },
  { 4671, 30, 37, 31, 1, -37 },
  { 4810, 31, 37, 31, 0, -37 },
  { 4954, 27, 39, 31, 2, -38 },
  { 5086, 30, 37, 31, 1, -37 },
  { 5225, 28, 44, 31, 2, -38 },
  { 5379, 29, 37, 31, 1, -37 },
  { 5514, 28, 39, 31, 2, -38 },
  { 5651, 29, 37, 31, 4, -37 },
  { 5786, 29, 38, 31, 2, -37 },
  { 5924, 29, 37, 31, 4, -37 },
  { 6059, 30, 37, 31, 3, -37 },
  { 6198, 35, 37, 31, -2, -37 },
  { 6360, 29, 37, 31, 5, -37 },
  { 6495, 31, 37, 31, 0, -37 },
  { 6639, 19, 51, 31, 6, -43 },
  { 6761, 12, 40, 31, 10, -37 },
  { 6821, 19, 51, 31, 6, -43 },
  { 6943, 20, 20, 31, 6, -37 },
  { 6993, 24, 5, 31, 0, 0 },
  { 7008, 10, 7, 31, 14, -38 },
  { 7017, 25, 29, 31, 2, -28 },
  { 7108, 26, 40, 31, 1, -39 },
  { 7238, 24, 29, 31, 3, -28 },
  { 7325, 29, 40, 31, 2, -39 },
  { 7470, 26, 29, 31, 2, -28 },
  { 7565, 28, 40, 31, 4, -40 },
  { 7705, 28, 39, 31, 1, -28 },
  { 7842, 27, 39, 31, 1, -39 },
  { 7974, 22, 38, 31, 3, -38 },
  { 8079, 24, 49, 31, 1, -38 },
  { 8226, 29, 39, 31, 1, -39 },
  { 8368, 24, 39, 31, 2, -39 },
  { 8485, 30, 28, 31, -1, -28 },
  { 8590, 27, 28, 31, 1, -28 },
  { 8685, 26, 29, 31, 2, -28 },
  { 8780, 28, 39, 31, -1, -28 },
  { 8917, 27, 39, 31, 2, -28 },
  { 9049, 24, 28, 31, 5, -28 },
  { 9133, 26, 29, 31, 2, -28 },
  { 9228, 24, 35, 31, 4, -34 },
  { 9333, 26, 28, 31, 3, -27 },
  { 9424, 26, 28, 31, 4, -28 },
  { 9515, 28, 27, 31, 3, -27 },
  { 9610, 31, 27, 31, 0, -27 },
  { 9715, 32, 38, 31, 0, -27 },
  { 9867, 28, 27, 31, 1, -27 },
  { 9962, 21, 50, 31, 7, -41 },
  { 10094, 12, 47, 31, 9, -37 },
  { 10165, 20, 50, 31, 5, -41 },
  { 10290, 29, 11, 31, 0, -21 },
};

const GFXfont RobotoMono_SemiBoldItalic52pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic52pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic52pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC52PT7B_H_
