#ifndef _ROBOTOMONO_SEMIBOLDITALIC32PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x38, 0x38, 0x78, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0xF0, 0xF0,
  0x38, 0xE7, 0x1D, 0xC7, 0x38, 0xE7, 0x1C, 0xE3, 0x98, 0x67, 0x0C, 0x00,
  0x71, 0xC0, 0x0E, 0x30, 0x01, 0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x30, 0x03,
  0x8E, 0x00, 0x71, 0xC0, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x71, 0xC0, 0x0C,
  0x30, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0C, 0x30, 0x1F, 0xFF, 0xC7, 0xFF,
  0xF8, 0xFF, 0xFF, 0x03, 0x8E, 0x00, 0x71, 0x80, 0x0C, 0x70, 0x03, 0x8E,
  0x00, 0x71, 0x80, 0x1C, 0x70, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x1F, 0x80, 0x3F, 0xE0, 0x3F, 0xF8, 0x3E, 0x7E, 0x3E, 0x0F, 0x1E,
  0x07, 0x8F, 0x03, 0xC7, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7F, 0x00,
  0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x03, 0xCF, 0x01,
  0xE7, 0x80, 0xF3, 0xC0, 0xF1, 0xF0, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x07,
  0xF8, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x3E, 0x00, 0xFE, 0x01,
  0xDC, 0x07, 0x1C, 0x7E, 0x39, 0xDC, 0x73, 0x38, 0xCE, 0x7F, 0xB8, 0x7E,
  0x60, 0x79, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE6, 0x03, 0xBF,
  0x06, 0xFF, 0x1D, 0xCE, 0x73, 0x8D, 0xC6, 0x39, 0x8C, 0x70, 0x1C, 0xE0,
  0x3F, 0x80, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x1E,
  0x78, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0xF1, 0xE0, 0x1C, 0xF8, 0x07, 0x7C,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x1F, 0xE1, 0xCF, 0xF8, 0xF3,
  0xCF, 0x3D, 0xE3, 0xEE, 0x78, 0x7F, 0x9E, 0x1F, 0xC7, 0x83, 0xF1, 0xE1,
  0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFC, 0xF8, 0x77, 0x77, 0x7E, 0xEE,
  0x00, 0xC0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x80, 0xE0, 0x3C,
  0x07, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x0E, 0x01,
  0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x60, 0x04, 0x03, 0x80, 0x70,
  0x1E, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x81, 0xE0,
  0x70, 0x3C, 0x0F, 0x07, 0x81, 0xC0, 0xF0, 0x78, 0x3C, 0x0E, 0x03, 0x00,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x04, 0x18, 0x2C, 0x31, 0xFE,
  0xEF, 0xFF, 0xFF, 0x0F, 0xF0, 0x0F, 0x00, 0x3F, 0x00, 0xEE, 0x03, 0x8E,
  0x1F, 0x1C, 0x1C, 0x1C, 0x10, 0x20, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFF, 0x83, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x1E, 0x38, 0xF1, 0xE3, 0xC7, 0x9E, 0x38, 0xF0,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x79, 0xFF, 0xDF, 0x78,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0,
  0xF9, 0xF3, 0xC1, 0xE7, 0x83, 0xDE, 0x03, 0xBC, 0x0F, 0x78, 0x3E, 0xF0,
  0xFD, 0xE7, 0xFB, 0x9E, 0xFF, 0xF9, 0xFF, 0xC3, 0xFF, 0x0F, 0x78, 0x1E,
  0xF0, 0x3D, 0xE0, 0x7B, 0xC1, 0xE3, 0xC7, 0xC7, 0xFF, 0x07, 0xFC, 0x07,
  0xF0, 0x00, 0x00, 0x20, 0x38, 0x3F, 0x3F, 0xEF, 0xFD, 0xF7, 0xB0, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x01, 0xF8,
  0x01, 0xFF, 0x03, 0xFF, 0xC1, 0xF3, 0xE1, 0xE0, 0xF8, 0xF0, 0x3C, 0xF0,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x2F, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF8, 0x01,
  0xF8, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0x1F, 0x3E, 0x0F, 0x3C, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x03, 0xFC, 0x03, 0xF0, 0x07,
  0xFC, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0xF0, 0x1E, 0xF0,
  0x3C, 0xF8, 0x7C, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xBC,
  0x03, 0xDC, 0x03, 0xDE, 0x03, 0xCF, 0x03, 0xC7, 0x81, 0xC3, 0xC1, 0xE1,
  0xE1, 0xE1, 0xE1, 0xE0, 0xF0, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0xFF,
  0x83, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xF0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1D, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0x07, 0xCF, 0xC0,
  0x41, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x78, 0x0F,
  0x1E, 0x0F, 0x8F, 0x0F, 0x87, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0x80, 0x00,
  0x3C, 0x01, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0xF8, 0x03, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x3D, 0xF0, 0x77, 0xF9, 0xFF, 0xF3, 0xF1, 0xF7, 0xC1, 0xEF,
  0x03, 0xDE, 0x07, 0xB8, 0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0xF3, 0xE3,
  0xE3, 0xFF, 0x83, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0x9F,
  0xFF, 0xCF, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x07, 0xFE,
  0x0F, 0xFE, 0x1F, 0x9F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F,
  0x1E, 0x1F, 0x1F, 0x3E, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xFC, 0x3C, 0x3C,
  0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF8, 0x3E, 0x78, 0x7C,
  0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0, 0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xF1,
  0xF1, 0xE3, 0xC1, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3D, 0xE0, 0xFB, 0xC1, 0xF7, 0xFF, 0xC7, 0xFF, 0x87, 0xFF, 0x03, 0x1C,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x7F, 0x03, 0xFC, 0x07, 0xE0, 0x1F,
  0x00, 0x00, 0x1E, 0x3E, 0x3F, 0x3E, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0xF8, 0xF8, 0xF8, 0xF8, 0x07, 0x81, 0xF0, 0xFC,
  0x1F, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x0F,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x3C, 0x03, 0xF8, 0x1F, 0xF1, 0xFF, 0x0F,
  0xF0, 0x1F, 0x80, 0x7C, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F,
  0xC0, 0x0F, 0x80, 0x07, 0x00, 0x02, 0x00, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F,
  0xFE, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFF, 0xFC, 0x10, 0x00, 0x38, 0x00, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x3F, 0xC0, 0x0F, 0x80, 0x1F, 0x01, 0xFE, 0x1F, 0xF1, 0xFF, 0x83,
  0xF8, 0x07, 0xC0, 0x1C, 0x00, 0x20, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0xC7,
  0xFF, 0x9F, 0x1F, 0xF8, 0x3F, 0xC0, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78,
  0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x3C, 0x0C, 0x1C, 0x03,
  0x86, 0x1C, 0x63, 0x9F, 0xD9, 0xCF, 0x66, 0x73, 0x19, 0x99, 0xC6, 0x6E,
  0x63, 0x9B, 0xB8, 0xC6, 0xCE, 0x31, 0xB3, 0x8C, 0xEC, 0xE7, 0x33, 0x3B,
  0xDC, 0xCF, 0xFE, 0x31, 0xEF, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x78, 0x60,
  0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xBC, 0x01,
  0xEF, 0x00, 0x73, 0xC0, 0x3C, 0xF0, 0x0E, 0x1C, 0x07, 0x87, 0x01, 0xE1,
  0xC0, 0xF0, 0x78, 0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE3, 0xC0, 0x78,
  0xF0, 0x1E, 0x78, 0x07, 0x9E, 0x00, 0xFF, 0x00, 0x3C, 0x0F, 0xF8, 0x01,
  0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xF0, 0x3C, 0x3C, 0x07, 0x87,
  0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x07, 0xC3, 0xC1, 0xF0, 0x7F, 0xFC, 0x1F,
  0xFF, 0x03, 0xFF, 0xF0, 0x78, 0x1F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C,
  0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x3E, 0x3C, 0x1F, 0x87, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xF3,
  0xE1, 0xE0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0xF8, 0x0F, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x0F, 0x78, 0x0F, 0x1E, 0x07, 0x8F, 0x87, 0x83, 0xFF,
  0xC1, 0xFF, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xE0,
  0x3F, 0xFC, 0x0F, 0x0F, 0x87, 0x81, 0xE1, 0xE0, 0x7C, 0x78, 0x0F, 0x1E,
  0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x07, 0xCF, 0x01,
  0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x78, 0x0F, 0x1E, 0x07, 0xC7, 0x83, 0xE1,
  0xE3, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xC7,
  0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xF8,
  0x3F, 0xFE, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0xC1,
  0xF3, 0xF1, 0xE0, 0x79, 0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x0F, 0xE7, 0x87, 0xF7, 0x87, 0xFB, 0xC3,
  0xFD, 0xE0, 0x1E, 0xF0, 0x0F, 0x3C, 0x0F, 0x9E, 0x07, 0x8F, 0x87, 0xC3,
  0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xC0, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C,
  0x07, 0x07, 0x81, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xF0,
  0x1E, 0x1E, 0x03, 0x83, 0xC0, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF,
  0xF8, 0x78, 0x0F, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x78, 0x0F, 0x0F, 0x01,
  0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x81, 0xE0, 0xE0, 0x3C, 0x3C, 0x07,
  0x80, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x07, 0xFF, 0xC7, 0xFF, 0xC3,
  0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x03, 0xC1, 0xE1, 0xF0, 0x7F,
  0xF8, 0x0F, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0x00, 0xF8, 0x78, 0x0F, 0x83,
  0xC0, 0xF8, 0x1E, 0x0F, 0x80, 0xF0, 0xF8, 0x0F, 0x0F, 0x80, 0x78, 0xF8,
  0x03, 0xCF, 0x80, 0x1E, 0x78, 0x00, 0xF7, 0x80, 0x07, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xF9, 0xE0, 0x07, 0x8F, 0x80,
  0x3C, 0x3C, 0x03, 0xC1, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80,
  0xF0, 0x3C, 0x07, 0x83, 0xE0, 0x3E, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0x00, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x1F, 0x87, 0xC3,
  0xF0, 0xFC, 0xFE, 0x3F, 0x9F, 0x87, 0xF7, 0x70, 0xFE, 0xFE, 0x1D, 0xFB,
  0xC3, 0xBF, 0x78, 0x77, 0xEE, 0x1E, 0xF9, 0xC3, 0xCF, 0x78, 0x79, 0xCF,
  0x0E, 0x39, 0xE1, 0xC6, 0x3C, 0x78, 0x07, 0x0F, 0x00, 0xE1, 0xE0, 0x3C,
  0x3C, 0x07, 0x87, 0x00, 0xF0, 0xE0, 0x1E, 0x3C, 0x03, 0x80, 0x0F, 0x01,
  0xE1, 0xF0, 0x3C, 0x3E, 0x0F, 0x07, 0xC1, 0xE1, 0xF8, 0x3C, 0x3F, 0x87,
  0x87, 0xF0, 0xF0, 0xFE, 0x1E, 0x1F, 0xC7, 0x83, 0xFC, 0xF0, 0xF3, 0x9E,
  0x1E, 0x73, 0xC3, 0xCE, 0x78, 0x79, 0xEF, 0x0F, 0x1F, 0xC1, 0xE3, 0xF8,
  0x78, 0x7F, 0x0F, 0x07, 0xE1, 0xE0, 0xFC, 0x3C, 0x1F, 0x87, 0x83, 0xE0,
  0xF0, 0x3C, 0x3C, 0x07, 0x80, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x83,
  0xF3, 0xE1, 0xE0, 0xF1, 0xE0, 0x3C, 0xF0, 0x1E, 0xF0, 0x0F, 0x78, 0x07,
  0xBC, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x7F, 0x80, 0x7B, 0xC0,
  0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x0F, 0x1E, 0x0F, 0x8F, 0x8F, 0x83,
  0xFF, 0x81, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0xF8, 0x07, 0xFF, 0x81, 0xFF,
  0xF0, 0x7F, 0xFE, 0x1E, 0x07, 0x87, 0x80, 0xF1, 0xE0, 0x3C, 0xF0, 0x0F,
  0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x1F,
  0xFE, 0x07, 0xF8, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8,
  0x03, 0xFF, 0x03, 0xFF, 0x83, 0xF3, 0xE1, 0xE0, 0xF9, 0xE0, 0x3C, 0xF0,
  0x1E, 0xF8, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0xF7,
  0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x0F,
  0x1E, 0x0F, 0x8F, 0x8F, 0x83, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x02, 0x00, 0x0F, 0xF8, 0x01, 0xFF,
  0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x87, 0x80,
  0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0xF8, 0x78, 0x3E, 0x1F, 0xFF,
  0x83, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C,
  0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xF0, 0xF0, 0x1E,
  0x3E, 0x03, 0xC0, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7E, 0x3E,
  0x1E, 0x07, 0x8F, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x81, 0xF1, 0xF0, 0xF8,
  0x7F, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E,
  0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x1E, 0x1E, 0x07, 0x8F, 0x01,
  0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x03, 0xC3, 0xC0, 0xF1,
  0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x78, 0x78,
  0x1E, 0x1E, 0x07, 0x87, 0x83, 0xC1, 0xF1, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC,
  0x00, 0xFE, 0x00, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xDE, 0x03, 0xEF,
  0x01, 0xE7, 0xC1, 0xF1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x78, 0x3C, 0x3C,
  0x1E, 0x3E, 0x0F, 0x1E, 0x07, 0x8F, 0x01, 0xCF, 0x00, 0xE7, 0x80, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x70, 0xE1, 0xDC, 0x38, 0xF7, 0x1E, 0x3D, 0xC7,
  0x8E, 0x71, 0xE7, 0x9C, 0xF9, 0xEF, 0x3E, 0x7B, 0xCF, 0x9C, 0xF7, 0xEF,
  0x3D, 0xFB, 0xCF, 0x7E, 0xE3, 0xFB, 0xB8, 0xFE, 0xFE, 0x3F, 0xBF, 0x8F,
  0xCF, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE3,
  0xE0, 0xF8, 0xF8, 0x3C, 0x3C, 0x0F, 0x0F, 0x00, 0x0F, 0x80, 0xF8, 0x7C,
  0x07, 0xC1, 0xE0, 0x7C, 0x0F, 0x87, 0xC0, 0x3C, 0x3C, 0x01, 0xE3, 0xE0,
  0x0F, 0x9E, 0x00, 0x3D, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0xFB, 0xC0, 0x07, 0x9E, 0x00, 0x7C, 0xF8, 0x07, 0xC3, 0xC0, 0x3C, 0x1E,
  0x03, 0xE0, 0xF8, 0x3E, 0x03, 0xC3, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0xFE,
  0x03, 0xE7, 0x80, 0xF1, 0xE0, 0x7C, 0x78, 0x1E, 0x0F, 0x0F, 0x03, 0xC7,
  0xC0, 0xF1, 0xE0, 0x3C, 0xF0, 0x07, 0xBC, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC0, 0x07, 0xE1, 0xFC, 0x3F,
  0x87, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0xE1,
  0xFC, 0x3F, 0x80, 0xF0, 0xF0, 0xF0, 0x70, 0x70, 0x70, 0x78, 0x78, 0x78,
  0x38, 0x38, 0x38, 0x3C, 0x3C, 0x3C, 0x1C, 0x1C, 0x1C, 0x1E, 0x1E, 0x1E,
  0x0E, 0x0E, 0x0E, 0x0F, 0x07, 0xE1, 0xFC, 0x3F, 0x80, 0xF0, 0x1E, 0x03,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x0F, 0xE1, 0xFC, 0x3F, 0x80, 0x01,
  0xC0, 0x0E, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x39, 0xC3, 0x8E,
  0x1C, 0x71, 0xC3, 0x9E, 0x1F, 0xE0, 0x70, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF,
  0xF0, 0xF1, 0xC7, 0x8F, 0x07, 0xF0, 0x1F, 0xF8, 0x7F, 0xF9, 0xF0, 0xF3,
  0xC1, 0xE0, 0x03, 0xC0, 0x07, 0x87, 0xFF, 0x3F, 0xFE, 0xF8, 0x3F, 0xE0,
  0x77, 0x81, 0xEF, 0x03, 0xDF, 0x0F, 0xBF, 0xFF, 0x3F, 0xFE, 0x3F, 0xBC,
  0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1C, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x3E, 0x1E, 0x3C, 0x1F,
  0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x1E,
  0x78, 0x1E, 0xF8, 0x3E, 0xFC, 0x7C, 0xFF, 0xFC, 0xFF, 0xF8, 0xE7, 0xE0,
  0x07, 0xF0, 0x3F, 0xF0, 0xFF, 0xF1, 0xE1, 0xE7, 0x81, 0xFE, 0x03, 0xFC,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x81, 0xEF, 0x03,
  0x9F, 0x1F, 0x1F, 0xFC, 0x1F, 0xF0, 0x1F, 0xC0, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x1F,
  0xBE, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0x0F, 0x8F, 0x03, 0xCF, 0x01, 0xE7,
  0x80, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xE0, 0x3C, 0x70, 0x1E, 0x3C, 0x0F,
  0x1E, 0x0F, 0x0F, 0x8F, 0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0x7E, 0xF0, 0x03,
  0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x1F, 0x1E, 0x3C, 0x0F, 0x7C, 0x0F, 0x78,
  0x0F, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x70, 0x00, 0x78, 0x00, 0x78,
  0x08, 0x7C, 0x1C, 0x3F, 0xFE, 0x1F, 0xF8, 0x0F, 0xF0, 0x00, 0x1E, 0x00,
  0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFF, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xF3, 0xC1, 0xFE, 0xF0, 0xFF, 0xF8, 0x7C, 0x3E,
  0x1E, 0x07, 0x8F, 0x81, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x0F, 0x0F,
  0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x1F, 0x0F, 0x8F, 0xC3, 0xFF,
  0xE0, 0x7F, 0xF8, 0x0F, 0xDE, 0x00, 0x07, 0x82, 0x03, 0xC0, 0xC1, 0xF0,
  0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C,
  0xFC, 0x3D, 0xFE, 0x3F, 0xFE, 0x3E, 0x1F, 0x3C, 0x0F, 0x3C, 0x0F, 0x78,
  0x0F, 0x78, 0x0F, 0x78, 0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x3F,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x81, 0xFE, 0x0F, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x0D,
  0xF8, 0x3F, 0xE0, 0xFF, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x1F,
  0x3C, 0x1F, 0x1E, 0x1F, 0x0F, 0x1F, 0x07, 0x9F, 0x03, 0xDF, 0x03, 0xDF,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3E, 0xF8, 0x1E, 0x3C, 0x1E,
  0x1F, 0x0F, 0x07, 0x87, 0x83, 0xE3, 0xC0, 0xF1, 0xE0, 0x7C, 0x0F, 0xFC,
  0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x0F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0x3D, 0xE7, 0x8F, 0xFF, 0xE3,
  0xFF, 0xFC, 0xF3, 0xCF, 0x38, 0xF3, 0xCE, 0x38, 0xF7, 0x8E, 0x39, 0xE7,
  0x8E, 0x79, 0xE3, 0x9C, 0x79, 0xE7, 0x1E, 0x79, 0xC7, 0x1E, 0xF1, 0xC7,
  0x3C, 0xF1, 0xCF, 0x3C, 0x73, 0x8F, 0x3C, 0xE3, 0x8F, 0x00, 0x3C, 0xFC,
  0x3D, 0xFE, 0x3F, 0xFE, 0x3E, 0x1F, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F,
  0x78, 0x0F, 0x78, 0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x1E,
  0xF0, 0x1E, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0x03, 0xF0, 0x0F, 0xFC,
  0x1F, 0xFE, 0x3E, 0x1E, 0x3C, 0x1F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0x78, 0x3E, 0x78, 0x7C,
  0x3F, 0xF8, 0x3F, 0xF0, 0x0F, 0xE0, 0x0E, 0x7C, 0x0F, 0xFF, 0x07, 0xFF,
  0xC3, 0xE3, 0xE1, 0xE0, 0xF8, 0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C,
  0x07, 0x9E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE7, 0xC1, 0xF3, 0xE1, 0xF1,
  0xFF, 0xF0, 0xFF, 0xF8, 0x7B, 0xF0, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x0F, 0xCF, 0x1F,
  0xEE, 0x3F, 0xFE, 0x7C, 0x3E, 0x78, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0xF8,
  0xF8, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x1C, 0x7E, 0x3B,
  0xFC, 0xFF, 0xF1, 0xFF, 0xE3, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0x03, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x3E,
  0x1F, 0x3C, 0x0F, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFC, 0x00, 0x7E, 0x00, 0x1E, 0xF0, 0x1E, 0x78, 0x3E, 0x7F, 0xFC, 0x3F,
  0xF8, 0x1F, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC3, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xFF,
  0x07, 0xFC, 0x0F, 0xF0, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x1E, 0x78, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C,
  0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x7C, 0xF8, 0xFC, 0xFF, 0xF8, 0x7F, 0xB8,
  0x3F, 0x78, 0xF0, 0x0F, 0xBC, 0x07, 0x9E, 0x07, 0x8F, 0x03, 0xC7, 0x83,
  0xC1, 0xC1, 0xE0, 0xE1, 0xE0, 0x78, 0xF0, 0x3C, 0x70, 0x1E, 0x78, 0x07,
  0x38, 0x03, 0xBC, 0x01, 0xDC, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x00, 0xE1, 0xC3, 0xF0, 0xE3, 0xF8, 0xF1, 0xDC, 0x78, 0xEE,
  0x3C, 0xF7, 0x3E, 0x73, 0x9B, 0x39, 0xDD, 0xBC, 0xEE, 0xDC, 0x76, 0x6E,
  0x3F, 0x3F, 0x1F, 0x1F, 0x0F, 0x8F, 0x87, 0xC7, 0xC3, 0xC3, 0xC1, 0xE1,
  0xE0, 0xF0, 0xE0, 0x00, 0x1E, 0x03, 0xE1, 0xE0, 0xF8, 0x3C, 0x3E, 0x03,
  0xC7, 0x80, 0x79, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xF3, 0xC0, 0x3C,
  0x78, 0x0F, 0x07, 0x83, 0xE0, 0xF0, 0xF8, 0x0F, 0x00, 0x3C, 0x01, 0xF1,
  0xE0, 0x1E, 0x1E, 0x03, 0xC1, 0xE0, 0x7C, 0x1E, 0x07, 0x80, 0xF0, 0xF8,
  0x0F, 0x0F, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0x73, 0xC0, 0x07, 0xBC,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xFF, 0xC7,
  0xFF, 0xF1, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x00,
  0x00, 0x70, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70,
  0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xE0, 0xF8, 0x0F, 0x00,
  0xF8, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1F, 0x00, 0xF0, 0x02, 0x00, 0x0E,
  0x1C, 0x30, 0x60, 0xC3, 0x87, 0x0E, 0x18, 0x30, 0x61, 0xC3, 0x87, 0x0E,
  0x18, 0x30, 0xE1, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0xE1, 0xC3, 0x87, 0x0C,
  0x00, 0x06, 0x00, 0xF0, 0x0F, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x03, 0xC0,
  0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x03, 0xF0, 0x78, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0xF8, 0x0F, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x0F, 0xE0, 0x77, 0xFC, 0x3D, 0xFF, 0xDE, 0xE0, 0xFF, 0xB8,
  0x1F, 0xC0, 0x03, 0xE0,
};

const GFXglyph RobotoMono_SemiBoldItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 8, 23, 19, 6, -23 },
  { 24, 11, 8, 19, 5, -24 },
  { 35, 19, 23, 19, 0, -23 },
  { 90, 17, 29, 19, 1, -26 },
  { 152, 15, 23, 19, 2, -23 },
  { 196, 18, 23, 19, 0, -23 },
  { 248, 4, 8, 19, 8, -24 },
  { 252, 11, 32, 19, 5, -25 },
  { 296, 10, 32, 19, 3, -25 },
  { 336, 15, 16, 19, 3, -23 },
  { 366, 16, 17, 19, 1, -19 },
  { 400, 7, 10, 19, 3, -4 },
  { 409, 13, 4, 19, 4, -12 },
  { 416, 6, 5, 19, 5, -5 },
  { 420, 17, 25, 19, 1, -23 },
  { 474, 15, 23, 19, 2, -23 },
  { 518, 11, 23, 19, 4, -23 },
  { 550, 17, 23, 19, 0, -23 },
  { 599, 16, 23, 19, 1, -23 },
  { 645, 17, 23, 19, 0, -23 },
  { 694, 17, 23, 19, 1, -23 },
  { 743, 15, 23, 19, 1, -23 },
  { 787, 17, 23, 19, 2, -23 },
  { 836, 16, 23, 19, 1, -23 },
  { 882, 15, 23, 19, 2, -23 },
  { 926, 8, 18, 19, 6, -18 },
  { 944, 10, 24, 19, 4, -18 },
  { 974, 15, 15, 19, 2, -17 },
  { 1003, 16, 10, 19, 2, -15 },
  { 1023, 15, 15, 19, 1, -17 },
  { 1052, 14, 23, 19, 4, -23 },
  { 1093, 18, 23, 19, 1, -23 },
  { 1145, 18, 23, 19, -1, -23 },
  { 1197, 19, 23, 19, 0, -23 },
  { 1252, 17, 23, 19, 1, -23 },
  { 1301, 18, 23, 19, 0, -23 },
  { 1353, 18, 23, 19, 1, -23 },
  { 1405, 18, 23, 19, 1, -23 },
  { 1457, 17, 23, 19, 1, -23 },
  { 1506, 19, 23, 19, 0, -23 },
  { 1561, 17, 23, 19, 1, -23 },
  { 1610, 18, 23, 19, 1, -23 },
  { 1662, 21, 23, 19, 0, -23 },
  { 1723, 15, 23, 19, 1, -23 },
  { 1767, 19, 23, 19, 0, -23 },
  { 1822, 19, 23, 19, 0, -23 },
  { 1877, 17, 23, 19, 1, -23 },
  { 1926, 18, 23, 19, 1, -23 },
  { 1978, 17, 27, 19, 1, -23 },
  { 2036, 19, 23, 19, 0, -23 },
  { 2091, 18, 23, 19, 1, -23 },
  { 2143, 18, 23, 19, 2, -23 },
  { 2195, 18, 23, 19, 1, -23 },
  { 2247, 17, 23, 19, 3, -23 },
  { 2296, 18, 23, 19, 2, -23 },
  { 2348, 21, 23, 19, -1, -23 },
  { 2409, 18, 23, 19, 3, -23 },
  { 2461, 19, 23, 19, 0, -23 },
  { 2516, 11, 31, 19, 4, -26 },
  { 2559, 8, 25, 19, 6, -23 },
  { 2584, 11, 31, 19, 4, -26 },
  { 2627, 13, 12, 19, 3, -23 },
  { 2647, 15, 3, 19, 0, 0 },
  { 2653, 6, 4, 19, 9, -23 },
  { 2656, 15, 17, 19, 1, -17 },
  { 2688, 16, 24, 19, 1, -24 },
  { 2736, 15, 17, 19, 2, -17 },
  { 2768, 17, 24, 19, 2, -24 },
  { 2819, 16, 17, 19, 1, -17 },
  { 2853, 17, 25, 19, 3, -25 },
  { 2907, 18, 24, 19, 0, -17 },
  { 2961, 16, 24, 19, 1, -24 },
  { 3009, 14, 23, 19, 2, -23 },
  { 3050, 14, 30, 19, 1, -23 },
  { 3103, 17, 24, 19, 1, -24 },
  { 3154, 15, 24, 19, 1, -24 },
  { 3199, 18, 17, 19, 0, -17 },
  { 3238, 16, 17, 19, 1, -17 },
  { 3272, 16, 17, 19, 1, -17 },
  { 3306, 17, 24, 19, 0, -17 },
  { 3357, 16, 24, 19, 2, -17 },
  { 3405, 15, 17, 19, 3, -17 },
  { 3437, 16, 17, 19, 1, -17 },
  { 3471, 14, 21, 19, 3, -21 },
  { 3508, 16, 17, 19, 2, -17 },
  { 3542, 17, 17, 19, 2, -17 },
  { 3579, 17, 17, 19, 2, -17 },
  { 3616, 19, 17, 19, 0, -17 },
  { 3657, 20, 24, 19, 0, -17 },
  { 3717, 18, 17, 19, 0, -17 },
  { 3756, 12, 31, 19, 5, -25 },
  { 3803, 7, 29, 19, 6, -23 },
  { 3829, 12, 31, 19, 3, -25 },
  { 3876, 18, 7, 19, 0, -13 },
};

const GFXfont RobotoMono_SemiBoldItalic32pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic32pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic32pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC32PT7B_H_
