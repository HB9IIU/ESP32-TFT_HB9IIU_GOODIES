#ifndef _ROBOTOMONO_SEMIBOLDITALIC19PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x19, 0xCE, 0x63, 0x18, 0xC6, 0x70, 0x00, 0x8E, 0x70, 0x65, 0x34,
  0xF3, 0xC8, 0x02, 0x60, 0xC8, 0x13, 0x06, 0x63, 0xFE, 0x7F, 0xC6, 0x60,
  0xC8, 0x13, 0x1F, 0xF8, 0xC8, 0x13, 0x06, 0x40, 0xD8, 0x00, 0x02, 0x00,
  0x80, 0x60, 0x7E, 0x39, 0x9C, 0x77, 0x1C, 0xC0, 0x3C, 0x07, 0xC0, 0x70,
  0x0E, 0xC1, 0xB8, 0xE7, 0xF0, 0xF8, 0x18, 0x04, 0x00, 0x30, 0x3C, 0x32,
  0x79, 0x2D, 0xA3, 0xB0, 0x10, 0x10, 0x1B, 0x1B, 0xCB, 0x2D, 0x90, 0xD8,
  0x38, 0x06, 0x01, 0xF0, 0x66, 0x0C, 0xC1, 0x98, 0x3E, 0x07, 0x81, 0xE3,
  0x7E, 0x6C, 0xDB, 0x9F, 0x71, 0xC7, 0xF8, 0x7F, 0x80, 0xFF, 0x80, 0x04,
  0x31, 0x8C, 0x31, 0x86, 0x18, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x61,
  0x83, 0x00, 0x10, 0x30, 0x30, 0x20, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x60, 0xC1, 0x86, 0x0C, 0x31, 0xC1, 0x00, 0x0C, 0x06, 0x02, 0x11, 0x2F,
  0xF9, 0xE0, 0xE0, 0xD8, 0xC6, 0x22, 0x00, 0x0E, 0x06, 0x03, 0x01, 0x8F,
  0xFF, 0xFC, 0x60, 0x30, 0x18, 0x0C, 0x00, 0x76, 0x66, 0xC8, 0x7F, 0xFF,
  0x6F, 0xE0, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30,
  0x1C, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x00, 0x0E, 0x0F, 0x8C,
  0xEE, 0x36, 0x1B, 0x1D, 0x9F, 0xFB, 0xF3, 0xF1, 0xF0, 0xDC, 0x67, 0xE1,
  0xE0, 0x02, 0x19, 0xF7, 0xE8, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0x61, 0xC3,
  0x86, 0x00, 0x07, 0x07, 0xE3, 0x9C, 0xC3, 0x70, 0xC0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xFF, 0xBF, 0xE0, 0x07, 0x07, 0xE3, 0x9C,
  0xC3, 0x00, 0xC0, 0x70, 0xF8, 0x3C, 0x01, 0x80, 0x6E, 0x19, 0x8E, 0x7F,
  0x0F, 0x80, 0x01, 0xC0, 0x70, 0x3C, 0x1E, 0x0D, 0x87, 0x61, 0x98, 0xCE,
  0x63, 0xBF, 0xFF, 0xFC, 0x0C, 0x07, 0x01, 0xC0, 0x1F, 0xCF, 0xF3, 0xF8,
  0xC0, 0x30, 0x1B, 0x87, 0xF0, 0x8C, 0x03, 0x80, 0xEC, 0x3B, 0x0C, 0xFF,
  0x1F, 0x00, 0x03, 0x07, 0x87, 0x86, 0x07, 0x03, 0x73, 0xFD, 0xC6, 0xC3,
  0xE1, 0xF0, 0xDC, 0x67, 0xE1, 0xE0, 0x7F, 0xDF, 0xF0, 0x1C, 0x06, 0x03,
  0x01, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x38, 0x00,
  0x0E, 0x1F, 0xCE, 0xEE, 0x36, 0x1B, 0x9C, 0xFC, 0x7C, 0xE3, 0x61, 0xB0,
  0xD8, 0x6F, 0xF3, 0xE0, 0x0E, 0x1F, 0x9C, 0xEC, 0x36, 0x1F, 0x0D, 0x8E,
  0xEF, 0x7F, 0x8D, 0x81, 0xC1, 0xC7, 0xC3, 0x80, 0x39, 0xCE, 0x00, 0x00,
  0x00, 0x67, 0x98, 0x39, 0xCE, 0x00, 0x00, 0x00, 0x03, 0x18, 0xCE, 0x62,
  0x00, 0x01, 0x83, 0xCF, 0xCF, 0x0E, 0x03, 0xE0, 0x7C, 0x0E, 0x01, 0x00,
  0x7F, 0xBF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x60, 0x3C, 0x0F, 0x80, 0xF0,
  0x79, 0xFB, 0xE1, 0xC0, 0x80, 0x00, 0x1C, 0x3F, 0x9C, 0xDC, 0x70, 0x30,
  0x38, 0x38, 0x38, 0x18, 0x1C, 0x00, 0x04, 0x07, 0x01, 0x80, 0x0F, 0xC3,
  0x08, 0xCD, 0x97, 0xD6, 0x92, 0xB2, 0x56, 0x5E, 0xDA, 0xDB, 0x4B, 0xF1,
  0x00, 0x39, 0x03, 0xE0, 0x01, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x6C, 0x0D,
  0x83, 0x30, 0x66, 0x18, 0xC3, 0xF8, 0xFF, 0x18, 0x77, 0x0F, 0xC1, 0xC0,
  0x1E, 0x07, 0xF8, 0xE7, 0x98, 0x73, 0x0E, 0x61, 0x8F, 0xE3, 0xFC, 0x70,
  0xCC, 0x19, 0x83, 0x30, 0xE7, 0xF9, 0xFE, 0x00, 0x0E, 0x07, 0xE3, 0x99,
  0x87, 0x60, 0xF8, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x3B, 0x8C, 0x7F,
  0x0F, 0x00, 0x1C, 0x07, 0xF0, 0xEF, 0x18, 0x63, 0x0C, 0x61, 0xCC, 0x3B,
  0x86, 0x70, 0xCC, 0x39, 0x87, 0x31, 0xCF, 0xF1, 0xF8, 0x00, 0x1F, 0xE3,
  0xFC, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0F, 0xF1, 0xFC, 0x70, 0x0E, 0x01,
  0x80, 0x30, 0x07, 0xF9, 0xFF, 0x00, 0x1F, 0xF1, 0xFE, 0x38, 0x03, 0x80,
  0x30, 0x03, 0x00, 0x3F, 0xC3, 0xFC, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0x0E, 0x07, 0xE3, 0x99, 0xC7, 0x60, 0xF8, 0x0E, 0x03,
  0x1E, 0xCF, 0xB0, 0x6C, 0x3B, 0x8E, 0x7F, 0x0F, 0x80, 0x18, 0x67, 0x0C,
  0xC1, 0x98, 0x73, 0x0E, 0x61, 0x9F, 0xF3, 0xFE, 0x60, 0xCC, 0x39, 0x86,
  0x30, 0xCE, 0x19, 0xC3, 0x00, 0x3F, 0xCF, 0xF0, 0xE0, 0x38, 0x0C, 0x03,
  0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60, 0xFF, 0x3F, 0x80, 0x00,
  0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0xEC,
  0x33, 0x1C, 0xFE, 0x1F, 0x00, 0x18, 0x73, 0x87, 0x38, 0xE3, 0x1C, 0x33,
  0x83, 0x70, 0x3E, 0x07, 0xE0, 0x7F, 0x07, 0x30, 0x63, 0x86, 0x38, 0x61,
  0xCE, 0x1C, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70,
  0x38, 0x18, 0x0C, 0x07, 0xFF, 0xFC, 0x18, 0xE7, 0x9C, 0xF3, 0x9E, 0xF3,
  0xD6, 0x7F, 0xCF, 0xB3, 0x76, 0x66, 0xCC, 0x99, 0x83, 0x30, 0xEE, 0x19,
  0x83, 0x00, 0x18, 0x67, 0x0C, 0xE3, 0x9E, 0x73, 0xCE, 0x79, 0x9D, 0x33,
  0xB6, 0x77, 0xCC, 0xF9, 0x8E, 0x31, 0xCE, 0x39, 0xC7, 0x00, 0x0E, 0x0F,
  0xC3, 0xB9, 0x86, 0x61, 0xF8, 0x7C, 0x1F, 0x06, 0xC1, 0xB0, 0x6C, 0x3B,
  0x8C, 0x7E, 0x1F, 0x00, 0x1E, 0x03, 0xF8, 0xE7, 0x9C, 0x33, 0x06, 0x60,
  0xCC, 0x39, 0xFE, 0x7F, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x00,
  0x0E, 0x0F, 0xE3, 0xB9, 0x87, 0x61, 0xF8, 0x7C, 0x1F, 0x07, 0xC1, 0xB0,
  0x6C, 0x3B, 0x8C, 0x7E, 0x0F, 0x80, 0x70, 0x0E, 0x1E, 0x07, 0xF8, 0xE7,
  0x98, 0x73, 0x06, 0x61, 0xCC, 0x73, 0xFC, 0x7F, 0x0C, 0x61, 0x8E, 0x31,
  0xC6, 0x19, 0xC3, 0x80, 0x0E, 0x0F, 0xE7, 0x9D, 0x83, 0x60, 0x1C, 0x03,
  0xC0, 0x7C, 0x07, 0x80, 0x6C, 0x1B, 0x0E, 0xFF, 0x0F, 0x80, 0x7F, 0xEF,
  0xFE, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x60, 0x0C, 0x01, 0x80, 0x70, 0x00, 0x30, 0xDC, 0x37, 0x0D, 0x87, 0x61,
  0xD8, 0x66, 0x1B, 0x86, 0xE1, 0xB0, 0xEC, 0x3B, 0x8C, 0x7E, 0x1F, 0x00,
  0xC1, 0xF0, 0x7C, 0x3B, 0x0E, 0xE3, 0x39, 0xCE, 0x61, 0xB8, 0x6C, 0x1B,
  0x07, 0x81, 0xE0, 0x78, 0x1C, 0x00, 0x66, 0x6C, 0xCD, 0xBB, 0xF7, 0x6E,
  0xED, 0xBD, 0xB7, 0xE6, 0xBC, 0xF7, 0x9E, 0xE3, 0x9C, 0x73, 0x8E, 0x71,
  0xCC, 0x00, 0x18, 0x38, 0xE1, 0x83, 0x1C, 0x19, 0xC0, 0xEC, 0x03, 0xE0,
  0x1E, 0x00, 0xE0, 0x0F, 0x80, 0x6C, 0x07, 0x70, 0x73, 0x83, 0x0C, 0x78,
  0x70, 0xC0, 0xF8, 0x7E, 0x39, 0x8C, 0x67, 0x1D, 0x83, 0xC0, 0xF0, 0x38,
  0x0E, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x00, 0x3F, 0xE7, 0xFC, 0x03, 0x80,
  0xE0, 0x18, 0x06, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x00, 0xC0, 0x38, 0x0F,
  0xFD, 0xFF, 0x00, 0x1E, 0x3C, 0x60, 0xC1, 0x87, 0x0E, 0x18, 0x30, 0x60,
  0xC3, 0x87, 0x0C, 0x18, 0x30, 0x60, 0xF3, 0xC0, 0xCC, 0xCC, 0xCE, 0x66,
  0x66, 0x67, 0x33, 0x30, 0x1E, 0x3C, 0x38, 0x70, 0xC1, 0x83, 0x06, 0x0C,
  0x38, 0x70, 0xC1, 0x83, 0x06, 0x1C, 0x39, 0xE3, 0xC0, 0x0C, 0x18, 0x71,
  0xB3, 0x6C, 0xD9, 0xE1, 0xFF, 0xFF, 0x80, 0xE6, 0x30, 0x3E, 0x3F, 0x98,
  0xE0, 0x77, 0xF7, 0x9B, 0x0D, 0x8E, 0xFF, 0x3D, 0x80, 0x18, 0x06, 0x03,
  0x80, 0xE0, 0x37, 0x8F, 0xF3, 0x1C, 0xC3, 0x70, 0xDC, 0x76, 0x1D, 0x86,
  0x7F, 0xBF, 0xC0, 0x1F, 0x3F, 0x98, 0xFC, 0x3C, 0x06, 0x03, 0x01, 0xC6,
  0x7F, 0x1E, 0x00, 0x00, 0xC0, 0x30, 0x1C, 0x07, 0x3D, 0x9F, 0xE6, 0x3B,
  0x8E, 0xC3, 0xB0, 0xCC, 0x33, 0x9C, 0xFF, 0x1E, 0xC0, 0x1F, 0x3F, 0x98,
  0x7C, 0x3F, 0xFF, 0xFF, 0x01, 0xC2, 0x7F, 0x1F, 0x00, 0x03, 0x83, 0xF1,
  0xC4, 0x60, 0x18, 0x3F, 0xCF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0,
  0x70, 0x18, 0x06, 0x00, 0x1F, 0xE7, 0xF8, 0xC3, 0x38, 0x66, 0x1C, 0xC3,
  0x98, 0x63, 0x8C, 0x7F, 0x87, 0xB0, 0x0E, 0x21, 0x8F, 0xF0, 0x78, 0x00,
  0x18, 0x06, 0x03, 0x80, 0xC0, 0x37, 0x8F, 0xF3, 0x0D, 0xC3, 0x70, 0xD8,
  0x76, 0x1D, 0x86, 0x61, 0xB8, 0x60, 0x06, 0x07, 0x06, 0x00, 0x3E, 0x7E,
  0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0x1C, 0xFF, 0xFF, 0x01, 0x81, 0xC0, 0x40,
  0x11, 0xF0, 0xF8, 0x0C, 0x06, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30,
  0x38, 0x18, 0x7C, 0x7C, 0x00, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x1E,
  0x67, 0x0D, 0xC1, 0xF0, 0x7E, 0x0F, 0xC1, 0xDC, 0x31, 0x86, 0x39, 0xC3,
  0x80, 0x3F, 0x3E, 0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C,
  0x1C, 0xFF, 0xFF, 0x7F, 0xCF, 0xFD, 0x9B, 0xB3, 0x66, 0xEC, 0xD9, 0xB3,
  0x36, 0x66, 0xCD, 0xDB, 0xB0, 0x37, 0x8F, 0xF3, 0x1D, 0xC3, 0x71, 0xD8,
  0x76, 0x1D, 0x86, 0x61, 0xB8, 0x60, 0x3E, 0x3F, 0x98, 0xFC, 0x3C, 0x1E,
  0x0F, 0x0F, 0xC6, 0x7F, 0x3E, 0x00, 0x37, 0x8F, 0xE3, 0x1C, 0xC3, 0x70,
  0xDC, 0x76, 0x1D, 0x86, 0x7F, 0xBF, 0xCE, 0x03, 0x80, 0xC0, 0x30, 0x00,
  0x3F, 0xBF, 0xD8, 0x7C, 0x3C, 0x3E, 0x1B, 0x0D, 0xC6, 0xFF, 0x3D, 0x81,
  0xC0, 0xC0, 0x60, 0x30, 0x77, 0xBF, 0x9E, 0x0C, 0x06, 0x07, 0x03, 0x81,
  0x80, 0xC0, 0x60, 0x00, 0x3F, 0x3F, 0xD8, 0x6C, 0x07, 0xC0, 0xF8, 0x0D,
  0x86, 0xFF, 0x3F, 0x00, 0x38, 0x38, 0xFF, 0xFF, 0x30, 0x30, 0x70, 0x70,
  0x60, 0x70, 0x7E, 0x3E, 0x71, 0xD8, 0x66, 0x19, 0x86, 0xE3, 0xB8, 0xEC,
  0x33, 0x8C, 0xFF, 0x1E, 0xC0, 0xE1, 0xD8, 0x66, 0x39, 0x8C, 0x77, 0x0D,
  0x83, 0x60, 0xF0, 0x3C, 0x06, 0x00, 0xCC, 0xF3, 0x3C, 0xCF, 0x76, 0xD5,
  0xBD, 0x6F, 0x73, 0x9C, 0xE6, 0x31, 0x80, 0x30, 0xE3, 0x38, 0x6E, 0x07,
  0x80, 0xE0, 0x1C, 0x07, 0xC1, 0xD8, 0x73, 0x9C, 0x38, 0x70, 0x73, 0x0E,
  0x30, 0xC3, 0x9C, 0x39, 0x81, 0xB0, 0x1F, 0x01, 0xE0, 0x0E, 0x00, 0xC0,
  0x18, 0x03, 0x80, 0xF0, 0x0E, 0x00, 0x3F, 0xE7, 0xF8, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFF, 0xDF, 0xF0, 0x06, 0x1C, 0x70, 0xC1,
  0x83, 0x06, 0x18, 0xF1, 0x81, 0x81, 0x83, 0x0E, 0x1C, 0x30, 0x30, 0x70,
  0x18, 0x84, 0x23, 0x18, 0xC4, 0x21, 0x18, 0xC6, 0x31, 0x08, 0x46, 0x00,
  0x10, 0x70, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x0E, 0x1C, 0x61, 0x83, 0x06,
  0x0C, 0x38, 0x61, 0x80, 0x30, 0x0F, 0x8F, 0xBF, 0x63, 0xE0,
};

const GFXglyph RobotoMono_SemiBoldItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 5, 14, 11, 3, -14 },
  { 10, 6, 5, 11, 3, -14 },
  { 14, 11, 14, 11, 0, -14 },
  { 34, 10, 18, 11, 1, -16 },
  { 57, 9, 14, 11, 1, -14 },
  { 73, 11, 14, 11, 0, -14 },
  { 93, 2, 5, 11, 5, -14 },
  { 95, 6, 19, 11, 3, -15 },
  { 110, 7, 19, 11, 1, -15 },
  { 127, 9, 10, 11, 2, -14 },
  { 139, 9, 10, 11, 1, -11 },
  { 151, 4, 6, 11, 2, -2 },
  { 154, 8, 2, 11, 2, -7 },
  { 156, 4, 3, 11, 3, -3 },
  { 158, 10, 15, 11, 1, -14 },
  { 177, 9, 14, 11, 1, -14 },
  { 193, 7, 14, 11, 2, -14 },
  { 206, 10, 14, 11, 0, -14 },
  { 224, 10, 14, 11, 0, -14 },
  { 242, 10, 14, 11, 0, -14 },
  { 260, 10, 14, 11, 1, -14 },
  { 278, 9, 14, 11, 1, -14 },
  { 294, 10, 14, 11, 1, -14 },
  { 312, 9, 14, 11, 1, -14 },
  { 328, 9, 14, 11, 1, -14 },
  { 344, 5, 11, 11, 3, -11 },
  { 351, 5, 15, 11, 3, -11 },
  { 361, 9, 9, 11, 1, -10 },
  { 372, 9, 6, 11, 1, -9 },
  { 379, 9, 9, 11, 1, -10 },
  { 390, 9, 14, 11, 2, -14 },
  { 406, 11, 13, 11, 0, -13 },
  { 424, 11, 14, 11, -1, -14 },
  { 444, 11, 14, 11, 0, -14 },
  { 464, 10, 14, 11, 1, -14 },
  { 482, 11, 14, 11, 0, -14 },
  { 502, 11, 14, 11, 0, -14 },
  { 522, 12, 14, 11, 0, -14 },
  { 543, 10, 14, 11, 1, -14 },
  { 561, 11, 14, 11, 0, -14 },
  { 581, 10, 14, 11, 1, -14 },
  { 599, 10, 14, 11, 1, -14 },
  { 617, 12, 14, 11, 0, -14 },
  { 638, 9, 14, 11, 0, -14 },
  { 654, 11, 14, 11, 0, -14 },
  { 674, 11, 14, 11, 0, -14 },
  { 694, 10, 14, 11, 1, -14 },
  { 712, 11, 14, 11, 0, -14 },
  { 732, 10, 16, 11, 1, -14 },
  { 752, 11, 14, 11, 0, -14 },
  { 772, 10, 14, 11, 1, -14 },
  { 790, 11, 14, 11, 1, -14 },
  { 810, 10, 14, 11, 1, -14 },
  { 828, 10, 14, 11, 2, -14 },
  { 846, 11, 14, 11, 1, -14 },
  { 866, 13, 14, 11, -1, -14 },
  { 889, 10, 14, 11, 2, -14 },
  { 907, 11, 14, 11, 0, -14 },
  { 927, 7, 19, 11, 2, -16 },
  { 944, 4, 15, 11, 4, -14 },
  { 952, 7, 19, 11, 2, -16 },
  { 969, 7, 8, 11, 2, -14 },
  { 976, 9, 2, 11, 0, 0 },
  { 979, 4, 3, 11, 5, -14 },
  { 981, 9, 10, 11, 1, -10 },
  { 993, 10, 14, 11, 0, -14 },
  { 1011, 9, 10, 11, 1, -10 },
  { 1023, 10, 14, 11, 1, -14 },
  { 1041, 9, 10, 11, 1, -10 },
  { 1053, 10, 15, 11, 2, -15 },
  { 1072, 11, 14, 11, 0, -10 },
  { 1092, 10, 14, 11, 0, -14 },
  { 1110, 8, 14, 11, 1, -14 },
  { 1124, 9, 18, 11, 0, -14 },
  { 1145, 11, 14, 11, 0, -14 },
  { 1165, 8, 14, 11, 1, -14 },
  { 1179, 11, 10, 11, 0, -10 },
  { 1193, 10, 10, 11, 0, -10 },
  { 1206, 9, 10, 11, 1, -10 },
  { 1218, 10, 14, 11, 0, -10 },
  { 1236, 9, 14, 11, 1, -10 },
  { 1252, 9, 10, 11, 2, -10 },
  { 1264, 9, 10, 11, 1, -10 },
  { 1276, 8, 12, 11, 2, -12 },
  { 1288, 10, 10, 11, 1, -10 },
  { 1301, 10, 10, 11, 1, -10 },
  { 1314, 10, 10, 11, 1, -10 },
  { 1327, 11, 10, 11, 0, -10 },
  { 1341, 12, 14, 11, 0, -10 },
  { 1362, 11, 10, 11, 0, -10 },
  { 1376, 7, 18, 11, 3, -15 },
  { 1392, 5, 18, 11, 3, -14 },
  { 1404, 7, 18, 11, 2, -15 },
  { 1420, 11, 4, 11, 0, -8 },
};

const GFXfont RobotoMono_SemiBoldItalic19pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic19pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic19pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC19PT7B_H_
