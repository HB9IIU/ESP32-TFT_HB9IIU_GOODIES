#ifndef _ROBOTOMONO_SEMIBOLDITALIC58PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0,
  0x3F, 0xC0, 0x3F, 0x80, 0x3E, 0x00, 0x3F, 0x07, 0xE7, 0xE0, 0xF8, 0xF8,
  0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xE0,
  0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3C, 0x07, 0x8F, 0x81,
  0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x1E, 0x07, 0xC0,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x7C, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x78, 0x1F,
  0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3F, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF,
  0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0x81, 0xFC, 0x00,
  0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE,
  0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xC1, 0xFE,
  0x01, 0xFF, 0x07, 0xFF, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xC3, 0xE0, 0x20, 0xF8, 0x3E, 0x03,
  0x0F, 0x83, 0xE0, 0x7C, 0xF8, 0x3E, 0x0F, 0x8F, 0x83, 0xE0, 0xF0, 0xF8,
  0x3E, 0x1F, 0x0F, 0x83, 0xE3, 0xE0, 0xF8, 0x7E, 0x7C, 0x0F, 0xC7, 0xC7,
  0xC0, 0xFF, 0xFC, 0xF8, 0x07, 0xFF, 0x9F, 0x00, 0x3F, 0xF1, 0xF0, 0x01,
  0xFC, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x08, 0x00, 0x0F, 0x8F, 0xF0, 0x00, 0xF1, 0xFF, 0xC0, 0x1F,
  0x3F, 0xFC, 0x03, 0xE7, 0xFF, 0xE0, 0x7C, 0x7C, 0x3E, 0x07, 0xCF, 0x83,
  0xE0, 0xF8, 0xF8, 0x3E, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0xF8, 0x3E, 0x3E,
  0x0F, 0x83, 0xE0, 0xC0, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8,
  0x7C, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0x0F, 0xE0, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xE0, 0x01,
  0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0xC0, 0x01,
  0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0xFC, 0xFF, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xC0, 0x3F, 0x0F, 0xFF, 0xE0, 0x3F, 0x1F, 0xFF, 0xE0, 0x7F, 0x1F,
  0xEF, 0xF0, 0x7E, 0x3F, 0xC7, 0xF8, 0x7E, 0x7F, 0x83, 0xF8, 0xFE, 0x7F,
  0x83, 0xFC, 0xFC, 0x7F, 0x01, 0xFD, 0xFC, 0xFF, 0x01, 0xFF, 0xFC, 0xFF,
  0x00, 0xFF, 0xF8, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0x00, 0x7F, 0xF0, 0xFF,
  0x00, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE7, 0xF8, 0x03, 0xFF, 0x83, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x3E,
  0x7C, 0xFB, 0xF7, 0xEF, 0xDF, 0x3E, 0x7C, 0xFB, 0xF7, 0xCF, 0x9F, 0x3E,
  0x78, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xE0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x02, 0x00, 0xF8, 0x02, 0x38,
  0x0F, 0x80, 0xE7, 0xE0, 0xF8, 0x3E, 0x7F, 0x8F, 0x1F, 0xEF, 0xFE, 0xF7,
  0xFE, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0xFE, 0x3F, 0x00,
  0x1F, 0xC1, 0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x40, 0x06, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF0, 0x7F, 0x0F, 0xE0, 0x7C, 0x01,
  0x80, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x3F, 0x1F, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x7F, 0x02, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x07, 0xFC, 0x3F, 0xC0, 0xFF, 0x01,
  0xFE, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE3,
  0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0xFF, 0x3F, 0x80,
  0x0F, 0xF7, 0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x7F, 0xE7, 0xF0, 0x0F, 0xFE,
  0x7F, 0x03, 0xFF, 0xE7, 0xF0, 0x7F, 0xFE, 0x7F, 0x1F, 0xEF, 0xE7, 0xF3,
  0xF9, 0xFE, 0xFE, 0xFF, 0x1F, 0xCF, 0xFF, 0xC1, 0xFC, 0xFF, 0xF8, 0x1F,
  0xCF, 0xFE, 0x01, 0xFC, 0xFF, 0xC0, 0x1F, 0xCF, 0xF0, 0x03, 0xFC, 0xFE,
  0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x07,
  0xF8, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x07,
  0xF0, 0x1F, 0xE0, 0x7F, 0xC7, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x7C, 0x00, 0x7F, 0x80,
  0x7F, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F,
  0xFF, 0xDF, 0xF3, 0xFB, 0xF0, 0xFF, 0x70, 0x1F, 0xC8, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xE3, 0xFF, 0x01, 0xFE, 0x01,
  0xFE, 0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07,
  0xF0, 0x7F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x00, 0xFF, 0xC1, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFC,
  0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3C, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x3F, 0x80, 0x07, 0xF8, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x1F, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xCF,
  0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xF8,
  0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0x80, 0xFE, 0x00, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x00,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0x0E, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xF0, 0xFE, 0x00,
  0x3F, 0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x7F, 0xC0, 0x3F, 0xBF, 0xFC, 0x07, 0xEF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xDF, 0xF8, 0xFF,
  0xC0, 0xFF, 0xBF, 0xE0, 0x0F, 0xF7, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x1F,
  0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xE0,
  0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0xFE,
  0xFE, 0x00, 0x3F, 0xDF, 0xE0, 0x07, 0xF1, 0xFC, 0x01, 0xFE, 0x3F, 0xC0,
  0x7F, 0x83, 0xFE, 0x3F, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xF1, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xF8, 0x1F, 0xC0,
  0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x03,
  0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x81, 0xFC, 0x01, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x00,
  0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0xFE, 0x3F, 0xC0, 0x03, 0xF8,
  0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xFC, 0x1F,
  0xE0, 0x1F, 0xF0, 0x7F, 0xE3, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x03, 0xFE, 0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x1F,
  0xC7, 0xF0, 0x03, 0xF9, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF7, 0xF0,
  0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFD, 0xFC, 0x00, 0x7F, 0x3F, 0x80,
  0x0F, 0xE7, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x8F, 0xF8, 0x7F, 0xF1,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x3F, 0xFE,
  0xFE, 0x01, 0xFF, 0x3F, 0x80, 0x03, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0xFF, 0xE0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x03, 0xF8, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x7F, 0x81, 0xFF, 0x03, 0xFE, 0x0F, 0xFE, 0x1F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0x80, 0x08, 0x00, 0x00, 0x3E, 0x00, 0x7F,
  0x80, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0x7E, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x1E, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFE,
  0x0F, 0xF9, 0xFE, 0x01, 0xFE, 0x7F, 0x00, 0x3F, 0xBF, 0xC0, 0x0F, 0xEF,
  0xE0, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x00,
  0xF8, 0x03, 0xE0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x0F, 0x03, 0xE0, 0x7F,
  0x87, 0x81, 0xF0, 0xFF, 0xE3, 0xC1, 0xF0, 0xFF, 0xF9, 0xE0, 0xF0, 0xFF,
  0xF8, 0xF0, 0xF8, 0x7C, 0x3C, 0x78, 0x78, 0x7C, 0x1E, 0x3C, 0x7C, 0x7C,
  0x1E, 0x1E, 0x3E, 0x3E, 0x0F, 0x0F, 0x1E, 0x1E, 0x07, 0x87, 0x9F, 0x1F,
  0x03, 0xC3, 0xCF, 0x8F, 0x83, 0xE1, 0xE7, 0x87, 0x81, 0xE0, 0xF3, 0xC3,
  0xC0, 0xF0, 0x71, 0xE3, 0xE0, 0x78, 0x79, 0xF1, 0xF0, 0x7C, 0x3C, 0xF8,
  0xF8, 0x3C, 0x1E, 0x7C, 0x7C, 0x1E, 0x1E, 0x3E, 0x3E, 0x1F, 0x0F, 0x1F,
  0x1F, 0x9F, 0x8F, 0x0F, 0x87, 0xFF, 0xFF, 0x87, 0xC3, 0xFF, 0xFF, 0x81,
  0xE0, 0xFE, 0x7F, 0x80, 0xF0, 0x3E, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x02, 0x00,
  0x01, 0xFC, 0x07, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x03,
  0xFB, 0xF0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F,
  0xC1, 0xF8, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0,
  0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0, 0x07, 0xFC, 0x07,
  0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xFC,
  0x0F, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x0F, 0xF0, 0x1F, 0xC0, 0x03,
  0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0x80,
  0x07, 0xFC, 0x1F, 0xC0, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x01,
  0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x3F,
  0x80, 0x03, 0xF8, 0xFF, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0xFE, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF8,
  0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x81,
  0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFE, 0x07, 0xFE, 0x03, 0xFC,
  0x03, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0,
  0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0xE1, 0xFE, 0x00,
  0x1F, 0xC3, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0xFF, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x7F,
  0x8F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x80, 0x03, 0xF8,
  0xFE, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x87,
  0xF0, 0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F,
  0x00, 0x3F, 0xE0, 0xFE, 0x00, 0xFF, 0x81, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0xFF, 0xC3, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFC, 0x1F,
  0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x1F,
  0xFF, 0x9F, 0xC0, 0x7F, 0xFE, 0x3F, 0x80, 0xFF, 0xFC, 0x7F, 0x01, 0xFF,
  0xF8, 0xFE, 0x03, 0xFF, 0xF3, 0xFC, 0x07, 0xFF, 0xE7, 0xF8, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC,
  0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE0,
  0xFE, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x01, 0xFF, 0x9F, 0xFE, 0x03,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8,
  0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F,
  0xC0, 0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03,
  0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0x80,
  0x07, 0xF0, 0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0,
  0x01, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x1F,
  0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x80, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xC0,
  0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x80,
  0x7F, 0xE3, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xE0, 0x01,
  0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x3F,
  0x80, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x0F, 0xF8,
  0x00, 0x7F, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xC0,
  0xFF, 0x80, 0x01, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0xFF, 0x80, 0x00,
  0x7F, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0xFF, 0x80, 0x00, 0x3F, 0xC7, 0xFC,
  0x00, 0x01, 0xFC, 0x7F, 0xC0, 0x00, 0x0F, 0xE7, 0xFC, 0x00, 0x00, 0x7F,
  0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFD, 0xFE, 0x00, 0x00,
  0xFF, 0xCF, 0xF0, 0x00, 0x0F, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0xC1, 0xFE,
  0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0xFE,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0xE0, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F,
  0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE,
  0x07, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x7E, 0xF8, 0xFB,
  0xF0, 0x1F, 0xBE, 0x7F, 0xFC, 0x07, 0xEF, 0x9F, 0x7F, 0x03, 0xFB, 0xEF,
  0xDF, 0xC0, 0xFE, 0xFB, 0xF7, 0xE0, 0x3F, 0xBF, 0xF9, 0xF8, 0x0F, 0xCF,
  0xFE, 0x7E, 0x03, 0xF3, 0xFF, 0x3F, 0x80, 0xFC, 0xFF, 0xCF, 0xE0, 0x7F,
  0x1F, 0xE3, 0xF0, 0x1F, 0xC7, 0xF8, 0xFC, 0x07, 0xF1, 0xFC, 0x3F, 0x01,
  0xF8, 0x7F, 0x1F, 0xC0, 0x7E, 0x1F, 0x87, 0xF0, 0x3F, 0x87, 0xE1, 0xFC,
  0x0F, 0xE1, 0xF0, 0x7E, 0x03, 0xF8, 0x7C, 0x1F, 0x80, 0xFE, 0x1E, 0x0F,
  0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x03, 0xF0, 0x1F, 0xC0,
  0x01, 0xFC, 0x07, 0xE0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x3F, 0x81, 0xFE, 0x00, 0x1F, 0xC0, 0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0xC0,
  0x0F, 0xF0, 0x3F, 0xE0, 0x07, 0xF0, 0x1F, 0xF0, 0x03, 0xF8, 0x0F, 0xFC,
  0x01, 0xFC, 0x0F, 0xFE, 0x00, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0x03, 0xFF,
  0x80, 0x7F, 0x81, 0xFF, 0xE0, 0x3F, 0x80, 0xFF, 0xF0, 0x1F, 0xC0, 0xFF,
  0xF8, 0x0F, 0xE0, 0x7F, 0xFC, 0x07, 0xF0, 0x3F, 0xBF, 0x07, 0xF8, 0x1F,
  0xDF, 0x83, 0xF8, 0x0F, 0xEF, 0xC1, 0xFC, 0x07, 0xF3, 0xF0, 0xFE, 0x07,
  0xF9, 0xF8, 0x7F, 0x03, 0xFC, 0xFC, 0x7F, 0x81, 0xFC, 0x3E, 0x3F, 0xC0,
  0xFE, 0x1F, 0x9F, 0xC0, 0x7F, 0x0F, 0xCF, 0xE0, 0x3F, 0x87, 0xE7, 0xF0,
  0x3F, 0xC1, 0xF3, 0xF8, 0x1F, 0xC0, 0xFF, 0xFC, 0x0F, 0xE0, 0x7F, 0xFE,
  0x07, 0xF0, 0x3F, 0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0x01, 0xFC, 0x07, 0xFF,
  0x81, 0xFE, 0x03, 0xFF, 0xC0, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0x00, 0x7F,
  0xF0, 0x3F, 0x80, 0x3F, 0xF0, 0x1F, 0xC0, 0x1F, 0xF8, 0x1F, 0xE0, 0x07,
  0xFC, 0x0F, 0xF0, 0x03, 0xFE, 0x07, 0xF0, 0x01, 0xFF, 0x03, 0xF8, 0x00,
  0xFF, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xC7, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0,
  0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F, 0x9F, 0xC0, 0x00,
  0xFF, 0x3F, 0x80, 0x01, 0xFE, 0x7F, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x07,
  0xF3, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F,
  0x9F, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xF9,
  0xFE, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0xFE, 0x3F, 0xC0, 0x01, 0xFC, 0x3F,
  0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xF0, 0x07, 0xFC, 0x07, 0xF0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x81,
  0xFC, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x07, 0xF0,
  0x7F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFE,
  0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF,
  0x83, 0xF8, 0x00, 0xFF, 0x81, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xC7, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x1F,
  0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xF1, 0xFC,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFD, 0xFE, 0x00,
  0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0x3F, 0x9F, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x03,
  0xFD, 0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFC,
  0x3F, 0x80, 0x07, 0xF8, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x61, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xE0, 0x0F, 0xFC, 0x07, 0xF0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x03,
  0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC,
  0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xE0, 0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFF,
  0x03, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F,
  0xC0, 0x07, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x07, 0xF8, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xF8, 0x0F, 0xE0,
  0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x03, 0xF8,
  0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0,
  0x3F, 0xF9, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x1F, 0xE0,
  0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x1F, 0xE1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x00,
  0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x0F,
  0xF0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF8,
  0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xFC, 0x3F,
  0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFF, 0x0F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0,
  0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x3F, 0x81, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFF, 0x3F,
  0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x07,
  0xF8, 0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x0F,
  0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0x80, 0x1F,
  0xC0, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F,
  0x80, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x0F, 0xCF, 0xE0,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x03, 0xE0,
  0x3F, 0xBF, 0x03, 0xF0, 0x1F, 0x9F, 0x81, 0xF8, 0x1F, 0xCF, 0xC0, 0xFC,
  0x0F, 0xE7, 0xE0, 0x7E, 0x07, 0xF3, 0xF0, 0x7F, 0x03, 0xF1, 0xF8, 0x3F,
  0x83, 0xF8, 0xFC, 0x1F, 0xC1, 0xFC, 0x7E, 0x1F, 0xE0, 0xFC, 0x3F, 0x0F,
  0xF0, 0xFE, 0x1F, 0x87, 0xF8, 0x7F, 0x1F, 0xC7, 0xFC, 0x3F, 0x8F, 0xE3,
  0xFE, 0x1F, 0x87, 0xF1, 0xFF, 0x1F, 0xC3, 0xF8, 0xFF, 0x8F, 0xE1, 0xFC,
  0xFF, 0xC7, 0xE0, 0xFE, 0x7F, 0xE3, 0xF0, 0x7F, 0x3F, 0xF3, 0xF8, 0x3F,
  0xBE, 0xF9, 0xFC, 0x1F, 0x9F, 0x7C, 0xFC, 0x0F, 0xCF, 0xBE, 0x7E, 0x07,
  0xEF, 0x9F, 0x7F, 0x03, 0xF7, 0xCF, 0xBF, 0x01, 0xFB, 0xE7, 0xDF, 0x80,
  0xFF, 0xF3, 0xFF, 0xC0, 0x7F, 0xF1, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xE0,
  0x1F, 0xFC, 0x7F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF8, 0x07, 0xFE, 0x1F, 0xF8,
  0x03, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x1F, 0xE0, 0x7F,
  0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF0, 0x1F, 0xE0, 0x03, 0xF8, 0x0F,
  0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00,
  0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x01, 0xFF, 0x00,
  0x07, 0xF0, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x00, 0x3F, 0x87, 0xF8, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x3F, 0xC0, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x01, 0xFD, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01,
  0xFE, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00, 0x0F, 0xF1, 0xFE,
  0x00, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x03,
  0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x0F,
  0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x00,
  0x7F, 0x80, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xBF,
  0x80, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x7F, 0x83,
  0xF8, 0x00, 0x7F, 0xC1, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0,
  0x3F, 0x80, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0,
  0x03, 0xF8, 0x0F, 0xF0, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x7F, 0x07, 0xF8, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x07, 0xF3, 0xFC, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x80, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x07,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0xFD, 0xF0, 0x03, 0xF3, 0xE0, 0x07, 0xC7, 0xC0,
  0x1F, 0x8F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x1F, 0x03, 0xF0, 0x3E, 0x07,
  0xE0, 0x7C, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0xFC, 0x01, 0xF3, 0xF8,
  0x03, 0xE7, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xC0, 0x7F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xC0,
  0x7C, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xC7,
  0xFE, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xC3, 0xFE, 0x01, 0xFC, 0x7F, 0x80, 0x1F, 0xC7, 0xF0,
  0x01, 0xFC, 0xFF, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x3F,
  0x8F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x8F, 0xF8, 0x3F, 0xF8, 0x7F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xBF, 0x81, 0xFF, 0xF3,
  0xF8, 0x07, 0xFC, 0x3F, 0x80, 0x06, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x1F,
  0xCF, 0xFE, 0x00, 0xFE, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0xFF, 0x80, 0x7F,
  0x87, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F,
  0xE0, 0x03, 0xF8, 0xFF, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80,
  0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F,
  0xE7, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F,
  0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x1F, 0xE3, 0xFC, 0x01, 0xFE, 0x3F, 0xF0,
  0x1F, 0xF1, 0xFF, 0xE7, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0x9F, 0xFF, 0x01, 0xFC, 0x3F, 0xF0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x87, 0xFC, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xE7, 0xF0,
  0x01, 0xFD, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x3F, 0xC0, 0x0F, 0xE3, 0xF8, 0x03,
  0xFC, 0x7F, 0x80, 0xFF, 0x0F, 0xFC, 0x7F, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x7F,
  0xF9, 0xFE, 0x01, 0xFF, 0xFB, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x83, 0xFE, 0x01,
  0xFF, 0x07, 0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x3F, 0xC0, 0x07,
  0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x7F,
  0x87, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8,
  0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0xC1,
  0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F,
  0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF9, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x7E, 0x00, 0x3F,
  0xFD, 0xFC, 0x00, 0x3F, 0xE3, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x1F, 0xF8, 0x1F, 0xE1,
  0xFE, 0x00, 0xFE, 0x3F, 0xC0, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x7F, 0x80,
  0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFE, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x04, 0x07, 0xF8, 0x00, 0xE0, 0x7F,
  0xC0, 0x1F, 0x03, 0xFF, 0x0F, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0x03, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x7E, 0x00, 0x7F, 0xF9, 0xFC, 0x03, 0xFF, 0xFB, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0x03,
  0xFF, 0x07, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x07,
  0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F,
  0x87, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xFC,
  0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFE, 0x0F,
  0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xF3, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFB, 0xF8, 0x00, 0x7F, 0xE7, 0xF0, 0x00, 0x0C,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x40, 0x01,
  0xFE, 0x01, 0xC0, 0x07, 0xF8, 0x07, 0xE0, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x7F, 0x1F, 0xFC, 0x01, 0xFC, 0xFF, 0xF8, 0x07, 0xF7, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0x03, 0xFE,
  0x0F, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0xC3,
  0xF8, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x80, 0x0F, 0xE1, 0xFC,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00,
  0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0x8F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07,
  0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC,
  0x7F, 0x80, 0x0F, 0xF1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F,
  0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x8F, 0xF0,
  0x01, 0xFE, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x03, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x0F,
  0xFC, 0x1F, 0xC0, 0x0F, 0xF8, 0x0F, 0xE0, 0x0F, 0xF8, 0x07, 0xF0, 0x0F,
  0xF8, 0x03, 0xF8, 0x0F, 0xF8, 0x01, 0xFC, 0x0F, 0xF8, 0x01, 0xFE, 0x0F,
  0xF8, 0x00, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0x0F, 0xF8, 0x00, 0x3F, 0x8F,
  0xF8, 0x00, 0x1F, 0xCF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F,
  0xF7, 0xF0, 0x00, 0x3F, 0xF3, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F,
  0xE0, 0x7F, 0x80, 0x07, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x03,
  0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x80,
  0x7F, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xFC,
  0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFE, 0x07, 0xF3, 0xF0, 0x7C, 0x03, 0xF3, 0xFC, 0xFF,
  0x81, 0xFB, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xC7, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8,
  0x3F, 0x0F, 0xE1, 0xFC, 0x1F, 0x87, 0xE0, 0xFE, 0x0F, 0xC3, 0xF0, 0x7F,
  0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xF1, 0xFC, 0x1F, 0x83, 0xF8, 0xFE, 0x0F,
  0xC1, 0xF8, 0x7F, 0x0F, 0xE0, 0xFC, 0x3F, 0x07, 0xF0, 0x7E, 0x1F, 0x83,
  0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x3F, 0x8F, 0xE0, 0xFC, 0x1F, 0xC7, 0xF0,
  0x7E, 0x0F, 0xC3, 0xF8, 0x7F, 0x07, 0xE1, 0xF8, 0x3F, 0x83, 0xF0, 0xFC,
  0x1F, 0xC3, 0xF8, 0x7E, 0x0F, 0xC1, 0xFC, 0x7F, 0x07, 0xE0, 0xFE, 0x3F,
  0x83, 0xF0, 0x7E, 0x1F, 0xC3, 0xF8, 0x3F, 0x0F, 0xC1, 0xFC, 0x1F, 0x87,
  0xE0, 0xFC, 0x1F, 0xC7, 0xF0, 0x7E, 0x0F, 0xE3, 0xF8, 0x3F, 0x07, 0xF0,
  0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xC7, 0xFF, 0x00, 0x7F, 0x7F, 0xFE, 0x01,
  0xFB, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xC0, 0xFF, 0x83, 0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0x80,
  0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFE, 0x1F, 0xE0, 0x03,
  0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE,
  0x1F, 0xC0, 0x03, 0xF8, 0xFF, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x7F, 0x0F,
  0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x7F, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F,
  0xE3, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xE0, 0x7F, 0x83, 0xFC,
  0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF1, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x01,
  0xFC, 0x7F, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x7F, 0xBF, 0x80, 0x03, 0xFD,
  0xFC, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFF, 0x7F, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x3F, 0xBF, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xE7, 0xF0, 0x00,
  0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8,
  0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF9, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x01, 0xFF, 0x00, 0xFF,
  0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8,
  0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x0F,
  0xE0, 0x01, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xF0,
  0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xF0, 0x3F, 0xFC, 0x7F, 0xE0, 0x7F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFB, 0xFF,
  0xE0, 0x0F, 0xF1, 0xFF, 0x80, 0x1F, 0xC0, 0x30, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC3, 0xF8, 0x0F, 0xFF, 0x1F, 0xC0,
  0xFF, 0xFE, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xC0, 0xFF, 0xC7, 0xFC, 0x03, 0xFE, 0x3F, 0xC0, 0x0F,
  0xF3, 0xFC, 0x00, 0x7F, 0x1F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0xFE, 0x7F, 0x80, 0x0F, 0xF3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0,
  0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07,
  0xF1, 0xFC, 0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3,
  0xFC, 0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x83, 0xFF,
  0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xBF, 0x80, 0x1F, 0xF1, 0xFC, 0x00, 0x0C, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x3F, 0xF0, 0x7F, 0x0F, 0xFF, 0x07,
  0xF3, 0xFF, 0xE0, 0x7F, 0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xF8, 0x0C, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00, 0xFF, 0x1F, 0xC0,
  0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xE3,
  0xFE, 0x03, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0x7C,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xE0, 0x03, 0xF8,
  0xFF, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC,
  0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC7, 0xF8, 0x00,
  0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xFC,
  0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xF1, 0xFC,
  0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xE3, 0xF8, 0x00,
  0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x8F, 0xF0, 0x01, 0xFC,
  0x7F, 0x80, 0x1F, 0xE1, 0xFC, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F,
  0x80, 0xFF, 0x83, 0xFF, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0x7F, 0x01, 0xFF, 0xF3, 0xF0, 0x0F, 0xFF, 0x1F, 0x80, 0x1F, 0xF0, 0xFC,
  0x00, 0x1C, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0x7F, 0x9F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xF1, 0xFC,
  0x00, 0x3F, 0x83, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80,
  0x3F, 0xC0, 0xFE, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF8, 0x07, 0xE0, 0x1F,
  0xC0, 0x1F, 0x80, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xC0,
  0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x0F, 0xE0, 0x00,
  0xFE, 0x3F, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F,
  0xBF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x03, 0xC0, 0x7F, 0xFE, 0x07, 0xC0, 0x7F, 0xFE, 0x07, 0xC0,
  0x7E, 0xFE, 0x0F, 0xC0, 0xFE, 0xFE, 0x0F, 0xC0, 0xFE, 0xFC, 0x0F, 0xC0,
  0xFC, 0xFC, 0x1F, 0xC1, 0xFC, 0xFC, 0x1F, 0xE1, 0xF8, 0xFC, 0x1F, 0xE1,
  0xF8, 0xFC, 0x3F, 0xE1, 0xF8, 0xFC, 0x3F, 0xE3, 0xF0, 0xFC, 0x3F, 0xE3,
  0xF0, 0xFC, 0x7F, 0xE3, 0xF0, 0xFC, 0x7B, 0xE7, 0xE0, 0xFC, 0xFB, 0xE7,
  0xE0, 0xFC, 0xFB, 0xE7, 0xE0, 0xFC, 0xF3, 0xEF, 0xC0, 0xFD, 0xF3, 0xEF,
  0xC0, 0xFD, 0xE3, 0xEF, 0xC0, 0xFD, 0xE1, 0xFF, 0x80, 0xFF, 0xE1, 0xFF,
  0x80, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x00, 0xFF, 0xC1, 0xFF,
  0x00, 0xFF, 0x81, 0xFE, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0xFE, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF8, 0x07, 0xF0, 0x07, 0xFC, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01,
  0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x0F, 0xEF, 0xF8, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xDF, 0xE0, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07,
  0xF8, 0x1F, 0xC0, 0x03, 0xFE, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x07, 0xF0, 0x1F, 0xE0, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x01, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x03, 0xFC, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0xFF,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01,
  0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x0F, 0xE3,
  0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80,
  0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x1C, 0x1F, 0xFF, 0x80, 0x1F, 0x1F, 0xFF, 0xC0, 0x1F, 0x3F, 0xFF, 0xE0,
  0x3F, 0x7F, 0xFF, 0xF0, 0x7E, 0x7E, 0x0F, 0xFF, 0xFE, 0x7C, 0x03, 0xFF,
  0xFC, 0x7C, 0x01, 0xFF, 0xFC, 0xF8, 0x00, 0xFF, 0xF8, 0x08, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xC0,
};

const GFXglyph RobotoMono_SemiBoldItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 15, 41, 34, 10, -41 },
  { 78, 19, 15, 34, 10, -44 },
  { 114, 34, 41, 34, 0, -41 },
  { 289, 30, 54, 34, 3, -48 },
  { 492, 28, 43, 34, 4, -42 },
  { 643, 32, 43, 34, 1, -42 },
  { 815, 7, 16, 34, 15, -44 },
  { 829, 19, 59, 34, 9, -46 },
  { 970, 19, 59, 34, 5, -46 },
  { 1111, 28, 29, 34, 5, -41 },
  { 1213, 28, 30, 34, 3, -34 },
  { 1318, 12, 18, 34, 5, -7 },
  { 1345, 24, 6, 34, 7, -21 },
  { 1363, 10, 10, 34, 10, -9 },
  { 1376, 30, 45, 34, 3, -41 },
  { 1545, 28, 43, 34, 4, -42 },
  { 1696, 19, 41, 34, 7, -41 },
  { 1794, 31, 42, 34, 0, -42 },
  { 1957, 31, 43, 34, 1, -42 },
  { 2124, 30, 41, 34, 1, -41 },
  { 2278, 30, 42, 34, 3, -41 },
  { 2436, 27, 43, 34, 3, -42 },
  { 2582, 30, 41, 34, 4, -41 },
  { 2736, 30, 43, 34, 2, -42 },
  { 2898, 27, 42, 34, 4, -42 },
  { 3040, 15, 34, 34, 10, -33 },
  { 3104, 17, 44, 34, 8, -33 },
  { 3198, 27, 26, 34, 4, -31 },
  { 3286, 29, 18, 34, 3, -27 },
  { 3352, 28, 27, 34, 2, -31 },
  { 3447, 26, 42, 34, 7, -42 },
  { 3584, 33, 41, 34, 1, -41 },
  { 3754, 32, 41, 34, -2, -41 },
  { 3918, 33, 41, 34, 1, -41 },
  { 4088, 31, 43, 34, 2, -42 },
  { 4255, 31, 41, 34, 1, -41 },
  { 4414, 34, 41, 34, 1, -41 },
  { 4589, 34, 41, 34, 1, -41 },
  { 4764, 31, 43, 34, 2, -42 },
  { 4931, 33, 41, 34, 1, -41 },
  { 5101, 31, 41, 34, 2, -41 },
  { 5260, 32, 42, 34, 2, -41 },
  { 5428, 37, 41, 34, 1, -41 },
  { 5618, 28, 41, 34, 1, -41 },
  { 5762, 34, 41, 34, 1, -41 },
  { 5937, 33, 41, 34, 1, -41 },
  { 6107, 31, 43, 34, 2, -42 },
  { 6274, 33, 41, 34, 1, -41 },
  { 6444, 31, 49, 34, 2, -42 },
  { 6634, 33, 41, 34, 1, -41 },
  { 6804, 32, 43, 34, 2, -42 },
  { 6976, 33, 41, 34, 4, -41 },
  { 7146, 31, 42, 34, 3, -41 },
  { 7309, 32, 41, 34, 5, -41 },
  { 7473, 33, 41, 34, 4, -41 },
  { 7643, 39, 41, 34, -2, -41 },
  { 7843, 33, 41, 34, 5, -41 },
  { 8013, 35, 41, 34, 0, -41 },
  { 8193, 21, 57, 34, 7, -48 },
  { 8343, 14, 45, 34, 11, -41 },
  { 8422, 21, 57, 34, 7, -48 },
  { 8572, 23, 22, 34, 6, -41 },
  { 8636, 26, 6, 34, 0, 0 },
  { 8656, 12, 8, 34, 15, -42 },
  { 8668, 28, 32, 34, 2, -31 },
  { 8780, 29, 45, 34, 1, -44 },
  { 8944, 27, 32, 34, 3, -31 },
  { 9052, 31, 45, 34, 3, -44 },
  { 9227, 28, 32, 34, 3, -31 },
  { 9339, 31, 45, 34, 5, -45 },
  { 9514, 31, 43, 34, 1, -31 },
  { 9681, 30, 44, 34, 1, -44 },
  { 9846, 25, 43, 34, 3, -43 },
  { 9981, 27, 55, 34, 1, -43 },
  { 10167, 33, 44, 34, 1, -44 },
  { 10349, 26, 44, 34, 3, -44 },
  { 10492, 33, 31, 34, -1, -31 },
  { 10620, 30, 31, 34, 1, -31 },
  { 10737, 29, 32, 34, 2, -31 },
  { 10853, 31, 43, 34, -1, -31 },
  { 11020, 29, 43, 34, 3, -31 },
  { 11176, 28, 31, 34, 5, -31 },
  { 11285, 29, 32, 34, 2, -31 },
  { 11401, 26, 39, 34, 5, -38 },
  { 11528, 29, 32, 34, 3, -31 },
  { 11644, 30, 31, 34, 4, -31 },
  { 11761, 32, 31, 34, 3, -31 },
  { 11885, 34, 31, 34, 0, -31 },
  { 12017, 36, 43, 34, 0, -31 },
  { 12211, 31, 31, 34, 1, -31 },
  { 12332, 23, 55, 34, 8, -45 },
  { 12491, 13, 53, 34, 10, -41 },
  { 12578, 23, 55, 34, 5, -45 },
  { 12737, 32, 12, 34, 0, -23 },
};

const GFXfont RobotoMono_SemiBoldItalic58pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic58pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic58pt7bGlyphs,
  0x20, 0x7E, 77
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC58PT7B_H_
