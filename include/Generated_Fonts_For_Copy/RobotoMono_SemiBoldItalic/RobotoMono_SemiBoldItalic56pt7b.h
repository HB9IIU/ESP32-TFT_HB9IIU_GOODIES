#ifndef _ROBOTOMONO_SEMIBOLDITALIC56PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x01, 0xF8,
  0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0x00, 0x3E,
  0x0F, 0xCF, 0x83, 0xE7, 0xE0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03,
  0xE7, 0xC1, 0xF1, 0xF0, 0x7C, 0x78, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF3,
  0xE0, 0x78, 0xF8, 0x3E, 0x3C, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x07, 0x81, 0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x01, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F,
  0x03, 0xE0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03,
  0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00,
  0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x7F, 0xE0,
  0x7F, 0x80, 0xFF, 0x03, 0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xC1, 0xFC,
  0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC,
  0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xFC, 0x00,
  0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x81, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0xF8, 0x3E, 0x06, 0x1F, 0x07, 0xC1,
  0xF3, 0xC0, 0xF8, 0x3C, 0x78, 0x1F, 0x0F, 0x9F, 0x03, 0xC3, 0xE3, 0xE0,
  0xF8, 0xF8, 0x3E, 0x1F, 0x1E, 0x07, 0xC7, 0xE7, 0xC0, 0xFF, 0xF9, 0xF0,
  0x0F, 0xFE, 0x3C, 0x00, 0xFF, 0x8F, 0x80, 0x0F, 0xC3, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x78,
  0xFF, 0x80, 0x1F, 0x3F, 0xF8, 0x07, 0xCF, 0xFF, 0x81, 0xF3, 0xF3, 0xF0,
  0x3C, 0x7C, 0x3E, 0x0F, 0x9F, 0x07, 0xC3, 0xE3, 0xE0, 0x78, 0x78, 0x7C,
  0x1F, 0x1F, 0x0F, 0x83, 0xE1, 0xC1, 0xF0, 0x7C, 0x08, 0x3E, 0x0F, 0x80,
  0x07, 0xC3, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xCF, 0xF0, 0x00,
  0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x07,
  0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F,
  0x07, 0xF0, 0x00, 0x7E, 0x3F, 0xC0, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xF0,
  0x1F, 0x87, 0xFF, 0xE0, 0x3F, 0x1F, 0xEF, 0xE0, 0xFC, 0x7F, 0x9F, 0xE1,
  0xF8, 0xFE, 0x1F, 0xC3, 0xF3, 0xF8, 0x3F, 0xCF, 0xE7, 0xF0, 0x3F, 0xBF,
  0x9F, 0xE0, 0x7F, 0xFF, 0x3F, 0x80, 0x7F, 0xFC, 0x7F, 0x00, 0x7F, 0xF8,
  0xFE, 0x00, 0xFF, 0xE1, 0xFE, 0x00, 0xFF, 0x83, 0xFC, 0x03, 0xFE, 0x03,
  0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xF7, 0xF8, 0x03, 0xFF, 0x07, 0xF8, 0x00,
  0x60, 0x00, 0x00, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C,
  0x7C, 0x7C, 0x78, 0xF8, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x30, 0x0F,
  0x01, 0xDF, 0x03, 0xC1, 0xF7, 0xF0, 0xF1, 0xFF, 0xFF, 0x3B, 0xFF, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0x9F,
  0x00, 0x07, 0xC7, 0xC0, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0xFC,
  0x07, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0x80, 0x7C, 0x00, 0xC0, 0x0E, 0x00,
  0x10, 0x02, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F,
  0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0x38, 0x01, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0x1F,
  0x0F, 0xE7, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFD, 0xFE, 0x3F, 0x01, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFC, 0x7F, 0x81, 0xFE, 0x07, 0xF0,
  0x7F, 0x80, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xF8, 0x00, 0xFC, 0x7F, 0x00,
  0x1F, 0x8F, 0xE0, 0x03, 0xF1, 0xFC, 0x00, 0x7E, 0x7F, 0x00, 0x1F, 0xCF,
  0xE0, 0x07, 0xF9, 0xFC, 0x03, 0xFF, 0x3F, 0x80, 0xFF, 0xE7, 0xF0, 0x7F,
  0xFC, 0xFE, 0x1F, 0xFF, 0xBF, 0x8F, 0xF7, 0xF7, 0xF3, 0xF8, 0xFC, 0xFF,
  0xFE, 0x3F, 0x9F, 0xFF, 0x07, 0xF3, 0xFF, 0xC0, 0xFE, 0x7F, 0xE0, 0x1F,
  0xCF, 0xF8, 0x03, 0xFB, 0xFC, 0x00, 0x7E, 0x7F, 0x00, 0x1F, 0xCF, 0xE0,
  0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0xC3, 0xF0, 0x03, 0xF8,
  0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0xF0,
  0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC7, 0xFF, 0xF7, 0xFF, 0xF9, 0xFF,
  0xFE, 0xFF, 0xFF, 0xBF, 0xEF, 0xEF, 0xC3, 0xFB, 0x80, 0xFE, 0x80, 0x3F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x3F,
  0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0x8F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F,
  0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x0F,
  0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x1F, 0xF8,
  0x7F, 0xE0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xF9,
  0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x07, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0x80,
  0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x03, 0xF8, 0x07, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xF0,
  0x3F, 0x00, 0x7F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x7F, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x7F, 0xE0, 0x0F,
  0xC0, 0x3F, 0xC0, 0x02, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F,
  0x07, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x81,
  0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0xFC, 0xFF, 0xF0, 0x7F, 0x7F,
  0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF1, 0xFF, 0xC7, 0xFC, 0xFF,
  0xC0, 0x7F, 0xBF, 0xE0, 0x0F, 0xEF, 0xF0, 0x03, 0xFB, 0xF8, 0x00, 0xFE,
  0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x07, 0xEF, 0xE0, 0x01, 0xFB, 0xF8, 0x00,
  0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8,
  0x01, 0xFC, 0x7F, 0x00, 0xFF, 0x1F, 0xC0, 0x7F, 0x87, 0xFC, 0x3F, 0xE0,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x3F, 0xF3, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0x80,
  0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0,
  0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xF0,
  0x0F, 0xE0, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x7F, 0xC0, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x1F, 0xF9, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x3F, 0x80, 0x3F,
  0x87, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0xFE,
  0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xF0, 0x03,
  0xF8, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x0F, 0xF8, 0x7F, 0xC3, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x07, 0xFE, 0x7F, 0xC1, 0xFE, 0x07, 0xF0, 0xFF, 0x00, 0xFE, 0x3F,
  0x80, 0x3F, 0x9F, 0xE0, 0x07, 0xE7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x7F,
  0x7E, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xBF, 0xC0, 0x0F, 0xE7, 0xF0, 0x03, 0xF9, 0xFC,
  0x01, 0xFE, 0x7F, 0x81, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xDF, 0x80, 0x1F, 0xC7,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0xE0, 0x7F,
  0x83, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x81, 0xFE, 0x03, 0xF0, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x7F, 0x81, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFE, 0x07,
  0xF8, 0x0F, 0xC0, 0x08, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFE,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0x00, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x04, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE,
  0x7F, 0xF7, 0xFF, 0x7F, 0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0xF8, 0x01, 0xF8, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x1E, 0x07, 0xC1, 0xFE,
  0x1E, 0x07, 0x83, 0xFF, 0x1E, 0x0F, 0x87, 0xFF, 0x9E, 0x1F, 0x0F, 0xFF,
  0x1E, 0x1E, 0x1F, 0x8F, 0x1E, 0x1E, 0x1F, 0x0F, 0x1E, 0x3E, 0x3E, 0x0F,
  0x1E, 0x3C, 0x3C, 0x1E, 0x1E, 0x3C, 0x7C, 0x1E, 0x1E, 0x7C, 0x78, 0x1E,
  0x1E, 0x78, 0x78, 0x1E, 0x1E, 0x78, 0xF8, 0x3C, 0x1C, 0x78, 0xF8, 0x3C,
  0x1C, 0xF8, 0xF0, 0x3C, 0x3C, 0xF8, 0xF0, 0x3C, 0x3C, 0xF8, 0xF0, 0x7C,
  0x38, 0xF0, 0xF0, 0x78, 0x78, 0xF0, 0xF8, 0xF8, 0x70, 0xF8, 0xFF, 0xFC,
  0xF0, 0xF8, 0x7F, 0xFF, 0xE0, 0x78, 0x7F, 0xBF, 0xC0, 0x78, 0x3F, 0x1F,
  0x80, 0x78, 0x08, 0x0E, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x60, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0x7F, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x07, 0xF1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x87, 0xE0, 0x00,
  0x7E, 0x0F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0x80, 0x0F,
  0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0xFE,
  0x01, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0xC0, 0x01,
  0xF8, 0x7F, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F,
  0xEF, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80,
  0xFE, 0x01, 0xFF, 0x83, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFE, 0x0F,
  0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x7F, 0x07, 0xF0,
  0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFC, 0x07, 0xF0, 0x07, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x03,
  0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFE,
  0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0xC1,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0xFF, 0xC0, 0x7F, 0xC0,
  0x7F, 0x81, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07,
  0xF1, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFC,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0x7F,
  0x00, 0x3F, 0xC0, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x1F, 0xF8, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0x03, 0xFF, 0x01,
  0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F,
  0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80,
  0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01,
  0xFC, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F,
  0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F,
  0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xF1, 0xFC, 0x00,
  0x3F, 0x87, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0xFF,
  0x81, 0xFC, 0x07, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0xFF, 0xC0, 0x3F, 0xC0, 0x7F, 0x81,
  0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF1, 0xFE,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x01, 0xFF, 0xF9, 0xFC, 0x07, 0xFF, 0xC7, 0xF0, 0x1F, 0xFF, 0x3F,
  0xC0, 0xFF, 0xFC, 0xFE, 0x03, 0xFF, 0xF3, 0xF8, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x80, 0x1F,
  0xE0, 0xFF, 0x00, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7E, 0x03,
  0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFC, 0x07,
  0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x0F,
  0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x0F,
  0xC0, 0x03, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x3F,
  0x80, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x80, 0x01,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03,
  0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x7F,
  0x80, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F,
  0xF0, 0x3F, 0x80, 0x03, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0x80,
  0x0F, 0xF8, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x03,
  0xF8, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0xFF, 0x80, 0x07, 0xF0, 0x1F, 0xF0,
  0x00, 0x7F, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0xFE, 0x1F, 0xF0, 0x00, 0x0F,
  0xE3, 0xFE, 0x00, 0x00, 0xFE, 0x7F, 0xC0, 0x00, 0x0F, 0xEF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xF9, 0xFC, 0x00,
  0x03, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x03,
  0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0,
  0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8,
  0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x07, 0xFF, 0x0F, 0xFE,
  0x03, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0xC7, 0xFF, 0x80, 0xFF, 0xE3, 0xEF,
  0xC0, 0xFF, 0xF3, 0xFF, 0xE0, 0x7E, 0xF9, 0xF7, 0xE0, 0x3F, 0x3D, 0xFB,
  0xF0, 0x1F, 0x9E, 0xF9, 0xF8, 0x0F, 0xCF, 0xFC, 0xFC, 0x07, 0xE7, 0xFC,
  0xFE, 0x07, 0xF3, 0xFE, 0x7F, 0x03, 0xF1, 0xFE, 0x3F, 0x01, 0xF8, 0xFF,
  0x1F, 0x80, 0xFC, 0x7F, 0x0F, 0xC0, 0x7E, 0x3F, 0x8F, 0xE0, 0x7F, 0x0F,
  0x87, 0xF0, 0x3F, 0x87, 0xC3, 0xF0, 0x1F, 0xC3, 0xC1, 0xF8, 0x0F, 0xC1,
  0xE0, 0xFC, 0x07, 0xE0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x03, 0xF8, 0x1F,
  0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0x03, 0xFC, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0xFE,
  0x03, 0xFC, 0x00, 0xFE, 0x07, 0xFE, 0x00, 0xFE, 0x07, 0xFE, 0x00, 0xFE,
  0x07, 0xFE, 0x00, 0xFE, 0x07, 0xFF, 0x00, 0xFE, 0x07, 0xFF, 0x01, 0xFC,
  0x07, 0xFF, 0x01, 0xFC, 0x0F, 0xFF, 0x01, 0xFC, 0x0F, 0xFF, 0x81, 0xFC,
  0x0F, 0xFF, 0x81, 0xFC, 0x0F, 0xEF, 0x83, 0xFC, 0x0F, 0xEF, 0x83, 0xF8,
  0x0F, 0xEF, 0xC3, 0xF8, 0x1F, 0xCF, 0xC3, 0xF8, 0x1F, 0xC7, 0xC3, 0xF8,
  0x1F, 0xC7, 0xC3, 0xF8, 0x1F, 0xC7, 0xE7, 0xF0, 0x1F, 0xC7, 0xE7, 0xF0,
  0x1F, 0xC3, 0xE7, 0xF0, 0x3F, 0x83, 0xE7, 0xF0, 0x3F, 0x83, 0xF7, 0xF0,
  0x3F, 0x83, 0xF7, 0xF0, 0x3F, 0x81, 0xFF, 0xE0, 0x3F, 0x81, 0xFF, 0xE0,
  0x3F, 0x81, 0xFF, 0xE0, 0x7F, 0x00, 0xFF, 0xE0, 0x7F, 0x00, 0xFF, 0xE0,
  0x7F, 0x00, 0xFF, 0xE0, 0x7F, 0x00, 0xFF, 0xC0, 0x7F, 0x00, 0x7F, 0xC0,
  0xFE, 0x00, 0x7F, 0xC0, 0xFE, 0x00, 0x7F, 0xC0, 0xFE, 0x00, 0x7F, 0xC0,
  0xFE, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xC0, 0xFF, 0x01, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80,
  0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x01,
  0xF8, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE,
  0x7F, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0x9F,
  0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x7F, 0xBF, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0,
  0x7F, 0x00, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x03, 0xFE, 0x3F, 0xF0, 0x07,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xF8,
  0x03, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x0F, 0xE0,
  0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xC0, 0xFF, 0x01, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xF8,
  0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7F, 0x3F,
  0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x7F, 0x7F, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFC, 0xFE,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x1F, 0xC0,
  0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x3F,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x18, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFE,
  0x01, 0xFF, 0x01, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0,
  0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xF8, 0x3F, 0x80, 0x7F,
  0xE0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x03,
  0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xE0, 0x3F,
  0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x81, 0xFC,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0,
  0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xF3, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x07, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03,
  0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0x7F, 0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x00,
  0x07, 0xF0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x83,
  0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07,
  0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xF8,
  0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F,
  0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x07, 0xF0,
  0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80,
  0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03,
  0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0xFF, 0x00, 0xFF, 0x01, 0xFC, 0x07, 0xF8,
  0x07, 0xFC, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xBF, 0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x3F, 0xC7, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF8, 0x7F, 0x00, 0x1F,
  0xE1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0,
  0x7F, 0x80, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x0F,
  0xE0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8,
  0x1F, 0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x7E, 0x0F,
  0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x03, 0xF7, 0xF0, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x7F, 0x7E, 0x07, 0xC0, 0x7E, 0x7E, 0x07, 0xC0, 0xFE, 0x7E, 0x0F, 0xC0,
  0xFE, 0x7E, 0x0F, 0xC0, 0xFC, 0xFE, 0x0F, 0xC0, 0xFC, 0xFE, 0x1F, 0xC1,
  0xFC, 0xFE, 0x1F, 0xC1, 0xFC, 0xFE, 0x1F, 0xC1, 0xF8, 0xFE, 0x1F, 0xC1,
  0xF8, 0xFE, 0x3F, 0xC3, 0xF8, 0xFC, 0x3F, 0xC3, 0xF0, 0xFC, 0x3F, 0xC3,
  0xF0, 0xFC, 0x7F, 0xC7, 0xF0, 0xFC, 0x7F, 0xC7, 0xF0, 0xFC, 0x7F, 0xC7,
  0xE0, 0xFC, 0xFB, 0xC7, 0xE0, 0xFC, 0xFB, 0xCF, 0xE0, 0xFC, 0xFB, 0xCF,
  0xC0, 0xFD, 0xF3, 0xCF, 0xC0, 0xFD, 0xF3, 0xCF, 0xC0, 0xFD, 0xF3, 0xDF,
  0x80, 0xFD, 0xE3, 0xDF, 0x80, 0xFF, 0xE3, 0xDF, 0x80, 0xFF, 0xE3, 0xDF,
  0x80, 0xFF, 0xE3, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xC3, 0xFF,
  0x00, 0xFF, 0xC3, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x3F,
  0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00, 0x7F, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0x0F,
  0xE7, 0xF8, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x00, 0x1F, 0xE7,
  0xF0, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x07,
  0xF0, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x01, 0xFE, 0xFE, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x0F, 0xF3, 0xF8,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0x87, 0xF0, 0x01, 0xFE, 0x0F, 0xE0,
  0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0xFE, 0x0F,
  0xE0, 0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF1, 0xFC,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0,
  0x00, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x10, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3E, 0xF8, 0x01, 0xFB, 0xE0,
  0x07, 0xCF, 0x80, 0x3F, 0x3E, 0x00, 0xF8, 0xFC, 0x07, 0xE1, 0xF0, 0x3F,
  0x07, 0xC0, 0xFC, 0x1F, 0x07, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0xFC, 0x03,
  0xE3, 0xE0, 0x0F, 0x9F, 0x80, 0x3E, 0xFC, 0x00, 0xFC, 0x7F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xF8, 0x1F,
  0x81, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xF0, 0xFF, 0x87, 0xF8,
  0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xF8, 0x1F, 0x8F,
  0xF8, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03,
  0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x07, 0xF8, 0xFF,
  0x03, 0xFF, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x81, 0xFF, 0xF7, 0xF0, 0x1F, 0xF8, 0xFE, 0x00, 0x30, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x7F, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xE0, 0x07,
  0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F,
  0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00,
  0x7F, 0x1F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF3,
  0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x01, 0xFE, 0x7F, 0x80,
  0x1F, 0xC7, 0xFC, 0x03, 0xFC, 0x7F, 0xF0, 0xFF, 0x87, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0x07, 0xEF, 0xFF, 0xE0, 0xFE, 0x7F, 0xFC, 0x0F, 0xE3,
  0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE1, 0xFE, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xDF,
  0xE0, 0x03, 0xF7, 0xF0, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x3F, 0x3F, 0x80, 0x1F, 0xCF, 0xF0, 0x07, 0xF1, 0xFC, 0x03, 0xFC,
  0x7F, 0xC3, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x87, 0xF0,
  0x07, 0xFF, 0x1F, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFE, 0x03, 0xFE, 0x0F, 0xF0,
  0x07, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01,
  0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F,
  0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xC0, 0xFE,
  0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0,
  0x7F, 0xC0, 0x7F, 0xC7, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xDF, 0x80, 0x1F, 0xFE, 0x7E, 0x00, 0x1F, 0xF1, 0xF8,
  0x00, 0x04, 0x08, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xF8, 0x1F, 0xE1, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x07,
  0xE3, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x7F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x20, 0x7F, 0x80,
  0x06, 0x03, 0xFC, 0x01, 0xF0, 0x3F, 0xF0, 0x7F, 0x81, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0xFC, 0x01, 0xFF, 0xE7, 0xF0, 0x0F, 0xFF, 0xDF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F,
  0x80, 0xFF, 0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x80,
  0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x07,
  0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC,
  0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F,
  0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xFC,
  0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xDF,
  0x80, 0x07, 0xFC, 0xFE, 0x00, 0x01, 0x83, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x40, 0x03, 0xFC, 0x03, 0x80, 0x1F, 0xE0, 0x1F,
  0x80, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x0F,
  0xE0, 0x03, 0xF9, 0xFF, 0xC0, 0x1F, 0xDF, 0xFF, 0x00, 0xFD, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFE, 0x03, 0xFC, 0x1F,
  0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x7F, 0x00,
  0x0F, 0xC3, 0xF8, 0x00, 0x7E, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F,
  0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x1F,
  0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80,
  0x0F, 0xE1, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x1F,
  0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x1F,
  0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0xFE, 0x00,
  0xFF, 0x81, 0xFC, 0x03, 0xFE, 0x03, 0xF8, 0x0F, 0xF8, 0x07, 0xE0, 0x3F,
  0xE0, 0x1F, 0xC0, 0xFF, 0x80, 0x3F, 0x83, 0xFE, 0x00, 0x7F, 0x0F, 0xF8,
  0x00, 0xFE, 0x3F, 0xE0, 0x01, 0xFC, 0xFF, 0x80, 0x03, 0xF3, 0xFE, 0x00,
  0x0F, 0xEF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0xFD, 0xFE, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x3F,
  0x83, 0xFC, 0x00, 0x7E, 0x03, 0xFC, 0x01, 0xFC, 0x07, 0xF8, 0x03, 0xF8,
  0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xC0,
  0x1F, 0xE0, 0x3F, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0xE1, 0xFC, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x07, 0xE3, 0xE0, 0xF8, 0x07,
  0xE7, 0xF9, 0xFE, 0x07, 0xEF, 0xFB, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0x0F,
  0xC1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F,
  0xC1, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF0, 0x7E, 0x1F,
  0x83, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0x7E, 0x1F,
  0x83, 0xF0, 0xFE, 0x3F, 0x87, 0xF0, 0xFE, 0x3F, 0x87, 0xE0, 0xFC, 0x3F,
  0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x3F,
  0x07, 0xE1, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F, 0x0F, 0xC1, 0xF8, 0x7E,
  0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0xFE,
  0x0F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8, 0x07, 0xE0, 0xFF, 0x00, 0x3F,
  0x1F, 0xFC, 0x01, 0xF9, 0xFF, 0xF0, 0x0F, 0xDF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xE0, 0x3F, 0xC1, 0xFE, 0x00, 0xFE,
  0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFC, 0x3F,
  0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x7F,
  0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F,
  0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0x7F, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x3F,
  0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE,
  0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xE7, 0xF0,
  0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07,
  0xF7, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE,
  0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x03,
  0xFC, 0x7F, 0x00, 0x3F, 0x87, 0xF8, 0x07, 0xF8, 0x3F, 0xC1, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFC, 0x7F,
  0x00, 0x07, 0xE7, 0xFF, 0x00, 0x1F, 0xBF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x00, 0xFF, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0,
  0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x01,
  0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE,
  0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x07,
  0xFC, 0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xDF, 0xFE, 0x00, 0xFE, 0x3F,
  0xF0, 0x03, 0xF8, 0x0E, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x83, 0xF0, 0x1F,
  0xFE, 0x7F, 0x03, 0xFF, 0xF7, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFE, 0x1F, 0xE0, 0x3F, 0xE3, 0xFC, 0x01, 0xFE, 0x3F,
  0x80, 0x1F, 0xC7, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01,
  0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x8F,
  0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00,
  0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0,
  0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC3, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0xFE,
  0x00, 0x7F, 0xCF, 0xE0, 0x00, 0x40, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0xE0, 0xFC,
  0x3F, 0xF8, 0x1F, 0x8F, 0xFF, 0x03, 0xF7, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xF0, 0x04, 0x0F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0x83, 0xFE, 0x0F, 0xE0,
  0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x03,
  0xFC, 0x7F, 0x80, 0x7F, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x70, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x78,
  0x00, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1,
  0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xF8, 0x00, 0xFE, 0x3F, 0x80,
  0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFE,
  0x3F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0,
  0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x3F,
  0x87, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE,
  0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x07, 0xF0, 0x1F,
  0xF0, 0x7F, 0x87, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03,
  0xFF, 0xF7, 0xF0, 0x1F, 0xFE, 0x7E, 0x00, 0xFF, 0x87, 0xE0, 0x01, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0x9F, 0x80, 0x03,
  0xFC, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFE, 0x3F, 0x80, 0x0F, 0xE0,
  0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x00, 0x3F, 0x01, 0xFC,
  0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x01, 0xFC, 0x01, 0xF8, 0x0F,
  0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x7F, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x1F,
  0x9F, 0xC0, 0x00, 0x7C, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0xFF, 0xF8, 0x0F, 0x81, 0xFB, 0xF0,
  0x3F, 0x03, 0xF7, 0xE0, 0x7E, 0x0F, 0xEF, 0xC0, 0xFC, 0x1F, 0x9F, 0x83,
  0xF8, 0x3F, 0x3F, 0x07, 0xF0, 0xFE, 0x7E, 0x1F, 0xE1, 0xF8, 0xFC, 0x3F,
  0xC3, 0xF1, 0xF8, 0x7F, 0x87, 0xE3, 0xF1, 0xFF, 0x1F, 0x87, 0xE3, 0xDE,
  0x3F, 0x0F, 0xC7, 0xBC, 0x7E, 0x1F, 0x9F, 0x79, 0xF8, 0x3F, 0x3C, 0xF3,
  0xF0, 0x7E, 0x79, 0xE7, 0xC0, 0xFD, 0xE3, 0xDF, 0x81, 0xFB, 0xC7, 0xBF,
  0x03, 0xFF, 0x8F, 0x7C, 0x07, 0xFE, 0x1E, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0,
  0x1F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00,
  0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x07,
  0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7E, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x7F,
  0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x07, 0xF0, 0x3F,
  0xC0, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x3F,
  0xC0, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x0F,
  0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x00,
  0x0F, 0xF0, 0x0F, 0xE0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x07, 0xE1,
  0xFE, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x01,
  0xF9, 0xFC, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x60, 0x00, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78,
  0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x00, 0x00,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7C,
  0x7F, 0xFC, 0x00, 0xF9, 0xFF, 0xFE, 0x03, 0xF3, 0xFF, 0xFE, 0x07, 0xCF,
  0xF7, 0xFF, 0x3F, 0x9F, 0x83, 0xFF, 0xFF, 0x3E, 0x01, 0xFF, 0xFC, 0xF8,
  0x01, 0xFF, 0xF0, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x10, 0x00,
};

const GFXglyph RobotoMono_SemiBoldItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 14, 40, 33, 10, -40 },
  { 71, 18, 14, 33, 10, -42 },
  { 103, 33, 40, 33, 0, -40 },
  { 268, 29, 52, 33, 3, -46 },
  { 457, 27, 41, 33, 3, -40 },
  { 596, 31, 42, 33, 1, -41 },
  { 759, 8, 14, 33, 14, -42 },
  { 773, 19, 57, 33, 9, -44 },
  { 909, 20, 57, 33, 4, -44 },
  { 1052, 26, 28, 33, 5, -40 },
  { 1143, 27, 29, 33, 3, -33 },
  { 1241, 12, 18, 33, 5, -7 },
  { 1268, 23, 5, 33, 7, -20 },
  { 1283, 10, 10, 33, 9, -9 },
  { 1296, 29, 43, 33, 2, -40 },
  { 1452, 27, 41, 33, 3, -40 },
  { 1591, 18, 40, 33, 7, -40 },
  { 1681, 30, 40, 33, 0, -40 },
  { 1831, 29, 41, 33, 1, -40 },
  { 1980, 28, 40, 33, 1, -40 },
  { 2120, 30, 41, 33, 2, -40 },
  { 2274, 26, 41, 33, 3, -40 },
  { 2408, 29, 40, 33, 4, -40 },
  { 2553, 28, 41, 33, 2, -40 },
  { 2697, 26, 40, 33, 4, -40 },
  { 2827, 14, 33, 33, 10, -32 },
  { 2885, 17, 43, 33, 8, -32 },
  { 2977, 26, 26, 33, 4, -30 },
  { 3062, 28, 18, 33, 3, -26 },
  { 3125, 27, 26, 33, 2, -30 },
  { 3213, 24, 40, 33, 7, -40 },
  { 3333, 32, 40, 33, 1, -40 },
  { 3493, 31, 40, 33, -2, -40 },
  { 3648, 31, 40, 33, 1, -40 },
  { 3803, 30, 41, 33, 2, -40 },
  { 3957, 30, 40, 33, 1, -40 },
  { 4107, 33, 40, 33, 1, -40 },
  { 4272, 33, 40, 33, 1, -40 },
  { 4437, 30, 41, 33, 2, -40 },
  { 4591, 32, 40, 33, 1, -40 },
  { 4751, 30, 40, 33, 2, -40 },
  { 4901, 31, 41, 33, 2, -40 },
  { 5060, 36, 40, 33, 1, -40 },
  { 5240, 27, 40, 33, 1, -40 },
  { 5375, 33, 40, 33, 1, -40 },
  { 5540, 32, 40, 33, 1, -40 },
  { 5700, 30, 41, 33, 2, -40 },
  { 5854, 32, 40, 33, 1, -40 },
  { 6014, 30, 47, 33, 2, -40 },
  { 6191, 31, 40, 33, 1, -40 },
  { 6346, 31, 41, 33, 2, -40 },
  { 6505, 32, 40, 33, 4, -40 },
  { 6665, 30, 41, 33, 3, -40 },
  { 6819, 30, 40, 33, 5, -40 },
  { 6969, 32, 40, 33, 4, -40 },
  { 7129, 38, 40, 33, -2, -40 },
  { 7319, 31, 40, 33, 5, -40 },
  { 7474, 33, 40, 33, 0, -40 },
  { 7639, 20, 55, 33, 7, -46 },
  { 7777, 14, 43, 33, 10, -40 },
  { 7853, 20, 55, 33, 7, -46 },
  { 7991, 22, 21, 33, 6, -40 },
  { 8049, 25, 6, 33, 0, 0 },
  { 8068, 11, 7, 33, 15, -40 },
  { 8078, 27, 31, 33, 2, -30 },
  { 8183, 28, 43, 33, 1, -42 },
  { 8334, 26, 31, 33, 3, -30 },
  { 8435, 30, 43, 33, 3, -42 },
  { 8597, 28, 31, 33, 2, -30 },
  { 8706, 30, 43, 33, 5, -43 },
  { 8868, 30, 42, 33, 1, -30 },
  { 9026, 29, 42, 33, 1, -42 },
  { 9179, 24, 41, 33, 3, -41 },
  { 9302, 26, 53, 33, 1, -41 },
  { 9475, 31, 42, 33, 1, -42 },
  { 9638, 26, 42, 33, 2, -42 },
  { 9775, 32, 30, 33, -1, -30 },
  { 9895, 29, 30, 33, 1, -30 },
  { 10004, 28, 31, 33, 2, -30 },
  { 10113, 30, 41, 33, -1, -30 },
  { 10267, 28, 41, 33, 3, -30 },
  { 10411, 27, 30, 33, 5, -30 },
  { 10513, 28, 31, 33, 2, -30 },
  { 10622, 25, 38, 33, 5, -37 },
  { 10741, 28, 31, 33, 3, -30 },
  { 10850, 29, 30, 33, 4, -30 },
  { 10959, 31, 30, 33, 3, -30 },
  { 11076, 33, 30, 33, 0, -30 },
  { 11200, 35, 42, 33, 0, -30 },
  { 11384, 30, 30, 33, 1, -30 },
  { 11497, 22, 54, 33, 8, -44 },
  { 11646, 12, 51, 33, 10, -40 },
  { 11723, 22, 54, 33, 5, -44 },
  { 11872, 31, 12, 33, 0, -22 },
};

const GFXfont RobotoMono_SemiBoldItalic56pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic56pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic56pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC56PT7B_H_
