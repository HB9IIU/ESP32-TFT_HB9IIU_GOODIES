#ifndef _ROBOTOMONO_SEMIBOLDITALIC44PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C,
  0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1E, 0x00, 0x78, 0x3D, 0xE1, 0xE7,
  0x87, 0x9E, 0x1E, 0x78, 0x7B, 0xC1, 0xEF, 0x07, 0x3C, 0x3C, 0xF0, 0xF3,
  0x83, 0xCE, 0x0F, 0x00, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x00,
  0xF0, 0xF0, 0x00, 0x38, 0x38, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x80,
  0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x38, 0x3C, 0x03, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x10, 0xF0, 0xF0, 0x00, 0x3C,
  0x3C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00,
  0x70, 0x70, 0x00, 0x3C, 0x3C, 0x21, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x00, 0x78, 0x78, 0x00, 0x1C, 0x1C, 0x00, 0x0F, 0x0F,
  0x00, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1C,
  0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x1F,
  0xC1, 0xF8, 0x3F, 0x01, 0xF8, 0x7C, 0x03, 0xF0, 0xF8, 0x07, 0xE1, 0xF0,
  0x0F, 0xC3, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF3,
  0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x1F,
  0x80, 0xFC, 0x3F, 0x87, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x7F,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x01, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0x0F, 0x04, 0x78, 0x78, 0x7B, 0xC3,
  0xC7, 0x9E, 0x1E, 0x38, 0xF0, 0xE3, 0xC7, 0x8F, 0x3C, 0x3E, 0xF9, 0xC1,
  0xFF, 0x9E, 0x07, 0xF9, 0xE0, 0x0F, 0x8E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x9F, 0x80,
  0x39, 0xFF, 0x03, 0xDF, 0xF8, 0x3C, 0xF3, 0xE1, 0xCF, 0x0F, 0x1C, 0x78,
  0x79, 0xE3, 0xC3, 0xCE, 0x1E, 0x1E, 0x10, 0xF0, 0xE0, 0x07, 0x8F, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xE1,
  0xF0, 0x07, 0xE1, 0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xC1,
  0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xCF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC,
  0x1F, 0x1F, 0xFC, 0x1F, 0x3F, 0x7E, 0x1F, 0x7E, 0x3F, 0x3E, 0x7C, 0x3F,
  0x3E, 0xFC, 0x1F, 0xFE, 0xFC, 0x1F, 0xFC, 0xF8, 0x0F, 0xF8, 0xFC, 0x07,
  0xF8, 0xFC, 0x07, 0xF0, 0xFE, 0x1F, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFE, 0xFC, 0x0F, 0xF8, 0xFC, 0x3C, 0xF7, 0xDE, 0x79, 0xE7,
  0x9E, 0xF3, 0xCF, 0x00, 0x00, 0x04, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xF0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x10, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x70, 0x00, 0x40, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x20, 0x3C, 0x01, 0xC1, 0xC0, 0xCF, 0x8E, 0x3E, 0xFF, 0x77, 0xF7, 0xFF,
  0xFF, 0xC7, 0xFF, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xFC, 0x00,
  0x1E, 0xF0, 0x01, 0xE7, 0x80, 0x1F, 0x1E, 0x01, 0xF0, 0xF8, 0x1F, 0x03,
  0xC0, 0x70, 0x1F, 0x01, 0x80, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x87, 0xC3, 0xE3, 0xF1, 0xF0, 0xF8, 0x7C, 0x7E, 0x3E, 0x3E,
  0x1F, 0x1F, 0x07, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3C, 0x7E, 0x7F, 0xFF, 0xFF, 0x7F, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F,
  0xE1, 0xF8, 0x7C, 0x07, 0xC7, 0xE0, 0x3F, 0x3E, 0x00, 0xF9, 0xF0, 0x07,
  0xDF, 0x80, 0x3E, 0xFC, 0x03, 0xF7, 0xC0, 0x7F, 0xBE, 0x07, 0xFD, 0xF0,
  0xFF, 0xCF, 0x8F, 0xFE, 0xFD, 0xF9, 0xF7, 0xFF, 0x8F, 0xBF, 0xF0, 0xFD,
  0xFF, 0x07, 0xEF, 0xE0, 0x3F, 0x7E, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00,
  0xFC, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3F, 0x03, 0xF0, 0xFC, 0x3F, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0xFC, 0x07, 0xF8, 0x7F, 0xE7, 0xFF, 0xCF, 0xFF,
  0x9F, 0xFF, 0x3E, 0x7E, 0xE0, 0xFD, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0xFC, 0x1F, 0xC3, 0xF0, 0x1F, 0x87, 0xC0, 0x1F, 0x1F,
  0x80, 0x3E, 0x3F, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFC,
  0x1F, 0x83, 0xF0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xE3, 0xF0,
  0x0F, 0xC3, 0xF8, 0x7F, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xF3, 0xE0,
  0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x80, 0x7C, 0x3F, 0x00, 0xF8, 0x7C, 0x03,
  0xE0, 0xF8, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0xF8, 0x0F, 0xC1, 0xF0,
  0x1F, 0x87, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x20, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0x83, 0xF8, 0x02, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x01, 0xF8, 0xFC, 0x03, 0xE1, 0xF8, 0x0F,
  0xC1, 0xF8, 0x3F, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x7F, 0x00,
  0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x3C, 0x03, 0xEF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0x7F, 0x07, 0xF3, 0xF0, 0x1F, 0xBF, 0x00, 0x7D, 0xF8, 0x03, 0xEF, 0xC0,
  0x1F, 0x7E, 0x00, 0xFB, 0xF0, 0x07, 0xDF, 0x80, 0x3E, 0xFC, 0x03, 0xF3,
  0xE0, 0x1F, 0x1F, 0x81, 0xF8, 0xFE, 0x3F, 0x83, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x87, 0xE0, 0xF8, 0x0F, 0xC7, 0xE0,
  0x3F, 0x1F, 0x80, 0xFC, 0x7C, 0x03, 0xF1, 0xF0, 0x0F, 0x87, 0xE0, 0x3E,
  0x1F, 0x81, 0xF8, 0x3F, 0x9F, 0xC0, 0x7F, 0xFE, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xF8, 0xFE, 0x1F, 0x80, 0xF8, 0x7C, 0x03,
  0xF3, 0xF0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0xFC, 0xF8, 0x03, 0xF3,
  0xF0, 0x0F, 0xCF, 0xC0, 0x7E, 0x3F, 0x87, 0xF8, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xF0,
  0x07, 0xFF, 0x80, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xF8, 0x7E, 0x3F, 0x03,
  0xF7, 0xE0, 0x1F, 0x7E, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0x7C, 0x03, 0xF7, 0xC0, 0x3F, 0x7E,
  0x07, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFB, 0xE0,
  0x3C, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xC0,
  0x03, 0xF0, 0x00, 0x07, 0x81, 0xF8, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0x83,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x3F, 0x0F, 0xE1, 0xFE, 0x3F, 0x87, 0xF0,
  0x7C, 0x00, 0x01, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03,
  0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0x70, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x03, 0x80, 0x00, 0x7C, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xF8,
  0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x00,
  0x01, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF0, 0x10, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x80, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x1F, 0xE0,
  0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xE0,
  0x07, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE7, 0xF0, 0x7E, 0x7E, 0x03, 0xF7, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x3C, 0x00, 0x78, 0x3C, 0x08, 0x1C, 0x1C, 0x3F, 0x8E, 0x1E, 0x3F, 0xE7,
  0x1E, 0x3F, 0xF3, 0x8E, 0x3C, 0x39, 0xC7, 0x1E, 0x38, 0xE7, 0x9E, 0x1C,
  0x73, 0x8F, 0x0E, 0x39, 0xC7, 0x07, 0x1D, 0xE7, 0x87, 0x0E, 0xF3, 0xC3,
  0x87, 0x71, 0xE1, 0xC7, 0x38, 0xE0, 0xE3, 0x9C, 0x78, 0xF1, 0xCE, 0x3C,
  0xF1, 0xC7, 0x1F, 0xFF, 0xE3, 0xC7, 0xEF, 0xE1, 0xE3, 0xE7, 0xE0, 0x70,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x07, 0xCF, 0x80, 0x03,
  0xE3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x7C, 0x00,
  0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE,
  0x0F, 0x80, 0x1F, 0x0F, 0xC0, 0x0F, 0x87, 0xC0, 0x07, 0xC7, 0xE0, 0x03,
  0xF3, 0xF0, 0x01, 0xFB, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7E, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xC0,
  0xFF, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80,
  0x1F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x7E, 0x1F, 0x01,
  0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x3E, 0x01, 0xFC, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x7C, 0x7C, 0x00,
  0xFC, 0x7C, 0x01, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFC, 0x1F,
  0x87, 0xE0, 0x1F, 0x8F, 0x80, 0x3F, 0x3F, 0x00, 0x3E, 0x7C, 0x00, 0x7D,
  0xF8, 0x00, 0xFB, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x3E, 0x7C, 0x00, 0xFC, 0xFC, 0x01, 0xF1, 0xF8, 0x07, 0xE1, 0xF0, 0x1F,
  0xC3, 0xF8, 0x7F, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7E, 0x3F, 0xC0, 0x3E, 0x03,
  0xF0, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x07, 0xE0,
  0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xF0, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0x7C,
  0x00, 0xF8, 0x7E, 0x00, 0x7C, 0x3F, 0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x0F,
  0x80, 0x1F, 0x87, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xC3, 0xF0, 0x07, 0xE1,
  0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0x7C, 0x01, 0xF8, 0x3E, 0x01, 0xF8,
  0x3F, 0x03, 0xF8, 0x1F, 0xDF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC1, 0xFC, 0x1F, 0x87, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F,
  0x3F, 0x00, 0x3E, 0x7E, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x1F, 0xFD, 0xF8, 0x3F, 0xFB, 0xF0, 0x7F, 0xF7, 0xC0, 0xFF, 0xEF, 0x80,
  0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01,
  0xF9, 0xF8, 0x03, 0xF1, 0xF8, 0x07, 0xC3, 0xF8, 0x3F, 0x83, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x03, 0xE0, 0x0F,
  0xC0, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xF8, 0x1F, 0x80, 0x3E, 0x07, 0xC0,
  0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F,
  0xC0, 0x1F, 0x03, 0xF0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C,
  0x0F, 0x80, 0x3F, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xC0, 0x1F, 0x81, 0xF0, 0x07, 0xE0, 0xFC,
  0x01, 0xF8, 0x3F, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0,
  0xF8, 0x03, 0xF0, 0x3E, 0x00, 0xFC, 0x1F, 0x80, 0x3E, 0x07, 0xE0, 0x0F,
  0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x7E, 0x0F, 0xC0,
  0x1F, 0x80, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0x7C,
  0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0xC3, 0xF8, 0x07, 0xFF, 0xF8, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xE0, 0x0F,
  0xF0, 0x7C, 0x01, 0xFC, 0x07, 0xC0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x0F,
  0xC0, 0x7E, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0x81, 0xFC, 0x00, 0xF8, 0x3F,
  0x80, 0x0F, 0x87, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x1F, 0x9F, 0xC0, 0x01,
  0xF3, 0xF8, 0x00, 0x1F, 0x7F, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x3F, 0xDF, 0x80, 0x03, 0xF9, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xE0,
  0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xC0, 0x7E, 0x00, 0x7C, 0x03, 0xF0,
  0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0xFC,
  0x01, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x7F,
  0xC1, 0xFE, 0x1F, 0xE0, 0x7F, 0x8F, 0xF8, 0x1F, 0xE3, 0xFE, 0x0F, 0xB9,
  0xFF, 0x83, 0xEF, 0x7B, 0xE0, 0xFB, 0xDE, 0xF8, 0x3E, 0xFF, 0x3C, 0x0F,
  0xBF, 0xDF, 0x03, 0xCF, 0xE7, 0xC1, 0xF3, 0xF9, 0xF0, 0x7C, 0xFC, 0x7C,
  0x1F, 0x3F, 0x1F, 0x07, 0xC7, 0x8F, 0x81, 0xF1, 0xE3, 0xE0, 0xFC, 0x78,
  0xF8, 0x3E, 0x1C, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x07, 0xE0, 0xF8,
  0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x07, 0xC0, 0x07, 0xC1,
  0xF0, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x0F, 0xC0, 0x0F,
  0x80, 0x03, 0xE0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0xF8, 0x1F,
  0xC0, 0x3E, 0x07, 0xF8, 0x0F, 0x81, 0xFE, 0x07, 0xE0, 0x7F, 0x81, 0xF8,
  0x3F, 0xE0, 0x7E, 0x0F, 0xFC, 0x1F, 0x03, 0xFF, 0x07, 0xC0, 0xFB, 0xC1,
  0xF0, 0x3E, 0xF0, 0xFC, 0x0F, 0xBE, 0x3F, 0x07, 0xE7, 0x8F, 0xC1, 0xF9,
  0xE3, 0xE0, 0x7E, 0x78, 0xF8, 0x1F, 0x1F, 0x7E, 0x07, 0xC3, 0xDF, 0x81,
  0xF0, 0xF7, 0xE0, 0xFC, 0x3D, 0xF8, 0x3F, 0x0F, 0xFC, 0x0F, 0xC1, 0xFF,
  0x03, 0xE0, 0x7F, 0xC0, 0xF8, 0x1F, 0xF0, 0x3E, 0x07, 0xFC, 0x1F, 0x80,
  0xFE, 0x07, 0xE0, 0x3F, 0x81, 0xF8, 0x0F, 0xE0, 0x7C, 0x03, 0xF8, 0x1F,
  0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFC, 0x3F, 0x87,
  0xE0, 0x3F, 0x0F, 0x80, 0x3E, 0x3F, 0x00, 0x7C, 0x7C, 0x00, 0xFD, 0xF8,
  0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xC0, 0x07, 0xEF, 0x80, 0x0F, 0xDF, 0x00,
  0x1F, 0xFE, 0x00, 0x3E, 0xFC, 0x00, 0x7D, 0xF8, 0x00, 0xFB, 0xE0, 0x03,
  0xF7, 0xC0, 0x07, 0xEF, 0x80, 0x0F, 0xDF, 0x00, 0x1F, 0x3E, 0x00, 0x7E,
  0x7C, 0x00, 0xFC, 0xF8, 0x03, 0xF1, 0xF8, 0x07, 0xE1, 0xF0, 0x1F, 0x83,
  0xF8, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x7C, 0x0F, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0x7E,
  0x1F, 0x80, 0x3F, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x0F, 0xC3, 0xE0, 0x07,
  0xE3, 0xF0, 0x03, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xF8, 0x7C, 0x07,
  0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFC, 0x3F, 0x87, 0xE0, 0x3F, 0x0F,
  0x80, 0x3E, 0x3F, 0x00, 0x7E, 0x7C, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0,
  0x03, 0xF7, 0xC0, 0x07, 0xEF, 0x80, 0x0F, 0xDF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7D, 0xF8, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x07,
  0xEF, 0x80, 0x0F, 0xDF, 0x00, 0x1F, 0xBE, 0x00, 0x3E, 0x7C, 0x00, 0xFC,
  0xFC, 0x01, 0xF1, 0xF8, 0x07, 0xE1, 0xF0, 0x1F, 0x83, 0xF8, 0xFE, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x0C, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0xFC, 0x0F, 0xF0, 0x7E, 0x01, 0xF8, 0x3E, 0x00, 0xFC,
  0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x0F, 0xC0, 0x0F, 0x87, 0xE0, 0x0F,
  0xC3, 0xF0, 0x07, 0xE1, 0xF0, 0x07, 0xE0, 0xF8, 0x07, 0xF0, 0x7C, 0x1F,
  0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x07, 0xC1, 0xF8, 0x03, 0xE0, 0x7C, 0x03, 0xF0, 0x3F, 0x01, 0xF8,
  0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x3F,
  0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xC0, 0x0F, 0xC3,
  0xE0, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0x83, 0xF8, 0x3F, 0x00,
  0xFC, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE3,
  0xF0, 0x01, 0xF1, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0x7C, 0x3E, 0x00, 0x7E,
  0x1F, 0x80, 0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x0F,
  0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F,
  0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F,
  0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x3E,
  0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x7C,
  0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC,
  0x01, 0xF0, 0xFC, 0x01, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xE0, 0x7E,
  0x07, 0xE0, 0x7F, 0x1F, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0x7C,
  0x01, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E,
  0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x3E,
  0x3F, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x3E, 0x0F, 0xBE, 0x1F, 0x0F, 0x9E,
  0x0F, 0x87, 0xCF, 0x0F, 0xC3, 0xE7, 0x87, 0xE1, 0xF7, 0xC3, 0xF1, 0xF3,
  0xE1, 0xF8, 0xF9, 0xF1, 0xFC, 0x7C, 0xF8, 0xFE, 0x7C, 0x7C, 0x7F, 0x3E,
  0x3E, 0x7F, 0x9F, 0x1F, 0x3F, 0xCF, 0x8F, 0x9F, 0xEF, 0x87, 0xDE, 0xF7,
  0xC3, 0xEF, 0x7B, 0xE1, 0xF7, 0xBD, 0xE0, 0xFB, 0x9F, 0xF0, 0x7F, 0xCF,
  0xF8, 0x3F, 0xE7, 0xFC, 0x1F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF8,
  0xFF, 0x03, 0xFC, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F,
  0x0F, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07,
  0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0x80,
  0x3F, 0x80, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x1F, 0x81, 0xFC,
  0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x00,
  0x7C, 0x7E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xFC,
  0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x7F, 0x00, 0xFC, 0x07,
  0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x3F, 0xBE, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0x83,
  0xE0, 0x1F, 0x81, 0xF0, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0,
  0x1F, 0x07, 0xE0, 0x0F, 0x87, 0xE0, 0x07, 0xE3, 0xF0, 0x01, 0xF3, 0xF0,
  0x00, 0xF9, 0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x03,
  0xFF, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0xF8, 0x0F, 0x01, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x03, 0xFF, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1E, 0xE0, 0x1F, 0x78, 0x0F,
  0x3C, 0x0F, 0x9E, 0x07, 0x8F, 0x07, 0xC7, 0xC7, 0xC1, 0xE3, 0xC0, 0xF3,
  0xE0, 0x79, 0xE0, 0x3F, 0xF0, 0x1F, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x7C, 0x7C, 0x3E, 0x1E, 0x0F, 0x00, 0x3E,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x7E, 0x07, 0xE1, 0xF8, 0x0F, 0x87, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0x07,
  0xE7, 0xF0, 0x1F, 0x1F, 0x80, 0x7C, 0x7C, 0x01, 0xF3, 0xF0, 0x0F, 0xCF,
  0xC0, 0x7F, 0x1F, 0x83, 0xFC, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF,
  0xBE, 0x03, 0xFC, 0xFC, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x1C, 0x00, 0xF9, 0xFE, 0x03, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFC, 0x1F, 0x87, 0xE0, 0x3F,
  0x1F, 0x00, 0xFC, 0x7C, 0x01, 0xF3, 0xF0, 0x07, 0xCF, 0xC0, 0x1F, 0x3F,
  0x00, 0x7C, 0xF8, 0x03, 0xF3, 0xE0, 0x0F, 0xCF, 0x80, 0x3F, 0x7E, 0x00,
  0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0xFC, 0x7F, 0x87, 0xF1,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3E, 0x7F, 0xE0, 0xF8, 0xFF, 0x00, 0x00,
  0x3C, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x0F, 0xC1, 0xF8, 0xFC, 0x07, 0xE7, 0xC0, 0x1F, 0x7E, 0x00, 0xFB, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x03, 0xF3, 0xE0, 0x1F, 0x1F, 0x81,
  0xF8, 0xFE, 0x1F, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x70, 0x7C, 0x03,
  0xFE, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F,
  0x83, 0xF8, 0x3F, 0x01, 0xF8, 0x7E, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0x7C,
  0x01, 0xF8, 0x7C, 0x01, 0xF8, 0xFC, 0x01, 0xF0, 0xFC, 0x01, 0xF0, 0xFC,
  0x01, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xE0, 0xFC,
  0x03, 0xE0, 0x7C, 0x07, 0xE0, 0x7F, 0x1F, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFB, 0xC0, 0x0F, 0xE7, 0xC0, 0x00, 0x1C, 0x00, 0x0F,
  0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xE1, 0xFC,
  0xFC, 0x03, 0xE7, 0xC0, 0x1F, 0x7E, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x04, 0x1F, 0x80, 0x70, 0xFE, 0x0F,
  0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x03, 0xFE, 0x7C, 0x0F, 0xFE, 0xF8, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE3, 0xF8, 0x3F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0x3E,
  0x3F, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7,
  0xE0, 0x0F, 0x8F, 0xC0, 0x1F, 0x1F, 0x80, 0x3E, 0x3F, 0x00, 0xFC, 0x7E,
  0x01, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x0F, 0xC1, 0xFC, 0x3F, 0x83, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFD, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x80, 0x1F, 0x83, 0x80, 0x7E, 0x0F, 0xC3, 0xFC,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x0E, 0x00, 0xF9, 0xFE, 0x03, 0xEF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF1, 0xFC, 0x1F, 0xC7, 0xE0, 0x3F, 0x1F, 0x00, 0x7C, 0x7C,
  0x01, 0xF3, 0xF0, 0x07, 0xCF, 0xC0, 0x1F, 0x3E, 0x00, 0xFC, 0xF8, 0x03,
  0xF3, 0xE0, 0x0F, 0x9F, 0x80, 0x3E, 0x7E, 0x00, 0xF9, 0xF8, 0x03, 0xE7,
  0xC0, 0x1F, 0x9F, 0x00, 0x7E, 0x7C, 0x01, 0xF3, 0xF0, 0x07, 0xCF, 0xC0,
  0x1F, 0x3F, 0x00, 0x7C, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x01, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x7F, 0x0F, 0x80, 0xFE, 0x1F, 0x81,
  0xFC, 0x1F, 0x87, 0xF0, 0x1F, 0x8F, 0xE0, 0x1F, 0x1F, 0xC0, 0x1F, 0x3F,
  0x80, 0x1F, 0x7F, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0x1F,
  0x80, 0x7E, 0x1F, 0x80, 0x7C, 0x0F, 0xC0, 0x7C, 0x0F, 0xC0, 0x7C, 0x07,
  0xE0, 0x7C, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xF8, 0x01,
  0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x07,
  0xFF, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0,
  0x00, 0x0E, 0x0E, 0x03, 0xEF, 0xCF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xE3, 0xF3, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C,
  0x3E, 0x3E, 0x1F, 0x0F, 0x8F, 0x87, 0xC3, 0xC3, 0xE1, 0xF1, 0xF0, 0xF8,
  0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x0F, 0x8F, 0x87, 0xC7, 0xC3, 0xE1, 0xF1,
  0xF0, 0xF8, 0x78, 0x7C, 0x3E, 0x3E, 0x1F, 0x0F, 0x0F, 0x87, 0xC7, 0xC3,
  0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x87,
  0xC7, 0xC3, 0xE3, 0xE1, 0xF0, 0xF8, 0x00, 0x03, 0x80, 0x3E, 0x7F, 0x80,
  0xFB, 0xFF, 0x87, 0xDF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0x07, 0xF1, 0xF8,
  0x0F, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0xFC, 0x01, 0xF3, 0xF0, 0x0F,
  0xCF, 0x80, 0x3F, 0x3E, 0x00, 0xFC, 0xF8, 0x03, 0xE7, 0xE0, 0x0F, 0x9F,
  0x80, 0x3E, 0x7E, 0x01, 0xF9, 0xF0, 0x07, 0xE7, 0xC0, 0x1F, 0x9F, 0x00,
  0x7C, 0xFC, 0x01, 0xF3, 0xF0, 0x07, 0xCF, 0xC0, 0x3F, 0x3E, 0x00, 0xFC,
  0x00, 0x3C, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x1F, 0xC1, 0xF8, 0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x00, 0xFB,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3E, 0xFC, 0x01, 0xF7, 0xE0, 0x1F, 0x9F,
  0x01, 0xF8, 0xFC, 0x1F, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x03, 0xEF, 0xF8,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF0, 0x7E,
  0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F,
  0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3F,
  0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x7E, 0x1F, 0x00, 0x7E,
  0x1F, 0x80, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x3F, 0x3F, 0xC0, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0xF9, 0xF0, 0x7F, 0xF7, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFE,
  0x0F, 0xE3, 0xF0, 0x1F, 0x9F, 0x80, 0x3E, 0x7E, 0x01, 0xF9, 0xF0, 0x07,
  0xE7, 0xC0, 0x1F, 0xBF, 0x00, 0x7C, 0xFC, 0x01, 0xF3, 0xF0, 0x07, 0xCF,
  0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xE3, 0xF0, 0x0F, 0x87, 0xC0,
  0x7E, 0x1F, 0x87, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFC,
  0x03, 0xF9, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x7C, 0x7F, 0xC3, 0xEF, 0xFC,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xFE,
  0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFF, 0x7F, 0x9F, 0x80, 0xFC, 0xFC,
  0x03, 0xE7, 0xC0, 0x1F, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xF7, 0xC0, 0x0F, 0xBF, 0x00, 0xFD, 0xF8, 0x0F, 0xC7,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC1,
  0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x3E,
  0x00, 0xFC, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x9F, 0x80, 0x7E, 0x7E, 0x01,
  0xF9, 0xF8, 0x07, 0xE7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF3,
  0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xF8, 0x03, 0xE3, 0xE0,
  0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x01, 0xF8, 0xF8, 0x07, 0xE3, 0xE0, 0x3F,
  0x0F, 0xC3, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xF7, 0xC0, 0xFF, 0x9F, 0x01,
  0xFC, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0xF8, 0x01, 0xF9, 0xF0,
  0x03, 0xE3, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0x07, 0xC0, 0x7E, 0x0F, 0x80,
  0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x1F, 0x80, 0x78, 0x3E,
  0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE7, 0xC0, 0x03, 0xCF, 0x80,
  0x07, 0xBE, 0x00, 0x0F, 0x7C, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x3C, 0x1F, 0xFC, 0x1E, 0x0F, 0xBE, 0x0F, 0x07, 0xCF, 0x0F, 0x87,
  0xC7, 0x87, 0xC3, 0xE3, 0xC3, 0xE1, 0xF1, 0xE3, 0xF1, 0xF0, 0xF1, 0xF8,
  0xF8, 0x79, 0xFC, 0x78, 0x3C, 0xEE, 0x3C, 0x1E, 0x77, 0x3E, 0x0F, 0x7B,
  0x9E, 0x07, 0xB9, 0xCF, 0x03, 0xDC, 0xEF, 0x81, 0xFE, 0x77, 0x80, 0xFE,
  0x3B, 0xC0, 0x7F, 0x1F, 0xE0, 0x3F, 0x0F, 0xE0, 0x1F, 0x87, 0xF0, 0x0F,
  0xC3, 0xF8, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3C, 0x00,
  0x0F, 0xC0, 0x1F, 0xC1, 0xF8, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x0F, 0xC1,
  0xF8, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xDF, 0x00, 0x07, 0xE7, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0xFC,
  0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x0F,
  0xC0, 0x07, 0xC0, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0x3E, 0x00,
  0x7F, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01,
  0xF0, 0x1F, 0x80, 0x3E, 0x03, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0x7C, 0x1F,
  0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0x10, 0x00, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07,
  0x81, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80,
  0xE0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1C,
  0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x03, 0xFE, 0x03, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xE0, 0x08, 0x3F, 0xF8, 0x0F, 0x3F,
  0xFC, 0x0F, 0x7F, 0xFE, 0x1F, 0x7C, 0x7F, 0xFE, 0x78, 0x1F, 0xFE, 0xF0,
  0x0F, 0xFC, 0x10, 0x07, 0xF8, 0x00, 0x01, 0xE0,
};

const GFXglyph RobotoMono_SemiBoldItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 11, 31, 26, 8, -31 },
  { 44, 14, 11, 26, 8, -33 },
  { 64, 26, 31, 26, 0, -31 },
  { 165, 23, 41, 26, 2, -36 },
  { 283, 21, 32, 26, 3, -32 },
  { 367, 24, 32, 26, 1, -32 },
  { 463, 6, 11, 26, 11, -33 },
  { 472, 15, 45, 26, 7, -35 },
  { 557, 16, 45, 26, 3, -35 },
  { 647, 21, 22, 26, 4, -31 },
  { 705, 22, 23, 26, 2, -26 },
  { 769, 9, 13, 26, 4, -5 },
  { 784, 18, 4, 26, 5, -16 },
  { 793, 8, 7, 26, 7, -7 },
  { 800, 23, 34, 26, 2, -31 },
  { 898, 21, 33, 26, 3, -32 },
  { 985, 15, 31, 26, 5, -31 },
  { 1044, 23, 32, 26, 0, -32 },
  { 1136, 23, 32, 26, 1, -32 },
  { 1228, 23, 31, 26, 0, -31 },
  { 1318, 23, 32, 26, 2, -31 },
  { 1410, 21, 33, 26, 2, -32 },
  { 1497, 23, 31, 26, 3, -31 },
  { 1587, 22, 32, 26, 2, -32 },
  { 1675, 20, 32, 26, 3, -32 },
  { 1755, 11, 25, 26, 8, -25 },
  { 1790, 13, 33, 26, 6, -25 },
  { 1844, 21, 21, 26, 3, -24 },
  { 1900, 22, 13, 26, 2, -20 },
  { 1936, 21, 21, 26, 2, -24 },
  { 1992, 20, 32, 26, 5, -32 },
  { 2072, 25, 31, 26, 1, -31 },
  { 2169, 25, 31, 26, -2, -31 },
  { 2266, 24, 31, 26, 1, -31 },
  { 2359, 23, 33, 26, 2, -32 },
  { 2454, 25, 31, 26, 0, -31 },
  { 2551, 25, 31, 26, 1, -31 },
  { 2648, 26, 31, 26, 1, -31 },
  { 2749, 23, 32, 26, 2, -32 },
  { 2841, 26, 31, 26, 0, -31 },
  { 2942, 23, 31, 26, 2, -31 },
  { 3032, 25, 31, 26, 1, -31 },
  { 3129, 28, 31, 26, 1, -31 },
  { 3238, 21, 31, 26, 1, -31 },
  { 3320, 26, 31, 26, 0, -31 },
  { 3421, 26, 31, 26, 0, -31 },
  { 3522, 23, 32, 26, 2, -32 },
  { 3614, 25, 31, 26, 1, -31 },
  { 3711, 23, 37, 26, 2, -32 },
  { 3818, 25, 31, 26, 1, -31 },
  { 3915, 25, 32, 26, 1, -32 },
  { 4015, 25, 31, 26, 3, -31 },
  { 4112, 24, 32, 26, 2, -31 },
  { 4208, 24, 31, 26, 4, -31 },
  { 4301, 25, 31, 26, 3, -31 },
  { 4398, 29, 31, 26, -1, -31 },
  { 4511, 25, 31, 26, 4, -31 },
  { 4608, 26, 31, 26, 0, -31 },
  { 4709, 16, 43, 26, 5, -36 },
  { 4795, 11, 34, 26, 8, -31 },
  { 4842, 16, 43, 26, 5, -36 },
  { 4928, 17, 16, 26, 5, -31 },
  { 4962, 20, 4, 26, 0, 0 },
  { 4972, 8, 6, 26, 12, -32 },
  { 4978, 22, 24, 26, 1, -24 },
  { 5044, 22, 33, 26, 1, -33 },
  { 5135, 21, 25, 26, 2, -24 },
  { 5201, 24, 33, 26, 2, -33 },
  { 5300, 21, 24, 26, 2, -24 },
  { 5363, 23, 34, 26, 4, -34 },
  { 5461, 23, 33, 26, 1, -24 },
  { 5556, 22, 33, 26, 1, -33 },
  { 5647, 20, 32, 26, 2, -32 },
  { 5727, 20, 41, 26, 1, -32 },
  { 5830, 24, 33, 26, 1, -33 },
  { 5929, 20, 33, 26, 2, -33 },
  { 6012, 26, 24, 26, -1, -24 },
  { 6090, 22, 24, 26, 1, -24 },
  { 6156, 21, 25, 26, 2, -24 },
  { 6222, 24, 33, 26, -1, -24 },
  { 6321, 22, 33, 26, 2, -24 },
  { 6412, 21, 24, 26, 4, -24 },
  { 6475, 21, 24, 26, 2, -24 },
  { 6538, 20, 29, 26, 4, -29 },
  { 6611, 22, 24, 26, 3, -23 },
  { 6677, 23, 23, 26, 3, -23 },
  { 6744, 25, 23, 26, 2, -23 },
  { 6816, 26, 23, 26, 0, -23 },
  { 6891, 27, 32, 26, 0, -23 },
  { 6999, 24, 23, 26, 1, -23 },
  { 7068, 17, 42, 26, 6, -34 },
  { 7158, 10, 40, 26, 8, -31 },
  { 7208, 17, 42, 26, 4, -34 },
  { 7298, 24, 10, 26, 0, -18 },
};

const GFXfont RobotoMono_SemiBoldItalic44pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic44pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic44pt7bGlyphs,
  0x20, 0x7E, 58
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC44PT7B_H_
