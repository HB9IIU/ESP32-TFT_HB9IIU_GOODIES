#ifndef _ROBOTOMONO_SEMIBOLDITALIC37PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x0F,
  0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x07, 0xC3, 0xF0, 0x7C, 0x1E, 0x00, 0x38, 0x73,
  0x87, 0x78, 0xF7, 0x8F, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xEE,
  0x1C, 0x00, 0x1C, 0x78, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x1E, 0x38,
  0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x0F, 0x1C, 0x07, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0x1C, 0x38, 0x00, 0x71, 0xE0, 0x03, 0x87,
  0x00, 0x0E, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC3, 0x80, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x03, 0x87, 0x00, 0x0E, 0x38, 0x00, 0x70,
  0xE0, 0x01, 0xC3, 0x80, 0x0F, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE3, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x03, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xC7, 0xC3, 0xE0,
  0x7C, 0x7C, 0x0F, 0x8F, 0x01, 0xF1, 0xE0, 0x3E, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE7, 0x80, 0x3C, 0xF8, 0x07,
  0x9F, 0x01, 0xF3, 0xE0, 0x7E, 0x3F, 0xBF, 0x87, 0xFF, 0xE0, 0x7F, 0xF8,
  0x03, 0xFC, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xE7, 0x00, 0x71, 0xC3,
  0x3C, 0x70, 0xEF, 0x1C, 0x73, 0xC7, 0x38, 0xF3, 0xDE, 0x1F, 0xE7, 0x07,
  0xF3, 0x80, 0x79, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0x9F, 0x01, 0xCF, 0xE0, 0xF7, 0xFC, 0x3B, 0xC7, 0x1C, 0xE1,
  0xCE, 0x38, 0x73, 0x8E, 0x1C, 0x03, 0x8F, 0x00, 0xF7, 0x80, 0x1F, 0xE0,
  0x03, 0xF0, 0x00, 0x30, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xCF, 0x80, 0xF8, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0xF8, 0x0F, 0x0F,
  0x00, 0xFB, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0xE0, 0xF3, 0xFF, 0x0F, 0x7E, 0xF0, 0xF7, 0xCF, 0x9E, 0xF8,
  0x7D, 0xEF, 0x87, 0xFE, 0xF0, 0x3F, 0xCF, 0x83, 0xF8, 0xF8, 0x1F, 0x0F,
  0xCF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xE7, 0xE0, 0x39, 0xDE,
  0xF7, 0xB9, 0xCE, 0xF7, 0x00, 0x00, 0x30, 0x0F, 0x01, 0xF0, 0x3E, 0x03,
  0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x07, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x04,
  0x00, 0x02, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03,
  0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x3C,
  0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78,
  0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x0C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x1C, 0x38, 0x67, 0xCE, 0x7B, 0xFF, 0xFF, 0x3F, 0xFF, 0x80, 0xFE,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0x70, 0x07, 0x9E, 0x03, 0xC3, 0x81,
  0xE0, 0xF0, 0x38, 0x3C, 0x04, 0x04, 0x00, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x0F, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x3E, 0x3C, 0x78, 0xF8,
  0x30, 0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0x38, 0xFB, 0xFF, 0xFF, 0xCF,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0xFF,
  0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x0F, 0x8F, 0x87, 0xC1, 0xF3, 0xE0, 0x7C,
  0xF8, 0x0F, 0x3C, 0x03, 0xCF, 0x01, 0xF7, 0xC0, 0xFD, 0xF0, 0xFF, 0x7C,
  0x7F, 0xDF, 0x7D, 0xF7, 0xBE, 0x79, 0xFE, 0x1E, 0xFF, 0x07, 0xBF, 0x03,
  0xEF, 0x80, 0xFB, 0xE0, 0x3C, 0xF8, 0x0F, 0x1E, 0x07, 0xC7, 0x83, 0xE1,
  0xF9, 0xF8, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x38, 0x0F,
  0x83, 0xFC, 0x7F, 0xE7, 0xFF, 0x3F, 0xF9, 0xE7, 0xD8, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0,
  0x7F, 0xFE, 0x0F, 0xC7, 0xE1, 0xF8, 0x3E, 0x1F, 0x01, 0xE1, 0xE0, 0x1E,
  0x1E, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x80,
  0x00, 0x38, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xF8, 0x7E,
  0x3E, 0x07, 0xC7, 0x80, 0xF8, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0xC0,
  0x11, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xCF,
  0x80, 0x79, 0xF0, 0x1F, 0x3E, 0x07, 0xE3, 0xF3, 0xF8, 0x7F, 0xFE, 0x07,
  0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1E, 0xF0, 0x07, 0xFE,
  0x00, 0xF7, 0xC0, 0x3C, 0xF8, 0x0F, 0x1E, 0x03, 0xC3, 0xC0, 0xF8, 0x78,
  0x1E, 0x1F, 0x07, 0x83, 0xE1, 0xE0, 0x7C, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0xBF, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x87,
  0xF7, 0xF0, 0x18, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x78, 0x07, 0x8F, 0x01, 0xF1, 0xF0, 0x7E, 0x3F,
  0x9F, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x01, 0x00,
  0x1F, 0x80, 0x3F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x7E, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x7F, 0x0F, 0x7F, 0xC7, 0xFF,
  0xF7, 0xF9, 0xFB, 0xF0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xF7, 0xC0, 0xFB, 0xE0, 0xFC, 0xFC, 0xFC,
  0x3F, 0xFC, 0x1F, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xFC, 0x7E, 0x1F, 0x07, 0xC7,
  0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x3C, 0x1F, 0x07,
  0xEF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xFD, 0xF8, 0x3E,
  0x0F, 0x8F, 0x80, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xCF, 0x80, 0x78, 0xF0,
  0x1F, 0x1F, 0x07, 0xE3, 0xFB, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x3F,
  0xE0, 0x00, 0x01, 0xE0, 0x03, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC3, 0xE3,
  0xF3, 0xE0, 0xF9, 0xE0, 0x3D, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xEF, 0x81, 0xF7, 0xC0, 0xF9, 0xF1, 0xFC, 0xFF, 0xFE,
  0x3F, 0xFE, 0x0F, 0xEF, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0x00, 0x00,
  0x0E, 0x0F, 0x8F, 0xE7, 0xF3, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0x80,
  0x03, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x03,
  0xC0, 0x30, 0x00, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x07, 0xC0, 0x1F, 0xE0,
  0x3F, 0xF0, 0xFF, 0xE1, 0xFF, 0x81, 0xFE, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xE0, 0x03, 0xF0, 0x00,
  0x78, 0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xFC, 0x10, 0x00, 0x07, 0x00, 0x01,
  0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xC0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF8,
  0x1F, 0xF0, 0x07, 0xF0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0xFC, 0x3E, 0xF8, 0x1F, 0xF0, 0x1F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8,
  0x0F, 0x01, 0xC0, 0xF0, 0x07, 0x0F, 0x0E, 0x38, 0x71, 0xFC, 0xC7, 0x1F,
  0xE6, 0x39, 0xE7, 0x33, 0x9E, 0x31, 0x9C, 0xE1, 0x8C, 0xC7, 0x1C, 0x6E,
  0x70, 0xE7, 0x73, 0x86, 0x3B, 0x9C, 0x71, 0x9C, 0xE3, 0x8C, 0xE7, 0x1C,
  0xE7, 0x39, 0xE6, 0x39, 0xFF, 0xF1, 0xC7, 0x9F, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x20, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xBC, 0x00, 0xFB, 0xC0,
  0x0F, 0x3C, 0x01, 0xF3, 0xC0, 0x1E, 0x3C, 0x03, 0xE3, 0xE0, 0x3C, 0x3E,
  0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE1, 0xFF, 0xFE, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0,
  0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0x01, 0xF1, 0xF0, 0x0F, 0x1F, 0x00, 0xF1,
  0xE0, 0x0F, 0x1E, 0x01, 0xF3, 0xE0, 0x3E, 0x3E, 0x0F, 0xE3, 0xFF, 0xF8,
  0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x3C, 0x0F, 0xC7, 0xC0, 0x3E, 0x7C, 0x03,
  0xE7, 0xC0, 0x3E, 0x78, 0x03, 0xE7, 0x80, 0x3E, 0xF8, 0x07, 0xCF, 0x80,
  0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x00,
  0x3C, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xC7, 0xE1,
  0xF0, 0x1F, 0x1F, 0x01, 0xF3, 0xE0, 0x0F, 0x3E, 0x00, 0xF3, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x3C, 0x78, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x0F, 0x83, 0xF3, 0xF0, 0x3F,
  0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFC,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x3C,
  0x07, 0xC1, 0xE0, 0x1E, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E,
  0x3E, 0x01, 0xF1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0xF8, 0x07, 0xC7, 0xC0,
  0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0x0F, 0x00, 0xF8, 0x78, 0x0F, 0x87,
  0xC0, 0xFC, 0x3E, 0x0F, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF0, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x10, 0x7F, 0xFF, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xF8, 0xFC, 0x3E, 0x07,
  0xCF, 0x80, 0xF9, 0xE0, 0x0F, 0x7C, 0x01, 0xEF, 0x00, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x1F, 0xF7, 0x83, 0xFE,
  0xF0, 0x7F, 0xDE, 0x00, 0xFB, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0xF9,
  0xF0, 0x1F, 0x3F, 0x03, 0xE3, 0xFB, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xC0,
  0x3F, 0xE0, 0x00, 0x07, 0x80, 0x7C, 0x1E, 0x01, 0xF0, 0xF8, 0x07, 0x83,
  0xE0, 0x1E, 0x0F, 0x80, 0xF8, 0x3C, 0x03, 0xE0, 0xF0, 0x0F, 0x83, 0xC0,
  0x3C, 0x1F, 0x00, 0xF0, 0x7C, 0x03, 0xC1, 0xF0, 0x1F, 0x07, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xE0, 0x1E, 0x0F, 0x80, 0x78, 0x3E,
  0x03, 0xE0, 0xF0, 0x0F, 0x83, 0xC0, 0x3E, 0x1F, 0x00, 0xF0, 0x7C, 0x03,
  0xC1, 0xF0, 0x0F, 0x07, 0x80, 0x7C, 0x1E, 0x01, 0xF0, 0x78, 0x07, 0xC3,
  0xE0, 0x1E, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F,
  0x0F, 0x80, 0xF8, 0x3E, 0x0F, 0x81, 0xFD, 0xFC, 0x07, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0x80, 0x7E, 0x1E, 0x01, 0xF8, 0x3C,
  0x07, 0xE0, 0xF8, 0x1F, 0x81, 0xF0, 0x7E, 0x03, 0xE1, 0xF8, 0x07, 0xC7,
  0xE0, 0x0F, 0x1F, 0x80, 0x1E, 0x7E, 0x00, 0x7C, 0xF8, 0x00, 0xFB, 0xE0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x3F, 0xBE, 0x00, 0x7E, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xE0, 0xFC, 0x03,
  0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C,
  0x03, 0xE0, 0xF0, 0x07, 0xC1, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x7F, 0x83,
  0xF9, 0xDE, 0x1F, 0xEF, 0x78, 0x7B, 0xBB, 0xE1, 0xEF, 0xEF, 0x07, 0x9F,
  0x3C, 0x1E, 0x7C, 0xF0, 0x79, 0xF3, 0xC3, 0xE7, 0x9F, 0x0F, 0x1E, 0x7C,
  0x3C, 0x71, 0xE0, 0xF1, 0xC7, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x7C,
  0x03, 0xE1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x03,
  0xC3, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0xFC, 0x07,
  0x83, 0xF0, 0x1E, 0x0F, 0xE0, 0xF8, 0x3F, 0x83, 0xE0, 0xFE, 0x0F, 0x83,
  0xFC, 0x3C, 0x1F, 0xF0, 0xF0, 0x7F, 0xC7, 0xC1, 0xF7, 0x1F, 0x07, 0xDE,
  0x7C, 0x1E, 0x79, 0xF0, 0x79, 0xE7, 0x83, 0xE3, 0x9E, 0x0F, 0x8F, 0xF8,
  0x3E, 0x3F, 0xE0, 0xF0, 0xFF, 0x83, 0xC1, 0xFE, 0x1F, 0x07, 0xF0, 0x7C,
  0x1F, 0xC1, 0xF0, 0x3F, 0x07, 0xC0, 0xFC, 0x1E, 0x03, 0xF0, 0x78, 0x0F,
  0xC3, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80,
  0x7F, 0xFC, 0x0F, 0xC7, 0xE1, 0xF0, 0x3E, 0x1F, 0x01, 0xE3, 0xE0, 0x1F,
  0x3E, 0x01, 0xF3, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01,
  0xF7, 0xC0, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x03, 0xEF, 0x80,
  0x3E, 0xF8, 0x03, 0xC7, 0x80, 0x7C, 0x78, 0x07, 0xC7, 0xC0, 0xF8, 0x7C,
  0x1F, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xF0,
  0x1F, 0x0F, 0x80, 0x78, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8,
  0xF0, 0x07, 0x87, 0x80, 0x7C, 0x7C, 0x07, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x1F, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xC7, 0xE1, 0xF8, 0x3E,
  0x1F, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xC0, 0x1F, 0x7C, 0x01,
  0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x78, 0x01, 0xE7, 0x80,
  0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3C, 0x78,
  0x07, 0xC7, 0xC0, 0xF8, 0x7C, 0x1F, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x78,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x00, 0xF1, 0xE0,
  0x0F, 0x1E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x03, 0xF3, 0xE0, 0x7E, 0x3F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x7C, 0x3E, 0x07,
  0xC3, 0xE0, 0x78, 0x1F, 0x07, 0x81, 0xF0, 0x78, 0x1F, 0x0F, 0x80, 0xF8,
  0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF0, 0x07, 0xCF, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFC, 0x3F, 0x0F,
  0x80, 0xF8, 0x7C, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0x08, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF9,
  0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xE1, 0xF0, 0x1F, 0x0F, 0xF7,
  0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x01, 0xF1, 0xE0, 0x1F, 0x3E,
  0x01, 0xE3, 0xE0, 0x1E, 0x3E, 0x01, 0xE3, 0xE0, 0x3E, 0x3C, 0x03, 0xE3,
  0xC0, 0x3E, 0x7C, 0x03, 0xC7, 0xC0, 0x3C, 0x7C, 0x03, 0xC7, 0xC0, 0x7C,
  0x78, 0x07, 0xC7, 0x80, 0x7C, 0xF8, 0x07, 0x8F, 0x80, 0x78, 0xF8, 0x0F,
  0x8F, 0x80, 0xF8, 0xF0, 0x0F, 0x8F, 0x80, 0xF0, 0xF8, 0x1F, 0x0F, 0x83,
  0xF0, 0x7E, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFE, 0x00, 0xF8,
  0x01, 0xFF, 0x80, 0x3F, 0x78, 0x03, 0xE7, 0x80, 0x3E, 0x7C, 0x07, 0xC7,
  0xC0, 0x7C, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x1F, 0x03, 0xC1, 0xF0,
  0x3C, 0x1E, 0x03, 0xC3, 0xE0, 0x3C, 0x3E, 0x03, 0xE7, 0xC0, 0x3E, 0x7C,
  0x03, 0xE7, 0x80, 0x3E, 0xF8, 0x01, 0xEF, 0x00, 0x1F, 0xF0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x78, 0x78, 0x7D, 0xE1, 0xE1, 0xE7, 0x87, 0x8F,
  0x9E, 0x3E, 0x3C, 0x78, 0xF8, 0xF1, 0xE3, 0xE3, 0xC7, 0x9F, 0x9F, 0x1E,
  0x7E, 0x78, 0x79, 0xF9, 0xE1, 0xEF, 0xE7, 0x87, 0xBB, 0xBC, 0x1E, 0xEE,
  0xF0, 0x7B, 0xBB, 0xC1, 0xFE, 0xFF, 0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0,
  0x7F, 0x3F, 0x81, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7C,
  0x3F, 0x01, 0xF0, 0xF8, 0x0F, 0xC3, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x3C,
  0x03, 0xE0, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x83, 0xE0, 0x1F, 0x00, 0xF8,
  0x1F, 0x80, 0x7C, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x0F, 0x8F, 0x80, 0x07,
  0xC7, 0xC0, 0x01, 0xE7, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xF7, 0xC0,
  0x01, 0xF1, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0xFC, 0x1F,
  0x00, 0xFC, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7E, 0x01, 0xF0, 0x7E, 0x00,
  0xF8, 0x00, 0xFC, 0x01, 0xFB, 0xE0, 0x0F, 0x9F, 0x00, 0xF8, 0x78, 0x0F,
  0xC3, 0xE0, 0x7C, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x03, 0xC3, 0xE0, 0x1F,
  0x3E, 0x00, 0xF9, 0xF0, 0x03, 0xDF, 0x00, 0x1E, 0xF0, 0x00, 0xFF, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7F, 0x81, 0xFE, 0x07, 0xF0,
  0x3F, 0xC0, 0xF0, 0x78, 0x3C, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x7C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xE0, 0xF0, 0x03, 0xFC,
  0x0F, 0xE0, 0x3F, 0x81, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x3F,
  0xC0, 0x00, 0xE0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1D, 0xE0,
  0xF7, 0x87, 0x8E, 0x1E, 0x38, 0xF0, 0xE3, 0xC3, 0xDE, 0x0F, 0x70, 0x1F,
  0xC0, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0xF8,
  0xF0, 0xF1, 0xE1, 0xE0, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF8, 0x7F,
  0xFE, 0x1F, 0x07, 0xCF, 0x81, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x03, 0xFF,
  0xC7, 0xFF, 0xE3, 0xFF, 0xF9, 0xF8, 0x1E, 0x7C, 0x0F, 0xBE, 0x03, 0xEF,
  0x80, 0xFB, 0xE0, 0x7C, 0xFC, 0x7F, 0x1F, 0xFF, 0xC3, 0xFE, 0xF0, 0x7F,
  0x3C, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x3C, 0x07, 0xBF, 0xC1,
  0xFF, 0xF8, 0x7F, 0xFF, 0x3F, 0x87, 0xCF, 0x81, 0xF3, 0xE0, 0x3C, 0xF8,
  0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF7, 0xC0, 0x3D, 0xF0, 0x1F, 0x7C, 0x07,
  0xDE, 0x01, 0xF7, 0x80, 0xF9, 0xF0, 0x3E, 0xFF, 0x7F, 0x3F, 0xFF, 0xCF,
  0x7F, 0xE3, 0xCF, 0xE0, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF,
  0xE3, 0xE0, 0xFB, 0xE0, 0x3D, 0xF0, 0x1E, 0xF0, 0x0F, 0xF8, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x7B, 0xE0, 0x7D,
  0xF0, 0x3E, 0x7E, 0x7E, 0x3F, 0xFE, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE3, 0xC0, 0xFF, 0xFC,
  0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3E, 0x0F, 0xC7, 0xC0, 0xF8, 0x7C, 0x07,
  0x8F, 0x80, 0x78, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF0, 0x0F, 0x8F, 0x00,
  0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF8, 0x1F, 0x0F, 0x83, 0xF0, 0x7E,
  0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xF9, 0xE0, 0x01, 0xF8, 0x01,
  0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0x0F, 0x9F, 0x01, 0xE7, 0xC0,
  0x7B, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFE,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x43, 0xF0, 0x38, 0x7F, 0x3F, 0x0F,
  0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x03, 0x00, 0x01, 0xFF, 0x00,
  0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFC, 0x20, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF8,
  0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF1, 0xF0, 0x7F, 0xDE,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0x87, 0xE3, 0xE0, 0x3E, 0x3E, 0x03,
  0xE7, 0xC0, 0x3C, 0x7C, 0x03, 0xC7, 0xC0, 0x7C, 0x78, 0x07, 0xC7, 0x80,
  0x7C, 0x78, 0x07, 0xC7, 0x80, 0x78, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x3F,
  0x7F, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFE, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x60, 0x3E, 0x0F, 0x07, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80,
  0x3F, 0xF0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x3E, 0x03, 0xCF, 0xF0, 0x7B, 0xFE, 0x0F, 0xFF, 0xE3, 0xF8, 0x7C,
  0x7C, 0x07, 0x8F, 0x80, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x79,
  0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF0, 0x0F, 0x9E, 0x01, 0xE7,
  0xC0, 0x3C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x78, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x07,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x03,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x81,
  0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF1, 0xF0, 0x7E, 0x1E, 0x0F,
  0xC1, 0xE1, 0xF8, 0x3E, 0x3F, 0x03, 0xE7, 0xE0, 0x3E, 0xFC, 0x03, 0xDF,
  0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x7E,
  0x7C, 0x07, 0xC7, 0xC0, 0x78, 0x3E, 0x07, 0x83, 0xE0, 0xF8, 0x1F, 0x0F,
  0x81, 0xF0, 0xF8, 0x0F, 0x8F, 0x00, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F,
  0xFC, 0x0F, 0xFC, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0x38, 0xF0, 0x3F, 0xF7, 0xE0, 0xFF, 0xFF, 0x87,
  0xFF, 0xFE, 0x1F, 0x3E, 0x7C, 0x78, 0xF1, 0xF1, 0xE3, 0xC7, 0x87, 0x8F,
  0x1E, 0x3E, 0x3C, 0x78, 0xF8, 0xF1, 0xE3, 0xC7, 0xC7, 0x8F, 0x1E, 0x3E,
  0x3C, 0x78, 0xF0, 0xF1, 0xE3, 0xC7, 0xC7, 0x8F, 0x1E, 0x1E, 0x3C, 0x78,
  0xF0, 0xF1, 0xE3, 0xC7, 0xC7, 0x8F, 0x1E, 0x3E, 0x3C, 0x78, 0x1E, 0x3E,
  0x03, 0xCF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE3, 0xF8, 0x7C, 0x7C, 0x07,
  0x8F, 0x80, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x79, 0xF0, 0x1F,
  0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF0, 0x0F, 0x1E, 0x01, 0xE7, 0xC0, 0x3C,
  0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x78, 0x07, 0x80, 0x01, 0xF8,
  0x01, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x3E, 0x0F, 0x9F, 0x03, 0xE7,
  0x80, 0x7B, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xEF, 0x00, 0x7B, 0xC0,
  0x1E, 0xF0, 0x0F, 0xBC, 0x03, 0xEF, 0x81, 0xF3, 0xE0, 0x7C, 0x7C, 0x7E,
  0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0x80, 0x07, 0x8F, 0x00, 0x7B, 0xFC,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xC3, 0xF0, 0xF8, 0x1F, 0x0F, 0x80,
  0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x1F, 0x00, 0xF1, 0xF0,
  0x1F, 0x1F, 0x01, 0xF1, 0xE0, 0x1E, 0x1E, 0x03, 0xE1, 0xF0, 0x7E, 0x3F,
  0xCF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xEF, 0xE0, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE3, 0xC3, 0xFE, 0xF1, 0xFF, 0xFC,
  0xFF, 0xFF, 0x3E, 0x0F, 0xDF, 0x01, 0xE7, 0xC0, 0x7B, 0xE0, 0x1E, 0xF8,
  0x0F, 0xBE, 0x03, 0xEF, 0x00, 0xFB, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03,
  0xCF, 0x81, 0xF3, 0xE0, 0xFC, 0x7E, 0xFF, 0x1F, 0xFF, 0x83, 0xFF, 0xE0,
  0x7E, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x0F, 0xC7, 0xCF,
  0xF1, 0xFF, 0xF8, 0x7B, 0xFE, 0x1F, 0xFF, 0x87, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0,
  0xFF, 0xFE, 0x3E, 0x07, 0x8F, 0x01, 0xF7, 0xC0, 0x00, 0xF0, 0x00, 0x3F,
  0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0x00, 0x03,
  0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xFC, 0x3F, 0x1F, 0xFF, 0x83, 0xFF, 0xC0,
  0x7F, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x07, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xFD, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF8, 0x07, 0xF8, 0x3E, 0x03, 0xE7, 0xC0, 0x78, 0xF0, 0x0F,
  0x1E, 0x01, 0xE3, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3C,
  0x78, 0x07, 0x8F, 0x01, 0xF1, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9,
  0xF0, 0x1E, 0x3E, 0x07, 0xC7, 0xC1, 0xF8, 0x7E, 0xFF, 0x0F, 0xFF, 0xE0,
  0xFF, 0x7C, 0x0F, 0xCF, 0x00, 0xF0, 0x03, 0xFE, 0x00, 0xFB, 0xE0, 0x1F,
  0x7C, 0x07, 0xC7, 0x80, 0xF0, 0xF0, 0x3E, 0x1E, 0x07, 0x83, 0xC1, 0xF0,
  0x3C, 0x3C, 0x07, 0x8F, 0x80, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xCF, 0x00,
  0x39, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x70, 0xFF, 0x0F, 0x0F, 0xF0, 0xF1,
  0xFF, 0x1F, 0x1E, 0xF1, 0xF1, 0xEF, 0x1F, 0x1E, 0xF3, 0xF3, 0xCF, 0x3F,
  0x3C, 0xF3, 0xF3, 0x8F, 0x77, 0x78, 0xF7, 0x77, 0x8F, 0x67, 0x70, 0xFE,
  0x7F, 0x0F, 0xE7, 0xF0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F,
  0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x3E, 0x03,
  0xE0, 0xF8, 0x1F, 0x01, 0xF0, 0xF8, 0x07, 0xC7, 0xE0, 0x0F, 0xBF, 0x00,
  0x3E, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFD, 0xF0,
  0x03, 0xE3, 0xC0, 0x1F, 0x0F, 0x80, 0xF8, 0x1F, 0x07, 0xC0, 0x7C, 0x3E,
  0x00, 0xF8, 0x1E, 0x00, 0x3E, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8,
  0x07, 0xC0, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0xF8, 0x07, 0xC1,
  0xF0, 0x07, 0x87, 0xC0, 0x0F, 0x0F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x78,
  0x00, 0x3D, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF8, 0x00, 0x0C, 0x00, 0x78, 0x01, 0xF8, 0x07, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x7F, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0E, 0x00, 0x02, 0x00, 0x03, 0x83, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x00, 0x03,
  0x00, 0x07, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xFE, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xE0, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3E,
  0x01, 0xF8, 0x01, 0xC0, 0x02, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFC, 0x07,
  0x3F, 0xE0, 0x77, 0xFF, 0x8F, 0x78, 0xFF, 0xFF, 0x07, 0xFE, 0xE0, 0x3F,
  0xC0, 0x00, 0xF8,
};

const GFXglyph RobotoMono_SemiBoldItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 10, 26, 22, 6, -26 },
  { 34, 12, 10, 22, 6, -28 },
  { 49, 22, 26, 22, 0, -26 },
  { 121, 19, 35, 22, 2, -31 },
  { 205, 18, 27, 22, 2, -27 },
  { 266, 20, 27, 22, 1, -27 },
  { 334, 5, 10, 22, 9, -28 },
  { 341, 12, 37, 22, 6, -29 },
  { 397, 13, 37, 22, 3, -29 },
  { 458, 18, 18, 22, 3, -26 },
  { 499, 18, 19, 22, 2, -22 },
  { 542, 8, 11, 22, 3, -4 },
  { 553, 16, 3, 22, 4, -13 },
  { 559, 7, 6, 22, 6, -6 },
  { 565, 19, 28, 22, 2, -26 },
  { 632, 18, 27, 22, 2, -27 },
  { 693, 13, 26, 22, 4, -26 },
  { 736, 20, 27, 22, 0, -27 },
  { 804, 19, 27, 22, 1, -27 },
  { 869, 19, 26, 22, 0, -26 },
  { 931, 19, 26, 22, 2, -26 },
  { 993, 17, 27, 22, 2, -27 },
  { 1051, 19, 26, 22, 3, -26 },
  { 1113, 19, 27, 22, 1, -27 },
  { 1178, 17, 27, 22, 3, -27 },
  { 1236, 9, 21, 22, 7, -21 },
  { 1260, 11, 28, 22, 5, -21 },
  { 1299, 17, 17, 22, 3, -20 },
  { 1336, 18, 12, 22, 2, -17 },
  { 1363, 18, 17, 22, 1, -20 },
  { 1402, 16, 27, 22, 5, -27 },
  { 1456, 21, 26, 22, 1, -26 },
  { 1525, 20, 26, 22, -1, -26 },
  { 1590, 20, 26, 22, 1, -26 },
  { 1655, 20, 27, 22, 1, -27 },
  { 1723, 21, 26, 22, 0, -26 },
  { 1792, 21, 26, 22, 1, -26 },
  { 1861, 21, 26, 22, 1, -26 },
  { 1930, 19, 27, 22, 2, -27 },
  { 1995, 22, 26, 22, 0, -26 },
  { 2067, 20, 26, 22, 1, -26 },
  { 2132, 21, 26, 22, 1, -26 },
  { 2201, 23, 26, 22, 1, -26 },
  { 2276, 17, 26, 22, 1, -26 },
  { 2332, 22, 26, 22, 0, -26 },
  { 2404, 22, 26, 22, 0, -26 },
  { 2476, 20, 27, 22, 1, -27 },
  { 2544, 21, 26, 22, 1, -26 },
  { 2613, 20, 32, 22, 1, -27 },
  { 2693, 20, 26, 22, 1, -26 },
  { 2758, 21, 27, 22, 1, -27 },
  { 2829, 21, 26, 22, 3, -26 },
  { 2898, 20, 26, 22, 2, -26 },
  { 2963, 20, 26, 22, 3, -26 },
  { 3028, 22, 26, 22, 2, -26 },
  { 3100, 25, 26, 22, -1, -26 },
  { 3182, 21, 26, 22, 3, -26 },
  { 3251, 22, 26, 22, 0, -26 },
  { 3323, 14, 36, 22, 4, -30 },
  { 3386, 9, 28, 22, 7, -26 },
  { 3418, 14, 36, 22, 4, -30 },
  { 3481, 14, 14, 22, 4, -26 },
  { 3506, 17, 4, 22, 0, 0 },
  { 3515, 7, 5, 22, 10, -27 },
  { 3520, 18, 20, 22, 1, -20 },
  { 3565, 18, 28, 22, 1, -28 },
  { 3628, 17, 20, 22, 2, -20 },
  { 3671, 20, 28, 22, 2, -28 },
  { 3741, 18, 20, 22, 2, -20 },
  { 3786, 20, 29, 22, 3, -29 },
  { 3859, 20, 28, 22, 1, -20 },
  { 3929, 19, 28, 22, 1, -28 },
  { 3996, 16, 27, 22, 2, -27 },
  { 4050, 17, 35, 22, 1, -27 },
  { 4125, 20, 28, 22, 1, -28 },
  { 4195, 16, 28, 22, 2, -28 },
  { 4251, 22, 20, 22, -1, -20 },
  { 4306, 19, 20, 22, 1, -20 },
  { 4354, 18, 20, 22, 2, -20 },
  { 4399, 20, 28, 22, -1, -20 },
  { 4469, 18, 28, 22, 2, -20 },
  { 4532, 18, 20, 22, 3, -20 },
  { 4577, 18, 20, 22, 2, -20 },
  { 4622, 17, 24, 22, 3, -24 },
  { 4673, 19, 20, 22, 2, -20 },
  { 4721, 19, 20, 22, 3, -20 },
  { 4769, 20, 20, 22, 2, -20 },
  { 4819, 22, 20, 22, 0, -20 },
  { 4874, 23, 28, 22, 0, -20 },
  { 4955, 20, 20, 22, 1, -20 },
  { 5005, 15, 36, 22, 5, -29 },
  { 5073, 9, 33, 22, 6, -26 },
  { 5111, 15, 36, 22, 3, -29 },
  { 5179, 20, 8, 22, 0, -15 },
};

const GFXfont RobotoMono_SemiBoldItalic37pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic37pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic37pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC37PT7B_H_
