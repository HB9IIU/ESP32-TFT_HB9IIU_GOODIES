#ifndef _ROBOTOMONO_SEMIBOLDITALIC43PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1F,
  0x87, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x0F, 0x83, 0xF0,
  0xFC, 0x3E, 0x0F, 0x80, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCE, 0x0F, 0x78,
  0x39, 0xE1, 0xE7, 0x87, 0x9E, 0x1E, 0x70, 0x71, 0xC1, 0xCF, 0x07, 0x00,
  0x00, 0x07, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0x83, 0x80, 0x03, 0xC3,
  0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78,
  0x78, 0x00, 0x38, 0x38, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x07, 0x87, 0x00, 0x03, 0x87, 0x80, 0x03,
  0xC3, 0xC0, 0x01, 0xE1, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x0F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE0, 0x1C, 0x1C, 0x00,
  0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x07, 0x00, 0x07, 0x87, 0x80,
  0x03, 0xC3, 0xC0, 0x01, 0xC1, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFC,
  0x07, 0xFB, 0xF8, 0x1F, 0x81, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE1,
  0xF8, 0x07, 0xC3, 0xF0, 0x0F, 0x87, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x08, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xE0, 0x0F, 0x8F, 0xC0, 0x1F,
  0x0F, 0x80, 0x7E, 0x1F, 0x83, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xFC, 0x00, 0x7F,
  0xE0, 0x07, 0x9E, 0x00, 0xF0, 0xE0, 0xCF, 0x0E, 0x1E, 0xE0, 0xE1, 0xCE,
  0x0E, 0x3C, 0xE1, 0xE7, 0x8F, 0x1E, 0x70, 0xFF, 0xCF, 0x07, 0xF9, 0xE0,
  0x3F, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xC7, 0x80, 0x39, 0xFE, 0x07, 0xBF, 0xF0, 0xF7,
  0xCF, 0x0E, 0x78, 0xF1, 0xC7, 0x87, 0x3C, 0x70, 0x77, 0x87, 0x0F, 0x10,
  0x70, 0xF0, 0x07, 0x8F, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x3F, 0x3E, 0x00, 0x7C, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07,
  0xC1, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8,
  0x1E, 0x3F, 0xF8, 0x3C, 0xFD, 0xF0, 0xFB, 0xF3, 0xF1, 0xF7, 0xC3, 0xF3,
  0xFF, 0x87, 0xEF, 0xBE, 0x07, 0xFF, 0x7C, 0x07, 0xFC, 0xF8, 0x0F, 0xF1,
  0xF8, 0x0F, 0xE3, 0xF0, 0x7F, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x03, 0xFE, 0x3F, 0x00, 0x7D, 0xE7, 0x9E, 0x79, 0xEF, 0x3C,
  0xF3, 0xCF, 0x00, 0x00, 0x08, 0x00, 0xF0, 0x07, 0xC0, 0x3F, 0x01, 0xF0,
  0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0,
  0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0x60, 0x00, 0x80, 0x01, 0x80, 0x03, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC,
  0x00, 0xF0, 0x01, 0x80, 0x02, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x40, 0x70,
  0x17, 0x07, 0x0F, 0xFC, 0x73, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x7F,
  0xF0, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0xF3, 0xC0, 0x1F,
  0x3C, 0x03, 0xE1, 0xE0, 0x7C, 0x1F, 0x07, 0x81, 0xF0, 0x18, 0x0C, 0x01,
  0x00, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x87, 0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1E,
  0x1F, 0x03, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFE,
  0xFF, 0xFF, 0x80, 0x3C, 0x7E, 0x7F, 0xFF, 0xFF, 0x7E, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F,
  0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xE7, 0xE1, 0xF8, 0x3F, 0x1F,
  0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF7, 0xE0, 0x1F, 0x7C, 0x01, 0xF7,
  0xC0, 0x3F, 0x7C, 0x0F, 0xF7, 0xC1, 0xFF, 0x7C, 0x7F, 0xFF, 0xCF, 0xBF,
  0xFF, 0xF3, 0xFF, 0xFC, 0x3E, 0xFF, 0x83, 0xEF, 0xE0, 0x3E, 0xFC, 0x03,
  0xEF, 0x80, 0x7E, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x0F, 0xCF, 0x80,
  0xF8, 0xFC, 0x1F, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F,
  0xF0, 0x00, 0x00, 0x02, 0x00, 0x38, 0x03, 0xF0, 0x3F, 0xE1, 0xFF, 0xCF,
  0xFF, 0x9F, 0xFF, 0x3F, 0x7C, 0xF8, 0xF9, 0x81, 0xF0, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC1, 0xFC, 0x1F, 0x83, 0xE0, 0x1F, 0x0F, 0xC0, 0x3F,
  0x1F, 0x00, 0x7E, 0x3E, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF,
  0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xF3, 0xFC, 0x3F, 0x03, 0xF1,
  0xF8, 0x07, 0xC7, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x3E, 0x00,
  0x7C, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0x87, 0xE0, 0xFE, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3E, 0xF8, 0x00,
  0x7D, 0xF0, 0x01, 0xF7, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x1F, 0x00, 0x3E,
  0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xF0, 0x3E, 0x07,
  0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x1F, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x80, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFB,
  0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xC7,
  0xF0, 0x06, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x7C, 0x01, 0xF0,
  0xF8, 0x07, 0xE1, 0xF8, 0x0F, 0xC1, 0xF8, 0x7F, 0x03, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE7, 0xF0, 0x3F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xF8,
  0x7E, 0x7E, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3E, 0xFC, 0x07, 0xE7,
  0xC0, 0x7C, 0x7E, 0x1F, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xE0,
  0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0x7F, 0x87, 0xE0, 0xFC, 0x7E, 0x03, 0xE3,
  0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x7E, 0x3F, 0x03,
  0xE0, 0xF8, 0x3F, 0x07, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F,
  0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0x81, 0xF8, 0xF8, 0x07, 0xCF, 0xC0, 0x3E,
  0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x07, 0xE7, 0xE0,
  0x3F, 0x3F, 0x87, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x80, 0xFF,
  0xFC, 0x1F, 0xCF, 0xE3, 0xF0, 0x7E, 0x3E, 0x03, 0xE7, 0xE0, 0x3F, 0x7C,
  0x01, 0xF7, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0x7C, 0x03, 0xE7, 0xE0, 0x7E, 0x7F, 0x1F, 0xE3, 0xFF, 0xFE,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x07, 0xE7, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x03, 0xFF,
  0x80, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x03, 0xF1,
  0xFC, 0x7F, 0x1F, 0xC7, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x81, 0xF8, 0xFE, 0x3F,
  0x8F, 0xE3, 0xF8, 0x7C, 0x00, 0x01, 0xE0, 0x1F, 0x80, 0xFE, 0x0F, 0xF0,
  0x7F, 0x81, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1E, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x0F, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xE0,
  0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0x80, 0x00,
  0x08, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x80, 0x10, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x01,
  0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFF,
  0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xC0,
  0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xE0, 0x7F,
  0xFE, 0x1F, 0xFF, 0xE7, 0xFD, 0xFE, 0xFC, 0x0F, 0xDF, 0x01, 0xFF, 0xE0,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x1E, 0x0F,
  0x00, 0x0E, 0x0F, 0x0F, 0x8E, 0x1E, 0x3F, 0xC7, 0x1C, 0x7F, 0xE7, 0x3C,
  0xF9, 0xC7, 0x38, 0xF1, 0xC7, 0x79, 0xE1, 0xC7, 0x71, 0xC1, 0xC7, 0x71,
  0xC3, 0x86, 0xF3, 0xC3, 0x8E, 0xF3, 0xC3, 0x8E, 0xE3, 0x83, 0x8E, 0xE3,
  0x87, 0x0C, 0xE3, 0x87, 0x1C, 0xE3, 0x8F, 0x1C, 0xE3, 0xFF, 0xB8, 0xE3,
  0xFF, 0xF0, 0xF1, 0xF3, 0xE0, 0xF0, 0x00, 0x80, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3E, 0x06, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01,
  0xF0, 0x78, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x07,
  0xE0, 0x7C, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFC, 0x1F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x7E,
  0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0x07,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3F, 0x0F,
  0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x7E, 0x1F,
  0x00, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x3E, 0x03, 0xF8, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x7E,
  0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x7C,
  0x00, 0xFC, 0x7C, 0x03, 0xF8, 0xFC, 0x1F, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0x3F, 0x81, 0xF8,
  0x1F, 0x87, 0xE0, 0x1F, 0x1F, 0x80, 0x3E, 0x3E, 0x00, 0x7E, 0x7C, 0x00,
  0xFD, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x06, 0x3E,
  0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xFC, 0x03, 0xF0, 0xF8, 0x0F, 0xC1, 0xF8,
  0x3F, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xC1, 0xFC, 0x07, 0xC0,
  0x7E, 0x07, 0xC0, 0x7E, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x3F, 0x0F, 0x80,
  0x3F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x3F, 0x1F, 0x80,
  0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3E, 0x1F, 0x00,
  0x3E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x3E, 0x00,
  0xFC, 0x3E, 0x01, 0xF8, 0x3E, 0x03, 0xF8, 0x7E, 0x07, 0xF0, 0x7E, 0x3F,
  0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0xFF, 0x7F, 0x81, 0xF8, 0x1F, 0x87, 0xE0, 0x1F, 0x0F,
  0x80, 0x3E, 0x3F, 0x00, 0x7E, 0x7C, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x0F,
  0xFE, 0xFC, 0x1F, 0xF9, 0xF0, 0x3F, 0xF3, 0xE0, 0x7F, 0xE7, 0xC1, 0xFF,
  0xCF, 0x80, 0x1F, 0x9F, 0x00, 0x3F, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0xF8,
  0xFC, 0x01, 0xF0, 0xF8, 0x07, 0xE1, 0xFC, 0x1F, 0xC1, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x0F,
  0x83, 0xF0, 0x07, 0xC1, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x01,
  0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x1F, 0x80, 0x3E, 0x0F, 0xC0,
  0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x0F, 0xC1, 0xF0, 0x07, 0xC0, 0xF8,
  0x03, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xC0, 0x1F, 0x07, 0xE0, 0x0F, 0x83,
  0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0x7C, 0x01, 0xF0,
  0x3E, 0x00, 0xF8, 0x3F, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x3F,
  0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC0, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x7C, 0x01, 0xF0,
  0x7C, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7F, 0x0F, 0xE0, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xC0, 0x0F,
  0xE0, 0xF8, 0x03, 0xF8, 0x1F, 0x00, 0xFE, 0x07, 0xE0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x1F, 0x01, 0xFC, 0x03, 0xE0, 0x7F, 0x00, 0x7C, 0x1F, 0xC0,
  0x0F, 0x87, 0xF0, 0x03, 0xF1, 0xFC, 0x00, 0x7E, 0x7F, 0x00, 0x0F, 0x9F,
  0xC0, 0x01, 0xF3, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x7E,
  0x00, 0x1F, 0xCF, 0xC0, 0x07, 0xF0, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x1F,
  0x03, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x7C, 0x07, 0xE0, 0x0F, 0x80, 0x7E,
  0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xFC, 0x0F, 0x80, 0x1F, 0x81, 0xF0,
  0x03, 0xF0, 0x3E, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xF0, 0x1F, 0xC0, 0xFC, 0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFE, 0x07, 0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x8F, 0xF8, 0x1F,
  0xE3, 0xFE, 0x0F, 0xF9, 0xFF, 0x03, 0xFE, 0x7B, 0xC0, 0xFB, 0xBF, 0xF0,
  0x3E, 0xEF, 0x7C, 0x0F, 0x3F, 0xDF, 0x03, 0xCF, 0xE7, 0xC1, 0xF3, 0xF9,
  0xE0, 0x7C, 0xFC, 0xF8, 0x1F, 0x3F, 0x3E, 0x07, 0xCF, 0x8F, 0x81, 0xF3,
  0xE3, 0xE0, 0xF8, 0x70, 0xF8, 0x3E, 0x1C, 0x7C, 0x0F, 0x80, 0x1F, 0x03,
  0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x1F,
  0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00,
  0x3E, 0x0F, 0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC1,
  0xFC, 0x03, 0xE0, 0xFE, 0x03, 0xF0, 0x7F, 0x01, 0xF8, 0x3F, 0x80, 0xF8,
  0x1F, 0xE0, 0x7C, 0x1F, 0xF0, 0x3E, 0x0F, 0xF8, 0x1F, 0x07, 0xFC, 0x1F,
  0x83, 0xFF, 0x0F, 0xC1, 0xF7, 0x87, 0xC0, 0xFB, 0xC3, 0xE0, 0xFD, 0xE1,
  0xF0, 0x7E, 0xF9, 0xF8, 0x3E, 0x3C, 0xFC, 0x1F, 0x1E, 0x7E, 0x0F, 0x8F,
  0x3E, 0x07, 0xC7, 0xDF, 0x07, 0xE1, 0xEF, 0x83, 0xF0, 0xFF, 0xC1, 0xF0,
  0x7F, 0xE0, 0xF8, 0x1F, 0xF0, 0x7C, 0x0F, 0xF0, 0x3E, 0x07, 0xF8, 0x3F,
  0x03, 0xFC, 0x1F, 0x80, 0xFE, 0x0F, 0x80, 0x7F, 0x07, 0xC0, 0x3F, 0x03,
  0xE0, 0x1F, 0x83, 0xF0, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0x07, 0xE1, 0xF8,
  0x0F, 0xCF, 0xC0, 0x3F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF7, 0xE0, 0x07,
  0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00,
  0x3E, 0xF8, 0x01, 0xFB, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0xFC,
  0xFC, 0x03, 0xE1, 0xF0, 0x1F, 0x87, 0xE1, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F,
  0xC0, 0x7E, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F,
  0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F,
  0x00, 0x7E, 0x1F, 0x01, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0x00, 0x3F,
  0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0x07, 0xE1, 0xF8, 0x0F,
  0xCF, 0xC0, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF7, 0xE0, 0x07, 0xDF,
  0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xBE, 0x00, 0x3E,
  0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xEF, 0x80, 0x1F, 0x3E, 0x00, 0xFC, 0xFC,
  0x03, 0xE3, 0xF0, 0x1F, 0x87, 0xE1, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x60, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F,
  0x80, 0xFE, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3F, 0x1F,
  0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7E, 0x1F,
  0x00, 0xFE, 0x1F, 0x01, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3E, 0x0F, 0x80, 0x7E, 0x0F, 0xC0, 0x7E,
  0x0F, 0xC0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x7C, 0x07, 0xE0, 0x7C,
  0x03, 0xE0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xF8, 0x01, 0xF0, 0xF8,
  0x01, 0xF8, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xF9, 0xFE, 0x0F, 0xE0, 0x7E, 0x0F,
  0xC0, 0x3F, 0x0F, 0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x7C, 0xFC, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x7F,
  0x03, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x7E, 0x00, 0xF8, 0xFC, 0x01, 0xF1, 0xF0,
  0x03, 0xE3, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x3F, 0x00,
  0x7C, 0x7E, 0x00, 0xF8, 0xF8, 0x03, 0xF1, 0xF0, 0x07, 0xE3, 0xE0, 0x0F,
  0x87, 0xC0, 0x1F, 0x1F, 0x80, 0x3E, 0x3F, 0x00, 0x7C, 0x7C, 0x01, 0xF8,
  0xF8, 0x03, 0xF1, 0xF0, 0x07, 0xC7, 0xE0, 0x0F, 0x8F, 0xC0, 0x1F, 0x1F,
  0x80, 0x3E, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF0, 0xFC, 0x07, 0xE0, 0xF8,
  0x0F, 0xC1, 0xF8, 0x7F, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x01, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x1F, 0x00,
  0x7C, 0x3E, 0x01, 0xF8, 0x7C, 0x03, 0xE0, 0xF8, 0x0F, 0xC1, 0xF0, 0x1F,
  0x83, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF0, 0x0F, 0x87, 0xE0,
  0x1F, 0x0F, 0x80, 0x3E, 0x3F, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01,
  0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78,
  0x3C, 0x1F, 0x78, 0x3C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x7C, 0x1E, 0xF8,
  0x7C, 0x3E, 0xF8, 0x7C, 0x3E, 0xF8, 0xFC, 0x3E, 0xF8, 0xFC, 0x7C, 0xF8,
  0xFC, 0x7C, 0xF8, 0xFC, 0x7C, 0xF9, 0xFC, 0x78, 0xF9, 0xFC, 0xF8, 0xF9,
  0xDC, 0xF8, 0xFB, 0xDC, 0xF8, 0xFB, 0xDC, 0xF0, 0xFB, 0xDD, 0xF0, 0xFF,
  0x9D, 0xF0, 0xFF, 0x9D, 0xE0, 0xFF, 0x9F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF,
  0x1F, 0xE0, 0xFF, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE,
  0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xF8,
  0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xE0, 0x03, 0xF0,
  0x7E, 0x00, 0x7F, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x01, 0xF0,
  0x1F, 0xC0, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0x87, 0xE0,
  0x00, 0xFC, 0x7E, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x1F, 0xBF,
  0x00, 0x03, 0xF1, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xE1, 0xF8, 0x00,
  0xFC, 0x0F, 0x80, 0x1F, 0x80, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00,
  0x7E, 0x07, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x7E, 0x7C, 0x00, 0xFE, 0x7C, 0x00, 0xFC, 0x7E, 0x01, 0xF8,
  0x7E, 0x01, 0xF8, 0x3E, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x3F, 0x07, 0xE0,
  0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x80, 0x0F, 0x9F, 0x00,
  0x0F, 0xBE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xF8,
  0x3E, 0x0F, 0x81, 0xE0, 0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x03,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x03, 0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x1E, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xF0, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x7F, 0xC0,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8,
  0x01, 0xF8, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xBC, 0x0F, 0x9E,
  0x0F, 0x1E, 0x1F, 0x1E, 0x1E, 0x1E, 0x3C, 0x1E, 0x7C, 0x0F, 0x78, 0x0F,
  0xF8, 0x0F, 0xF0, 0x0F, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFC, 0x1F, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x00, 0xFF, 0x00,
  0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFC, 0x3F, 0x0F, 0xC0,
  0xFC, 0x7C, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x07, 0xFF, 0xC1,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0x1F, 0x3F, 0x80, 0xF9, 0xF8, 0x0F,
  0xCF, 0x80, 0x7E, 0xFC, 0x03, 0xE7, 0xE0, 0x3F, 0x1F, 0x83, 0xF8, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFE, 0x1F, 0xFD, 0xF0, 0x3F, 0x8F, 0x80, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x7E, 0x00, 0xFB, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0x8F,
  0xE1, 0xF8, 0x1F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0xFC, 0x03, 0xF3,
  0xF0, 0x0F, 0xCF, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0,
  0x0F, 0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xF0, 0x07, 0xC7, 0xE0, 0x3F,
  0x1F, 0xC1, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xBF, 0xF8, 0x3E,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC1, 0xFC, 0x7F, 0x1F, 0x80, 0xF8, 0xF8, 0x07, 0xCF, 0xC0, 0x3E, 0x7C,
  0x01, 0xF3, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x7C, 0xFC, 0x03, 0xE3, 0xE0,
  0x3F, 0x1F, 0x83, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x03, 0xF1, 0xF8, 0x1F, 0xFB, 0xE0, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xF8, 0xFF, 0x0F, 0xC0, 0xFE, 0x1F, 0x00,
  0xFC, 0x7E, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC7, 0xE0, 0x0F,
  0x8F, 0xC0, 0x3F, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0,
  0xF8, 0x03, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x83, 0xF0, 0xFF, 0x07,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFD, 0xF0, 0x07, 0xF3, 0xE0, 0x00,
  0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFC, 0x7F,
  0x1F, 0xC0, 0xF8, 0xFC, 0x07, 0xEF, 0xC0, 0x1F, 0x7C, 0x00, 0xFB, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x83, 0xF0, 0x0C, 0x1F, 0xC1,
  0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x0F, 0xF0, 0x40, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFE, 0x3E, 0x07, 0xFE, 0x7C, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFE,
  0x3F, 0xC3, 0xF0, 0x1F, 0x87, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3E, 0x00,
  0xFC, 0x7C, 0x01, 0xF1, 0xF8, 0x03, 0xE3, 0xF0, 0x07, 0xC7, 0xC0, 0x1F,
  0x8F, 0x80, 0x3F, 0x1F, 0x00, 0x7C, 0x3F, 0x00, 0xF8, 0x7E, 0x01, 0xF0,
  0x7C, 0x07, 0xE0, 0xFC, 0x3F, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x01, 0xFC, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x40,
  0x0F, 0x81, 0xC0, 0x7F, 0x07, 0xE3, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x3F, 0x00, 0xFB,
  0xFF, 0x07, 0xDF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0x8F, 0xE1, 0xF8, 0x0F,
  0x87, 0xC0, 0x3F, 0x1F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xE0, 0x0F, 0xCF,
  0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE7, 0xE0, 0x0F, 0x9F, 0x80,
  0x7E, 0x7C, 0x01, 0xF9, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C,
  0xFC, 0x01, 0xF3, 0xF0, 0x0F, 0xCF, 0x80, 0x3F, 0x3E, 0x00, 0xF8, 0x00,
  0x02, 0x00, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xFC, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x83, 0xF8, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x7F, 0x0F, 0x80, 0xFE, 0x1F, 0x81, 0xFC, 0x1F, 0x83,
  0xF0, 0x1F, 0x07, 0xE0, 0x1F, 0x1F, 0xC0, 0x1F, 0x3F, 0x80, 0x1F, 0x7F,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x3F, 0x00, 0x7E, 0x1F,
  0x80, 0x7C, 0x1F, 0x80, 0x7C, 0x0F, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x07,
  0xE0, 0xFC, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xF8, 0x07, 0xFF,
  0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0x9E, 0x3E, 0x07, 0xFF, 0xBF, 0x83, 0xDF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF0, 0xFD, 0xFD, 0xF8, 0xF8, 0x7C, 0x7C, 0x7C, 0x3C, 0x3E,
  0x3E, 0x1E, 0x1F, 0x1F, 0x1F, 0x0F, 0x8F, 0x8F, 0x87, 0x87, 0x87, 0xC7,
  0xC7, 0xC3, 0xE3, 0xE3, 0xE1, 0xE1, 0xF1, 0xF0, 0xF0, 0xF8, 0xF8, 0xF8,
  0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3E, 0x3E, 0x3E, 0x1F, 0x1F, 0x1F, 0x0F,
  0x0F, 0x8F, 0x8F, 0x87, 0xC7, 0xC7, 0xC3, 0xE3, 0xE3, 0xE1, 0xE1, 0xE1,
  0xF1, 0xF0, 0x0F, 0x8F, 0xC0, 0x3C, 0xFF, 0xC1, 0xF7, 0xFF, 0x07, 0xFF,
  0xFE, 0x1F, 0xE3, 0xF8, 0x7E, 0x03, 0xE1, 0xF0, 0x0F, 0xC7, 0xC0, 0x3F,
  0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E,
  0x00, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x00, 0x7C, 0x7C, 0x01,
  0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3,
  0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFC, 0x01,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFC, 0x7F, 0x1F, 0x81, 0xF9, 0xF8, 0x07,
  0xCF, 0xC0, 0x3F, 0x7C, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x7E,
  0xFC, 0x03, 0xE7, 0xE0, 0x3F, 0x1F, 0x83, 0xF0, 0xFF, 0xFF, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE7, 0xE0,
  0x03, 0xDF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xF9, 0xFE,
  0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E,
  0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E,
  0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x7E, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0xFC,
  0x1F, 0x80, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x3E, 0x3F, 0x80, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x7C,
  0x1F, 0xFB, 0xE0, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xC7, 0xF8, 0xFC,
  0x07, 0xE3, 0xE0, 0x1F, 0x9F, 0x80, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07,
  0xCF, 0xC0, 0x1F, 0x3F, 0x00, 0xFC, 0xF8, 0x03, 0xF3, 0xE0, 0x0F, 0x8F,
  0x80, 0x3E, 0x3F, 0x00, 0xF8, 0xFC, 0x03, 0xE3, 0xF0, 0x1F, 0x87, 0xE1,
  0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xDF, 0x00, 0xFE, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x0F, 0x87, 0xF0, 0xF9, 0xFF, 0x1F, 0x3F, 0xF1, 0xF7, 0xFE, 0x1F,
  0xFF, 0xE1, 0xFF, 0x06, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xF8, 0x3F,
  0x1F, 0x80, 0xFC, 0xF8, 0x03, 0xE7, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3F, 0x01,
  0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x08, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0x7C, 0x7C, 0x03,
  0xF1, 0xF0, 0x0F, 0xCF, 0xC0, 0x3E, 0x3F, 0x00, 0xF8, 0xF8, 0x03, 0xE3,
  0xE0, 0x0F, 0x8F, 0x80, 0x7E, 0x3E, 0x01, 0xF9, 0xF8, 0x07, 0xC7, 0xE0,
  0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x0F, 0xC7, 0xC0, 0x3F,
  0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x1F, 0x87, 0xE1, 0xFE, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFB, 0xC0, 0xFF, 0xDF, 0x00, 0xFE, 0x7C, 0x00, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x9F, 0x00, 0x7C, 0x7C, 0x03,
  0xF1, 0xF0, 0x0F, 0x83, 0xE0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x07, 0x87, 0xC0, 0x1F, 0x1F, 0x00, 0x7C,
  0xF8, 0x01, 0xF3, 0xE0, 0x03, 0xDF, 0x00, 0x0F, 0x7C, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x7C, 0x3E,
  0xF8, 0x7C, 0x3E, 0xF8, 0x7C, 0x3C, 0xF8, 0xFC, 0x7C, 0xF8, 0xFC, 0x7C,
  0xF8, 0xFC, 0x78, 0xF9, 0xFC, 0xF8, 0xF9, 0xDC, 0xF8, 0xF9, 0xDC, 0xF0,
  0x7B, 0xDC, 0xF0, 0x7B, 0x9D, 0xF0, 0x7F, 0x9D, 0xE0, 0x7F, 0x1D, 0xE0,
  0x7F, 0x1F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0x80,
  0x7E, 0x1F, 0x80, 0x7C, 0x1F, 0x80, 0x7C, 0x1F, 0x00, 0x78, 0x1F, 0x00,
  0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x1F, 0x81, 0xF8, 0x1F, 0xC0, 0x7C, 0x0F,
  0xC0, 0x3F, 0x0F, 0xC0, 0x0F, 0x8F, 0xC0, 0x07, 0xEF, 0xC0, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x07, 0xE7, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF0, 0xFC, 0x03,
  0xF0, 0x7E, 0x03, 0xF0, 0x1F, 0x83, 0xF0, 0x07, 0xC3, 0xF0, 0x03, 0xF0,
  0x1F, 0x80, 0x0F, 0xE3, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x7E, 0x07, 0xC0,
  0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x1F, 0x80,
  0x3E, 0x03, 0xE0, 0x07, 0xC0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0x87,
  0xE0, 0x01, 0xF1, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xCF, 0xC0, 0x00,
  0x7D, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x80, 0x07, 0xC0,
  0x07, 0xE0, 0x07, 0xF0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x0F,
  0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x10,
  0x00, 0x03, 0x81, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x0F, 0x07,
  0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x03, 0x81,
  0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xC0,
  0xE0, 0x70, 0x38, 0x3C, 0x1E, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0x02, 0x00,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x03, 0xFC, 0x03,
  0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xF0,
  0x00, 0x40, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xF0, 0x0F, 0x3F, 0xF8,
  0x0F, 0x7F, 0xFC, 0x1E, 0x7C, 0xFF, 0xFE, 0x78, 0x3F, 0xFE, 0xF0, 0x1F,
  0xFC, 0x30, 0x07, 0xF8, 0x00, 0x03, 0xE0,
};

const GFXglyph RobotoMono_SemiBoldItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 10, 31, 25, 8, -31 },
  { 40, 14, 11, 25, 7, -32 },
  { 60, 25, 31, 25, 0, -31 },
  { 157, 23, 39, 25, 2, -35 },
  { 270, 20, 31, 25, 3, -31 },
  { 348, 23, 31, 25, 1, -31 },
  { 438, 6, 11, 25, 11, -32 },
  { 447, 14, 44, 25, 7, -34 },
  { 524, 15, 44, 25, 3, -34 },
  { 607, 20, 22, 25, 4, -31 },
  { 662, 21, 22, 25, 2, -25 },
  { 720, 9, 13, 25, 4, -5 },
  { 735, 18, 5, 25, 5, -16 },
  { 747, 8, 7, 25, 7, -7 },
  { 754, 22, 34, 25, 2, -31 },
  { 848, 20, 31, 25, 3, -31 },
  { 926, 15, 31, 25, 5, -31 },
  { 985, 23, 31, 25, 0, -31 },
  { 1075, 22, 31, 25, 1, -31 },
  { 1161, 23, 31, 25, 0, -31 },
  { 1251, 23, 31, 25, 2, -31 },
  { 1341, 20, 31, 25, 2, -31 },
  { 1419, 22, 31, 25, 3, -31 },
  { 1505, 21, 31, 25, 2, -31 },
  { 1587, 20, 31, 25, 3, -31 },
  { 1665, 10, 25, 25, 8, -25 },
  { 1697, 13, 33, 25, 6, -25 },
  { 1751, 20, 20, 25, 3, -23 },
  { 1801, 22, 14, 25, 2, -20 },
  { 1840, 20, 20, 25, 2, -23 },
  { 1890, 19, 31, 25, 5, -31 },
  { 1964, 24, 30, 25, 1, -30 },
  { 2054, 24, 31, 25, -1, -31 },
  { 2147, 24, 31, 25, 1, -31 },
  { 2240, 23, 32, 25, 2, -31 },
  { 2332, 24, 31, 25, 0, -31 },
  { 2425, 25, 31, 25, 1, -31 },
  { 2522, 25, 31, 25, 1, -31 },
  { 2619, 23, 31, 25, 2, -31 },
  { 2709, 25, 31, 25, 0, -31 },
  { 2806, 22, 31, 25, 2, -31 },
  { 2892, 24, 31, 25, 1, -31 },
  { 2985, 27, 31, 25, 1, -31 },
  { 3090, 20, 31, 25, 1, -31 },
  { 3168, 26, 31, 25, 0, -31 },
  { 3269, 25, 31, 25, 0, -31 },
  { 3366, 22, 31, 25, 2, -31 },
  { 3452, 24, 31, 25, 1, -31 },
  { 3545, 22, 36, 25, 2, -31 },
  { 3644, 24, 31, 25, 1, -31 },
  { 3737, 24, 31, 25, 1, -31 },
  { 3830, 24, 31, 25, 3, -31 },
  { 3923, 23, 31, 25, 2, -31 },
  { 4013, 23, 31, 25, 4, -31 },
  { 4103, 24, 31, 25, 3, -31 },
  { 4196, 28, 31, 25, -1, -31 },
  { 4305, 24, 31, 25, 4, -31 },
  { 4398, 26, 31, 25, 0, -31 },
  { 4499, 16, 42, 25, 5, -35 },
  { 4583, 10, 34, 25, 8, -31 },
  { 4626, 16, 42, 25, 5, -35 },
  { 4710, 16, 17, 25, 5, -31 },
  { 4744, 19, 4, 25, 0, 0 },
  { 4754, 9, 6, 25, 11, -31 },
  { 4761, 21, 23, 25, 1, -23 },
  { 4822, 22, 32, 25, 1, -32 },
  { 4910, 21, 23, 25, 2, -23 },
  { 4971, 23, 32, 25, 2, -32 },
  { 5063, 21, 23, 25, 2, -23 },
  { 5124, 23, 33, 25, 4, -33 },
  { 5219, 23, 32, 25, 1, -23 },
  { 5311, 22, 32, 25, 1, -32 },
  { 5399, 19, 32, 25, 2, -32 },
  { 5475, 20, 41, 25, 1, -32 },
  { 5578, 24, 32, 25, 1, -32 },
  { 5674, 19, 32, 25, 2, -32 },
  { 5750, 25, 23, 25, -1, -23 },
  { 5822, 22, 23, 25, 1, -23 },
  { 5886, 21, 24, 25, 2, -23 },
  { 5949, 24, 32, 25, -1, -23 },
  { 6045, 22, 32, 25, 2, -23 },
  { 6133, 20, 23, 25, 4, -23 },
  { 6191, 21, 23, 25, 2, -23 },
  { 6252, 19, 28, 25, 4, -28 },
  { 6319, 22, 23, 25, 2, -23 },
  { 6383, 22, 23, 25, 3, -23 },
  { 6447, 24, 23, 25, 2, -23 },
  { 6516, 25, 23, 25, 0, -23 },
  { 6588, 27, 32, 25, 0, -23 },
  { 6696, 23, 23, 25, 1, -23 },
  { 6763, 17, 42, 25, 6, -34 },
  { 6853, 9, 40, 25, 8, -31 },
  { 6898, 17, 42, 25, 4, -34 },
  { 6988, 24, 9, 25, 0, -17 },
};

const GFXfont RobotoMono_SemiBoldItalic43pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic43pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic43pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC43PT7B_H_
