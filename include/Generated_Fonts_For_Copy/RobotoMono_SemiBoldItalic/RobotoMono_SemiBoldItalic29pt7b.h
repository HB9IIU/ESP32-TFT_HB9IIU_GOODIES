#ifndef _ROBOTOMONO_SEMIBOLDITALIC29PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x3C, 0x78, 0xF1, 0xE3, 0x87, 0x1E, 0x3C, 0x78, 0xE1, 0xC3,
  0x8F, 0x00, 0x00, 0x00, 0xC3, 0xC7, 0x87, 0x00, 0x71, 0xB9, 0xD8, 0xEC,
  0x7E, 0x37, 0x1B, 0x8D, 0x8E, 0x00, 0xE3, 0x00, 0x73, 0x80, 0x31, 0x80,
  0x38, 0xC0, 0x18, 0xE0, 0x0C, 0x60, 0x7F, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF,
  0x83, 0x8C, 0x01, 0x8E, 0x00, 0xC6, 0x00, 0xE3, 0x07, 0xFF, 0xF3, 0xFF,
  0xF8, 0x39, 0xC0, 0x18, 0xE0, 0x1C, 0x60, 0x0E, 0x70, 0x06, 0x38, 0x07,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x01, 0xF0, 0x07, 0xFC,
  0x0F, 0xFE, 0x1F, 0x1E, 0x1E, 0x1E, 0x1C, 0x0E, 0x1C, 0x0E, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x3C, 0xF0, 0x3C, 0x70, 0x3C, 0x78, 0x7C, 0x7F, 0xF8, 0x3F, 0xF0,
  0x1F, 0xC0, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x3C, 0x01, 0xF8, 0x0E,
  0x70, 0x39, 0xC6, 0xC7, 0x33, 0x1D, 0xCE, 0x66, 0x3F, 0xB0, 0x7D, 0xC0,
  0x0E, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x60, 0x37, 0xE1, 0xBF, 0x8E, 0xE7,
  0x33, 0x1D, 0x8C, 0x70, 0x31, 0x80, 0xFE, 0x01, 0xF0, 0x01, 0xF0, 0x03,
  0xF8, 0x07, 0xFC, 0x0F, 0x3C, 0x0F, 0x1C, 0x0E, 0x1C, 0x0E, 0x38, 0x0F,
  0x78, 0x0F, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xC7, 0x3D, 0xC7, 0x79,
  0xE7, 0x78, 0xFF, 0x70, 0xFE, 0x70, 0x7C, 0x78, 0x7C, 0x7F, 0xFC, 0x3F,
  0xFE, 0x1F, 0xDE, 0x77, 0x77, 0x66, 0xEE, 0x00, 0x40, 0x70, 0x3C, 0x1E,
  0x0F, 0x03, 0x81, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x30, 0x0E, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x00, 0x04, 0x03, 0x80,
  0x70, 0x0C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x01,
  0xC0, 0xF0, 0x38, 0x1C, 0x0F, 0x07, 0x83, 0xC0, 0x60, 0x20, 0x00, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x41, 0x85, 0xC6, 0x7F, 0xDF, 0xC7,
  0xFE, 0x07, 0x80, 0x3E, 0x01, 0xDC, 0x0F, 0x38, 0x78, 0xE0, 0xC1, 0xC1,
  0x04, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x5F, 0xFF, 0x3F, 0xFE, 0xFF, 0xFC, 0x0F, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x3C, 0xE3, 0x8E, 0x79, 0xCF,
  0x38, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x27, 0xFF, 0xFF, 0x00, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x3F, 0xC1, 0xFF,
  0x8F, 0x1E, 0x38, 0x3D, 0xE0, 0xF7, 0x83, 0xDC, 0x0F, 0x70, 0xFF, 0xC7,
  0xEF, 0x7B, 0xBF, 0xCE, 0xFC, 0x7B, 0xE1, 0xEE, 0x07, 0xB8, 0x1C, 0xE0,
  0xF3, 0xC3, 0xC7, 0xFE, 0x1F, 0xF0, 0x3F, 0x80, 0x00, 0x40, 0x70, 0xFD,
  0xFF, 0x7F, 0x9C, 0xEC, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07,
  0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x00, 0x01,
  0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0xF8, 0xF1, 0xC1, 0xE7, 0x81, 0xCF, 0x03,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xFF, 0xF7, 0xFF,
  0xEF, 0xFF, 0xC0, 0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xF1, 0xF1, 0xE3, 0xC1,
  0xE7, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x0F, 0xF0, 0x1F, 0x80,
  0x3F, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x70, 0x1C, 0xE0, 0x79, 0xE0,
  0xF3, 0xFF, 0xC3, 0xFF, 0x01, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x77, 0x01, 0xDE, 0x07, 0x3C,
  0x1E, 0x78, 0x78, 0xE0, 0xE1, 0xC3, 0x87, 0x8F, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x07,
  0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x1E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x80, 0x3F, 0xF0, 0x3F, 0xF8, 0x3C, 0xF8, 0x08, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0x78, 0x78, 0x7F,
  0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x00, 0x38, 0x07, 0xE0, 0x7F, 0x83, 0xF0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x70, 0x7F, 0xF1, 0xFF, 0xE7, 0xC7,
  0x9E, 0x0F, 0x70, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0E, 0x70, 0x79, 0xE1,
  0xE7, 0xFF, 0x0F, 0xF8, 0x1F, 0xC0, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFC,
  0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x1C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x03, 0xE0,
  0x0F, 0xF0, 0x3F, 0xF0, 0xF1, 0xE1, 0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x9E,
  0x0E, 0x1E, 0x3C, 0x3F, 0xF0, 0x3F, 0x81, 0xFF, 0x87, 0x87, 0x8E, 0x07,
  0x3C, 0x0E, 0x78, 0x1C, 0xF0, 0x79, 0xE0, 0xF1, 0xFF, 0xC1, 0xFF, 0x01,
  0xFC, 0x00, 0x07, 0xC0, 0xFF, 0x0F, 0xFC, 0x78, 0xF7, 0x87, 0xB8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xDC, 0x1E, 0xFF, 0xF7, 0xFF, 0x8F,
  0xB8, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x3E, 0x1F, 0xE0, 0xFE, 0x07, 0xC0,
  0x00, 0x0C, 0x3C, 0xF9, 0xF1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x0F, 0x3E, 0x7C, 0x78, 0x06, 0x07, 0x83, 0xE1, 0xF0, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x38, 0x1C,
  0x1E, 0x0E, 0x0F, 0x07, 0x01, 0x00, 0x00, 0x08, 0x01, 0xC0, 0x3E, 0x07,
  0xF1, 0xFE, 0x3F, 0xC3, 0xF0, 0x1F, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xE0, 0x06, 0x00, 0x10, 0x3F, 0xFE, 0x7F, 0xFC, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x3F, 0xFE, 0xFF, 0xF8, 0x20, 0x00,
  0xE0, 0x03, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xC0, 0x1F,
  0x03, 0xF8, 0x7F, 0x87, 0xF8, 0x1F, 0x00, 0xF0, 0x02, 0x00, 0x00, 0x0F,
  0x83, 0xFE, 0x7F, 0xFF, 0x8F, 0xF0, 0xFE, 0x07, 0x00, 0xF0, 0x0F, 0x01,
  0xE0, 0x3C, 0x0F, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x78, 0x07, 0x80, 0x38, 0x00, 0x03, 0xF8, 0x07, 0xFC, 0x1E,
  0x0E, 0x18, 0x06, 0x31, 0xF2, 0x73, 0xF3, 0x67, 0x33, 0x66, 0x33, 0xEE,
  0x63, 0xCC, 0x66, 0xCC, 0x66, 0xCC, 0x66, 0xCC, 0xE4, 0xCF, 0xEC, 0xCF,
  0x78, 0xC2, 0x30, 0xE0, 0x00, 0x70, 0x40, 0x3F, 0xC0, 0x1F, 0x80, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xDC, 0x01, 0xDC, 0x03, 0xDC, 0x03, 0x9E, 0x07, 0x9E, 0x07, 0x0E, 0x0F,
  0x0E, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x3C, 0x0F, 0x38, 0x0F, 0x78,
  0x0F, 0x78, 0x0F, 0xF0, 0x0F, 0x0F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xC3,
  0xC3, 0xE1, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x38, 0x0E, 0x1C, 0x1F,
  0x1F, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0xC3, 0xC1, 0xE1, 0xC0, 0x70, 0xE0,
  0x3C, 0xF0, 0x1C, 0x78, 0x1E, 0x3C, 0x1F, 0x1F, 0xFF, 0x0F, 0xFF, 0x0F,
  0xFE, 0x00, 0x01, 0xF0, 0x07, 0xF8, 0x0F, 0xFC, 0x1E, 0x1E, 0x3C, 0x0E,
  0x38, 0x0F, 0x78, 0x0F, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x3C, 0xF0, 0x3C,
  0x78, 0x78, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xC0, 0x0F, 0x80, 0x0F, 0xF8,
  0x0F, 0xFC, 0x1E, 0x7E, 0x1E, 0x1E, 0x1E, 0x0F, 0x1C, 0x0F, 0x1C, 0x0F,
  0x3C, 0x07, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x38, 0x0F, 0x38, 0x0E,
  0x78, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0x78, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0,
  0xFF, 0x80, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x1C, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x3F, 0xFC, 0x7F, 0xF8,
  0x7F, 0xF8, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x1F, 0xFF, 0x8F, 0xFF,
  0x87, 0xFF, 0xC3, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x1F,
  0x1E, 0x3C, 0x0E, 0x3C, 0x0E, 0x78, 0x0F, 0x78, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xF0, 0xFE, 0xF1, 0xFE, 0xF0, 0x1C, 0xF0, 0x1C, 0xF0,
  0x3C, 0x70, 0x3C, 0x78, 0x3C, 0x7F, 0xFC, 0x3F, 0xF8, 0x1F, 0xE0, 0x0E,
  0x03, 0x87, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x70, 0xF0, 0x38,
  0x70, 0x1C, 0x38, 0x1E, 0x3C, 0x0F, 0x1F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF,
  0xC3, 0x81, 0xE1, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x38, 0x78, 0x1C, 0x38,
  0x0E, 0x1C, 0x0F, 0x0E, 0x07, 0x8F, 0x03, 0xC0, 0x0F, 0xFE, 0x3F, 0xFC,
  0x7F, 0xF8, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0E, 0x01, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x00,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0xF0, 0x38, 0xF0, 0x78, 0xF0, 0xF8,
  0x7F, 0xF0, 0x7F, 0xE0, 0x1F, 0x80, 0x0F, 0x03, 0xE1, 0xC0, 0xF8, 0x38,
  0x3E, 0x0F, 0x07, 0x81, 0xE1, 0xE0, 0x3C, 0x78, 0x07, 0x9E, 0x00, 0xE7,
  0x80, 0x1D, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF,
  0x00, 0x7D, 0xE0, 0x0E, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x3C, 0x0F, 0x07,
  0x81, 0xC0, 0xF0, 0x38, 0x0F, 0x0F, 0x01, 0xF0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0,
  0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x07, 0x87, 0x87, 0xC3,
  0xE3, 0xE3, 0xF3, 0xF1, 0xF9, 0xF8, 0xFC, 0xFC, 0x7E, 0xFC, 0x3F, 0x6E,
  0x3D, 0xF7, 0x1E, 0xF3, 0x8E, 0x7B, 0xC7, 0x39, 0xE3, 0x9C, 0xE1, 0xCE,
  0x71, 0xE0, 0x38, 0xF0, 0x3C, 0x70, 0x1E, 0x38, 0x0E, 0x1C, 0x07, 0x0E,
  0x03, 0x8F, 0x01, 0xC0, 0x0E, 0x07, 0x87, 0x83, 0xC7, 0xC1, 0xE3, 0xE0,
  0xF1, 0xF8, 0x70, 0xFC, 0x38, 0x7E, 0x3C, 0x3F, 0x1E, 0x3D, 0xCF, 0x1E,
  0xE7, 0x8F, 0x73, 0x87, 0xB9, 0xC3, 0x8F, 0xE1, 0xC7, 0xF1, 0xE3, 0xF8,
  0xF0, 0xF8, 0x78, 0x7C, 0x3C, 0x3E, 0x1C, 0x1F, 0x0E, 0x07, 0x8F, 0x03,
  0xC0, 0x01, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0xF1, 0xF3, 0xC1, 0xE7, 0x01,
  0xDE, 0x03, 0xBC, 0x07, 0x70, 0x0E, 0xE0, 0x1D, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xBC, 0x07, 0x78, 0x1E, 0xF0, 0x38, 0xF0, 0xF1, 0xFF,
  0xC1, 0xFF, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xFC, 0x1F, 0xFE, 0x1C,
  0x3E, 0x1C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x38, 0x0F, 0x38,
  0x1E, 0x3F, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0x78, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0xF1, 0xF3, 0xC1, 0xE7, 0x81, 0xDE, 0x03,
  0xBC, 0x07, 0x78, 0x0E, 0xE0, 0x1D, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0x78, 0x1E, 0xF0, 0x3C, 0xF0, 0xF1, 0xFF, 0xC1, 0xFF,
  0x01, 0xFF, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1C, 0x00, 0x10, 0x0F, 0xF0,
  0x07, 0xFE, 0x03, 0xFF, 0xC3, 0xC3, 0xE1, 0xE0, 0x78, 0xF0, 0x3C, 0x78,
  0x1E, 0x38, 0x0F, 0x1C, 0x0F, 0x1E, 0x0F, 0x8F, 0xFF, 0x87, 0xFF, 0x83,
  0xFF, 0x01, 0xC3, 0xC0, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x3C, 0x1E,
  0x1E, 0x0F, 0x0E, 0x03, 0x8F, 0x01, 0xE0, 0x01, 0xF0, 0x07, 0xFC, 0x1F,
  0xFE, 0x1E, 0x1E, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3C, 0x00,
  0x1C, 0xF0, 0x1C, 0xF0, 0x1C, 0xF8, 0x3C, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xC0, 0x78, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x1C, 0x07,
  0x1C, 0x0F, 0x1C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0E, 0x3C, 0x0E, 0x38, 0x0E,
  0x38, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x78, 0x1C, 0x70, 0x1C,
  0x70, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0x70, 0x78, 0x78, 0x78, 0x7F, 0xF0,
  0x3F, 0xE0, 0x1F, 0xC0, 0xF0, 0x0F, 0x70, 0x0F, 0x78, 0x1E, 0x78, 0x1E,
  0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x78, 0x38, 0x78, 0x38, 0xF0,
  0x38, 0xF0, 0x38, 0xE0, 0x3D, 0xE0, 0x3D, 0xC0, 0x3F, 0xC0, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0xF1, 0xC7,
  0xF1, 0xC7, 0xF3, 0xCF, 0xF3, 0xCF, 0xE3, 0xCE, 0xE7, 0xCE, 0xE7, 0xDE,
  0xE7, 0xDC, 0xE7, 0xDC, 0xEF, 0xDC, 0xED, 0xFC, 0xED, 0xF8, 0xFD, 0xF8,
  0xFD, 0xF8, 0xF9, 0xF0, 0xF9, 0xF0, 0xF9, 0xF0, 0xF1, 0xF0, 0xF1, 0xE0,
  0xF1, 0xE0, 0xE1, 0xE0, 0x0F, 0x01, 0xF0, 0xF0, 0x3E, 0x07, 0x03, 0xC0,
  0x78, 0x78, 0x07, 0x8F, 0x80, 0x38, 0xF0, 0x03, 0xDE, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x07, 0xBC, 0x00, 0xF3, 0xC0, 0x1F, 0x1C, 0x01, 0xE1,
  0xE0, 0x3C, 0x1E, 0x07, 0xC0, 0xF0, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0xF0,
  0x1E, 0xF0, 0x3C, 0x70, 0x3C, 0x78, 0x78, 0x78, 0x78, 0x38, 0xF0, 0x39,
  0xE0, 0x3D, 0xE0, 0x3F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xC0,
  0x07, 0xE0, 0xFC, 0x1F, 0x87, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xF8, 0x3F, 0x0F, 0xE0, 0xF0, 0xE1, 0xC3, 0x87, 0x0F, 0x1E, 0x1C, 0x38,
  0x70, 0xE1, 0xE3, 0xC3, 0x87, 0x0E, 0x1C, 0x3C, 0x78, 0x70, 0xE1, 0xC3,
  0x80, 0x07, 0xE0, 0xFC, 0x3F, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x03,
  0xC1, 0xF8, 0x3F, 0x0F, 0xC0, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xE0, 0xFC,
  0x3B, 0x87, 0x31, 0xC7, 0x38, 0xEE, 0x1F, 0xC3, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xF3, 0x8E, 0x70, 0x01, 0x80, 0x3F, 0xC1, 0xFF, 0x8F, 0x1E,
  0x38, 0x3D, 0x00, 0xF0, 0x03, 0xC7, 0xFE, 0x7F, 0xF9, 0xE0, 0xEF, 0x07,
  0xBC, 0x1E, 0xF0, 0xFB, 0xFF, 0xE7, 0xFF, 0x0F, 0xDE, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xCC, 0x0F, 0xFC, 0x3F,
  0xF8, 0xF9, 0xF3, 0xC3, 0xDE, 0x0F, 0x78, 0x1D, 0xE0, 0x77, 0x01, 0xDC,
  0x0F, 0x70, 0x3F, 0xC0, 0xEF, 0x87, 0xBF, 0xFC, 0xEF, 0xF3, 0x9F, 0x00,
  0x01, 0x80, 0x3F, 0xC1, 0xFF, 0x8F, 0x9F, 0x3C, 0x3D, 0xE0, 0x77, 0x00,
  0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x0E, 0x78, 0x79, 0xFF,
  0xC3, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x0E, 0x03, 0x1E, 0x0F, 0xDE, 0x1F, 0xFE, 0x3E, 0x7C,
  0x3C, 0x3C, 0x78, 0x1C, 0x70, 0x3C, 0x70, 0x3C, 0xF0, 0x3C, 0xF0, 0x38,
  0xF0, 0x38, 0xF0, 0x78, 0x78, 0x78, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0x70,
  0x01, 0x80, 0x1F, 0xC1, 0xFF, 0x8F, 0x9F, 0x3C, 0x1D, 0xE0, 0x77, 0x01,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x78, 0x31, 0xFF,
  0xE3, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0x8F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x07, 0xF7, 0x0F, 0xFF, 0x1F, 0x3F, 0x1E, 0x1E, 0x3C, 0x0E,
  0x3C, 0x0E, 0x38, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x38, 0x1C,
  0x3C, 0x3C, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xBC, 0x00, 0x38, 0x20, 0x78,
  0x70, 0xF8, 0xFF, 0xF0, 0x7F, 0xE0, 0x1F, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC6, 0x0F, 0x7E, 0x3B, 0xFC,
  0xFD, 0xF3, 0xC3, 0xDE, 0x07, 0x78, 0x1D, 0xE0, 0x77, 0x03, 0xDC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xEF, 0x03, 0xBC, 0x1E, 0xE0, 0x7B, 0x81, 0xE0, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x70, 0x03, 0x80, 0x3C, 0x1F, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00,
  0xF0, 0xFF, 0x07, 0xF0, 0x3F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x01, 0x3C, 0x3E, 0x3C, 0x7C,
  0x38, 0xF8, 0x39, 0xF0, 0x7B, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0xC0,
  0x7F, 0xC0, 0x79, 0xE0, 0xF1, 0xE0, 0xF0, 0xF0, 0xF0, 0xF0, 0xE0, 0x78,
  0xE0, 0x7C, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x21, 0xE0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFC, 0x01, 0x8C, 0x3B, 0xDE, 0x3F, 0xFF, 0x3D, 0xEF, 0x39, 0xE7,
  0x79, 0xC7, 0x79, 0xC7, 0x71, 0xCF, 0x71, 0xCE, 0x73, 0xCE, 0x73, 0x8E,
  0xF3, 0x8E, 0xE3, 0x8E, 0xE3, 0x9E, 0xE3, 0x9C, 0xE7, 0x9C, 0x00, 0x60,
  0xE7, 0xE3, 0xFF, 0xCF, 0xDF, 0x3C, 0x3D, 0xE0, 0x77, 0x81, 0xDE, 0x0F,
  0x70, 0x3D, 0xC0, 0xF7, 0x03, 0xFC, 0x0E, 0xF0, 0x3B, 0xC1, 0xEE, 0x07,
  0xB8, 0x1E, 0x01, 0xC0, 0x3F, 0xC1, 0xFF, 0x8F, 0x9F, 0x38, 0x3D, 0xE0,
  0x77, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0E, 0x78,
  0x79, 0xFF, 0xC3, 0xFE, 0x07, 0xF0, 0x02, 0x60, 0x3B, 0xF0, 0x7F, 0xF0,
  0xF9, 0xF1, 0xE1, 0xE7, 0x83, 0xCF, 0x03, 0x9E, 0x07, 0x38, 0x1E, 0x70,
  0x3C, 0xE0, 0x7B, 0xC1, 0xE7, 0x83, 0xCF, 0xFF, 0x1F, 0xFC, 0x3B, 0xF0,
  0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x1F, 0xFC, 0x7F, 0xF9, 0xF3, 0xE3, 0xC3, 0xCF, 0x03, 0x9C,
  0x0F, 0x38, 0x1E, 0xF0, 0x3D, 0xE0, 0x73, 0xC0, 0xE3, 0x83, 0xC7, 0x87,
  0x8F, 0xFF, 0x0F, 0xFE, 0x0F, 0xB8, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x04, 0x31, 0xCF, 0xCE, 0xFE, 0x7F,
  0xF3, 0xE0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0x01, 0x80, 0x3F, 0xC1,
  0xFF, 0xCF, 0x0F, 0x38, 0x1C, 0xE0, 0x03, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xE0, 0x07, 0xBC, 0x0E, 0xF0, 0x39, 0xF3, 0xE3, 0xFF, 0x07, 0xF8,
  0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC1, 0x7F, 0xF9, 0xFF, 0xE8, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x80, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x00, 0x78, 0x3D,
  0xE0, 0xF7, 0x03, 0xDC, 0x0F, 0x70, 0x3B, 0xC0, 0xEF, 0x07, 0xBC, 0x1E,
  0xE0, 0x7B, 0x81, 0xCE, 0x07, 0x3C, 0x3C, 0xFF, 0xF1, 0xFF, 0xC3, 0xEF,
  0x00, 0xF0, 0x1E, 0xE0, 0x79, 0xC0, 0xE3, 0x83, 0xC7, 0x87, 0x0F, 0x1E,
  0x0E, 0x38, 0x1C, 0xF0, 0x39, 0xC0, 0x77, 0x80, 0x7E, 0x00, 0xFC, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x00, 0xE3, 0x8F, 0xE3, 0x8E, 0xE7, 0x9E,
  0xE7, 0x9C, 0xE7, 0x9C, 0xED, 0xB8, 0xED, 0xB8, 0xFD, 0xB8, 0xD9, 0xF0,
  0xD9, 0xF0, 0xF9, 0xF0, 0xF1, 0xE0, 0xF1, 0xE0, 0xE1, 0xE0, 0xE1, 0xC0,
  0x1E, 0x0F, 0x87, 0x07, 0x83, 0xC7, 0x80, 0xE7, 0x80, 0x7F, 0x80, 0x1F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xF8, 0x03, 0xDC, 0x03,
  0xCF, 0x03, 0xC3, 0x83, 0xC1, 0xE3, 0xC0, 0x78, 0x3C, 0x07, 0xCF, 0x01,
  0xE1, 0xC0, 0xF0, 0x78, 0x3C, 0x1E, 0x1E, 0x03, 0x87, 0x00, 0xE3, 0xC0,
  0x38, 0xE0, 0x0F, 0x78, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x1F, 0xFF,
  0x3F, 0xFE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7F, 0xFE, 0x7F, 0xFC,
  0xFF, 0xFC, 0x00, 0x20, 0x1C, 0x07, 0x81, 0xC0, 0x38, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x01, 0xE1, 0xF0, 0x3C, 0x07, 0xC0,
  0x3C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0xC0, 0x3C, 0x03, 0x00, 0x0E, 0x18, 0x30, 0x60, 0xC3, 0x87, 0x0C,
  0x18, 0x30, 0x61, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0x61, 0xC3, 0x86, 0x0C,
  0x18, 0x30, 0xE1, 0xC3, 0x80, 0x08, 0x01, 0xC0, 0x7C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x07,
  0xC0, 0xF8, 0x3F, 0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x01, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0x60, 0x00, 0x0C, 0x00, 0x3F, 0x03,
  0x7F, 0x87, 0x77, 0xEF, 0xE1, 0xFE, 0xE0, 0xFC, 0x00, 0x10,
};

const GFXglyph RobotoMono_SemiBoldItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 7, 21, 17, 5, -21 },
  { 20, 9, 8, 17, 5, -22 },
  { 29, 17, 21, 17, 0, -21 },
  { 74, 16, 27, 17, 1, -24 },
  { 128, 14, 21, 17, 2, -21 },
  { 165, 16, 21, 17, 0, -21 },
  { 207, 4, 8, 17, 7, -22 },
  { 211, 10, 30, 17, 4, -23 },
  { 249, 10, 30, 17, 2, -23 },
  { 287, 14, 15, 17, 2, -21 },
  { 314, 15, 15, 17, 1, -17 },
  { 343, 6, 9, 17, 3, -3 },
  { 350, 11, 3, 17, 4, -11 },
  { 355, 5, 5, 17, 5, -5 },
  { 359, 15, 23, 17, 1, -21 },
  { 403, 14, 21, 17, 2, -21 },
  { 440, 10, 21, 17, 3, -21 },
  { 467, 15, 21, 17, 0, -21 },
  { 507, 15, 21, 17, 1, -21 },
  { 547, 15, 21, 17, 0, -21 },
  { 587, 16, 21, 17, 1, -21 },
  { 629, 14, 21, 17, 1, -21 },
  { 666, 15, 21, 17, 2, -21 },
  { 706, 15, 21, 17, 1, -21 },
  { 746, 13, 21, 17, 2, -21 },
  { 781, 7, 17, 17, 5, -17 },
  { 796, 9, 23, 17, 4, -17 },
  { 822, 13, 14, 17, 2, -16 },
  { 845, 15, 9, 17, 1, -13 },
  { 862, 14, 14, 17, 1, -16 },
  { 887, 12, 21, 17, 4, -21 },
  { 919, 16, 20, 17, 1, -20 },
  { 959, 16, 21, 17, -1, -21 },
  { 1001, 17, 21, 17, 0, -21 },
  { 1046, 16, 21, 17, 1, -21 },
  { 1088, 16, 21, 17, 0, -21 },
  { 1130, 16, 21, 17, 1, -21 },
  { 1172, 17, 21, 17, 1, -21 },
  { 1217, 16, 21, 17, 1, -21 },
  { 1259, 17, 21, 17, 0, -21 },
  { 1304, 15, 21, 17, 1, -21 },
  { 1344, 16, 21, 17, 1, -21 },
  { 1386, 19, 21, 17, 0, -21 },
  { 1436, 13, 21, 17, 1, -21 },
  { 1471, 17, 21, 17, 0, -21 },
  { 1516, 17, 21, 17, 0, -21 },
  { 1561, 15, 21, 17, 1, -21 },
  { 1601, 16, 21, 17, 1, -21 },
  { 1643, 15, 25, 17, 1, -21 },
  { 1690, 17, 21, 17, 0, -21 },
  { 1735, 16, 21, 17, 1, -21 },
  { 1777, 17, 21, 17, 2, -21 },
  { 1822, 16, 21, 17, 1, -21 },
  { 1864, 16, 21, 17, 2, -21 },
  { 1906, 16, 21, 17, 2, -21 },
  { 1948, 20, 21, 17, -1, -21 },
  { 2001, 16, 21, 17, 3, -21 },
  { 2043, 17, 21, 17, 0, -21 },
  { 2088, 11, 29, 17, 3, -24 },
  { 2128, 7, 23, 17, 5, -21 },
  { 2149, 11, 29, 17, 3, -24 },
  { 2189, 11, 11, 17, 3, -21 },
  { 2205, 13, 3, 17, 0, 0 },
  { 2210, 5, 4, 17, 8, -21 },
  { 2213, 14, 16, 17, 1, -16 },
  { 2241, 14, 22, 17, 1, -22 },
  { 2280, 14, 16, 17, 1, -16 },
  { 2308, 16, 22, 17, 1, -22 },
  { 2352, 14, 16, 17, 1, -16 },
  { 2380, 16, 22, 17, 2, -22 },
  { 2424, 16, 22, 17, 0, -16 },
  { 2468, 14, 22, 17, 1, -22 },
  { 2507, 13, 21, 17, 1, -21 },
  { 2542, 13, 27, 17, 1, -21 },
  { 2586, 16, 22, 17, 1, -22 },
  { 2630, 13, 22, 17, 1, -22 },
  { 2666, 16, 16, 17, 0, -16 },
  { 2698, 14, 16, 17, 1, -16 },
  { 2726, 14, 16, 17, 1, -16 },
  { 2754, 15, 22, 17, 0, -16 },
  { 2796, 15, 22, 17, 1, -16 },
  { 2838, 13, 16, 17, 3, -16 },
  { 2864, 14, 16, 17, 1, -16 },
  { 2892, 14, 19, 17, 2, -19 },
  { 2926, 14, 15, 17, 2, -15 },
  { 2953, 15, 15, 17, 2, -15 },
  { 2982, 16, 15, 17, 2, -15 },
  { 3012, 17, 15, 17, 0, -15 },
  { 3044, 18, 21, 17, 0, -15 },
  { 3092, 16, 15, 17, 0, -15 },
  { 3122, 11, 28, 17, 4, -23 },
  { 3161, 7, 27, 17, 5, -21 },
  { 3185, 11, 28, 17, 3, -23 },
  { 3224, 16, 7, 17, 0, -12 },
};

const GFXfont RobotoMono_SemiBoldItalic29pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic29pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic29pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC29PT7B_H_
