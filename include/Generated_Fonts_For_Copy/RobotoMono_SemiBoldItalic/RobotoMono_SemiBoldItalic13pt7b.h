#ifndef _ROBOTOMONO_SEMIBOLDITALIC13PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x66, 0x64, 0x04, 0xC0, 0x55, 0xD9, 0x0A, 0x12, 0x7F, 0x34,
  0x24, 0xFE, 0x68, 0x58, 0x50, 0x08, 0x47, 0xD9, 0x45, 0x83, 0x83, 0x8F,
  0x37, 0x88, 0xE2, 0xBA, 0x94, 0x20, 0xF5, 0x6D, 0x1C, 0x3C, 0x48, 0xB1,
  0xC3, 0x0B, 0x73, 0xE6, 0x7E, 0x5E, 0x12, 0x64, 0x4C, 0xC8, 0x88, 0xC4,
  0x20, 0x21, 0x11, 0x11, 0x11, 0x32, 0x64, 0x80, 0x12, 0x5F, 0xCC, 0x73,
  0x20, 0x10, 0xC3, 0x3F, 0x20, 0x86, 0x00, 0x6D, 0xE0, 0xFF, 0xC0, 0xF0,
  0x0C, 0x21, 0x84, 0x30, 0x86, 0x10, 0xC2, 0x00, 0x79, 0x3C, 0x77, 0xFF,
  0x38, 0xB6, 0x70, 0x3F, 0xA2, 0x26, 0x66, 0x40, 0x3C, 0xCD, 0x98, 0x20,
  0xC3, 0x0C, 0x20, 0xFC, 0x3E, 0xCC, 0x18, 0x61, 0xC0, 0xB1, 0x66, 0x78,
  0x06, 0x18, 0x51, 0xA6, 0xC9, 0xBF, 0x84, 0x08, 0x7D, 0x04, 0x3E, 0x48,
  0x38, 0xF6, 0xF0, 0x39, 0x8C, 0x3E, 0xCA, 0x38, 0xB6, 0x70, 0xFE, 0x18,
  0x20, 0xC1, 0x06, 0x18, 0x30, 0xC0, 0x3E, 0x4D, 0x99, 0xA3, 0xCC, 0x91,
  0x26, 0x78, 0x7B, 0x3C, 0xF3, 0xDD, 0xE1, 0x8C, 0xE0, 0x76, 0x00, 0x0E,
  0xC0, 0x37, 0x00, 0x04, 0x44, 0xC0, 0x04, 0xFE, 0x38, 0x38, 0x20, 0xFC,
  0x00, 0x3F, 0xC3, 0xC1, 0xCE, 0xE2, 0x00, 0xFC, 0x46, 0x33, 0x30, 0x08,
  0xC0, 0x1E, 0x22, 0x5D, 0x75, 0xAA, 0xAA, 0xBC, 0x40, 0x78, 0x0C, 0x38,
  0x51, 0xA2, 0x4C, 0x9F, 0x63, 0xC6, 0x3E, 0x62, 0x62, 0x66, 0x7C, 0x46,
  0x46, 0xCE, 0xFC, 0x3E, 0x45, 0x8A, 0x04, 0x08, 0x11, 0xB6, 0x38, 0x3C,
  0xCD, 0x8B, 0x16, 0x68, 0xD1, 0xE6, 0xF8, 0x3F, 0x20, 0x60, 0x62, 0x7C,
  0x60, 0x40, 0x40, 0xFC, 0x3F, 0x20, 0x60, 0x60, 0x7E, 0x60, 0x40, 0x40,
  0xC0, 0x7D, 0x1C, 0x60, 0x9E, 0x78, 0xF3, 0x78, 0x23, 0x62, 0x62, 0x66,
  0x7E, 0x46, 0x44, 0xC4, 0xCC, 0x3E, 0x10, 0x60, 0xC1, 0x83, 0x04, 0x08,
  0xFC, 0x03, 0x02, 0x02, 0x06, 0x06, 0x06, 0xC4, 0x4C, 0x78, 0x23, 0xB3,
  0x1B, 0x0F, 0x07, 0x83, 0x41, 0x31, 0x98, 0xC6, 0x00, 0x30, 0x86, 0x18,
  0x61, 0x84, 0x10, 0xFC, 0x37, 0x77, 0x76, 0x7A, 0x5A, 0x56, 0x46, 0xC4,
  0xC4, 0x33, 0x72, 0x72, 0x76, 0x7E, 0x4E, 0x4C, 0xCC, 0xCC, 0x3E, 0x4D,
  0x8A, 0x14, 0x28, 0xD1, 0xB6, 0x38, 0x3E, 0x22, 0x63, 0x62, 0x7E, 0x78,
  0x40, 0x40, 0xC0, 0x3E, 0x4D, 0x8A, 0x14, 0x28, 0xD1, 0xB6, 0x3C, 0x0C,
  0x10, 0x3E, 0x22, 0x62, 0x66, 0x7C, 0x4C, 0x4C, 0xC4, 0xC6, 0x3E, 0x62,
  0x61, 0x30, 0x1C, 0x06, 0xC6, 0x66, 0x3C, 0xFE, 0x20, 0xC1, 0x83, 0x06,
  0x08, 0x10, 0x60, 0x47, 0x8B, 0x16, 0x6C, 0xD1, 0xA3, 0x6C, 0xF0, 0xC7,
  0x8B, 0x32, 0x45, 0x8B, 0x1C, 0x38, 0x60, 0xD3, 0x2E, 0xD5, 0xAB, 0xDB,
  0xB6, 0x6C, 0x98, 0x63, 0x36, 0x34, 0x1C, 0x18, 0x38, 0x6C, 0x64, 0xC6,
  0xC6, 0x89, 0xB3, 0xC3, 0x06, 0x08, 0x10, 0x60, 0x7F, 0x06, 0x0C, 0x08,
  0x18, 0x30, 0x60, 0xC0, 0xFE, 0x37, 0x66, 0x44, 0x4C, 0xCC, 0xC8, 0xC0,
  0xC4, 0x44, 0x66, 0x22, 0x23, 0x37, 0x33, 0x32, 0x22, 0x66, 0x64, 0xC0,
  0x19, 0x4A, 0x9C, 0x80, 0xFC, 0xE0, 0x3C, 0xCC, 0x1B, 0xE4, 0x59, 0x9F,
  0x00, 0x30, 0x40, 0x83, 0xE6, 0x6C, 0xD1, 0xA3, 0x6D, 0xF0, 0x7B, 0x3C,
  0xE0, 0x83, 0x67, 0x00, 0x06, 0x08, 0x13, 0xEC, 0xD9, 0xA3, 0x44, 0xD9,
  0xD0, 0x3B, 0x3C, 0xFF, 0x83, 0x27, 0x80, 0x1E, 0x30, 0xC7, 0xE2, 0x04,
  0x08, 0x30, 0x60, 0xC0, 0x3A, 0xCD, 0x9A, 0x34, 0x4D, 0x9D, 0x06, 0xF8,
  0xE0, 0x30, 0x40, 0x83, 0xE6, 0x6C, 0xD1, 0xA3, 0x45, 0x88, 0x10, 0xC0,
  0xE1, 0x18, 0xC6, 0x27, 0xC0, 0x04, 0x30, 0x0F, 0x0C, 0x20, 0x86, 0x18,
  0x61, 0xBC, 0xE0, 0x30, 0x20, 0x20, 0x67, 0x6C, 0x78, 0x78, 0x78, 0x4C,
  0xCE, 0x7B, 0xC6, 0x21, 0x18, 0xC6, 0x27, 0xC0, 0x5E, 0xF5, 0x6E, 0x9D,
  0x7A, 0xED, 0x00, 0x7C, 0xCD, 0x9A, 0x34, 0x68, 0xB3, 0x00, 0x7B, 0x38,
  0xE3, 0x8F, 0x6F, 0x00, 0x7C, 0xCD, 0x9A, 0x34, 0x69, 0xBE, 0x60, 0xC1,
  0x00, 0x77, 0x3C, 0xE3, 0x8B, 0x6E, 0x86, 0x18, 0x60, 0x7D, 0xF6, 0x10,
  0x43, 0x0C, 0x00, 0x7B, 0x3C, 0x1E, 0x0E, 0x2F, 0x80, 0x30, 0xCF, 0xC8,
  0x61, 0x86, 0x18, 0x38, 0xC7, 0x3C, 0xF3, 0x8B, 0x6E, 0x80, 0xC7, 0x99,
  0x22, 0xC5, 0x0E, 0x18, 0x00, 0x97, 0x6A, 0xD6, 0xED, 0x9B, 0x26, 0x00,
  0x63, 0x36, 0x3C, 0x18, 0x38, 0x6C, 0xC6, 0x63, 0x66, 0x26, 0x2C, 0x38,
  0x38, 0x10, 0x30, 0xE0, 0xC0, 0x7E, 0x0C, 0x30, 0xC3, 0x0C, 0x7F, 0x00,
  0x19, 0x8C, 0x42, 0x73, 0x0C, 0x62, 0x10, 0x40, 0x24, 0x94, 0x92, 0x4B,
  0x40, 0x30, 0x84, 0x23, 0x0C, 0x64, 0x21, 0x19, 0x80, 0x73, 0x3C, 0x10,
};

const GFXglyph RobotoMono_SemiBoldItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 4, 9, 8, 2, -9 },
  { 6, 4, 4, 8, 2, -10 },
  { 8, 8, 9, 8, 0, -9 },
  { 17, 6, 12, 8, 1, -11 },
  { 26, 6, 9, 8, 1, -9 },
  { 33, 7, 9, 8, 0, -9 },
  { 41, 2, 4, 8, 3, -10 },
  { 42, 4, 13, 8, 2, -10 },
  { 49, 4, 13, 8, 1, -10 },
  { 56, 6, 6, 8, 1, -9 },
  { 61, 6, 7, 8, 1, -8 },
  { 67, 3, 4, 8, 1, -2 },
  { 69, 5, 2, 8, 2, -5 },
  { 71, 2, 2, 8, 2, -2 },
  { 72, 6, 10, 8, 1, -9 },
  { 80, 6, 9, 8, 1, -9 },
  { 87, 4, 9, 8, 2, -9 },
  { 92, 7, 9, 8, 0, -9 },
  { 100, 7, 9, 8, 0, -9 },
  { 108, 7, 9, 8, 0, -9 },
  { 116, 6, 9, 8, 1, -9 },
  { 123, 6, 9, 8, 1, -9 },
  { 130, 7, 9, 8, 1, -9 },
  { 138, 7, 9, 8, 0, -9 },
  { 146, 6, 9, 8, 1, -9 },
  { 153, 4, 7, 8, 2, -7 },
  { 157, 4, 9, 8, 2, -7 },
  { 162, 6, 6, 8, 1, -7 },
  { 167, 6, 4, 8, 1, -6 },
  { 170, 6, 6, 8, 1, -7 },
  { 175, 5, 9, 8, 2, -9 },
  { 181, 8, 9, 8, 0, -9 },
  { 190, 7, 9, 8, 0, -9 },
  { 198, 8, 9, 8, 0, -9 },
  { 207, 7, 9, 8, 0, -9 },
  { 215, 7, 9, 8, 0, -9 },
  { 223, 8, 9, 8, 0, -9 },
  { 232, 8, 9, 8, 0, -9 },
  { 241, 6, 9, 8, 1, -9 },
  { 248, 8, 9, 8, 0, -9 },
  { 257, 7, 9, 8, 0, -9 },
  { 265, 8, 9, 8, 0, -9 },
  { 274, 9, 9, 8, 0, -9 },
  { 285, 6, 9, 8, 0, -9 },
  { 292, 8, 9, 8, 0, -9 },
  { 301, 8, 9, 8, 0, -9 },
  { 310, 7, 9, 8, 0, -9 },
  { 318, 8, 9, 8, 0, -9 },
  { 327, 7, 11, 8, 0, -9 },
  { 337, 8, 9, 8, 0, -9 },
  { 346, 8, 9, 8, 0, -9 },
  { 355, 7, 9, 8, 1, -9 },
  { 363, 7, 9, 8, 1, -9 },
  { 371, 7, 9, 8, 1, -9 },
  { 379, 7, 9, 8, 1, -9 },
  { 387, 8, 9, 8, 0, -9 },
  { 396, 7, 9, 8, 1, -9 },
  { 404, 8, 9, 8, 0, -9 },
  { 413, 4, 13, 8, 2, -11 },
  { 420, 4, 10, 8, 2, -9 },
  { 425, 4, 13, 8, 2, -11 },
  { 432, 5, 5, 8, 1, -9 },
  { 436, 6, 1, 8, 0, 0 },
  { 437, 3, 1, 8, 3, -9 },
  { 438, 7, 7, 8, 0, -7 },
  { 445, 7, 10, 8, 0, -10 },
  { 454, 6, 7, 8, 1, -7 },
  { 460, 7, 10, 8, 1, -10 },
  { 469, 6, 7, 8, 1, -7 },
  { 475, 7, 10, 8, 1, -10 },
  { 484, 7, 10, 8, 0, -7 },
  { 493, 7, 10, 8, 0, -10 },
  { 502, 5, 10, 8, 1, -10 },
  { 509, 6, 13, 8, 0, -10 },
  { 519, 8, 10, 8, 0, -10 },
  { 529, 5, 10, 8, 1, -10 },
  { 536, 7, 7, 8, 0, -7 },
  { 543, 7, 7, 8, 0, -7 },
  { 550, 6, 7, 8, 1, -7 },
  { 556, 7, 10, 8, 0, -7 },
  { 565, 6, 10, 8, 1, -7 },
  { 573, 6, 7, 8, 1, -7 },
  { 579, 6, 7, 8, 1, -7 },
  { 585, 6, 9, 8, 1, -9 },
  { 592, 6, 7, 8, 1, -7 },
  { 598, 7, 7, 8, 1, -7 },
  { 605, 7, 7, 8, 1, -7 },
  { 612, 8, 7, 8, 0, -7 },
  { 619, 8, 10, 8, 0, -7 },
  { 629, 7, 7, 8, 0, -7 },
  { 636, 5, 12, 8, 2, -10 },
  { 644, 3, 12, 8, 2, -9 },
  { 649, 5, 12, 8, 1, -10 },
  { 657, 7, 3, 8, 0, -5 },
};

const GFXfont RobotoMono_SemiBoldItalic13pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic13pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic13pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC13PT7B_H_
