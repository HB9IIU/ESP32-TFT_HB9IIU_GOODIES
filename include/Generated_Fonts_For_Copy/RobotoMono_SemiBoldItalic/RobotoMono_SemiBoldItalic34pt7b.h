#ifndef _ROBOTOMONO_SEMIBOLDITALIC34PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x0F, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x00, 0x00, 0x00, 0x20, 0xF8, 0xF8, 0xF8,
  0x70, 0x70, 0xEE, 0x3D, 0xC7, 0x38, 0xE7, 0x1D, 0xC3, 0xB8, 0x77, 0x0C,
  0xE3, 0x80, 0x00, 0x38, 0xE0, 0x07, 0x0C, 0x00, 0x71, 0xC0, 0x06, 0x1C,
  0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0xC3, 0x81, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF0, 0x18, 0x70, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x07, 0x0E, 0x00, 0x71,
  0xC0, 0x7F, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0xE3, 0x80, 0x1C,
  0x30, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x03, 0x86, 0x00, 0x38, 0xE0, 0x07,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x3F,
  0xE0, 0x3F, 0xF8, 0x3F, 0xFC, 0x3E, 0x1F, 0x1E, 0x07, 0x9F, 0x03, 0xCF,
  0x01, 0xE7, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF7, 0x80,
  0xFB, 0xC0, 0x7D, 0xF0, 0x3C, 0xFC, 0x7E, 0x3F, 0xFE, 0x0F, 0xFE, 0x03,
  0xFC, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x04, 0x00,
  0x3F, 0x00, 0x7F, 0x80, 0x73, 0x80, 0xE3, 0x87, 0xE3, 0x8E, 0xE3, 0x9C,
  0xE3, 0x9C, 0xF7, 0xB8, 0x7F, 0x70, 0x3E, 0x60, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x3E, 0x0E, 0xFF, 0x0E, 0xE7, 0x1D, 0xC7,
  0x39, 0xC7, 0x71, 0xC7, 0x11, 0xC7, 0x01, 0xEF, 0x00, 0xFE, 0x00, 0x7C,
  0x00, 0x20, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x0F, 0x9E, 0x03,
  0xC3, 0x80, 0xF0, 0xE0, 0x38, 0x78, 0x0F, 0x3C, 0x03, 0xDF, 0x00, 0xFF,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x73, 0xFE, 0x1D, 0xF7, 0x8F,
  0xF8, 0xF3, 0xFC, 0x3F, 0xEF, 0x07, 0xFB, 0xC1, 0xFC, 0xF0, 0x3E, 0x3E,
  0x3F, 0x8F, 0xFF, 0xF1, 0xFF, 0xFC, 0x1F, 0xCF, 0x80, 0x77, 0x7F, 0xEE,
  0xEE, 0xE0, 0x00, 0x20, 0x06, 0x01, 0xF0, 0x3E, 0x03, 0xC0, 0x78, 0x0F,
  0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3C,
  0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x04, 0x00, 0x04, 0x00, 0xC0, 0x3C, 0x03,
  0xC0, 0x38, 0x03, 0x80, 0x70, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C,
  0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x78,
  0x0F, 0x03, 0xC0, 0xF0, 0x18, 0x02, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0x41, 0xC1, 0x71, 0xC7, 0xFD, 0xBF, 0xFF, 0xFF,
  0x0F, 0xF8, 0x07, 0xC0, 0x0F, 0xC0, 0x1E, 0xE0, 0x3C, 0xE0, 0x38, 0x70,
  0x78, 0x78, 0x30, 0x70, 0x10, 0x20, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x3C, 0x78, 0xF3, 0xC7, 0x8F,
  0x3C, 0x71, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7B, 0xFF, 0xFE,
  0x78, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x40, 0x01, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xC1, 0xF1, 0xF1, 0xF0,
  0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x7C, 0x0F, 0x3C, 0x0F, 0x9E, 0x0F, 0xCF,
  0x1F, 0xE7, 0x9E, 0xF3, 0xFE, 0x7B, 0xFC, 0x7D, 0xFC, 0x3E, 0xF8, 0x1E,
  0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x07, 0x8F, 0x83, 0xC3, 0xE3, 0xC1, 0xFF,
  0xE0, 0x7F, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0x60, 0x7C, 0x3F, 0xBF, 0xF7,
  0xFF, 0xFF, 0xB8, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x07, 0xC0, 0xF0, 0x00, 0x10, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x3F, 0xFE,
  0x0F, 0x8F, 0xC7, 0xC1, 0xF1, 0xE0, 0x3C, 0xF8, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x2F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x00,
  0x00, 0x20, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0x0F, 0x87,
  0x81, 0xE3, 0xE0, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01,
  0xF0, 0x0F, 0xF8, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x7C, 0xF8, 0x1E, 0x3F,
  0x1F, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F,
  0xF8, 0x07, 0xBC, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x78, 0xF0, 0x3C, 0x3C,
  0x1E, 0x1F, 0x07, 0x07, 0x83, 0xC1, 0xE1, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xF8, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xF0, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0xF0, 0x07,
  0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x0C, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x3E, 0x03, 0xC7, 0x81, 0xF1, 0xE0, 0x78,
  0x7C, 0x3E, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0x7C, 0x03,
  0xF8, 0x1F, 0xF0, 0x7F, 0x01, 0xF8, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00,
  0x79, 0xF0, 0xFF, 0xF3, 0xFF, 0xF7, 0xF3, 0xFF, 0x83, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x81, 0xE7, 0x8F,
  0xCF, 0xFF, 0x0F, 0xFC, 0x0F, 0xE0, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF,
  0xF8, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0x00, 0x20, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x0F, 0x8F, 0x87,
  0xC1, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x83, 0xE1, 0xF1,
  0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x07, 0xFF, 0x03, 0xF3, 0xE1, 0xF0, 0x7C,
  0x78, 0x0F, 0x1E, 0x03, 0xCF, 0x80, 0xF3, 0xE0, 0x7C, 0xF8, 0x1E, 0x1F,
  0x1F, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x80, 0x1F,
  0xE0, 0x7F, 0xE1, 0xFF, 0xE7, 0xC3, 0xCF, 0x07, 0xFE, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x03, 0xFF, 0x9F, 0x9F,
  0xFF, 0x1F, 0xFE, 0x1F, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x03, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0x7C, 0x00, 0x1F, 0x1F, 0x3F, 0x1F,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0xFC,
  0xFC, 0xFC, 0x78, 0x07, 0x83, 0xF0, 0xFC, 0x3F, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0xE0, 0x00, 0x00,
  0x03, 0x00, 0x1F, 0x00, 0x7F, 0x03, 0xFF, 0x0F, 0xFC, 0x3F, 0xE0, 0x7F,
  0x00, 0x78, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFC, 0x00, 0x7C, 0x00, 0x0C, 0x3F, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0xCF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0xFF, 0xFE,
  0x7F, 0xFF, 0x3F, 0xFF, 0x80, 0x18, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x7F, 0x03,
  0xFF, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0x00, 0x7C, 0x00, 0x60, 0x00, 0x80,
  0x00, 0x01, 0x80, 0x1F, 0xE0, 0xFF, 0xF3, 0xFF, 0xE7, 0xC3, 0xFF, 0x03,
  0xFC, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0,
  0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1C, 0x00,
  0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x1F, 0xBE, 0x07, 0x80, 0xE1, 0xE0, 0x0C,
  0x38, 0xF1, 0x8E, 0x3F, 0xB1, 0x8F, 0x67, 0x73, 0x8C, 0xEC, 0x63, 0x9F,
  0x9C, 0x73, 0x73, 0x8C, 0x6E, 0x61, 0x8D, 0x9C, 0x71, 0xB3, 0x8E, 0x66,
  0x71, 0x8C, 0xC7, 0xFB, 0x18, 0xFF, 0xE3, 0x8E, 0x70, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xFC, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x3D, 0xC0, 0x07, 0xBC, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x0F, 0x9E, 0x01,
  0xE3, 0xC0, 0x7C, 0x78, 0x0F, 0x0F, 0x03, 0xE0, 0xF0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0xF8,
  0x07, 0x9E, 0x00, 0xFF, 0xC0, 0x1F, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0xF0, 0x7E, 0x0F, 0x01, 0xE0, 0xF0, 0x1F, 0x0F, 0x01, 0xF1,
  0xF0, 0x1E, 0x1E, 0x03, 0xE1, 0xE0, 0x7C, 0x1F, 0xFF, 0x81, 0xFF, 0xE0,
  0x3F, 0xFF, 0x83, 0xE0, 0xFC, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03,
  0xC3, 0xC0, 0x3C, 0x7C, 0x07, 0xC7, 0xC0, 0xFC, 0x7E, 0x7F, 0x87, 0xFF,
  0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x3F, 0xC0, 0x1F,
  0xFC, 0x07, 0xFF, 0xC0, 0xF8, 0x7C, 0x3C, 0x07, 0x8F, 0x80, 0xF1, 0xE0,
  0x1E, 0x3C, 0x03, 0xEF, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0xB3, 0xE0, 0x3E, 0x3C, 0x07, 0x87, 0x81, 0xF0, 0xF8, 0x7C, 0x0F, 0xFF,
  0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F,
  0xFE, 0x07, 0x8F, 0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0x87, 0xC0, 0xF8, 0xF8,
  0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x01, 0xF3, 0xE0,
  0x3E, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x07, 0xCF, 0x80,
  0xF1, 0xF0, 0x3E, 0x3C, 0x0F, 0x87, 0x9F, 0xE0, 0xFF, 0xF8, 0x1F, 0xFC,
  0x07, 0xFE, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x3F, 0xFE, 0x0F, 0x87, 0xC7,
  0xC0, 0xF1, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x5E, 0x1F, 0xE7, 0x87, 0xFB, 0xE1, 0xFE,
  0xF8, 0x07, 0xBE, 0x01, 0xE7, 0x80, 0xF9, 0xE0, 0x3E, 0x7C, 0x0F, 0x1F,
  0x8F, 0xC3, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xF0, 0x00, 0x0F, 0x80, 0xF0,
  0xF0, 0x0F, 0x0F, 0x01, 0xF0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x1E,
  0x1F, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x03, 0xE1, 0xE0, 0x3C, 0x1F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xC0, 0x3C, 0x3C, 0x07, 0xC3, 0xC0,
  0x78, 0x3C, 0x07, 0x87, 0xC0, 0x78, 0x78, 0x07, 0x87, 0x80, 0xF8, 0x78,
  0x0F, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x0F, 0x80, 0xF0, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF0, 0xFF, 0xFC, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF,
  0xC3, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x1E, 0x01, 0xE3, 0xE0, 0x7C,
  0x7C, 0x1F, 0x07, 0xC7, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x00,
  0x07, 0x80, 0xFC, 0x3E, 0x07, 0xE0, 0xF0, 0x3F, 0x03, 0xC0, 0xF8, 0x0F,
  0x07, 0xC0, 0x3C, 0x3E, 0x00, 0xF1, 0xF0, 0x07, 0xCF, 0x80, 0x1E, 0x7C,
  0x00, 0x7B, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0x8F, 0x00, 0x3C, 0x3E, 0x00, 0xF0,
  0x78, 0x07, 0xC1, 0xF0, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x81, 0xE0, 0x3E,
  0x07, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x0F, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x7F, 0x0F, 0xC7, 0xF0, 0xFC, 0xFE, 0x1F, 0xCE, 0xE1,
  0xEC, 0xFE, 0x1E, 0xFD, 0xE1, 0xEF, 0xDE, 0x1E, 0xF9, 0xE1, 0xCF, 0x9C,
  0x3C, 0xF3, 0xC3, 0xCF, 0x3C, 0x3C, 0xF3, 0xC3, 0xCE, 0x3C, 0x3C, 0x03,
  0xC7, 0x80, 0x78, 0x78, 0x07, 0x87, 0x80, 0x78, 0x78, 0x07, 0x87, 0x80,
  0x78, 0x78, 0x07, 0x8F, 0x00, 0xF0, 0x0F, 0x80, 0xF0, 0xF8, 0x1F, 0x0F,
  0x81, 0xF0, 0xFC, 0x1E, 0x0F, 0xC1, 0xE0, 0xFC, 0x1E, 0x1F, 0xC1, 0xE1,
  0xFE, 0x3E, 0x1E, 0xE3, 0xE1, 0xEE, 0x3C, 0x1E, 0xF3, 0xC3, 0xEF, 0x3C,
  0x3E, 0x73, 0xC3, 0xC7, 0x7C, 0x3C, 0x7F, 0x83, 0xC7, 0xF8, 0x3C, 0x3F,
  0x87, 0xC3, 0xF8, 0x7C, 0x3F, 0x87, 0x81, 0xF8, 0x78, 0x1F, 0x07, 0x81,
  0xF0, 0x78, 0x1F, 0x0F, 0x80, 0xF0, 0x00, 0x20, 0x00, 0x7F, 0x80, 0x7F,
  0xF0, 0x3F, 0xFE, 0x0F, 0x8F, 0x87, 0x81, 0xF3, 0xE0, 0x3C, 0xF0, 0x0F,
  0x3C, 0x03, 0xDF, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0F, 0x78, 0x03, 0xDE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1E, 0xF8, 0x07, 0xBE, 0x01, 0xEF, 0x80,
  0xF1, 0xE0, 0x3C, 0x78, 0x1E, 0x1F, 0x9F, 0x83, 0xFF, 0xC0, 0x7F, 0xE0,
  0x0F, 0xE0, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0x87,
  0xE1, 0xE0, 0x3E, 0x3C, 0x07, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x03,
  0xE7, 0xC0, 0x78, 0xF0, 0x1F, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC,
  0x1F, 0xFE, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x0F, 0x8F, 0x87,
  0xC1, 0xF3, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xDF, 0x00, 0xF7, 0x80,
  0x3D, 0xE0, 0x0F, 0x78, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x7F, 0xE0, 0x1E,
  0xF8, 0x07, 0xBE, 0x01, 0xEF, 0x80, 0xF9, 0xE0, 0x3C, 0x78, 0x1F, 0x1F,
  0x9F, 0x83, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x04, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F,
  0xFE, 0x0F, 0x07, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0xC7, 0x80, 0xF9, 0xF0,
  0x1F, 0x3C, 0x03, 0xC7, 0x80, 0xF8, 0xF0, 0x3E, 0x1F, 0xFF, 0xC3, 0xFF,
  0xF0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xC3, 0xE0, 0x78, 0x3C, 0x0F, 0x07,
  0x83, 0xE0, 0xF8, 0x7C, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3E, 0x3C, 0x03,
  0xC7, 0x80, 0x78, 0x00, 0x10, 0x00, 0x3F, 0xC0, 0x1F, 0xFE, 0x07, 0xFF,
  0xE1, 0xF8, 0x7C, 0x3C, 0x07, 0x87, 0x80, 0xF9, 0xF0, 0x0F, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF3, 0xC0, 0x1E,
  0x7C, 0x03, 0xCF, 0x80, 0xF8, 0xF8, 0x7E, 0x0F, 0xFF, 0x80, 0xFF, 0xE0,
  0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE8, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x3E, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x1F,
  0x3C, 0x07, 0x8F, 0x01, 0xE7, 0xC0, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9E,
  0x03, 0xE7, 0x80, 0xF1, 0xE0, 0x3C, 0xF8, 0x0F, 0x3C, 0x03, 0xCF, 0x01,
  0xF3, 0xC0, 0x7C, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x03, 0xE3, 0xC0, 0xF0,
  0xF8, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7B, 0xE0, 0x3E, 0x78, 0x0F, 0x1E, 0x07, 0xC7, 0x81,
  0xE1, 0xE0, 0xF8, 0x78, 0x3E, 0x1E, 0x0F, 0x07, 0xC7, 0xC0, 0xF1, 0xE0,
  0x3C, 0xF8, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x78, 0xF1, 0xF7, 0x8F, 0x1E, 0x78, 0xF1, 0xE7, 0x1F,
  0x1E, 0x71, 0xF3, 0xC7, 0x1F, 0x3C, 0x71, 0xF3, 0xC7, 0x3F, 0x38, 0x73,
  0xF7, 0x87, 0x3F, 0x78, 0x77, 0x77, 0x87, 0x77, 0x70, 0xF7, 0x7F, 0x0F,
  0xE7, 0xF0, 0xFE, 0x7E, 0x0F, 0xE7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0,
  0xFC, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0x80, 0xF8, 0x78,
  0x0F, 0x07, 0x80, 0x0F, 0x80, 0x7E, 0x0F, 0x01, 0xF8, 0x1F, 0x03, 0xE0,
  0x1E, 0x0F, 0x80, 0x3C, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x79, 0xF0, 0x00,
  0xF3, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0x00, 0x07, 0xCF, 0x00, 0x0F, 0x1E, 0x00, 0x3E, 0x3E, 0x00, 0xF8, 0x3C,
  0x03, 0xE0, 0x78, 0x07, 0xC0, 0xF8, 0x1F, 0x00, 0xF0, 0x7E, 0x01, 0xF0,
  0xF8, 0x03, 0xEF, 0x00, 0xF9, 0xE0, 0x1E, 0x3E, 0x07, 0xC3, 0xC1, 0xF0,
  0x78, 0x3C, 0x0F, 0x0F, 0x81, 0xF1, 0xE0, 0x1E, 0x78, 0x03, 0xDF, 0x00,
  0x7B, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7F,
  0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x7F, 0x0F, 0xE0, 0xFE, 0x00, 0xF0,
  0x38, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x70, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC0, 0xE0, 0x78, 0x3C, 0x1E, 0x0F, 0x03, 0x81, 0xC0, 0xF0, 0x78,
  0x3C, 0x1E, 0x07, 0x03, 0xC0, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x0F, 0x01,
  0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xC0, 0x1E, 0x01, 0xF8,
  0x0F, 0xC0, 0xFE, 0x07, 0x70, 0x7B, 0xC3, 0x8E, 0x3C, 0x73, 0xC3, 0x9C,
  0x1D, 0xE0, 0xFE, 0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0,
  0xF0, 0xE1, 0xE1, 0xE0, 0x03, 0xF8, 0x0F, 0xFE, 0x1F, 0xFF, 0x3E, 0x1F,
  0x3C, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x07, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF,
  0x7C, 0x1F, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0xF8, 0x7E, 0x7F, 0xFE,
  0x7F, 0xDE, 0x3F, 0x9E, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0xFC, 0x0F,
  0xFF, 0x0F, 0xFF, 0xC7, 0xE3, 0xE3, 0xE0, 0xF9, 0xE0, 0x7C, 0xF0, 0x1E,
  0x78, 0x0F, 0x7C, 0x07, 0xBC, 0x07, 0xDE, 0x03, 0xCF, 0x01, 0xE7, 0x80,
  0xF3, 0xC0, 0xFB, 0xF0, 0xF9, 0xFF, 0xF8, 0xF7, 0xF8, 0x79, 0xF8, 0x00,
  0x07, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x3E, 0x3E, 0x7C, 0x1F, 0x78, 0x0F,
  0xF8, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x1E, 0xF0, 0x3C, 0xF8, 0x7C, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x07, 0xEF, 0x87, 0xFF, 0xC3, 0xFF,
  0xF0, 0xF8, 0xFC, 0x7C, 0x1F, 0x1E, 0x03, 0xCF, 0x81, 0xF3, 0xC0, 0x78,
  0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0xF8, 0xF0, 0x3E, 0x3C,
  0x0F, 0x0F, 0x8F, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xCF, 0x00, 0x01,
  0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xE3, 0xE3, 0xE0, 0x79, 0xE0, 0x3D,
  0xF0, 0x1E, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDE, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x20, 0xF8, 0x78, 0x7F, 0xFE, 0x1F, 0xFC, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xC1, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0x3F, 0xFF,
  0x8F, 0xFF, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xF9, 0xE0, 0xFF, 0xBC, 0x3F, 0xFF, 0x07, 0xC7, 0xE1, 0xF0,
  0x7C, 0x3C, 0x07, 0x8F, 0x80, 0xF1, 0xE0, 0x3E, 0x3C, 0x07, 0x87, 0x80,
  0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x1F, 0x0F, 0x8F,
  0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFD, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x03, 0x03, 0xE0, 0xF1, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xC0,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x7E, 0x0F, 0xFF, 0x8F, 0xFF,
  0xC7, 0xE3, 0xF3, 0xE0, 0xF9, 0xE0, 0x3C, 0xF0, 0x1E, 0xF8, 0x0F, 0x7C,
  0x0F, 0xBC, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF7, 0xC0, 0x7B,
  0xC0, 0x7D, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x1F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFC, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F,
  0x08, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x07, 0xE3, 0xC1, 0xF0, 0xF8, 0x7C, 0x1E, 0x1F,
  0x03, 0xCF, 0xC0, 0x7B, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3E, 0x7C, 0x07, 0x8F, 0x81, 0xF0, 0xF8,
  0x3C, 0x1F, 0x07, 0x81, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xE0, 0x07, 0xFC,
  0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE,
  0xFF, 0xFE, 0x1D, 0xF7, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x9F, 0x7C, 0xF3,
  0xCF, 0x1E, 0x79, 0xE3, 0xCE, 0x3C, 0x7B, 0xC7, 0x8E, 0x78, 0xF3, 0xCF,
  0x1C, 0x79, 0xE3, 0x8F, 0x3C, 0xF1, 0xEF, 0x1E, 0x3D, 0xE3, 0xC7, 0x3C,
  0x79, 0xE7, 0x8E, 0x3C, 0xF3, 0xC7, 0x9C, 0x78, 0xF0, 0x1E, 0x7E, 0x0E,
  0xFF, 0x8F, 0xFF, 0xC7, 0xE3, 0xF3, 0xE0, 0xF9, 0xE0, 0x3C, 0xF0, 0x1E,
  0xF8, 0x0F, 0x7C, 0x0F, 0xBC, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80,
  0xF7, 0xC0, 0x7B, 0xC0, 0x7D, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x00,
  0x03, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0xC3, 0xE3, 0xE3, 0xE0, 0xF9, 0xE0,
  0x7D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xFE, 0x03, 0xFF,
  0x01, 0xE7, 0x80, 0xF3, 0xC0, 0xF1, 0xF0, 0xF8, 0x7F, 0xF8, 0x1F, 0xF8,
  0x07, 0xF0, 0x00, 0x07, 0xBF, 0x00, 0xEF, 0xF0, 0x3F, 0xFF, 0x07, 0xE3,
  0xE0, 0xF8, 0x3E, 0x1E, 0x07, 0xC3, 0xC0, 0xF8, 0x78, 0x0F, 0x1F, 0x01,
  0xE3, 0xC0, 0x7C, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x7C, 0x7C, 0x0F,
  0x0F, 0xC7, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0x9F, 0x80, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xE7, 0x8F, 0xFF, 0x8F, 0xFF, 0xC7, 0xC7, 0xE7,
  0xC1, 0xF3, 0xC0, 0x7B, 0xE0, 0x7D, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F,
  0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x03, 0xE7, 0x81, 0xE3, 0xE3, 0xF0, 0xFF,
  0xF8, 0x7F, 0xFC, 0x1F, 0xDE, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x1E, 0x7F, 0x1E,
  0xFF, 0x1F, 0xFF, 0x1F, 0xFE, 0x3F, 0x80, 0x3E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xFC, 0x07,
  0xFF, 0x07, 0xFF, 0xC3, 0xC1, 0xF3, 0xC0, 0x79, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0x80, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0x80, 0x03, 0xEF, 0x00,
  0xF7, 0xC0, 0x79, 0xF0, 0x7C, 0xFF, 0xFC, 0x3F, 0xFC, 0x07, 0xF8, 0x00,
  0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x87, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x20,
  0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0x3C, 0x07, 0x9E, 0x03, 0xDF, 0x03,
  0xEF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x3E, 0xF8,
  0x1E, 0x7C, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x81, 0xF3,
  0xE3, 0xF0, 0xFF, 0xF8, 0x7F, 0xBC, 0x1F, 0x9E, 0x00, 0xF0, 0x0F, 0xF8,
  0x07, 0xBC, 0x07, 0xDE, 0x03, 0xC7, 0x03, 0xC3, 0xC1, 0xE1, 0xE1, 0xE0,
  0xF0, 0xF0, 0x78, 0xF0, 0x1C, 0x78, 0x0E, 0x78, 0x07, 0xBC, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0xE3, 0xFE, 0x3C, 0x7B, 0xC7, 0x8F, 0x79, 0xF1, 0xCF, 0x3E, 0x79,
  0xC7, 0xCF, 0x39, 0xF9, 0xC7, 0x3F, 0x78, 0xE6, 0xEF, 0x1D, 0xDD, 0xC3,
  0xBB, 0xF8, 0x76, 0x7E, 0x0F, 0xCF, 0xC1, 0xF1, 0xF8, 0x3E, 0x3E, 0x07,
  0xC7, 0xC0, 0xF0, 0xF8, 0x1E, 0x0E, 0x00, 0x1F, 0x01, 0xF0, 0xF0, 0x3E,
  0x0F, 0x87, 0xC0, 0x78, 0xF8, 0x07, 0xCF, 0x00, 0x3D, 0xF0, 0x03, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0xC0, 0x0F, 0xBC, 0x00, 0xF1, 0xE0, 0x1F, 0x1E, 0x03, 0xE0, 0xF0, 0x7C,
  0x0F, 0x8F, 0x80, 0x78, 0x3E, 0x00, 0xF8, 0xF0, 0x0F, 0x87, 0x80, 0x7C,
  0x3E, 0x07, 0xC0, 0xF0, 0x3C, 0x07, 0x83, 0xE0, 0x3C, 0x1E, 0x01, 0xE1,
  0xF0, 0x07, 0x8F, 0x00, 0x3C, 0xF0, 0x01, 0xEF, 0x80, 0x0F, 0x78, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFC,
  0x7F, 0xFF, 0x9F, 0xFF, 0xF0, 0x00, 0x08, 0x03, 0xC0, 0x3E, 0x03, 0xC0,
  0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x07, 0x80, 0x7C, 0x1F, 0xC0, 0xF8, 0x07, 0xC0, 0x1F, 0x00,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x3E, 0x00, 0xE0, 0x03, 0x00, 0x07,
  0x06, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x18, 0x18, 0x38, 0x38, 0x38, 0x38, 0x30, 0x30, 0x70, 0x70, 0x70, 0x70,
  0x70, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0x04, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3F, 0x00, 0xF8, 0x0F, 0xC0,
  0xFC, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x03, 0xF0, 0x1F, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x07, 0xF0, 0x1C, 0xFF, 0x03, 0xBF, 0xF8, 0xE7, 0x1F, 0xFD,
  0xC0, 0xFF, 0x18, 0x0F, 0xE0, 0x00, 0x70,
};

const GFXglyph RobotoMono_SemiBoldItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 8, 24, 20, 6, -24 },
  { 25, 11, 9, 20, 6, -26 },
  { 38, 20, 24, 20, 0, -24 },
  { 98, 17, 32, 20, 2, -28 },
  { 166, 16, 25, 20, 2, -25 },
  { 216, 18, 25, 20, 1, -25 },
  { 273, 4, 9, 20, 9, -26 },
  { 278, 12, 35, 20, 5, -27 },
  { 331, 11, 35, 20, 3, -27 },
  { 380, 16, 17, 20, 3, -24 },
  { 414, 16, 18, 20, 2, -20 },
  { 450, 7, 10, 20, 3, -4 },
  { 459, 14, 3, 20, 4, -12 },
  { 465, 6, 5, 20, 6, -5 },
  { 469, 18, 26, 20, 1, -24 },
  { 528, 17, 25, 20, 2, -25 },
  { 582, 11, 24, 20, 4, -24 },
  { 615, 18, 25, 20, 0, -25 },
  { 672, 18, 25, 20, 1, -25 },
  { 729, 18, 24, 20, 0, -24 },
  { 783, 18, 24, 20, 1, -24 },
  { 837, 15, 24, 20, 2, -24 },
  { 882, 18, 24, 20, 2, -24 },
  { 936, 18, 25, 20, 1, -25 },
  { 993, 15, 25, 20, 3, -25 },
  { 1040, 8, 19, 20, 6, -19 },
  { 1059, 10, 25, 20, 5, -19 },
  { 1091, 16, 15, 20, 2, -18 },
  { 1121, 17, 11, 20, 2, -16 },
  { 1145, 16, 16, 20, 1, -18 },
  { 1177, 15, 25, 20, 4, -25 },
  { 1224, 19, 24, 20, 1, -24 },
  { 1281, 19, 24, 20, -1, -24 },
  { 1338, 20, 24, 20, 0, -24 },
  { 1398, 19, 25, 20, 1, -25 },
  { 1458, 19, 24, 20, 0, -24 },
  { 1515, 19, 24, 20, 1, -24 },
  { 1572, 20, 24, 20, 1, -24 },
  { 1632, 18, 25, 20, 1, -25 },
  { 1689, 20, 24, 20, 0, -24 },
  { 1749, 18, 24, 20, 1, -24 },
  { 1803, 19, 24, 20, 1, -24 },
  { 1860, 22, 24, 20, 0, -24 },
  { 1926, 16, 24, 20, 1, -24 },
  { 1974, 20, 24, 20, 0, -24 },
  { 2034, 20, 24, 20, 0, -24 },
  { 2094, 18, 25, 20, 1, -25 },
  { 2151, 19, 24, 20, 1, -24 },
  { 2208, 18, 29, 20, 1, -25 },
  { 2274, 19, 24, 20, 1, -24 },
  { 2331, 19, 25, 20, 1, -25 },
  { 2391, 20, 24, 20, 2, -24 },
  { 2451, 18, 24, 20, 2, -24 },
  { 2505, 18, 24, 20, 3, -24 },
  { 2559, 20, 24, 20, 2, -24 },
  { 2619, 23, 24, 20, -1, -24 },
  { 2688, 19, 24, 20, 3, -24 },
  { 2745, 20, 24, 20, 0, -24 },
  { 2805, 12, 33, 20, 4, -28 },
  { 2855, 9, 26, 20, 6, -24 },
  { 2885, 12, 33, 20, 4, -28 },
  { 2935, 13, 13, 20, 4, -24 },
  { 2957, 15, 3, 20, 0, 0 },
  { 2963, 7, 5, 20, 9, -25 },
  { 2968, 16, 18, 20, 1, -18 },
  { 3004, 17, 26, 20, 1, -26 },
  { 3060, 16, 18, 20, 2, -18 },
  { 3096, 18, 26, 20, 2, -26 },
  { 3155, 17, 18, 20, 1, -18 },
  { 3194, 18, 26, 20, 3, -26 },
  { 3253, 19, 25, 20, 0, -18 },
  { 3313, 17, 26, 20, 1, -26 },
  { 3369, 15, 25, 20, 2, -25 },
  { 3416, 15, 32, 20, 1, -25 },
  { 3476, 19, 26, 20, 1, -26 },
  { 3538, 16, 26, 20, 1, -26 },
  { 3590, 19, 18, 20, 0, -18 },
  { 3633, 17, 18, 20, 1, -18 },
  { 3672, 17, 18, 20, 1, -18 },
  { 3711, 19, 25, 20, -1, -18 },
  { 3771, 17, 25, 20, 2, -18 },
  { 3825, 16, 18, 20, 3, -18 },
  { 3861, 17, 18, 20, 1, -18 },
  { 3900, 15, 22, 20, 3, -22 },
  { 3942, 17, 18, 20, 2, -18 },
  { 3981, 17, 18, 20, 3, -18 },
  { 4020, 19, 18, 20, 2, -18 },
  { 4063, 20, 18, 20, 0, -18 },
  { 4108, 21, 25, 20, 0, -18 },
  { 4174, 19, 18, 20, 0, -18 },
  { 4217, 13, 33, 20, 5, -27 },
  { 4271, 8, 31, 20, 6, -24 },
  { 4302, 13, 33, 20, 3, -27 },
  { 4356, 19, 8, 20, 0, -14 },
};

const GFXfont RobotoMono_SemiBoldItalic34pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic34pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic34pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC34PT7B_H_
