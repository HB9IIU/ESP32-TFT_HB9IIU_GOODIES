#ifndef _ROBOTOMONO_SEMIBOLDITALIC55PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x0F,
  0xE0, 0x7F, 0x01, 0xF0, 0x00, 0x1F, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C,
  0xF8, 0x3F, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C,
  0x0F, 0x1F, 0x03, 0xC7, 0xC1, 0xF1, 0xE0, 0x7C, 0x78, 0x1F, 0x3E, 0x07,
  0x80, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0x08, 0x1E, 0x07, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x78, 0x1F,
  0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xC1, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0xFF,
  0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07,
  0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x8F, 0xE0, 0x01, 0xFC,
  0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0,
  0x03, 0xF8, 0xFF, 0x00, 0x7F, 0x87, 0xFC, 0x1F, 0xF0, 0x7F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0xF8, 0x7C, 0x04, 0x1F, 0x07, 0x81, 0xC3,
  0xC0, 0xF0, 0x3C, 0x78, 0x1E, 0x0F, 0x1F, 0x03, 0xC3, 0xE3, 0xE0, 0xF8,
  0xF8, 0x7C, 0x1F, 0x1E, 0x07, 0xC7, 0xE7, 0xC0, 0xFF, 0xF9, 0xF0, 0x1F,
  0xFE, 0x3C, 0x01, 0xFF, 0x8F, 0x00, 0x1F, 0xE3, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0xC0, 0x00, 0x78, 0xFF,
  0x00, 0x1E, 0x3F, 0xF0, 0x07, 0xCF, 0xFF, 0x01, 0xF3, 0xFF, 0xE0, 0x3C,
  0x7C, 0x3E, 0x0F, 0x9F, 0x07, 0xC3, 0xE3, 0xE0, 0xF8, 0x78, 0x7C, 0x1F,
  0x1F, 0x0F, 0x83, 0xE1, 0xC1, 0xF0, 0x78, 0x10, 0x3E, 0x0F, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x7F, 0x07,
  0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x07, 0xE1, 0xFC, 0x00,
  0x1F, 0x9F, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xFE, 0x03, 0xF0, 0xFF, 0xFC, 0x0F, 0xC7, 0xFF, 0xF0,
  0x3F, 0x3F, 0xCF, 0xE0, 0xFC, 0xFE, 0x3F, 0xC7, 0xE7, 0xF0, 0x7F, 0x1F,
  0x9F, 0xC0, 0xFE, 0xFE, 0xFE, 0x03, 0xFB, 0xF3, 0xF8, 0x07, 0xFF, 0xCF,
  0xE0, 0x1F, 0xFE, 0x3F, 0x80, 0x3F, 0xF0, 0xFE, 0x00, 0xFF, 0xC3, 0xFC,
  0x03, 0xFE, 0x07, 0xF8, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0xFE, 0x01, 0xFF, 0xC1,
  0xFC, 0x00, 0x30, 0x00, 0x00, 0x3E, 0x7C, 0xFB, 0xF7, 0xEF, 0x9F, 0x3E,
  0x7D, 0xF3, 0xE7, 0xCF, 0x9F, 0x00, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x80, 0x7C, 0x02, 0x78, 0x1F, 0x03, 0x9F, 0x87, 0x87, 0xEF, 0xF9, 0xE7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x3E, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0xC7, 0xC0, 0x07, 0xE0, 0xF8,
  0x03, 0xF0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x3E, 0x01, 0xF0, 0x07, 0x00,
  0x78, 0x00, 0x80, 0x08, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0xFE, 0x1F, 0x87,
  0xF0, 0xFC, 0x3F, 0x01, 0xC0, 0x10, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0,
  0x1E, 0x0F, 0xE7, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x3F, 0x02,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x3F, 0x80,
  0xFE, 0x0F, 0xE0, 0x0F, 0xC1, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F,
  0xE0, 0x07, 0xF1, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x07,
  0xF9, 0xFC, 0x03, 0xFF, 0x3F, 0x80, 0xFF, 0xE7, 0xF0, 0x3F, 0xF8, 0xFC,
  0x1F, 0xFF, 0x3F, 0x87, 0xFF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0xFE, 0x3F,
  0x9F, 0xFF, 0x07, 0xF3, 0xFF, 0xC0, 0xFE, 0x7F, 0xE0, 0x1F, 0x8F, 0xF8,
  0x07, 0xF3, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF9,
  0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0xC3, 0xF0, 0x03, 0xF0, 0x7F, 0x00,
  0xFE, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x0F, 0xF0, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xF0, 0x03, 0xFC,
  0x07, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF,
  0xFF, 0xBF, 0x8F, 0xCF, 0x03, 0xF2, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF,
  0x00, 0xFF, 0x07, 0xF0, 0x03, 0xF8, 0x7F, 0x80, 0x1F, 0xC3, 0xF8, 0x00,
  0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0,
  0xFF, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xF8,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x83, 0xFC, 0x03,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0x9F,
  0x80, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x01,
  0xFC, 0x3F, 0x80, 0x1F, 0x83, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x03,
  0xF0, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7F, 0x03,
  0xF0, 0x07, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF1, 0xC0, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0xFF, 0x00, 0x18, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0xFE,
  0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF1, 0xFC, 0x01, 0xF9, 0xFF, 0xC0, 0xFE, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF9, 0xFF,
  0x81, 0xFE, 0x7F, 0xC0, 0x3F, 0xDF, 0xE0, 0x07, 0xF7, 0xF0, 0x01, 0xFD,
  0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xF7, 0xE0, 0x01,
  0xFD, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0x9F, 0xC0, 0x0F, 0xE7, 0xF0,
  0x03, 0xF9, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0xFF, 0x0F, 0xF0, 0x7F, 0x81,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFC, 0x1F,
  0xE0, 0x7F, 0x80, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x0F,
  0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00,
  0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF8, 0x3F, 0xC0,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFE, 0x07, 0xF0,
  0x3F, 0x80, 0x3F, 0x87, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0x87, 0xE0,
  0x01, 0xF8, 0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x3F,
  0x8F, 0xE0, 0x03, 0xF8, 0xFF, 0x00, 0x7F, 0x87, 0xF0, 0x0F, 0xF0, 0x7F,
  0xC3, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xC3, 0xFC, 0x7F, 0x80,
  0xFE, 0x3F, 0x80, 0x3F, 0x3F, 0xC0, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0,
  0x07, 0xF7, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xEF,
  0xE0, 0x0F, 0xF7, 0xF8, 0x0F, 0xF3, 0xFE, 0x1F, 0xF8, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xBF, 0x00, 0xFF, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xC0, 0x3F, 0x83, 0xFE, 0x1F, 0xF0,
  0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFE, 0x07, 0xF0, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x0F, 0xE0, 0x7F, 0x87, 0xFC, 0x3F,
  0xE1, 0xFF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFC, 0x01, 0x00, 0x00, 0x1C, 0x00,
  0x3F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE,
  0x01, 0xFE, 0x00, 0x7E, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x38, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x04,
  0x00, 0x1F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFE, 0x7F, 0xC1, 0xFE, 0x7F, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0x1E,
  0x01, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x78, 0x3C, 0x0F, 0x07, 0xFC, 0x38,
  0x3E, 0x1F, 0xFC, 0x70, 0x78, 0x7F, 0xF8, 0xF1, 0xF1, 0xF8, 0xF1, 0xE3,
  0xC3, 0xE1, 0xC3, 0xCF, 0x8F, 0x87, 0x87, 0x9E, 0x1E, 0x0F, 0x0F, 0x3C,
  0x7C, 0x1E, 0x1C, 0xF8, 0xF0, 0x3C, 0x39, 0xE1, 0xE0, 0xF0, 0xF3, 0xC7,
  0xC1, 0xE1, 0xE7, 0x8F, 0x03, 0xC3, 0xCF, 0x1E, 0x07, 0x87, 0x3E, 0x3C,
  0x1E, 0x0E, 0x78, 0x78, 0x3C, 0x3C, 0xF0, 0xF0, 0x78, 0x71, 0xE1, 0xE1,
  0xF1, 0xE3, 0xC3, 0xE7, 0xE7, 0xC7, 0xC7, 0xFF, 0xFF, 0x0F, 0x87, 0xFF,
  0xFC, 0x0F, 0x0F, 0xE7, 0xF0, 0x1E, 0x03, 0x03, 0x80, 0x3E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x01, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x03, 0xF9, 0xF8, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x1F, 0xC3, 0xF0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x07,
  0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F,
  0x01, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x01,
  0xFC, 0x3F, 0x80, 0x03, 0xF8, 0xFF, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F,
  0xE7, 0xF8, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F,
  0x80, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x81, 0xFC, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFE,
  0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x07, 0xE0,
  0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x07,
  0xF0, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFC, 0x07, 0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80,
  0x03, 0xF0, 0x7F, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x03,
  0xFC, 0x3F, 0x80, 0x0F, 0xF8, 0x7F, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0xFF, 0x01,
  0xFE, 0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE1, 0xFC,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xFC, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x3F, 0x07, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x3F,
  0x81, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0x01, 0xFE, 0x01, 0xFC, 0x03,
  0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x07, 0xF0,
  0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x01, 0xFC, 0x7F,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC0,
  0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x00,
  0xFE, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFF,
  0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x7F, 0x07,
  0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x3F, 0xE0, 0x7F, 0x01, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0,
  0xFF, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC7, 0xF8,
  0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF1, 0xFC, 0x00, 0x1F, 0x9F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x1F, 0xFF, 0x3F, 0x81, 0xFF, 0xF9, 0xFC, 0x0F, 0xFF, 0xDF, 0xC0, 0x7F,
  0xFE, 0xFE, 0x03, 0xFF, 0xE7, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF9,
  0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0x3F, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x80, 0x1F, 0xC1, 0xFC, 0x01,
  0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x01, 0xFC, 0x0F,
  0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x1F, 0x81, 0xFC, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0,
  0x01, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00,
  0x0F, 0xC0, 0xFE, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0xFE, 0x07, 0xE0, 0x01, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF0,
  0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x81,
  0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x1F,
  0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xE0,
  0x03, 0xF8, 0x1F, 0x80, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x20, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0xFF,
  0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0x00, 0x0F, 0xF8,
  0x0F, 0xE0, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x3F,
  0xE0, 0x07, 0xE0, 0x0F, 0xF8, 0x01, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0x80,
  0xFF, 0x80, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x1F,
  0xC1, 0xFE, 0x00, 0x03, 0xF0, 0x7F, 0x80, 0x00, 0xFE, 0x1F, 0xF0, 0x00,
  0x1F, 0xC7, 0xFC, 0x00, 0x03, 0xF9, 0xFF, 0x00, 0x00, 0x7F, 0x7F, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xDF, 0xE0, 0x00,
  0x3F, 0xF1, 0xFC, 0x00, 0x07, 0xFC, 0x3F, 0x80, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x03,
  0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07,
  0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x1F,
  0xFE, 0x07, 0xFF, 0x1F, 0xFC, 0x07, 0xFF, 0x1F, 0xFC, 0x0F, 0xDF, 0x3E,
  0xFC, 0x0F, 0xDF, 0x3E, 0xFC, 0x0F, 0xDF, 0x7C, 0xFC, 0x0F, 0xDF, 0x7D,
  0xFC, 0x0F, 0xDF, 0xF9, 0xF8, 0x0F, 0xCF, 0xF9, 0xF8, 0x1F, 0xCF, 0xF9,
  0xF8, 0x1F, 0x8F, 0xF1, 0xF8, 0x1F, 0x8F, 0xF3, 0xF8, 0x1F, 0x8F, 0xE3,
  0xF8, 0x1F, 0x8F, 0xE3, 0xF0, 0x3F, 0x8F, 0xC3, 0xF0, 0x3F, 0x8F, 0xC3,
  0xF0, 0x3F, 0x0F, 0x83, 0xF0, 0x3F, 0x07, 0x87, 0xF0, 0x3F, 0x07, 0x07,
  0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xF0, 0x03,
  0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x7F, 0xC0, 0x0F, 0xE0, 0xFF, 0xC0, 0x1F,
  0x81, 0xFF, 0x80, 0x7F, 0x03, 0xFF, 0x00, 0xFE, 0x07, 0xFE, 0x01, 0xFC,
  0x0F, 0xFE, 0x03, 0xF8, 0x3F, 0xFC, 0x07, 0xF0, 0x7F, 0xF8, 0x0F, 0xC0,
  0xFF, 0xF0, 0x3F, 0x81, 0xFF, 0xF0, 0x7F, 0x03, 0xFF, 0xE0, 0xFE, 0x07,
  0xE7, 0xC1, 0xFC, 0x1F, 0xCF, 0x83, 0xF8, 0x3F, 0x9F, 0x8F, 0xE0, 0x7F,
  0x1F, 0x1F, 0xC0, 0xFE, 0x3E, 0x3F, 0x81, 0xFC, 0x7C, 0x7F, 0x03, 0xF0,
  0xFC, 0xFE, 0x0F, 0xE0, 0xF9, 0xF8, 0x1F, 0xC1, 0xF7, 0xF0, 0x3F, 0x83,
  0xFF, 0xE0, 0x7F, 0x07, 0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0x81, 0xF8, 0x0F,
  0xFF, 0x07, 0xF0, 0x1F, 0xFC, 0x0F, 0xE0, 0x3F, 0xF8, 0x1F, 0xC0, 0x3F,
  0xF0, 0x3F, 0x80, 0x7F, 0xE0, 0x7F, 0x00, 0xFF, 0xC1, 0xFC, 0x01, 0xFF,
  0x83, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xF8,
  0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0xFF,
  0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC,
  0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x7F, 0x3F, 0x80, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFE,
  0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0x3F, 0x80, 0x03, 0xF9, 0xFC,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE1, 0xF8, 0x00,
  0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x83, 0xFC, 0x07, 0xF8,
  0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x80, 0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0x03, 0xF0, 0x00,
  0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07,
  0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0,
  0x3F, 0x80, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01,
  0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x3F, 0xBF, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0xFE, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xF9,
  0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x7F, 0x83, 0xFC, 0x07,
  0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x10, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x80, 0xFC, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFE,
  0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07,
  0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x1F, 0x80, 0x1F, 0xF0, 0x7F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x07,
  0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F,
  0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F,
  0x81, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFE,
  0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0x81,
  0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFC,
  0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF8, 0xFF, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xE0, 0xFE,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF8, 0x7F, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x07,
  0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC,
  0x3F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0xFE, 0x0F,
  0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F,
  0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0,
  0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F,
  0x80, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x1F, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xFC,
  0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFE, 0x1F,
  0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0xFE, 0x07, 0xF0,
  0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x00, 0xFC, 0x03,
  0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0x81, 0xFC,
  0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00,
  0x1F, 0x87, 0xF0, 0x00, 0x7E, 0x1F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x07,
  0xE3, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFD,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7E, 0x07, 0xC0, 0xFF, 0xFC, 0x0F, 0x81, 0xFF, 0xF8, 0x3F, 0x03, 0xF7,
  0xF0, 0x7E, 0x07, 0xEF, 0xE0, 0xFC, 0x1F, 0xDF, 0xC3, 0xF8, 0x3F, 0x3F,
  0x07, 0xF0, 0x7E, 0x7E, 0x0F, 0xE0, 0xFC, 0xFC, 0x3F, 0xC3, 0xF1, 0xF8,
  0x7F, 0x87, 0xE3, 0xF0, 0xFF, 0x0F, 0xC7, 0xE1, 0xFE, 0x3F, 0x8F, 0xC7,
  0xFC, 0x7E, 0x1F, 0x8F, 0xF8, 0xFC, 0x3F, 0x1F, 0xF1, 0xF8, 0x7E, 0x7F,
  0xE7, 0xE0, 0xFC, 0xFF, 0xCF, 0xC1, 0xF9, 0xFF, 0x9F, 0x83, 0xF7, 0xDF,
  0x3F, 0x07, 0xEF, 0xBE, 0xFC, 0x0F, 0xDF, 0x7D, 0xF8, 0x1F, 0xFC, 0xFB,
  0xF0, 0x3F, 0xF9, 0xFF, 0xC0, 0x7F, 0xF3, 0xFF, 0x80, 0xFF, 0xC7, 0xFF,
  0x01, 0xFF, 0x8F, 0xFE, 0x03, 0xFF, 0x1F, 0xF8, 0x07, 0xFC, 0x3F, 0xF0,
  0x0F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xC1, 0xFF, 0x00,
  0x7F, 0x83, 0xFE, 0x00, 0xFF, 0x07, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x03,
  0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x3F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x1F,
  0x80, 0xFE, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0,
  0x00, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xC1,
  0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00,
  0x1F, 0xCF, 0xF0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0xFC, 0x00, 0x00, 0x1F, 0xE7, 0xF0,
  0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0xFF,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0xFE, 0x00,
  0x07, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F,
  0xE0, 0x00, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x03,
  0xFE, 0xFE, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x3F,
  0x87, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xF0,
  0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00,
  0x7F, 0x03, 0xFC, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0xFC, 0x1F, 0xE0, 0x01,
  0xFC, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF3, 0xFC, 0x00, 0x07,
  0xE7, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xF3, 0xE0,
  0x1F, 0x9F, 0x00, 0xF8, 0xF8, 0x0F, 0xC7, 0xC0, 0x7C, 0x3F, 0x07, 0xE0,
  0xF8, 0x7E, 0x07, 0xC3, 0xF0, 0x3E, 0x3F, 0x01, 0xF1, 0xF0, 0x0F, 0xDF,
  0x80, 0x3E, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0,
  0xFE, 0x1F, 0x87, 0xF0, 0xFC, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFE, 0x03, 0xFC, 0x7F, 0x00, 0x7F,
  0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x9F, 0xF0, 0x0F, 0xE7, 0xF0, 0x03, 0xFB,
  0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07,
  0xF3, 0xF8, 0x07, 0xFC, 0xFF, 0x03, 0xFF, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFE, 0x7F, 0x03, 0xFF, 0x1F, 0xC0,
  0x0C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x07, 0x00, 0x07, 0xF3, 0xFE,
  0x00, 0x7E, 0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xC3, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFE, 0x00,
  0xFF, 0x0F, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1,
  0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0x80,
  0x07, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x07, 0xE3, 0xF8, 0x00, 0xFE,
  0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0xC7, 0xF8,
  0x03, 0xFC, 0x7F, 0xC0, 0x7F, 0x87, 0xFE, 0x0F, 0xF8, 0x7F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xE0, 0x7E, 0xFF, 0xFC, 0x0F, 0xE7, 0xFF, 0x80, 0xFE,
  0x3F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC1, 0xFF, 0x07, 0xF8, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0x8F,
  0xE0, 0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x3F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xE1, 0xFC, 0x03, 0xF8,
  0x7F, 0x83, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x38, 0x1F, 0xC0, 0x0F, 0xF8, 0xFE, 0x01, 0xFF,
  0xF7, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xC0, 0xFF, 0x87, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0x87,
  0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7E, 0x1F, 0xC0,
  0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F,
  0xE1, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x83,
  0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0,
  0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x0F, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xDF, 0x80,
  0x07, 0xF8, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x7F, 0x80, 0xFE, 0x1F,
  0xE0, 0x0F, 0xE7, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x1F, 0x9F, 0xC0, 0x03,
  0xF7, 0xF0, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x03, 0x01, 0xFE, 0x00, 0xF0, 0x3F, 0xE0, 0x7F, 0x03, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF, 0xC7,
  0xF0, 0x0F, 0xFF, 0x9F, 0x80, 0x7F, 0xFF, 0x7E, 0x03, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xC1, 0xFF, 0x83, 0xFC, 0x03, 0xFC, 0x0F,
  0xE0, 0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF0,
  0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0x83, 0xF8, 0x00,
  0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x3F,
  0x83, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x80, 0x1F, 0xC0,
  0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xBF, 0x80, 0x07, 0xFC, 0xFE, 0x00, 0x01, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x10, 0x00, 0x7F, 0x00, 0xC0, 0x03, 0xFC,
  0x03, 0x80, 0x1F, 0xE0, 0x1F, 0x81, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x03,
  0x00, 0x07, 0xF1, 0xFF, 0x00, 0x7E, 0x7F, 0xF8, 0x07, 0xEF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0x0F, 0xF0,
  0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F,
  0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xFC,
  0x00, 0x7F, 0x1F, 0x80, 0x07, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F,
  0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3, 0xF0, 0x00, 0xFE, 0x3F,
  0x00, 0x0F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01,
  0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0x8F,
  0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x3F, 0xE0, 0xFE, 0x01, 0xFF, 0x01, 0xFC, 0x07, 0xFC,
  0x03, 0xF0, 0x1F, 0xF0, 0x0F, 0xE0, 0x7F, 0xC0, 0x1F, 0xC1, 0xFF, 0x00,
  0x3F, 0x87, 0xFC, 0x00, 0x7F, 0x1F, 0xF0, 0x00, 0xFC, 0x7F, 0xC0, 0x01,
  0xF9, 0xFF, 0x00, 0x07, 0xF7, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFE, 0xFE, 0x00, 0x0F, 0xF1,
  0xFE, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0xFE, 0x03,
  0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07,
  0xF0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F,
  0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x0F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x80, 0x60, 0x07, 0xE7, 0xF1, 0xFC, 0x07, 0xEF,
  0xF3, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFE, 0x0F, 0xF3, 0xFC, 0x7F, 0x0F, 0xE1, 0xF8, 0x7F, 0x0F, 0xC1,
  0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF8, 0x7E, 0x1F, 0xC3,
  0xF0, 0x7E, 0x1F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0x83,
  0xF0, 0xFE, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x87,
  0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x07,
  0xE1, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7F, 0x0F,
  0xC1, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F,
  0xC3, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0xFE, 0x1F,
  0x83, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x7E, 0x1F, 0xF0, 0x07, 0xE7, 0xFF,
  0x80, 0x7E, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF0, 0xFC, 0x00,
  0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1,
  0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFE, 0x3F, 0x80,
  0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFE,
  0x3F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0,
  0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x1F,
  0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0x00,
  0x03, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0xFF,
  0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x3F,
  0xBF, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xDF, 0x80,
  0x03, 0xFB, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xE7, 0xE0, 0x01, 0xFC, 0xFE, 0x00,
  0x7F, 0x1F, 0xC0, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0x3F, 0xC1, 0xFF, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x07, 0xE3, 0xFE, 0x00, 0x1F, 0xBF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0x80, 0xFF,
  0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07,
  0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xF8,
  0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F,
  0xE0, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xF8,
  0x07, 0xF8, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0x9F, 0xFE, 0x00, 0xFE, 0x3F, 0xE0,
  0x03, 0xF8, 0x0C, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xF0,
  0xFC, 0x0F, 0xFF, 0x9F, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x87, 0xFC, 0x1F, 0xF1, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x1F,
  0xCF, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xCF, 0xE0,
  0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xFC,
  0xFE, 0x00, 0x3F, 0x9F, 0x80, 0x07, 0xE3, 0xF0, 0x01, 0xFC, 0x7E, 0x00,
  0x3F, 0x8F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0xC7,
  0xF8, 0x0F, 0xF0, 0x7F, 0x87, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xEF, 0xC0, 0x0F, 0xF1, 0xF8, 0x00,
  0x30, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x01, 0xF8, 0x3F, 0xF0, 0x7E, 0x3F, 0xFC, 0x3F,
  0x9F, 0xFE, 0x0F, 0xEF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFC, 0x0C, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83,
  0xFC, 0x07, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x00,
  0xFC, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xF9, 0xFC, 0x00, 0x3F, 0x3F, 0x80, 0x07, 0xE3, 0xF8, 0x01, 0xFC,
  0x7F, 0x80, 0x7F, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xE0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0,
  0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xC0, 0x07, 0xF1,
  0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0xE1, 0xF8, 0x00, 0xFE, 0x1F, 0x80,
  0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFC,
  0x3F, 0x80, 0x1F, 0xC3, 0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0xC7, 0xF0,
  0x01, 0xFC, 0x7F, 0x00, 0x1F, 0x87, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x3F,
  0x87, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE,
  0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x0F,
  0xF0, 0x7F, 0x01, 0xFF, 0x07, 0xF8, 0x7F, 0xF0, 0x7F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x7E, 0x01, 0xFF, 0xC7, 0xE0, 0x0F, 0xF8,
  0x7E, 0x00, 0x0C, 0x08, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFE,
  0x7E, 0x00, 0x0F, 0xE7, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0,
  0x03, 0xF8, 0x3F, 0x00, 0x3F, 0x83, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x7F,
  0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xF8, 0x1F, 0xC0, 0x1F,
  0x81, 0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x1F, 0x83, 0xF0, 0x00, 0xF8, 0x3F,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0xFC, 0xFC, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x7D, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x07, 0x80, 0xFF, 0xF0, 0x3E, 0x07, 0xFF, 0xC0, 0xF8, 0x1F, 0xBF, 0x07,
  0xE0, 0x7E, 0xFC, 0x1F, 0x83, 0xFB, 0xF0, 0x7E, 0x0F, 0xCF, 0xC3, 0xF8,
  0x3F, 0x3F, 0x0F, 0xE0, 0xF8, 0xFC, 0x3F, 0x87, 0xE3, 0xF1, 0xFE, 0x1F,
  0x8F, 0xC7, 0xF8, 0x7C, 0x3F, 0x1F, 0xE3, 0xF0, 0xFC, 0xF7, 0xCF, 0xC3,
  0xF3, 0xDF, 0x3E, 0x0F, 0xDF, 0x7D, 0xF8, 0x3F, 0x78, 0xF7, 0xE0, 0xFD,
  0xE3, 0xDF, 0x03, 0xEF, 0x8F, 0xFC, 0x0F, 0xBC, 0x3F, 0xF0, 0x3E, 0xF0,
  0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F,
  0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xF8, 0x03, 0xFC, 0x0F, 0xE0,
  0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x81, 0xFC, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x7F, 0x80, 0x07, 0xF0, 0x7F,
  0x80, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x1F,
  0xE0, 0x7F, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x03, 0xF8, 0x0F, 0xF0, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07,
  0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8,
  0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0xFF, 0x00, 0x07,
  0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x0F, 0xC3, 0xF8, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0xFF,
  0xE0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0,
  0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F,
  0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x81, 0xFF,
  0xF0, 0x03, 0xCF, 0xFF, 0xE0, 0x1F, 0x3F, 0xFF, 0xC0, 0x7D, 0xFF, 0xFF,
  0xC7, 0xF7, 0xE0, 0xFF, 0xFF, 0x9F, 0x01, 0xFF, 0xFE, 0xF8, 0x03, 0xFF,
  0xF3, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xC0,
};

const GFXglyph RobotoMono_SemiBoldItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 13, 39, 32, 10, -39 },
  { 65, 18, 14, 32, 9, -41 },
  { 97, 32, 39, 32, 0, -39 },
  { 253, 28, 51, 32, 3, -45 },
  { 432, 27, 41, 32, 3, -40 },
  { 571, 30, 41, 32, 1, -40 },
  { 725, 7, 14, 32, 14, -41 },
  { 738, 18, 56, 32, 9, -44 },
  { 864, 19, 56, 32, 4, -44 },
  { 997, 26, 27, 32, 5, -39 },
  { 1085, 28, 28, 32, 2, -32 },
  { 1183, 11, 17, 32, 5, -6 },
  { 1207, 22, 6, 32, 7, -20 },
  { 1224, 10, 10, 32, 9, -9 },
  { 1237, 29, 42, 32, 2, -39 },
  { 1390, 27, 41, 32, 3, -40 },
  { 1529, 18, 39, 32, 7, -39 },
  { 1617, 29, 40, 32, 0, -40 },
  { 1762, 29, 41, 32, 1, -40 },
  { 1911, 28, 39, 32, 1, -39 },
  { 2048, 29, 40, 32, 2, -39 },
  { 2193, 26, 40, 32, 2, -39 },
  { 2323, 28, 39, 32, 4, -39 },
  { 2460, 28, 41, 32, 2, -40 },
  { 2604, 25, 40, 32, 4, -40 },
  { 2729, 13, 32, 32, 10, -31 },
  { 2781, 17, 42, 32, 7, -31 },
  { 2871, 25, 26, 32, 4, -30 },
  { 2953, 27, 17, 32, 3, -25 },
  { 3011, 26, 25, 32, 2, -29 },
  { 3093, 24, 40, 32, 7, -40 },
  { 3213, 31, 39, 32, 1, -39 },
  { 3365, 31, 39, 32, -2, -39 },
  { 3517, 31, 39, 32, 1, -39 },
  { 3669, 30, 41, 32, 2, -40 },
  { 3823, 30, 39, 32, 1, -39 },
  { 3970, 32, 39, 32, 1, -39 },
  { 4126, 32, 39, 32, 1, -39 },
  { 4282, 29, 41, 32, 2, -40 },
  { 4431, 31, 39, 32, 1, -39 },
  { 4583, 29, 39, 32, 2, -39 },
  { 4725, 30, 40, 32, 2, -39 },
  { 4875, 35, 39, 32, 1, -39 },
  { 5046, 26, 39, 32, 1, -39 },
  { 5173, 32, 39, 32, 1, -39 },
  { 5329, 31, 39, 32, 1, -39 },
  { 5481, 29, 41, 32, 2, -40 },
  { 5630, 31, 39, 32, 1, -39 },
  { 5782, 29, 47, 32, 2, -40 },
  { 5953, 31, 39, 32, 1, -39 },
  { 6105, 30, 41, 32, 2, -40 },
  { 6259, 31, 39, 32, 4, -39 },
  { 6411, 30, 40, 32, 3, -39 },
  { 6561, 30, 39, 32, 5, -39 },
  { 6708, 31, 39, 32, 4, -39 },
  { 6860, 37, 39, 32, -2, -39 },
  { 7041, 31, 39, 32, 5, -39 },
  { 7193, 33, 39, 32, 0, -39 },
  { 7354, 20, 54, 32, 7, -45 },
  { 7489, 14, 42, 32, 10, -39 },
  { 7563, 19, 54, 32, 7, -45 },
  { 7692, 21, 21, 32, 6, -39 },
  { 7748, 25, 5, 32, 0, 0 },
  { 7764, 10, 8, 32, 15, -40 },
  { 7774, 26, 31, 32, 2, -30 },
  { 7875, 28, 42, 32, 1, -41 },
  { 8022, 26, 31, 32, 3, -30 },
  { 8123, 29, 42, 32, 3, -41 },
  { 8276, 27, 31, 32, 2, -30 },
  { 8381, 29, 43, 32, 5, -43 },
  { 8537, 30, 42, 32, 1, -30 },
  { 8695, 28, 41, 32, 1, -41 },
  { 8839, 24, 40, 32, 3, -40 },
  { 8959, 25, 52, 32, 1, -40 },
  { 9122, 31, 41, 32, 1, -41 },
  { 9281, 25, 41, 32, 2, -41 },
  { 9410, 32, 30, 32, -1, -30 },
  { 9530, 28, 30, 32, 1, -30 },
  { 9635, 27, 31, 32, 2, -30 },
  { 9740, 30, 41, 32, -1, -30 },
  { 9894, 27, 41, 32, 3, -30 },
  { 10033, 26, 30, 32, 5, -30 },
  { 10131, 27, 31, 32, 2, -30 },
  { 10236, 25, 37, 32, 5, -36 },
  { 10352, 28, 30, 32, 3, -29 },
  { 10457, 28, 29, 32, 4, -29 },
  { 10559, 30, 29, 32, 3, -29 },
  { 10668, 33, 29, 32, 0, -29 },
  { 10788, 34, 41, 32, 0, -29 },
  { 10963, 30, 29, 32, 1, -29 },
  { 11072, 21, 53, 32, 8, -43 },
  { 11212, 12, 50, 32, 10, -39 },
  { 11287, 21, 53, 32, 5, -43 },
  { 11427, 30, 12, 32, 0, -22 },
};

const GFXfont RobotoMono_SemiBoldItalic55pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic55pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic55pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC55PT7B_H_
