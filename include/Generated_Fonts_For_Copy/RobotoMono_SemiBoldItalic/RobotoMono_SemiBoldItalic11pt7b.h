#ifndef _ROBOTOMONO_SEMIBOLDITALIC11PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x25, 0x06, 0xB6, 0x80, 0x14, 0x57, 0xCA, 0x2B, 0xF5, 0x3C,
  0x13, 0x93, 0x96, 0x18, 0x73, 0xF2, 0x00, 0xC5, 0x7D, 0x42, 0x3E, 0xA7,
  0x38, 0xA2, 0x8C, 0x77, 0x5D, 0x9F, 0xE0, 0x25, 0x69, 0x24, 0x91, 0x00,
  0x42, 0x23, 0x33, 0x22, 0x24, 0x80, 0x31, 0x3E, 0x45, 0x48, 0x10, 0x4F,
  0xCC, 0x20, 0x58, 0xF8, 0xF0, 0x04, 0x20, 0x84, 0x10, 0x82, 0x10, 0xC0,
  0x72, 0xE3, 0x3F, 0xCE, 0x5C, 0x17, 0xB2, 0x22, 0x26, 0x39, 0xB4, 0xC2,
  0x18, 0x84, 0x3E, 0x39, 0xB0, 0x4E, 0x38, 0x2C, 0x9E, 0x0C, 0x73, 0x8A,
  0x4B, 0xF1, 0x84, 0x3C, 0x86, 0x1E, 0x0E, 0x34, 0x9E, 0x18, 0xC6, 0x1E,
  0x4D, 0x34, 0x9E, 0xF8, 0x44, 0x62, 0x31, 0x18, 0x39, 0xB6, 0x4E, 0x79,
  0x2C, 0x9E, 0x76, 0xE3, 0x3F, 0x88, 0xDC, 0x4C, 0x0D, 0x80, 0x33, 0x00,
  0x06, 0x4C, 0x0B, 0xB1, 0xC1, 0x00, 0xF8, 0x3E, 0x41, 0xC0, 0xCE, 0xC0,
  0x76, 0x42, 0x22, 0x10, 0x0C, 0x18, 0x95, 0xEB, 0xAE, 0xF8, 0x1C, 0x18,
  0x63, 0x8A, 0x69, 0xEC, 0xE3, 0x79, 0x94, 0x5F, 0x7D, 0x1C, 0xFE, 0x39,
  0x94, 0x50, 0x43, 0x14, 0x9E, 0x79, 0xB4, 0x51, 0x45, 0x3D, 0xBC, 0x3E,
  0xC1, 0x83, 0xE7, 0x88, 0x30, 0x7C, 0x3E, 0xC1, 0x82, 0x27, 0x88, 0x10,
  0x60, 0x39, 0x94, 0x50, 0x5F, 0x34, 0xDE, 0x65, 0x94, 0x5F, 0x7D, 0x3C,
  0xB2, 0x3C, 0x41, 0x04, 0x10, 0xC3, 0x3E, 0x04, 0x10, 0x41, 0x0C, 0x3C,
  0x9C, 0x66, 0xD9, 0x63, 0x87, 0x0B, 0x32, 0x66, 0x23, 0x18, 0x84, 0x21,
  0x1F, 0x66, 0xD9, 0xB2, 0xA5, 0x4B, 0xB3, 0x44, 0x65, 0x96, 0x55, 0x5D,
  0x7D, 0xB2, 0x39, 0xB4, 0x51, 0x47, 0x34, 0x9E, 0x39, 0x96, 0x51, 0x79,
  0x04, 0x30, 0x39, 0xB4, 0x51, 0x47, 0x34, 0x9E, 0x0C, 0x79, 0x94, 0x53,
  0x79, 0x6C, 0xB3, 0x39, 0x94, 0x1C, 0x18, 0x3C, 0xDE, 0xFC, 0x82, 0x08,
  0x21, 0x86, 0x10, 0xCF, 0x28, 0xA2, 0x9A, 0x69, 0x3C, 0x8F, 0x2D, 0xB4,
  0x51, 0xC6, 0x18, 0xA6, 0xBA, 0xBA, 0xEB, 0xCB, 0x2C, 0x66, 0x58, 0xA1,
  0xC3, 0x0F, 0x12, 0x66, 0xCF, 0x25, 0x94, 0x61, 0x86, 0x10, 0x7E, 0x08,
  0x20, 0xC3, 0x0C, 0x10, 0x7E, 0x32, 0x26, 0x64, 0x44, 0x44, 0xE0, 0x93,
  0x24, 0x93, 0x60, 0x31, 0x13, 0x32, 0x22, 0x26, 0xE0, 0x33, 0x5D, 0xF8,
  0xD0, 0x39, 0x33, 0xD2, 0xC9, 0xE0, 0x21, 0x85, 0x9B, 0x4D, 0x3C, 0xBE,
  0x76, 0xE1, 0x09, 0x78, 0x08, 0x5B, 0xB9, 0xCA, 0x5E, 0x39, 0xB4, 0x5F,
  0x49, 0xE0, 0x08, 0xF2, 0x3E, 0x61, 0x84, 0x10, 0x40, 0x35, 0xB4, 0xD3,
  0x49, 0xE8, 0xBC, 0x21, 0x85, 0x9B, 0x4D, 0x3C, 0xB2, 0x30, 0xF2, 0x22,
  0x6F, 0x08, 0x0E, 0x31, 0x88, 0x42, 0x37, 0x00, 0x21, 0x86, 0xD6, 0x71,
  0xCD, 0xB3, 0x38, 0xC6, 0x21, 0x08, 0xDF, 0x7D, 0x5D, 0x7D, 0xAE, 0xA0,
  0x59, 0xB4, 0xD3, 0xCB, 0x20, 0x39, 0xB4, 0xF3, 0x49, 0xE0, 0x59, 0xB4,
  0xD3, 0xCB, 0xEC, 0x20, 0x6E, 0xE7, 0x29, 0x78, 0x46, 0x5B, 0x51, 0x8C,
  0x40, 0x39, 0x36, 0x06, 0xCD, 0xE0, 0x27, 0xD8, 0x84, 0x21, 0xC0, 0xCC,
  0x67, 0x39, 0x78, 0x8C, 0xF4, 0xE6, 0x30, 0xAE, 0xAE, 0xBC, 0xB2, 0xC0,
  0x66, 0x50, 0xE1, 0x87, 0x99, 0x80, 0x46, 0x89, 0xA1, 0xC3, 0x06, 0x08,
  0x60, 0x7C, 0x31, 0x8C, 0x67, 0xE0, 0x12, 0x66, 0x48, 0xC4, 0x44, 0x40,
  0x55, 0x5A, 0xA0, 0x42, 0x22, 0x21, 0x26, 0x44, 0x80, 0xF6, 0x60,
};

const GFXglyph RobotoMono_SemiBoldItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 8, 6, 2, -8 },
  { 4, 3, 3, 6, 2, -8 },
  { 6, 6, 8, 6, 0, -8 },
  { 12, 5, 10, 6, 1, -9 },
  { 19, 5, 8, 6, 1, -8 },
  { 24, 6, 8, 6, 0, -8 },
  { 30, 1, 3, 6, 3, -8 },
  { 31, 3, 11, 6, 2, -9 },
  { 36, 4, 11, 6, 1, -9 },
  { 42, 5, 6, 6, 1, -8 },
  { 46, 6, 5, 6, 0, -6 },
  { 50, 2, 3, 6, 1, -1 },
  { 51, 5, 1, 6, 1, -4 },
  { 52, 2, 2, 6, 2, -2 },
  { 53, 6, 9, 6, 0, -8 },
  { 60, 5, 8, 6, 1, -8 },
  { 65, 4, 8, 6, 1, -8 },
  { 69, 6, 8, 6, 0, -8 },
  { 75, 6, 8, 6, 0, -8 },
  { 81, 6, 8, 6, 0, -8 },
  { 87, 6, 8, 6, 0, -8 },
  { 93, 6, 8, 6, 0, -8 },
  { 99, 5, 8, 6, 1, -8 },
  { 104, 6, 8, 6, 0, -8 },
  { 110, 5, 8, 6, 1, -8 },
  { 115, 3, 6, 6, 2, -6 },
  { 118, 4, 8, 6, 1, -6 },
  { 122, 5, 5, 6, 1, -6 },
  { 126, 5, 3, 6, 1, -5 },
  { 128, 6, 5, 6, 0, -6 },
  { 132, 5, 8, 6, 1, -8 },
  { 137, 6, 8, 6, 0, -8 },
  { 143, 6, 8, 6, 0, -8 },
  { 149, 6, 8, 6, 0, -8 },
  { 155, 6, 8, 6, 0, -8 },
  { 161, 6, 8, 6, 0, -8 },
  { 167, 7, 8, 6, 0, -8 },
  { 174, 7, 8, 6, 0, -8 },
  { 181, 6, 8, 6, 0, -8 },
  { 187, 6, 8, 6, 0, -8 },
  { 193, 6, 8, 6, 0, -8 },
  { 199, 6, 8, 6, 0, -8 },
  { 205, 7, 8, 6, 0, -8 },
  { 212, 5, 8, 6, 0, -8 },
  { 217, 7, 8, 6, 0, -8 },
  { 224, 6, 8, 6, 0, -8 },
  { 230, 6, 8, 6, 0, -8 },
  { 236, 6, 8, 6, 0, -8 },
  { 242, 6, 9, 6, 0, -8 },
  { 249, 6, 8, 6, 0, -8 },
  { 255, 6, 8, 6, 0, -8 },
  { 261, 6, 8, 6, 1, -8 },
  { 267, 6, 8, 6, 1, -8 },
  { 273, 6, 8, 6, 1, -8 },
  { 279, 6, 8, 6, 1, -8 },
  { 285, 7, 8, 6, 0, -8 },
  { 292, 6, 8, 6, 1, -8 },
  { 298, 7, 8, 6, 0, -8 },
  { 305, 4, 11, 6, 1, -9 },
  { 311, 3, 9, 6, 2, -8 },
  { 315, 4, 11, 6, 1, -9 },
  { 321, 4, 4, 6, 1, -8 },
  { 323, 5, 1, 6, 0, 0 },
  { 324, 2, 2, 6, 3, -8 },
  { 325, 6, 6, 6, 0, -6 },
  { 330, 6, 8, 6, 0, -8 },
  { 336, 5, 6, 6, 1, -6 },
  { 340, 5, 8, 6, 1, -8 },
  { 345, 6, 6, 6, 0, -6 },
  { 350, 6, 9, 6, 1, -9 },
  { 357, 6, 8, 6, 0, -6 },
  { 363, 6, 8, 6, 0, -8 },
  { 369, 4, 8, 6, 1, -8 },
  { 373, 5, 10, 6, 0, -8 },
  { 380, 6, 8, 6, 0, -8 },
  { 386, 5, 8, 6, 0, -8 },
  { 391, 6, 6, 6, 0, -6 },
  { 396, 6, 6, 6, 0, -6 },
  { 401, 6, 6, 6, 0, -6 },
  { 406, 6, 8, 6, 0, -6 },
  { 412, 5, 8, 6, 1, -6 },
  { 417, 5, 6, 6, 1, -6 },
  { 421, 6, 6, 6, 0, -6 },
  { 426, 5, 7, 6, 1, -7 },
  { 431, 5, 6, 6, 1, -6 },
  { 435, 5, 6, 6, 1, -6 },
  { 439, 6, 6, 6, 1, -6 },
  { 444, 7, 6, 6, 0, -6 },
  { 450, 7, 8, 6, 0, -6 },
  { 457, 6, 6, 6, 0, -6 },
  { 462, 4, 11, 6, 2, -9 },
  { 468, 2, 10, 6, 2, -8 },
  { 471, 4, 11, 6, 1, -9 },
  { 477, 6, 2, 6, 0, -4 },
};

const GFXfont RobotoMono_SemiBoldItalic11pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic11pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC11PT7B_H_
