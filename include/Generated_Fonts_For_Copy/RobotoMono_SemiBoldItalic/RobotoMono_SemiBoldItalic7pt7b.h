#ifndef _ROBOTOMONO_SEMIBOLDITALIC7PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x54, 0x80, 0xF0, 0x37, 0x6F, 0xA0, 0x27, 0x56, 0x96, 0x40, 0xDE,
  0x27, 0x30, 0x66, 0x4B, 0xF0, 0xC0, 0x5A, 0xA9, 0x95, 0x5A, 0x5F, 0x20,
  0x2F, 0x44, 0xC0, 0xE0, 0x80, 0x12, 0x24, 0xC0, 0x75, 0xF9, 0x60, 0x75,
  0x80, 0x69, 0x24, 0xE0, 0x71, 0x61, 0xE0, 0x36, 0x6F, 0x20, 0x74, 0x61,
  0xE0, 0x24, 0xE9, 0x60, 0x71, 0x24, 0xC0, 0x75, 0x69, 0xE0, 0xD6, 0xAC,
  0x42, 0x42, 0x80, 0x16, 0xE0, 0x7F, 0x43, 0xE0, 0xE5, 0x48, 0x7B, 0xFF,
  0x60, 0x26, 0x6E, 0x90, 0x75, 0x69, 0xE0, 0x75, 0x89, 0x60, 0x65, 0x99,
  0xE0, 0x74, 0x78, 0xE0, 0x74, 0x78, 0x80, 0x75, 0xB9, 0x60, 0x55, 0xF9,
  0xA0, 0x72, 0x24, 0xE0, 0x11, 0x11, 0xE0, 0x5B, 0x19, 0x49, 0x00, 0x49,
  0x4E, 0x57, 0xB9, 0x90, 0x55, 0xBB, 0xA0, 0x75, 0x99, 0x60, 0x75, 0x78,
  0x80, 0x75, 0x99, 0x61, 0x75, 0x7A, 0xB0, 0x74, 0x69, 0x60, 0xF2, 0x24,
  0x40, 0x55, 0x99, 0x60, 0xB7, 0x68, 0xBB, 0x7E, 0xA0, 0x56, 0x26, 0xB0,
  0xBA, 0xC8, 0x80, 0x72, 0x24, 0xF0, 0x5A, 0xA8, 0xA5, 0x40, 0x55, 0x58,
  0x7C, 0xE0, 0x80, 0x61, 0xEE, 0x46, 0x59, 0xE0, 0x69, 0x86, 0x17, 0x99,
  0x60, 0x69, 0xE6, 0x7E, 0x48, 0x79, 0x96, 0xE0, 0x46, 0x99, 0xA0, 0x2C,
  0x9E, 0x2C, 0x92, 0xA0, 0x45, 0xAE, 0xB0, 0x64, 0x9E, 0x5B, 0xDD, 0x69,
  0x9A, 0x69, 0x96, 0x65, 0x9E, 0x80, 0x79, 0x96, 0x20, 0xF2, 0x40, 0x65,
  0x3E, 0x5E, 0x4C, 0x55, 0x96, 0xB7, 0x40, 0xBB, 0xEA, 0x56, 0x6B, 0x95,
  0x64, 0x48, 0x72, 0x4F, 0x6B, 0x24, 0x80, 0x56, 0xA0, 0x55, 0xA0, 0xDA,
};

const GFXglyph RobotoMono_SemiBoldItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 5, 4, 1, -5 },
  { 3, 2, 2, 4, 1, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 4, 7, 4, 0, -6 },
  { 11, 4, 5, 4, 0, -5 },
  { 14, 4, 5, 4, 0, -5 },
  { 17, 1, 2, 4, 2, -5 },
  { 18, 2, 8, 4, 1, -6 },
  { 20, 2, 8, 4, 1, -6 },
  { 22, 3, 4, 4, 1, -5 },
  { 24, 4, 4, 4, 0, -4 },
  { 26, 1, 2, 4, 1, -1 },
  { 27, 3, 1, 4, 1, -3 },
  { 28, 1, 1, 4, 1, -1 },
  { 29, 4, 5, 4, 0, -5 },
  { 32, 4, 5, 4, 0, -5 },
  { 35, 2, 5, 4, 1, -5 },
  { 37, 4, 5, 4, 0, -5 },
  { 40, 4, 5, 4, 0, -5 },
  { 43, 4, 5, 4, 0, -5 },
  { 46, 4, 5, 4, 0, -5 },
  { 49, 4, 5, 4, 0, -5 },
  { 52, 4, 5, 4, 0, -5 },
  { 55, 4, 5, 4, 0, -5 },
  { 58, 3, 5, 4, 1, -5 },
  { 60, 2, 4, 4, 1, -4 },
  { 61, 2, 5, 4, 1, -4 },
  { 63, 4, 3, 4, 0, -4 },
  { 65, 4, 2, 4, 0, -3 },
  { 66, 4, 3, 4, 0, -4 },
  { 68, 3, 5, 4, 1, -5 },
  { 70, 4, 5, 4, 0, -5 },
  { 73, 4, 5, 4, 0, -5 },
  { 76, 4, 5, 4, 0, -5 },
  { 79, 4, 5, 4, 0, -5 },
  { 82, 4, 5, 4, 0, -5 },
  { 85, 4, 5, 4, 0, -5 },
  { 88, 4, 5, 4, 0, -5 },
  { 91, 4, 5, 4, 0, -5 },
  { 94, 4, 5, 4, 0, -5 },
  { 97, 4, 5, 4, 0, -5 },
  { 100, 4, 5, 4, 0, -5 },
  { 103, 5, 5, 4, 0, -5 },
  { 107, 3, 5, 4, 0, -5 },
  { 109, 4, 5, 4, 0, -5 },
  { 112, 4, 5, 4, 0, -5 },
  { 115, 4, 5, 4, 0, -5 },
  { 118, 4, 5, 4, 0, -5 },
  { 121, 4, 6, 4, 0, -5 },
  { 124, 4, 5, 4, 0, -5 },
  { 127, 4, 5, 4, 0, -5 },
  { 130, 4, 5, 4, 0, -5 },
  { 133, 4, 5, 4, 0, -5 },
  { 136, 3, 5, 4, 1, -5 },
  { 138, 4, 5, 4, 0, -5 },
  { 141, 4, 5, 4, 0, -5 },
  { 144, 4, 5, 4, 1, -5 },
  { 147, 4, 5, 4, 0, -5 },
  { 150, 2, 7, 4, 1, -6 },
  { 152, 2, 5, 4, 1, -5 },
  { 154, 2, 7, 4, 1, -6 },
  { 156, 2, 3, 4, 1, -5 },
  { 157, 3, 1, 4, 0, 0 },
  { 158, 1, 1, 4, 2, -5 },
  { 159, 4, 4, 4, 0, -4 },
  { 161, 4, 5, 4, 0, -5 },
  { 164, 4, 4, 4, 0, -4 },
  { 166, 4, 5, 4, 0, -5 },
  { 169, 4, 4, 4, 0, -4 },
  { 171, 3, 5, 4, 1, -5 },
  { 173, 4, 5, 4, 0, -4 },
  { 176, 4, 5, 4, 0, -5 },
  { 179, 3, 5, 4, 0, -5 },
  { 181, 3, 7, 4, 0, -5 },
  { 184, 4, 5, 4, 0, -5 },
  { 187, 3, 5, 4, 0, -5 },
  { 189, 4, 4, 4, 0, -4 },
  { 191, 4, 4, 4, 0, -4 },
  { 193, 4, 4, 4, 0, -4 },
  { 195, 4, 5, 4, 0, -4 },
  { 198, 4, 5, 4, 0, -4 },
  { 201, 3, 4, 4, 1, -4 },
  { 203, 4, 4, 4, 0, -4 },
  { 205, 3, 5, 4, 1, -5 },
  { 207, 4, 4, 4, 0, -4 },
  { 209, 3, 4, 4, 1, -4 },
  { 211, 4, 4, 4, 0, -4 },
  { 213, 4, 4, 4, 0, -4 },
  { 215, 4, 6, 4, 0, -4 },
  { 218, 4, 4, 4, 0, -4 },
  { 220, 3, 6, 4, 1, -5 },
  { 223, 2, 6, 4, 1, -5 },
  { 225, 2, 6, 4, 1, -5 },
  { 227, 4, 2, 4, 0, -3 },
};

const GFXfont RobotoMono_SemiBoldItalic7pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic7pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic7pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC7PT7B_H_
