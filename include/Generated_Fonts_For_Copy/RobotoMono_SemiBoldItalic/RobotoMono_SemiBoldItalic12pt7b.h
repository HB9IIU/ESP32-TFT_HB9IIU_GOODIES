#ifndef _ROBOTOMONO_SEMIBOLDITALIC12PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x2D, 0xB4, 0x84, 0xC0, 0xD9, 0xA0, 0x1A, 0x28, 0x53, 0xF2, 0x85,
  0x3F, 0x28, 0x50, 0x10, 0xC7, 0xD3, 0x41, 0xC1, 0xA2, 0x9B, 0xC6, 0x00,
  0x42, 0xAA, 0xBC, 0x20, 0xE7, 0xEA, 0x38, 0x18, 0x78, 0xB1, 0xC3, 0x0E,
  0xF7, 0x66, 0x7C, 0xE8, 0x13, 0x64, 0xC8, 0x88, 0x88, 0x84, 0x40, 0x42,
  0x31, 0x11, 0x13, 0x32, 0x6C, 0x80, 0x10, 0x49, 0x5E, 0x73, 0x60, 0x31,
  0x3F, 0xF2, 0x30, 0x6B, 0x00, 0xF8, 0xF0, 0x0C, 0x21, 0x84, 0x30, 0x86,
  0x10, 0xC2, 0x00, 0x31, 0xEC, 0xB3, 0xBB, 0x28, 0xA6, 0xF0, 0x17, 0xD3,
  0x33, 0x22, 0x20, 0x19, 0xF4, 0x41, 0x0C, 0x63, 0x10, 0xFC, 0x18, 0x79,
  0x90, 0x23, 0x81, 0x83, 0x66, 0x78, 0x04, 0x31, 0xCF, 0x2D, 0x2F, 0xC2,
  0x18, 0x7D, 0xF4, 0x3C, 0xF8, 0x20, 0xA6, 0xF0, 0x09, 0xD1, 0xEF, 0xC6,
  0x33, 0xF0, 0xFF, 0xF0, 0x86, 0x10, 0x86, 0x10, 0xC0, 0x18, 0x79, 0x9B,
  0x23, 0x8D, 0xB1, 0x26, 0x78, 0x33, 0xF3, 0x1C, 0xFC, 0x66, 0xE0, 0x6C,
  0x01, 0xB0, 0x6C, 0x00, 0x16, 0x80, 0x08, 0xFD, 0x87, 0x0C, 0xFF, 0xE0,
  0x3E, 0x60, 0x70, 0xDE, 0xC0, 0x31, 0xFC, 0xC2, 0x18, 0x80, 0x08, 0x60,
  0x3C, 0xBD, 0xED, 0x5A, 0xB7, 0x90, 0x38, 0x08, 0x61, 0x8F, 0x2D, 0xB7,
  0xF1, 0x84, 0x38, 0xFD, 0x9B, 0x37, 0xC8, 0x91, 0x66, 0xF8, 0x18, 0x79,
  0x9A, 0x04, 0x18, 0x11, 0x26, 0x78, 0x30, 0xF9, 0x93, 0x34, 0x68, 0x91,
  0x66, 0xF0, 0x3E, 0x7D, 0x83, 0x07, 0xC8, 0x10, 0x20, 0xFC, 0x3E, 0x7D,
  0x83, 0x07, 0xC8, 0x10, 0x20, 0xC0, 0x18, 0x79, 0x9A, 0x04, 0x2B, 0x91,
  0x22, 0x78, 0x22, 0xCD, 0x9B, 0x37, 0xC8, 0x91, 0x66, 0xCC, 0x3E, 0x7C,
  0x60, 0xC1, 0x02, 0x04, 0x1A, 0xF8, 0x02, 0x0C, 0x18, 0x30, 0x40, 0xB1,
  0x26, 0x78, 0x23, 0x66, 0x6C, 0x78, 0x70, 0x78, 0x48, 0xCC, 0xC4, 0x20,
  0x86, 0x18, 0x61, 0x04, 0x10, 0xFC, 0x26, 0xED, 0xFA, 0xF5, 0xEA, 0x91,
  0x62, 0xCC, 0x22, 0xCD, 0xDB, 0xB5, 0x4A, 0x97, 0x66, 0xCC, 0x18, 0x79,
  0x9A, 0x34, 0x78, 0xD1, 0x26, 0x78, 0x38, 0x7D, 0x9B, 0x36, 0xEF, 0x10,
  0x20, 0xC0, 0x18, 0x79, 0x9A, 0x34, 0x68, 0xF1, 0x26, 0x78, 0x18, 0x10,
  0x38, 0xFD, 0x9B, 0x34, 0xCF, 0x12, 0x66, 0xCC, 0x18, 0x7D, 0x9B, 0x03,
  0x81, 0xB1, 0x26, 0x78, 0xFF, 0xF8, 0xC1, 0x82, 0x04, 0x08, 0x30, 0x60,
  0x47, 0x3C, 0xF3, 0x8A, 0x28, 0xA6, 0xF0, 0xC7, 0x9B, 0x36, 0x45, 0x8A,
  0x1C, 0x30, 0x60, 0x97, 0x6A, 0xD5, 0xEF, 0x9B, 0x36, 0x6C, 0x90, 0x63,
  0x26, 0x24, 0x38, 0x18, 0x38, 0x68, 0x4C, 0xCC, 0xC7, 0x99, 0x22, 0xC7,
  0x06, 0x08, 0x30, 0x60, 0x7E, 0xFC, 0x10, 0x41, 0x86, 0x18, 0x20, 0xFC,
  0x39, 0x88, 0x42, 0x31, 0x8C, 0x42, 0x11, 0xC0, 0xD9, 0x24, 0x9B, 0x24,
  0x38, 0xC4, 0x21, 0x18, 0xC6, 0x21, 0x09, 0xC0, 0x11, 0x8C, 0x9C, 0x80,
  0xF8, 0xCC, 0x7D, 0x93, 0xD3, 0xCD, 0xF0, 0x20, 0x86, 0x1F, 0x65, 0x14,
  0x53, 0xF8, 0x7E, 0x61, 0x09, 0xF8, 0x0C, 0x30, 0xDE, 0xCA, 0x29, 0xA6,
  0xF8, 0x7E, 0x7F, 0x08, 0xF8, 0x1C, 0xC2, 0x7E, 0x21, 0x86, 0x18, 0x40,
  0x3E, 0xC9, 0x12, 0x24, 0xCF, 0x82, 0x7C, 0x20, 0x20, 0x86, 0x1F, 0x45,
  0x14, 0x73, 0xCC, 0x10, 0x81, 0xE3, 0x18, 0x84, 0xF8, 0x0C, 0x30, 0x0E,
  0x08, 0x61, 0x86, 0x10, 0x4F, 0x30, 0x20, 0x41, 0x8B, 0x67, 0x8E, 0x1E,
  0x24, 0xCC, 0x70, 0x84, 0x63, 0x18, 0x84, 0xF8, 0x7E, 0xAF, 0x56, 0xAB,
  0x56, 0x80, 0x7D, 0x14, 0x51, 0xCF, 0x30, 0x3D, 0x14, 0x51, 0x4D, 0xE0,
  0x7D, 0x94, 0x51, 0x4F, 0xEC, 0x20, 0x7F, 0x28, 0xA6, 0x9B, 0xE1, 0x04,
  0x7D, 0x84, 0x10, 0xC3, 0x00, 0x7D, 0x97, 0x83, 0xCD, 0xE0, 0x21, 0x3E,
  0xC6, 0x31, 0x8F, 0xCF, 0x28, 0xA2, 0x9B, 0xE0, 0xCF, 0x25, 0x94, 0x61,
  0x80, 0xA6, 0xBD, 0xB6, 0xDA, 0x40, 0x66, 0x78, 0x61, 0xC6, 0x99, 0x80,
  0x66, 0xC8, 0xB1, 0x43, 0x86, 0x08, 0x70, 0x80, 0x7E, 0x18, 0x61, 0x86,
  0x1F, 0x80, 0x32, 0x22, 0x68, 0x44, 0x44, 0x60, 0x25, 0x24, 0x92, 0x52,
  0x00, 0x21, 0x8C, 0x63, 0x0C, 0x84, 0x62, 0x30, 0x67, 0xF8, 0x30,
};

const GFXglyph RobotoMono_SemiBoldItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 9, 7, 2, -9 },
  { 5, 4, 3, 7, 2, -9 },
  { 7, 7, 9, 7, 0, -9 },
  { 15, 6, 11, 7, 1, -10 },
  { 24, 6, 9, 7, 1, -9 },
  { 31, 7, 9, 7, 0, -9 },
  { 39, 2, 3, 7, 3, -9 },
  { 40, 4, 13, 7, 2, -10 },
  { 47, 4, 13, 7, 1, -10 },
  { 54, 6, 6, 7, 1, -9 },
  { 59, 5, 6, 7, 1, -7 },
  { 63, 3, 3, 7, 1, -1 },
  { 65, 5, 1, 7, 1, -4 },
  { 66, 2, 2, 7, 2, -2 },
  { 67, 6, 10, 7, 1, -9 },
  { 75, 6, 9, 7, 1, -9 },
  { 82, 4, 9, 7, 1, -9 },
  { 87, 6, 9, 7, 0, -9 },
  { 94, 7, 9, 7, 0, -9 },
  { 102, 6, 9, 7, 0, -9 },
  { 109, 6, 9, 7, 1, -9 },
  { 116, 5, 9, 7, 1, -9 },
  { 122, 6, 9, 7, 1, -9 },
  { 129, 7, 9, 7, 0, -9 },
  { 137, 5, 9, 7, 1, -9 },
  { 143, 3, 7, 7, 2, -7 },
  { 146, 3, 9, 7, 2, -7 },
  { 150, 5, 6, 7, 1, -7 },
  { 154, 6, 4, 7, 1, -6 },
  { 157, 6, 5, 7, 0, -6 },
  { 161, 6, 9, 7, 1, -9 },
  { 168, 7, 8, 7, 0, -8 },
  { 175, 6, 9, 7, 0, -9 },
  { 182, 7, 9, 7, 0, -9 },
  { 190, 7, 9, 7, 0, -9 },
  { 198, 7, 9, 7, 0, -9 },
  { 206, 7, 9, 7, 0, -9 },
  { 214, 7, 9, 7, 0, -9 },
  { 222, 7, 9, 7, 0, -9 },
  { 230, 7, 9, 7, 0, -9 },
  { 238, 7, 9, 7, 0, -9 },
  { 246, 7, 9, 7, 0, -9 },
  { 254, 8, 9, 7, 0, -9 },
  { 263, 6, 9, 7, 0, -9 },
  { 270, 7, 9, 7, 0, -9 },
  { 278, 7, 9, 7, 0, -9 },
  { 286, 7, 9, 7, 0, -9 },
  { 294, 7, 9, 7, 0, -9 },
  { 302, 7, 11, 7, 0, -9 },
  { 312, 7, 9, 7, 0, -9 },
  { 320, 7, 9, 7, 0, -9 },
  { 328, 7, 9, 7, 1, -9 },
  { 336, 6, 9, 7, 1, -9 },
  { 343, 7, 9, 7, 1, -9 },
  { 351, 7, 9, 7, 1, -9 },
  { 359, 8, 9, 7, 0, -9 },
  { 368, 7, 9, 7, 1, -9 },
  { 376, 7, 9, 7, 0, -9 },
  { 384, 5, 12, 7, 1, -10 },
  { 392, 3, 10, 7, 2, -9 },
  { 396, 5, 12, 7, 1, -10 },
  { 404, 5, 5, 7, 1, -9 },
  { 408, 5, 1, 7, 0, 0 },
  { 409, 3, 2, 7, 3, -9 },
  { 410, 6, 6, 7, 0, -6 },
  { 415, 6, 9, 7, 0, -9 },
  { 422, 5, 6, 7, 1, -6 },
  { 426, 6, 9, 7, 1, -9 },
  { 433, 5, 6, 7, 1, -6 },
  { 437, 6, 9, 7, 1, -9 },
  { 444, 7, 9, 7, 0, -6 },
  { 452, 6, 9, 7, 0, -9 },
  { 459, 5, 9, 7, 1, -9 },
  { 465, 6, 12, 7, 0, -9 },
  { 474, 7, 9, 7, 0, -9 },
  { 482, 5, 9, 7, 1, -9 },
  { 488, 7, 6, 7, 0, -6 },
  { 494, 6, 6, 7, 0, -6 },
  { 499, 6, 6, 7, 0, -6 },
  { 504, 6, 8, 7, 0, -6 },
  { 510, 6, 8, 7, 1, -6 },
  { 516, 6, 6, 7, 1, -6 },
  { 521, 6, 6, 7, 0, -6 },
  { 526, 5, 8, 7, 1, -8 },
  { 531, 6, 6, 7, 1, -6 },
  { 536, 6, 6, 7, 1, -6 },
  { 541, 6, 6, 7, 1, -6 },
  { 546, 7, 6, 7, 0, -6 },
  { 552, 7, 9, 7, 0, -6 },
  { 560, 7, 6, 7, 0, -6 },
  { 566, 4, 11, 7, 2, -9 },
  { 572, 3, 11, 7, 2, -9 },
  { 577, 5, 11, 7, 1, -9 },
  { 584, 7, 3, 7, 0, -5 },
};

const GFXfont RobotoMono_SemiBoldItalic12pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic12pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC12PT7B_H_
