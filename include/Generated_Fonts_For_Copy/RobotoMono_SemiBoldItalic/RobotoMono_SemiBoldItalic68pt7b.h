#ifndef _ROBOTOMONO_SEMIBOLDITALIC68PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07,
  0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x08, 0x00, 0x00, 0x3F, 0x81,
  0xFC, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8,
  0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8,
  0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F,
  0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF0, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0xF8, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xF8, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x3E, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xE0, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0x3F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x01, 0xFF,
  0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F,
  0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x40, 0xFC, 0x0F,
  0xC0, 0x70, 0x7C, 0x07, 0xE0, 0x7E, 0x7E, 0x03, 0xF0, 0x3E, 0x3F, 0x01,
  0xF8, 0x3F, 0x1F, 0x80, 0xF8, 0x3F, 0x0F, 0xC0, 0x7C, 0x1F, 0x07, 0xE0,
  0x7E, 0x1F, 0x03, 0xF0, 0x3F, 0x1F, 0x80, 0xFC, 0x3F, 0x1F, 0x80, 0x7F,
  0xFF, 0x8F, 0x80, 0x3F, 0xFF, 0x8F, 0xC0, 0x0F, 0xFF, 0x8F, 0xC0, 0x03,
  0xFF, 0x87, 0xC0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x18, 0x00, 0x00, 0xF8, 0x7F, 0xC0, 0x00, 0xFC, 0xFF,
  0xF0, 0x00, 0xFC, 0xFF, 0xFC, 0x00, 0xFC, 0xFF, 0xFF, 0x00, 0x7C, 0x7F,
  0xFF, 0x80, 0x7E, 0x7F, 0x0F, 0xE0, 0x7E, 0x3F, 0x03, 0xF0, 0x3E, 0x1F,
  0x81, 0xF8, 0x3F, 0x0F, 0x80, 0xFC, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x07,
  0xE0, 0x3F, 0x1F, 0x03, 0xF0, 0x1F, 0x83, 0x81, 0xF8, 0x1F, 0x80, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x00, 0x7F,
  0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x03, 0xFC,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0xFF, 0x00,
  0x00, 0x7F, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0xE0, 0x00, 0x07, 0xFB,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x3F, 0xC1, 0xFF, 0xFF, 0x00, 0xFE, 0x0F, 0xFF, 0xFE,
  0x03, 0xF8, 0x7F, 0xE7, 0xFC, 0x0F, 0xE1, 0xFF, 0x1F, 0xF0, 0x7F, 0x8F,
  0xF8, 0x3F, 0xE1, 0xFE, 0x3F, 0xE0, 0xFF, 0x8F, 0xF1, 0xFF, 0x01, 0xFF,
  0x3F, 0xC7, 0xFC, 0x07, 0xFD, 0xFE, 0x1F, 0xE0, 0x0F, 0xFF, 0xF8, 0xFF,
  0x80, 0x1F, 0xFF, 0xC3, 0xFE, 0x00, 0x7F, 0xFF, 0x0F, 0xF8, 0x00, 0xFF,
  0xF8, 0x3F, 0xE0, 0x03, 0xFF, 0xC0, 0x7F, 0xC0, 0x07, 0xFE, 0x01, 0xFF,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF7, 0xFC, 0x01, 0xFF, 0xFF, 0x1F, 0xF0, 0x01, 0xFF, 0xF0, 0x3F,
  0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x8F, 0xCF, 0xE7, 0xF3, 0xF9,
  0xF8, 0xFC, 0x7E, 0x7F, 0x3F, 0x9F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF1, 0xF8,
  0xFC, 0x7E, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x38, 0x03, 0xF0, 0x06, 0x3E, 0x03, 0xE0, 0x1E,
  0x7F, 0x83, 0xE0, 0xFF, 0x7F, 0xE3, 0xE3, 0xFF, 0xFF, 0xFB, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0xF8, 0x00,
  0x03, 0xF8, 0xFC, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x0F, 0xF0, 0x7E, 0x00,
  0x1F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0xC0, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x1E, 0x00,
  0x02, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0,
  0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x0F, 0x80,
  0x08, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0x07, 0xF9, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xF8, 0xFE, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF8, 0x07, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x07, 0xF8, 0xFF, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xC0,
  0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0xFF, 0xCF, 0xF8,
  0x00, 0xFF, 0xE7, 0xFC, 0x01, 0xFF, 0xF3, 0xFC, 0x01, 0xFF, 0xF9, 0xFE,
  0x03, 0xFF, 0xF8, 0xFF, 0x03, 0xFF, 0xFC, 0x7F, 0x87, 0xFD, 0xFE, 0x7F,
  0xC7, 0xFD, 0xFF, 0x3F, 0xEF, 0xF8, 0xFF, 0x9F, 0xEF, 0xF8, 0x7F, 0xCF,
  0xFF, 0xF0, 0x3F, 0xC7, 0xFF, 0xF0, 0x1F, 0xE3, 0xFF, 0xE0, 0x0F, 0xF3,
  0xFF, 0xE0, 0x07, 0xF9, 0xFF, 0xC0, 0x07, 0xFC, 0xFF, 0xC0, 0x03, 0xFE,
  0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x7F,
  0x8F, 0xF0, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x3F,
  0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xFC, 0x3F, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x7F, 0xFF, 0x87, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xDF, 0xE3, 0xFE, 0x3F, 0xCF, 0xE0, 0xFF,
  0x9E, 0x01, 0xFF, 0x20, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xF0,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x1F,
  0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0x7F, 0xC0, 0xFF, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x83, 0xFC,
  0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x8F,
  0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF,
  0x87, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xF8, 0x03,
  0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x03,
  0xFD, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0x0F, 0xF1, 0xFF, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xF8,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x07,
  0xFC, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x07,
  0xF0, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x0F, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x78, 0x00, 0x00,
  0x7F, 0xBF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x07, 0xF0, 0x07, 0xFE, 0x00,
  0x04, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F,
  0xE0, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x80,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x03,
  0xFF, 0x87, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0x00,
  0x1F, 0xE3, 0xFF, 0xC0, 0x1F, 0xEF, 0xFF, 0xE0, 0x3F, 0xDF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFC, 0x0F, 0xFE, 0x7F, 0xF0, 0x07, 0xFE, 0x7F, 0xE0, 0x03, 0xFE,
  0x7F, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFE,
  0xFF, 0x80, 0x03, 0xFE, 0x7F, 0x80, 0x03, 0xFE, 0x7F, 0x80, 0x07, 0xFC,
  0x7F, 0xC0, 0x07, 0xFC, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF8,
  0x3F, 0xF8, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x07, 0xFE,
  0x03, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x07,
  0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xC1, 0xFE, 0x00,
  0x1F, 0xF0, 0x7F, 0x80, 0x07, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x0F, 0xF8, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFC, 0x00,
  0x3F, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xE0,
  0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x3F, 0xC3,
  0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFE,
  0x07, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0,
  0x07, 0xF8, 0xFF, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x1F, 0xF7, 0xFC, 0x00,
  0x1F, 0xEF, 0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x7F, 0xBF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xDF, 0xE0, 0x00, 0xFF, 0xBF, 0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x0F, 0xFC,
  0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0xF7, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFD, 0xFE, 0x01,
  0xFF, 0xF7, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xFE,
  0x01, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F,
  0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x20, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFE, 0x07, 0xFE, 0x7F,
  0xE0, 0x0F, 0xFD, 0xFF, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x7F, 0xDF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x00, 0xF8, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0x01, 0xF8, 0x1F, 0xFC, 0x3E, 0x07, 0xC0,
  0xFF, 0xF8, 0xF8, 0x3F, 0x07, 0xFF, 0xE3, 0xE1, 0xF8, 0x3F, 0xFF, 0x8F,
  0x87, 0xC1, 0xFC, 0x3E, 0x3E, 0x1F, 0x0F, 0xE0, 0xF0, 0xF8, 0xFC, 0x3F,
  0x07, 0xC3, 0xE3, 0xE1, 0xF8, 0x1F, 0x0F, 0x9F, 0x87, 0xC0, 0x7C, 0x3E,
  0x7C, 0x3F, 0x01, 0xE0, 0xF9, 0xF0, 0xFC, 0x0F, 0x83, 0xE7, 0xC3, 0xE0,
  0x3E, 0x0F, 0xBF, 0x0F, 0x80, 0xF8, 0x3C, 0xF8, 0x7E, 0x03, 0xC0, 0xF3,
  0xE1, 0xF8, 0x1F, 0x07, 0xCF, 0x87, 0xC0, 0x7C, 0x1F, 0x3E, 0x1F, 0x01,
  0xF0, 0x78, 0xF8, 0x7C, 0x07, 0x81, 0xE3, 0xE1, 0xF0, 0x3E, 0x0F, 0x8F,
  0x87, 0xC0, 0xF8, 0x3C, 0x3E, 0x1F, 0x87, 0xE1, 0xF0, 0xF8, 0x7E, 0x7F,
  0x8F, 0x83, 0xE1, 0xFF, 0xFF, 0xFE, 0x0F, 0x83, 0xFF, 0x7F, 0xF0, 0x3E,
  0x0F, 0xF9, 0xFF, 0x80, 0xF8, 0x1F, 0xC3, 0xFC, 0x03, 0xF0, 0x1C, 0x07,
  0xC0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x08, 0x00, 0x03, 0xFC, 0x00, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x0F, 0xF3, 0xF8,
  0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x07,
  0xF8, 0xFE, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xC0,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x00,
  0x3F, 0xC0, 0xFF, 0x80, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x00,
  0xFF, 0x8F, 0xF8, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x07, 0xF9, 0xFF,
  0x00, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xC0, 0x07, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xF8, 0x00, 0x1F,
  0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0xFF, 0x03, 0xFE,
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F,
  0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xF0,
  0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x03, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFC, 0x00,
  0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x7F, 0x81,
  0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00,
  0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x01, 0xFE, 0x0F,
  0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x01,
  0xFF, 0x83, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x7F,
  0xC0, 0x07, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xF1,
  0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00,
  0xFF, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x08, 0xFF, 0x00,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x7F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x0F,
  0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x01, 0xFF, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xC1, 0xFE, 0x00,
  0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x87,
  0xFC, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x87, 0xFC,
  0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x01, 0xFF,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x83, 0xFC, 0x00,
  0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x03, 0xFE, 0x0F,
  0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0x80, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x1F,
  0xF0, 0x1F, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xF8,
  0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xE0,
  0xFF, 0x80, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x01,
  0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x3F, 0xFF, 0xC7, 0xF8, 0x07, 0xFF, 0xFC, 0xFF, 0x80, 0x7F, 0xFF, 0xCF,
  0xF8, 0x07, 0xFF, 0xFC, 0xFF, 0x80, 0x7F, 0xFF, 0xCF, 0xF0, 0x07, 0xFF,
  0xF8, 0xFF, 0x00, 0xFF, 0xFF, 0x8F, 0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x8F,
  0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x7F, 0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xE0,
  0x01, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x7F, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF8,
  0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x07,
  0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xFC,
  0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x80,
  0x01, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xE0,
  0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0xE1,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xE0, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xE0, 0x3F, 0xF8, 0x00, 0x03, 0xFE, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xC1, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC7,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x9F, 0xF8,
  0x00, 0x00, 0x07, 0xFB, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xE3, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x1F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F,
  0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x01,
  0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0xFF, 0xFC,
  0x03, 0xFB, 0xF1, 0xFF, 0xFC, 0x03, 0xFB, 0xF1, 0xFB, 0xFC, 0x03, 0xFB,
  0xF3, 0xFB, 0xF8, 0x07, 0xFB, 0xF3, 0xF3, 0xF8, 0x07, 0xFB, 0xF7, 0xF7,
  0xF8, 0x07, 0xFB, 0xF7, 0xF7, 0xF8, 0x07, 0xF3, 0xFF, 0xE7, 0xF8, 0x07,
  0xF1, 0xFF, 0xE7, 0xF0, 0x07, 0xF1, 0xFF, 0xC7, 0xF0, 0x0F, 0xF1, 0xFF,
  0xCF, 0xF0, 0x0F, 0xF1, 0xFF, 0x8F, 0xF0, 0x0F, 0xF1, 0xFF, 0x8F, 0xF0,
  0x0F, 0xF1, 0xFF, 0x0F, 0xF0, 0x0F, 0xE1, 0xFF, 0x0F, 0xE0, 0x1F, 0xE1,
  0xFE, 0x0F, 0xE0, 0x1F, 0xE1, 0xFE, 0x1F, 0xE0, 0x1F, 0xE1, 0xFC, 0x1F,
  0xE0, 0x1F, 0xE0, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xF8, 0x1F, 0xE0, 0x1F,
  0xC0, 0xF8, 0x1F, 0xC0, 0x3F, 0xC0, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xFC, 0x00, 0x3F,
  0xC0, 0x3F, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0xFF,
  0xE0, 0x03, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0xC0, 0x0F,
  0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xC0, 0x3F,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0xFC, 0x03,
  0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xF0, 0x0F,
  0xF7, 0xF0, 0x3F, 0xE0, 0x1F, 0xE7, 0xE0, 0x7F, 0xC0, 0x3F, 0xCF, 0xE0,
  0xFF, 0x80, 0xFF, 0x9F, 0xC1, 0xFE, 0x01, 0xFF, 0x3F, 0x83, 0xFC, 0x03,
  0xFE, 0x3F, 0x07, 0xF8, 0x07, 0xF8, 0x7F, 0x1F, 0xF0, 0x0F, 0xF0, 0xFE,
  0x3F, 0xE0, 0x1F, 0xE1, 0xFC, 0x7F, 0xC0, 0x7F, 0xC1, 0xF8, 0xFF, 0x00,
  0xFF, 0x83, 0xF9, 0xFE, 0x01, 0xFF, 0x07, 0xF3, 0xFC, 0x03, 0xFC, 0x07,
  0xEF, 0xF8, 0x07, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xF0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0x00,
  0x7F, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0xF8,
  0x0F, 0xF8, 0x01, 0xFF, 0xF0, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xE0,
  0x07, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xFE,
  0x01, 0xFE, 0x00, 0x1F, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xF8,
  0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF,
  0x80, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0x80,
  0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0xFF,
  0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x07, 0xF9,
  0xFF, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x0F, 0xF7, 0xFC, 0x00,
  0x01, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x0F, 0xFB, 0xFC,
  0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFB,
  0xFE, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x07,
  0xFD, 0xFE, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x1F, 0xF7, 0xF8, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x1F, 0xF3, 0xFC,
  0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x1F, 0xF1,
  0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x03,
  0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F,
  0x80, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x3F,
  0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0xFF, 0x00, 0x1F, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x01, 0xFE,
  0x1F, 0xE0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00,
  0x1F, 0xF3, 0xFC, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x1F, 0xF7, 0xFC,
  0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x01, 0xFE,
  0x7F, 0x80, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF8,
  0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x03, 0xFC,
  0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00,
  0x7F, 0x8F, 0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x8F, 0xF0,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F,
  0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x71, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xC0, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x1F,
  0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x07,
  0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xE0, 0x01, 0xFF, 0xC0, 0x7F,
  0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0xE0,
  0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00,
  0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x81,
  0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x01, 0xFE, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00,
  0x7F, 0xC1, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0x3F, 0xC3, 0xFE, 0x00,
  0x01, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xF0,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0xE3,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x03,
  0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x07,
  0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xF8,
  0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0xE7,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x0F,
  0xFD, 0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x07, 0xFE, 0x3F, 0xC0,
  0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x1F,
  0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x03, 0xFC, 0x0F,
  0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x03,
  0xFC, 0x3F, 0xE0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xF0,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x01, 0xFE,
  0x7F, 0x80, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x3F, 0xBF, 0xE0, 0x00,
  0x01, 0xFD, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x7E, 0x01, 0xFE, 0x7F, 0x01,
  0xFC, 0x03, 0xFC, 0xFE, 0x03, 0xF8, 0x07, 0xF1, 0xFC, 0x07, 0xF0, 0x1F,
  0xE7, 0xF8, 0x0F, 0xE0, 0x3F, 0xCF, 0xF0, 0x3F, 0xC0, 0x7F, 0x9F, 0xE0,
  0x7F, 0x81, 0xFE, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x7F, 0x83, 0xFE, 0x07,
  0xF8, 0xFF, 0x07, 0xFC, 0x0F, 0xE1, 0xFE, 0x0F, 0xF8, 0x3F, 0xC3, 0xFC,
  0x3F, 0xF0, 0x7F, 0x87, 0xF8, 0x7F, 0xE0, 0xFF, 0x0F, 0xF0, 0xFF, 0xC1,
  0xFC, 0x1F, 0xE1, 0xFF, 0x87, 0xF8, 0x3F, 0xC7, 0xFF, 0x0F, 0xF0, 0x7F,
  0x8F, 0xFE, 0x1F, 0xC0, 0xFF, 0x1F, 0xFC, 0x7F, 0x81, 0xFC, 0x7E, 0xF8,
  0xFF, 0x03, 0xF8, 0xFD, 0xF1, 0xFE, 0x07, 0xF1, 0xFB, 0xE3, 0xF8, 0x0F,
  0xE7, 0xE7, 0xCF, 0xF0, 0x1F, 0xCF, 0xCF, 0x9F, 0xE0, 0x3F, 0x9F, 0x9F,
  0x3F, 0x80, 0x7F, 0x3E, 0x3E, 0x7F, 0x00, 0xFE, 0xFC, 0x7D, 0xFE, 0x01,
  0xFD, 0xF8, 0xFB, 0xFC, 0x03, 0xFB, 0xF1, 0xF7, 0xF0, 0x07, 0xFF, 0xC3,
  0xEF, 0xE0, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x1F, 0xFF, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0x07, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF0,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x07, 0xF8,
  0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0,
  0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xF9, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x0F, 0xFD, 0xFF, 0x00,
  0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xFC,
  0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0x0F, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00,
  0x7F, 0x80, 0xFF, 0x80, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x3F,
  0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x00,
  0xFF, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xEF, 0xC0, 0x01,
  0xFD, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xC3, 0xF0, 0x03, 0xF8, 0x7E,
  0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE,
  0x03, 0xF0, 0x3F, 0x80, 0x7E, 0x07, 0xF0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC,
  0x7F, 0x80, 0x3F, 0x8F, 0xE0, 0x03, 0xF3, 0xF8, 0x00, 0x7E, 0xFF, 0x00,
  0x0F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0x7F, 0x83, 0xFE, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xE1,
  0xFF, 0xC0, 0x0F, 0xF1, 0xFF, 0x80, 0x07, 0xF8, 0xFF, 0x80, 0x07, 0xFC,
  0x7F, 0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0xFF,
  0x1F, 0xF0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0xFF,
  0xE1, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFD, 0xFF, 0x01, 0xFF, 0xFC,
  0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0xC0, 0x00, 0x0F, 0xF1, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0xFC,
  0x00, 0x7F, 0xBF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xEF, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC3, 0xFC, 0x00,
  0x0F, 0xF8, 0x7F, 0x80, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xE3, 0xFE,
  0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x1F,
  0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x00,
  0x3F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x03, 0xFF,
  0xE3, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFD, 0xFF, 0xFF, 0x80, 0x7F, 0x9F, 0xFF, 0xE0, 0x0F, 0xF1, 0xFF, 0xF8,
  0x03, 0xFC, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x1F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x07,
  0xFC, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE3,
  0xFE, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0x81, 0xFF, 0x00,
  0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x87,
  0xF8, 0x00, 0x7F, 0xFE, 0x3F, 0xC0, 0x07, 0xFF, 0xFB, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xCF, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFC, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x0F,
  0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xF0,
  0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x3F, 0xE0, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x1F,
  0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F,
  0xE0, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xFF,
  0x8F, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF7, 0xF8, 0x00, 0x3F, 0xFF,
  0x3F, 0x80, 0x00, 0x7F, 0xE1, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x1F, 0xFC, 0x0F, 0xFE, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x3F, 0xC3, 0xFE, 0x00,
  0x0F, 0xF3, 0xFE, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x03, 0xFD, 0xFF, 0x00,
  0x01, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0C, 0x07, 0xFE, 0x00, 0x0F, 0x01,
  0xFF, 0x80, 0x1F, 0xC0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x3F, 0xC0, 0x07, 0xFF,
  0xF1, 0xFE, 0x00, 0x7F, 0xFF, 0xDF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFC, 0x7F,
  0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x03, 0xFE,
  0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07,
  0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x01, 0xFE, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFC,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x7F, 0x80, 0x03, 0xFF, 0xF3, 0xFC, 0x00, 0x07,
  0xFE, 0x3F, 0xE0, 0x00, 0x07, 0x81, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x08, 0x00, 0x07, 0xFC, 0x00, 0xE0, 0x00,
  0x7F, 0xC0, 0x0F, 0x80, 0x07, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x60, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x03, 0xFC, 0x3F, 0xFE, 0x00, 0x7F,
  0x9F, 0xFF, 0xE0, 0x0F, 0xF7, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xE0, 0x3F,
  0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x00,
  0x07, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x07,
  0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xE1, 0xFE, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xE1, 0xFF,
  0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x1F, 0xF0,
  0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x0F,
  0xF0, 0xFF, 0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0xC3, 0xFC, 0x00,
  0x0F, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x87, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF,
  0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xC0,
  0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFC, 0x03, 0xFF, 0x80,
  0x0F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x01, 0xFF, 0x07,
  0xFE, 0x00, 0x07, 0xF8, 0x7F, 0xF0, 0x00, 0x1F, 0xE3, 0xFF, 0x80, 0x00,
  0x7F, 0x9F, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xF1, 0xFF, 0x00, 0x01, 0xFF, 0x87, 0xFC,
  0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFC,
  0x00, 0x7F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x03, 0xFF,
  0x01, 0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x18, 0x01, 0x80, 0x07, 0xF9,
  0xFE, 0x1F, 0xE0, 0x0F, 0xE7, 0xFE, 0x7F, 0xE0, 0x1F, 0xDF, 0xFD, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0x7F, 0xFF, 0xFF, 0x07, 0xF8, 0x3F, 0xE1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0xFF, 0x07, 0xF8, 0x7F,
  0x81, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x3F, 0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F,
  0xE0, 0x7F, 0x83, 0xFC, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x7F, 0x81, 0xFC,
  0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0x83,
  0xF8, 0x1F, 0xE0, 0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F,
  0x03, 0xFC, 0x3F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x1F,
  0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x03, 0xF8,
  0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFE, 0x07,
  0xF8, 0x3F, 0xC3, 0xFC, 0x0F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0xC0, 0xFF,
  0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x7F,
  0x83, 0xFF, 0x00, 0x0F, 0xF1, 0xFF, 0xF8, 0x01, 0xFE, 0x7F, 0xFF, 0x80,
  0x3F, 0xDF, 0xFF, 0xF8, 0x07, 0xF7, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xBF, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xC0,
  0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x1F, 0xF0, 0x7F,
  0x80, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF8,
  0x7F, 0x80, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00,
  0x07, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xC3, 0xFE, 0x00,
  0x0F, 0xF8, 0x7F, 0x80, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xE1, 0xFE,
  0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x3F, 0xFC, 0x0F, 0xFC, 0x03,
  0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xC7, 0xFC, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x00,
  0x03, 0xFE, 0xFF, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x03, 0xFD, 0xFE,
  0x00, 0x03, 0xFE, 0xFF, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x3F,
  0xE0, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0xC3,
  0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xF8, 0x7F, 0xE0, 0x00, 0x3F,
  0xCF, 0xFF, 0xC0, 0x01, 0xFE, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00,
  0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x7F,
  0xC0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0xC0,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0xC0,
  0xFF, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xFE, 0x1F, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFB, 0xFF, 0xFE, 0x00, 0x3F, 0xCF, 0xFF, 0xE0, 0x03,
  0xFE, 0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0x07, 0xF0, 0x07, 0xFF, 0xE3, 0xFC, 0x03, 0xFF,
  0xFE, 0xFF, 0x01, 0xFF, 0xFF, 0xBF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFE, 0x3F, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x87,
  0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x03, 0xFE,
  0x3F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x0F,
  0xF1, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFF, 0x1F, 0xE0, 0x00,
  0x7F, 0xC7, 0xF8, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x80,
  0x01, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xE3, 0xFE,
  0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xFC,
  0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x7F, 0x80, 0x1F, 0xFF, 0xBF, 0xC0, 0x01, 0xFF, 0x8F, 0xF0, 0x00, 0x0F,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x03, 0xFC, 0x0F, 0xFF, 0x03, 0xFC, 0x3F, 0xFF, 0x03, 0xFC,
  0x7F, 0xFF, 0x03, 0xFD, 0xFF, 0xFF, 0x03, 0xFB, 0xFF, 0xFE, 0x07, 0xFB,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x04, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC, 0x07, 0xFE, 0x0F,
  0xF8, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x3F, 0xCF, 0xF8, 0x00,
  0x3F, 0xE7, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF1, 0xF0, 0x01, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x1F, 0xF1, 0xFF,
  0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x03, 0xFE,
  0x3F, 0xE0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFF, 0x0F, 0xF0, 0x00,
  0x7F, 0xC7, 0xFC, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x3F, 0xE1, 0xFE,
  0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x0F,
  0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x07, 0xFC,
  0x3F, 0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F,
  0xE0, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFC, 0x7F, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xDF, 0xC0, 0x3F, 0xFF, 0xE7, 0xF0, 0x07, 0xFF,
  0xF3, 0xFC, 0x00, 0xFF, 0xF8, 0xFF, 0x00, 0x1F, 0xFC, 0x3F, 0xC0, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F,
  0xF9, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0xC7, 0xF8, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x80,
  0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x01,
  0xFF, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xF0, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xFF, 0xF0,
  0x0F, 0xC0, 0x3F, 0xFF, 0x80, 0x7E, 0x03, 0xFD, 0xFC, 0x07, 0xF0, 0x1F,
  0xEF, 0xE0, 0x3F, 0x80, 0xFE, 0x7F, 0x03, 0xFC, 0x07, 0xF3, 0xF8, 0x1F,
  0xE0, 0x7F, 0x9F, 0xC0, 0xFF, 0x03, 0xF8, 0xFE, 0x0F, 0xF8, 0x1F, 0xC7,
  0xF0, 0x7F, 0xC1, 0xFE, 0x3F, 0x83, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0xF0,
  0x7F, 0x0F, 0xE1, 0xFF, 0x87, 0xF8, 0x7F, 0x0F, 0xFC, 0x3F, 0x83, 0xF8,
  0xFB, 0xE1, 0xFC, 0x1F, 0xC7, 0xDF, 0x1F, 0xE0, 0xFE, 0x7E, 0xF8, 0xFE,
  0x07, 0xF3, 0xE7, 0xC7, 0xF0, 0x3F, 0x9F, 0x3E, 0x3F, 0x81, 0xFD, 0xF9,
  0xF3, 0xF8, 0x0F, 0xEF, 0x8F, 0x9F, 0xC0, 0x7F, 0x7C, 0x7C, 0xFC, 0x03,
  0xF7, 0xC1, 0xEF, 0xE0, 0x1F, 0xBE, 0x0F, 0x7F, 0x00, 0xFD, 0xF0, 0x7B,
  0xF0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF0,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x01, 0xFF,
  0x00, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00,
  0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0x1F, 0xE0,
  0xFF, 0x80, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0x0F, 0xF3, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x00, 0xFF,
  0xCF, 0xF8, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x0F,
  0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x00, 0x7F, 0xC0,
  0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC1, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x0F, 0xF0, 0x00,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x00, 0x0F, 0xF1, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x02, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xC7, 0xFF, 0xFC, 0x00, 0x7E,
  0x1F, 0xFF, 0xF8, 0x01, 0xF8, 0xFF, 0xFF, 0xF0, 0x0F, 0xE3, 0xFF, 0xFF,
  0xF0, 0x7F, 0x9F, 0xE0, 0xFF, 0xFF, 0xFC, 0x7F, 0x00, 0xFF, 0xFF, 0xF1,
  0xF8, 0x01, 0xFF, 0xFF, 0x87, 0xC0, 0x03, 0xFF, 0xFE, 0x3F, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
};

const GFXglyph RobotoMono_SemiBoldItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 17, 49, 40, 12, -48 },
  { 106, 22, 17, 40, 12, -51 },
  { 153, 40, 48, 40, 0, -48 },
  { 393, 36, 63, 40, 3, -56 },
  { 677, 33, 50, 40, 4, -49 },
  { 884, 38, 50, 40, 1, -49 },
  { 1122, 9, 18, 40, 17, -51 },
  { 1143, 22, 69, 40, 11, -54 },
  { 1333, 24, 69, 40, 5, -54 },
  { 1540, 32, 34, 40, 6, -48 },
  { 1676, 34, 35, 40, 3, -40 },
  { 1825, 14, 21, 40, 6, -8 },
  { 1862, 28, 7, 40, 8, -25 },
  { 1887, 11, 12, 40, 12, -11 },
  { 1904, 35, 52, 40, 3, -48 },
  { 2132, 33, 50, 40, 4, -49 },
  { 2339, 23, 48, 40, 8, -48 },
  { 2477, 36, 49, 40, 0, -49 },
  { 2698, 35, 50, 40, 2, -49 },
  { 2917, 35, 48, 40, 1, -48 },
  { 3127, 36, 49, 40, 3, -48 },
  { 3348, 32, 50, 40, 3, -49 },
  { 3548, 35, 48, 40, 5, -48 },
  { 3758, 34, 50, 40, 3, -49 },
  { 3971, 31, 49, 40, 5, -49 },
  { 4161, 17, 40, 40, 12, -39 },
  { 4246, 21, 52, 40, 9, -39 },
  { 4383, 31, 32, 40, 5, -37 },
  { 4507, 34, 21, 40, 3, -31 },
  { 4597, 32, 31, 40, 3, -36 },
  { 4721, 30, 50, 40, 8, -49 },
  { 4909, 38, 48, 40, 2, -48 },
  { 5137, 38, 48, 40, -2, -48 },
  { 5365, 38, 48, 40, 1, -48 },
  { 5593, 36, 50, 40, 3, -49 },
  { 5818, 37, 48, 40, 1, -48 },
  { 6040, 40, 48, 40, 1, -48 },
  { 6280, 39, 48, 40, 2, -48 },
  { 6514, 36, 50, 40, 3, -49 },
  { 6739, 39, 48, 40, 1, -48 },
  { 6973, 35, 48, 40, 3, -48 },
  { 7183, 38, 49, 40, 2, -48 },
  { 7416, 44, 48, 40, 1, -48 },
  { 7680, 32, 48, 40, 2, -48 },
  { 7872, 40, 48, 40, 1, -48 },
  { 8112, 39, 48, 40, 1, -48 },
  { 8346, 35, 50, 40, 3, -49 },
  { 8565, 38, 48, 40, 2, -48 },
  { 8793, 36, 57, 40, 3, -49 },
  { 9050, 38, 48, 40, 1, -48 },
  { 9278, 38, 50, 40, 2, -49 },
  { 9516, 38, 48, 40, 5, -48 },
  { 9744, 37, 49, 40, 3, -48 },
  { 9971, 37, 48, 40, 6, -48 },
  { 10193, 39, 48, 40, 4, -48 },
  { 10427, 45, 48, 40, -2, -48 },
  { 10697, 38, 48, 40, 6, -48 },
  { 10925, 40, 48, 40, 0, -48 },
  { 11165, 25, 67, 40, 8, -56 },
  { 11375, 16, 52, 40, 13, -48 },
  { 11479, 25, 67, 40, 8, -56 },
  { 11689, 27, 25, 40, 7, -48 },
  { 11774, 31, 7, 40, 0, 0 },
  { 11802, 13, 9, 40, 18, -49 },
  { 11817, 33, 38, 40, 2, -37 },
  { 11974, 35, 52, 40, 1, -51 },
  { 12202, 33, 38, 40, 3, -37 },
  { 12359, 37, 52, 40, 3, -51 },
  { 12600, 33, 38, 40, 3, -37 },
  { 12757, 36, 53, 40, 6, -53 },
  { 12996, 37, 51, 40, 1, -37 },
  { 13232, 35, 51, 40, 1, -51 },
  { 13456, 30, 50, 40, 3, -50 },
  { 13644, 32, 65, 40, 1, -50 },
  { 13904, 38, 51, 40, 1, -51 },
  { 14147, 31, 51, 40, 3, -51 },
  { 14345, 39, 37, 40, -1, -37 },
  { 14526, 35, 37, 40, 1, -37 },
  { 14688, 33, 38, 40, 3, -37 },
  { 14845, 37, 51, 40, -1, -37 },
  { 15081, 34, 51, 40, 3, -37 },
  { 15298, 32, 37, 40, 6, -37 },
  { 15446, 33, 38, 40, 3, -37 },
  { 15603, 31, 46, 40, 6, -45 },
  { 15782, 34, 37, 40, 4, -36 },
  { 15940, 35, 36, 40, 5, -36 },
  { 16098, 37, 36, 40, 4, -36 },
  { 16265, 40, 36, 40, 0, -36 },
  { 16445, 42, 51, 40, 0, -36 },
  { 16713, 37, 36, 40, 1, -36 },
  { 16880, 26, 65, 40, 10, -53 },
  { 17092, 15, 62, 40, 12, -48 },
  { 17209, 27, 65, 40, 6, -53 },
  { 17429, 38, 14, 40, 0, -27 },
};

const GFXfont RobotoMono_SemiBoldItalic68pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic68pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic68pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC68PT7B_H_
