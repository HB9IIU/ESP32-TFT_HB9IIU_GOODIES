#ifndef _ROBOTOMONO_SEMIBOLDITALIC39PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xC1, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0xF8, 0x7C, 0x3E, 0x0F, 0x00, 0x78, 0x77, 0x8F,
  0x70, 0xF7, 0x0F, 0x70, 0xEF, 0x0E, 0xF0, 0xEE, 0x1E, 0xE1, 0xCE, 0x1C,
  0x00, 0x1E, 0x3C, 0x00, 0x38, 0x70, 0x00, 0x70, 0xE0, 0x01, 0xE3, 0xC0,
  0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0x70, 0x0F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x0F, 0x0E, 0x00, 0x1C,
  0x3C, 0x00, 0x38, 0x70, 0x00, 0xF0, 0xE0, 0x01, 0xC3, 0x80, 0x03, 0x87,
  0x00, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x80, 0xF1, 0xE0,
  0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x0F, 0x1E, 0x00, 0x1C, 0x38, 0x00,
  0x38, 0x70, 0x00, 0xE1, 0xE0, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0x00, 0x1F, 0xFC,
  0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xC3, 0xF1, 0xF8, 0x1F, 0x1F, 0x01,
  0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF,
  0x80, 0x7C, 0xF8, 0x07, 0xC7, 0xC0, 0xFC, 0x7F, 0xFF, 0x83, 0xFF, 0xF0,
  0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x0F, 0x80, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x3C, 0xF0,
  0x87, 0x0E, 0x1C, 0xE1, 0xC7, 0xBC, 0x38, 0xE7, 0x8F, 0x38, 0x71, 0xCE,
  0x0F, 0xFB, 0xC0, 0xFE, 0x70, 0x0F, 0x9C, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xCF, 0x00, 0x73, 0xF8, 0x1C, 0xFF,
  0x87, 0xBC, 0xF0, 0xE7, 0x0E, 0x38, 0xE1, 0xCF, 0x1C, 0x38, 0xC7, 0x87,
  0x00, 0x71, 0xE0, 0x0F, 0x78, 0x01, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7C, 0x7C, 0x03,
  0xC3, 0xE0, 0x1E, 0x1F, 0x01, 0xF0, 0xF0, 0x0F, 0x8F, 0x80, 0x3C, 0xF8,
  0x01, 0xEF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x03, 0xFE, 0x0F, 0x3F, 0xF8, 0x7B, 0xE7, 0xC7, 0xFF, 0x1F, 0x3D,
  0xF0, 0xFF, 0xEF, 0x83, 0xFE, 0x7C, 0x0F, 0xF3, 0xE0, 0x7F, 0x1F, 0x03,
  0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFE, 0xF8, 0x3F, 0xC7, 0xE0,
  0x7B, 0xDE, 0xE7, 0x7B, 0xDE, 0xE7, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x07,
  0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x78,
  0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x18, 0x00, 0x40,
  0x02, 0x00, 0x1C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0,
  0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C,
  0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01,
  0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0xC0,
  0x78, 0x03, 0x80, 0x08, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x40, 0xE0, 0x5C, 0x1C, 0x33, 0xE3, 0x3F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFC, 0x0F, 0xF0, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x0E, 0xF0, 0x03, 0xCE, 0x00, 0xF1, 0xE0, 0x7C, 0x1E, 0x07, 0x83, 0xC0,
  0x60, 0x70, 0x00, 0x08, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x1F, 0x1E, 0x1E, 0x3E, 0x3E, 0x3C,
  0x3C, 0x7C, 0x78, 0xF0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0xF8, 0x7C, 0x3E, 0x07, 0xC7,
  0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF0, 0x1F, 0xBE,
  0x0F, 0xF7, 0xC3, 0xFE, 0xF9, 0xF7, 0xDF, 0x7C, 0xF3, 0xFE, 0x1E, 0x7F,
  0x87, 0xCF, 0xC0, 0xFB, 0xF0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x78, 0xF0,
  0x1F, 0x1E, 0x03, 0xE3, 0xE0, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F,
  0xF0, 0x07, 0xF8, 0x00, 0x00, 0x08, 0x03, 0xC0, 0xFC, 0x3F, 0xEF, 0xFF,
  0x7F, 0xFB, 0xFF, 0xDE, 0x3E, 0x81, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0,
  0x3E, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0xFC, 0x3F, 0x07, 0xC0, 0xF8, 0x7C, 0x03, 0xC3, 0xE0, 0x1E, 0x1E,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF9, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0,
  0xFF, 0xFE, 0x0F, 0xC3, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0x60, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x01, 0xFF,
  0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x80, 0x07, 0xCF, 0x80, 0x7C, 0xF8,
  0x07, 0xCF, 0xC0, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xFE, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x7B, 0xE0, 0x07, 0xDF, 0x00, 0x7C, 0xF8, 0x07, 0xC7, 0x80, 0x3C, 0x7C,
  0x03, 0xC3, 0xE0, 0x3E, 0x1F, 0x03, 0xE0, 0xF8, 0x3E, 0x07, 0xC1, 0xE0,
  0x3C, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0x03, 0xFF, 0xF8, 0x1E, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0xF0, 0x07, 0xCF, 0x80, 0xF8, 0xF8,
  0x0F, 0x8F, 0xC1, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x0F, 0xFC, 0x07,
  0xF8, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xCF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xFF, 0xEF, 0xE0, 0xFB,
  0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xBE, 0x03, 0xEF, 0x80, 0xF9, 0xF0, 0x7C, 0x7F, 0xFF, 0x0F, 0xFF,
  0x81, 0xFF, 0xC0, 0x3F, 0xC0, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F,
  0xFE, 0x0F, 0xC3, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF1, 0xF0, 0x1F, 0x1F,
  0x01, 0xF0, 0xF0, 0x1F, 0x0F, 0x83, 0xE0, 0xFC, 0x7C, 0x07, 0xFF, 0x80,
  0x3F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0x07, 0xC3, 0xE0, 0x7C,
  0x7C, 0x03, 0xC7, 0xC0, 0x3C, 0x78, 0x03, 0xC7, 0xC0, 0x7C, 0x7C, 0x07,
  0xC7, 0xC0, 0xFC, 0x7F, 0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF,
  0x80, 0x01, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0x1F,
  0x9F, 0x83, 0xE7, 0xC0, 0x7B, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xBE, 0x03, 0xE7, 0xC3, 0xF9, 0xFF,
  0xFE, 0x3F, 0xFF, 0x87, 0xFB, 0xC0, 0xF9, 0xF0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07,
  0xF8, 0x01, 0xF8, 0x00, 0x0F, 0x07, 0xE1, 0xFC, 0x7E, 0x1F, 0x83, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x3F, 0x0F, 0xE3, 0xF8, 0xFC, 0x1F, 0x00, 0x01, 0xE0, 0x3F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x0F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x7C,
  0x0F, 0x80, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x01, 0xF8, 0x01,
  0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0,
  0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x3F, 0xFF, 0xE7,
  0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F,
  0xFF, 0xC0, 0x10, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xC0, 0x07,
  0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF8, 0x0F, 0xF8, 0x03,
  0xF0, 0x00, 0xF0, 0x00, 0x20, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xFF, 0x0F,
  0xFF, 0xCF, 0xFF, 0xE7, 0xE1, 0xFF, 0xC0, 0x7F, 0xE0, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x01, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0xFC, 0x7C, 0x07, 0x80, 0x70, 0x3C, 0x00, 0xE1,
  0xE1, 0xE3, 0x87, 0x1F, 0xE6, 0x38, 0xFF, 0x98, 0xE7, 0x8C, 0x67, 0x1C,
  0x31, 0x9C, 0xF1, 0xC6, 0x73, 0x87, 0x1B, 0x8E, 0x1C, 0xEE, 0x38, 0x63,
  0xB9, 0xC3, 0x8E, 0xE7, 0x0E, 0x33, 0x9C, 0x39, 0xCE, 0x79, 0xC7, 0x38,
  0xFF, 0xF8, 0xE3, 0xFF, 0xC3, 0x87, 0x1E, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x08, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x7D, 0xE0,
  0x03, 0xCF, 0x00, 0x3E, 0x78, 0x01, 0xE3, 0xC0, 0x1F, 0x1E, 0x00, 0xF0,
  0xF0, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x83,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0xF8, 0x03,
  0xE7, 0xC0, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0,
  0x01, 0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0x83, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x1E,
  0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xE0, 0x1F, 0x8F, 0x80, 0xFC, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3C, 0x03,
  0xE1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1,
  0xF0, 0x0F, 0xCF, 0x80, 0x3E, 0x3E, 0x03, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFC, 0x1F, 0x07, 0xC0, 0x7C, 0x7C,
  0x03, 0xE3, 0xE0, 0x1F, 0x3E, 0x00, 0x79, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x03, 0xC7,
  0x80, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0x0F, 0xC1, 0xF8, 0x3F, 0xFF,
  0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0x8F, 0xF0, 0x3E,
  0x07, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0x78, 0x3E, 0x01,
  0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1,
  0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0,
  0x1F, 0x8F, 0x80, 0x7C, 0x3E, 0x03, 0xF0, 0xF0, 0x0F, 0x87, 0xC0, 0x7C,
  0x1F, 0x07, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0,
  0xFF, 0xFE, 0x1F, 0x83, 0xE1, 0xF0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F,
  0x7C, 0x00, 0xF7, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x3F, 0xEF, 0x83, 0xFE, 0xF8, 0x7F, 0xEF, 0x87,
  0xFE, 0xF8, 0x03, 0xEF, 0x80, 0x3C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8,
  0x07, 0xC7, 0xC0, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFE, 0x00,
  0xFF, 0x80, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3C,
  0x01, 0xE0, 0xF8, 0x03, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0,
  0x3E, 0x0F, 0x80, 0x7C, 0x1E, 0x00, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07,
  0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x83,
  0xC0, 0x1E, 0x0F, 0x80, 0x3C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C,
  0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xE0, 0x0F, 0x07, 0xC0, 0x3E, 0x00, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x03, 0xC3, 0xE0,
  0x1F, 0x07, 0xC0, 0xFC, 0x1F, 0x07, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC,
  0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0x80, 0x3F, 0x87, 0xC0, 0x3F,
  0x03, 0xE0, 0x3F, 0x81, 0xF0, 0x3F, 0x80, 0xF8, 0x1F, 0x80, 0xF8, 0x1F,
  0x80, 0x7C, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x1F, 0x1F, 0x80, 0x0F, 0x9F,
  0x80, 0x07, 0x9F, 0x80, 0x07, 0xDF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xBE, 0x00, 0x3F,
  0x9F, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF8, 0x03,
  0xE0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0,
  0x7C, 0x03, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x07,
  0xF0, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC, 0xFF, 0x07, 0xF9, 0xFE,
  0x0F, 0x77, 0xBC, 0x1E, 0xEF, 0x78, 0x7D, 0xDD, 0xF0, 0xFB, 0xFB, 0xE1,
  0xE7, 0xE7, 0x83, 0xCF, 0xCF, 0x07, 0x9F, 0x1E, 0x0F, 0x3E, 0x7C, 0x3E,
  0x78, 0xF8, 0x7C, 0x71, 0xE0, 0xF8, 0xE3, 0xC1, 0xE0, 0x07, 0x83, 0xC0,
  0x1F, 0x07, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF0, 0x7C, 0x01,
  0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x00, 0x07, 0xC0,
  0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x80, 0xF8, 0x3F, 0x01, 0xE0, 0xFE, 0x07,
  0xC1, 0xFC, 0x0F, 0x83, 0xFC, 0x1F, 0x07, 0xF8, 0x3E, 0x0F, 0xF0, 0x7C,
  0x1E, 0xE1, 0xF0, 0x7D, 0xE3, 0xE0, 0xFB, 0xC7, 0xC1, 0xF7, 0x8F, 0x83,
  0xE7, 0x1F, 0x07, 0xCF, 0x3E, 0x0F, 0x1E, 0xF8, 0x3E, 0x3D, 0xF0, 0x7C,
  0x3F, 0xE0, 0xF8, 0x7F, 0xC1, 0xF0, 0xFF, 0x83, 0xE1, 0xFE, 0x0F, 0x81,
  0xFC, 0x1F, 0x03, 0xF8, 0x3E, 0x07, 0xF0, 0x7C, 0x07, 0xE0, 0xF8, 0x0F,
  0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFC, 0x3F, 0x07, 0xC0, 0xF8, 0x7C,
  0x03, 0xE3, 0xE0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E,
  0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xCF, 0x80,
  0x3E, 0x7C, 0x01, 0xF3, 0xC0, 0x0F, 0x9E, 0x00, 0x7C, 0xF0, 0x07, 0xC7,
  0x80, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0x0F, 0xC1, 0xF0, 0x3F, 0xFF,
  0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0x83, 0xF8, 0x3E,
  0x03, 0xE0, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01,
  0xF1, 0xF0, 0x0F, 0xC7, 0xC0, 0x3E, 0x1E, 0x01, 0xF8, 0xF8, 0x3F, 0xC3,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0xFC, 0x3F, 0x07, 0xC0, 0xF8, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x3E,
  0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F,
  0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1E, 0x7C, 0x01, 0xF3, 0xC0,
  0x0F, 0xBE, 0x00, 0x7C, 0xF0, 0x03, 0xE7, 0x80, 0x3E, 0x3E, 0x01, 0xF1,
  0xF0, 0x1F, 0x0F, 0xC1, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x70, 0x00, 0x01, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0x83, 0xF8, 0x3C, 0x03, 0xE1, 0xF0, 0x0F,
  0x87, 0xC0, 0x1E, 0x1F, 0x00, 0x78, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x8F,
  0x80, 0x7E, 0x3E, 0x03, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFE, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF8, 0x3E, 0x03, 0xF0, 0xF8,
  0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7E, 0x3E, 0x00, 0xF8, 0x00, 0x7F,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xC1, 0xF8,
  0x7E, 0x03, 0xE1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x20, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xC7, 0xC0,
  0x3E, 0x1F, 0x81, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0xF8,
  0x07, 0xC7, 0xC0, 0x3E, 0x3C, 0x01, 0xF3, 0xE0, 0x0F, 0x1F, 0x00, 0xF8,
  0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xE0, 0x0F, 0x9F, 0x00,
  0x78, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F,
  0x00, 0x7C, 0xF8, 0x03, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F,
  0x8F, 0x80, 0x7C, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x83, 0xE0, 0x7F,
  0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x9F, 0x00, 0x7C, 0x7C, 0x03, 0xF1,
  0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0xF0,
  0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x87, 0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C,
  0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x1E, 0x7C, 0x00, 0x79, 0xF0, 0x01,
  0xE7, 0x80, 0x07, 0xBE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x78, 0x7F, 0xE1, 0xE1, 0xEF, 0x8F, 0x87, 0xBC,
  0x3E, 0x3E, 0xF0, 0xF8, 0xFB, 0xC7, 0xE3, 0xCF, 0x1F, 0x8F, 0x3C, 0x7E,
  0x7C, 0xF1, 0xF9, 0xE3, 0xCF, 0xE7, 0x8F, 0x3F, 0xBE, 0x3C, 0xFE, 0xF8,
  0xF7, 0xFB, 0xC3, 0xDD, 0xEF, 0x0F, 0x77, 0xFC, 0x3F, 0xDF, 0xE0, 0xFF,
  0x7F, 0x83, 0xF9, 0xFE, 0x0F, 0xE7, 0xF8, 0x3F, 0x9F, 0xC0, 0xFC, 0x7F,
  0x03, 0xF1, 0xFC, 0x0F, 0xC7, 0xE0, 0x3E, 0x1F, 0x80, 0xF8, 0x7E, 0x03,
  0xE1, 0xF8, 0x0F, 0x07, 0xC0, 0x3C, 0x1F, 0x00, 0x07, 0xC0, 0x0F, 0xC1,
  0xF0, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x03, 0xE0, 0x7E,
  0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC7, 0xE0, 0x00, 0xF9,
  0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0x9F,
  0x00, 0x07, 0xE7, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x7E,
  0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x0F, 0x83,
  0xF0, 0x03, 0xE0, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xBE, 0x00, 0xFC, 0xF8,
  0x07, 0xC7, 0xC0, 0x7E, 0x3E, 0x03, 0xE1, 0xF0, 0x3E, 0x07, 0xC3, 0xF0,
  0x3E, 0x1F, 0x01, 0xF1, 0xF0, 0x07, 0x8F, 0x80, 0x3E, 0xF8, 0x01, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xC0, 0x1F,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x00, 0xF8, 0x3E, 0x07,
  0x81, 0xE0, 0x78, 0x1F, 0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8,
  0x3E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3E, 0x0F, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xF0, 0x03,
  0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0,
  0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x80, 0x77, 0x01, 0xEE, 0x07, 0x9E, 0x0F, 0x3C, 0x3C,
  0x38, 0x78, 0x71, 0xE0, 0xF3, 0xC1, 0xEF, 0x03, 0xFE, 0x03, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFC, 0x3C, 0x3E, 0x1E,
  0x0F, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE1, 0xF0,
  0x7E, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x7F, 0xE0, 0xFF,
  0xF8, 0x7F, 0xFF, 0x1F, 0xE3, 0xE7, 0xE0, 0x7C, 0xF8, 0x0F, 0xBE, 0x01,
  0xF7, 0xC0, 0x7C, 0xFC, 0x1F, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF,
  0xC1, 0xFC, 0xF8, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x3E,
  0x03, 0xEF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xF8, 0x7E, 0x3E, 0x07,
  0xCF, 0x80, 0xF9, 0xF0, 0x0F, 0x3E, 0x01, 0xE7, 0xC0, 0x3C, 0xF0, 0x07,
  0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x01, 0xF3, 0xE0, 0x3E,
  0x7E, 0x0F, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7D, 0xFF, 0x0F, 0x1F, 0xC0,
  0x01, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0x0F, 0xCF,
  0x81, 0xF7, 0xC0, 0x3D, 0xF0, 0x0F, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0xFB, 0xE0, 0x3E,
  0x7C, 0x1F, 0x1F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xF3, 0xE0,
  0x3F, 0xDF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xF0, 0xFE, 0x3F, 0x03,
  0xF1, 0xF0, 0x0F, 0x0F, 0x80, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E,
  0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x78, 0x7C, 0x07, 0xC3, 0xE0, 0x3E,
  0x1F, 0x01, 0xF0, 0xFC, 0x1F, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F,
  0xDE, 0x01, 0xFC, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xFE,
  0x0F, 0xFF, 0xC3, 0xF0, 0xFC, 0x7C, 0x07, 0x9F, 0x00, 0xFB, 0xE0, 0x1F,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x10, 0x7C, 0x07, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x01, 0xFF,
  0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x03, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0xF8, 0x1F, 0xF7, 0x81, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE1, 0xF8, 0x7F, 0x1F, 0x81, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3C, 0x7C,
  0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E,
  0x3E, 0x01, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7E, 0x0F, 0xC1, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xEF, 0x00, 0xFE, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x0C, 0x03, 0xE0, 0x70, 0x3F, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0x00, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x1F, 0x01, 0xF7, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x1F, 0x87, 0xE3, 0xF0, 0x3E, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E,
  0x01, 0xE3, 0xE0, 0x1E, 0x3C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7,
  0xC0, 0x3E, 0x7C, 0x03, 0xC7, 0xC0, 0x7C, 0x78, 0x07, 0xCF, 0x80, 0x7C,
  0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0x80, 0x00, 0x0C, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0x00, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x01, 0xFC, 0x7C,
  0x0F, 0xC1, 0xF0, 0x7E, 0x07, 0xC3, 0xF0, 0x1E, 0x1F, 0x80, 0x78, 0xFC,
  0x03, 0xE7, 0xE0, 0x0F, 0xBF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0x7C, 0x01, 0xF9, 0xF8, 0x07, 0xC3,
  0xE0, 0x1F, 0x0F, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x7E, 0x0F, 0x80, 0xF8,
  0x3E, 0x03, 0xF0, 0xF8, 0x07, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x3C, 0x78, 0x1E,
  0xFD, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF1, 0xF3, 0xF3, 0xE3, 0xE3,
  0xC7, 0xC7, 0x87, 0x8F, 0x8F, 0x1F, 0x1E, 0x1E, 0x3E, 0x3C, 0x7C, 0x78,
  0x78, 0xF8, 0xF0, 0xF1, 0xF1, 0xE3, 0xE3, 0xC3, 0xC7, 0xC7, 0x8F, 0x8F,
  0x0F, 0x1F, 0x1E, 0x3E, 0x3C, 0x3C, 0x7C, 0x78, 0x78, 0xF0, 0xF1, 0xF1,
  0xE1, 0xE3, 0xE3, 0xC7, 0xC7, 0x8F, 0x8F, 0x8F, 0x00, 0x1F, 0x1F, 0x01,
  0xE7, 0xFC, 0x1E, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0x87, 0xE3, 0xF0, 0x3E,
  0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xE3, 0xE0, 0x3E, 0x3C, 0x03,
  0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xC7, 0xC0,
  0x7C, 0x78, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8,
  0x07, 0x80, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3,
  0xF0, 0xFC, 0xFC, 0x0F, 0x9F, 0x01, 0xF3, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xEF, 0x00, 0x7D, 0xF0, 0x0F, 0xBE,
  0x01, 0xF7, 0xC0, 0x7C, 0xFC, 0x1F, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F,
  0xFE, 0x00, 0xFF, 0x00, 0x07, 0xCF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x7E, 0x1F, 0x87, 0xE0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0,
  0x1F, 0x0F, 0x80, 0x78, 0x7C, 0x03, 0xC3, 0xC0, 0x3E, 0x3E, 0x01, 0xF1,
  0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x03,
  0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xE7, 0xF0, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF1, 0xE0,
  0xFF, 0xBC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF3, 0xF0, 0xFE, 0xFC, 0x0F, 0xDF,
  0x00, 0xF3, 0xE0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C,
  0x03, 0xEF, 0x80, 0x79, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xFC,
  0x1F, 0x8F, 0xFF, 0xF1, 0xFF, 0xFC, 0x1F, 0xF7, 0x81, 0xFD, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x0F, 0x8F, 0xE1, 0xE7, 0xFC, 0x3D,
  0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xC0, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0xFF,
  0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE3, 0xE0, 0x7C, 0x7C, 0x07, 0xCF, 0x00,
  0xF9, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x1F, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xF8, 0x0F,
  0x9F, 0x87, 0xF1, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0xFF, 0xF7,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x3E, 0x01, 0xF3,
  0xE0, 0x1F, 0x3E, 0x01, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xC0, 0x3E,
  0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07,
  0xC7, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x78, 0xF8, 0x0F, 0x8F, 0x80,
  0xF8, 0x7C, 0x1F, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFE, 0xF0, 0x1F,
  0xCF, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x3E, 0xF8, 0x03, 0xE7, 0x80, 0x7C,
  0x78, 0x07, 0xC7, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xC1, 0xF0, 0x3C, 0x1E,
  0x03, 0xC3, 0xE0, 0x3C, 0x3C, 0x03, 0xE7, 0xC0, 0x1E, 0x78, 0x01, 0xEF,
  0x80, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x70, 0x7F, 0xC1, 0xC1,
  0xEF, 0x0F, 0x0F, 0xBC, 0x3C, 0x3C, 0xF0, 0xF0, 0xF3, 0xC7, 0xC7, 0xCF,
  0x1F, 0x9E, 0x3C, 0x7E, 0x78, 0xF3, 0xB9, 0xE3, 0xCE, 0xEF, 0x0F, 0x73,
  0xBC, 0x3D, 0xCE, 0xF0, 0xF7, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8,
  0x3F, 0x8F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E,
  0x0F, 0x80, 0xF8, 0x3C, 0x00, 0x0F, 0x80, 0x7E, 0x1F, 0x00, 0xF8, 0x1F,
  0x03, 0xE0, 0x3E, 0x0F, 0x80, 0x3E, 0x3F, 0x00, 0x7C, 0xFC, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0,
  0x07, 0xE7, 0xC0, 0x0F, 0x8F, 0x80, 0x3E, 0x0F, 0x80, 0xF8, 0x0F, 0x83,
  0xF0, 0x1F, 0x0F, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x3E,
  0x1F, 0x00, 0x7E, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0xFC, 0x0F, 0x80, 0xF8,
  0x0F, 0x81, 0xF0, 0x07, 0x81, 0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0,
  0x07, 0xC7, 0xC0, 0x03, 0xCF, 0x80, 0x03, 0xCF, 0x80, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xE2, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0xFC, 0x03, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0xFF,
  0x01, 0xF8, 0x03, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x3C,
  0x00, 0x18, 0x00, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x3C, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x00, 0x07, 0x00, 0x0F, 0x80,
  0x1F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF0, 0x0F, 0xE0, 0x3F, 0x00,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x07, 0x80, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x7F, 0x00, 0xC3,
  0xFF, 0x03, 0xDF, 0xFE, 0x1E, 0x7D, 0xFC, 0xF9, 0xC1, 0xFF, 0xEF, 0x03,
  0xFF, 0x08, 0x03, 0xF8, 0x00, 0x03, 0x80,
};

const GFXglyph RobotoMono_SemiBoldItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 9, 28, 23, 7, -28 },
  { 33, 12, 10, 23, 7, -29 },
  { 48, 23, 28, 23, 0, -28 },
  { 129, 20, 36, 23, 2, -32 },
  { 219, 19, 28, 23, 2, -28 },
  { 286, 21, 28, 23, 1, -28 },
  { 360, 5, 10, 23, 10, -29 },
  { 367, 13, 40, 23, 6, -31 },
  { 432, 13, 40, 23, 3, -31 },
  { 497, 19, 20, 23, 3, -28 },
  { 545, 19, 20, 23, 2, -23 },
  { 593, 8, 12, 23, 4, -5 },
  { 605, 16, 4, 23, 5, -14 },
  { 613, 6, 6, 23, 7, -6 },
  { 618, 20, 30, 23, 2, -28 },
  { 693, 19, 28, 23, 2, -28 },
  { 760, 13, 28, 23, 5, -28 },
  { 806, 21, 28, 23, 0, -28 },
  { 880, 20, 28, 23, 1, -28 },
  { 950, 21, 28, 23, 0, -28 },
  { 1024, 20, 28, 23, 2, -28 },
  { 1094, 18, 28, 23, 2, -28 },
  { 1157, 20, 28, 23, 3, -28 },
  { 1227, 20, 28, 23, 1, -28 },
  { 1297, 18, 28, 23, 3, -28 },
  { 1360, 10, 22, 23, 7, -22 },
  { 1388, 12, 29, 23, 5, -22 },
  { 1432, 18, 18, 23, 3, -21 },
  { 1473, 19, 12, 23, 2, -18 },
  { 1502, 18, 18, 23, 2, -21 },
  { 1543, 17, 28, 23, 5, -28 },
  { 1603, 22, 28, 23, 1, -28 },
  { 1680, 21, 28, 23, -1, -28 },
  { 1754, 22, 28, 23, 1, -28 },
  { 1831, 21, 28, 23, 1, -28 },
  { 1905, 22, 28, 23, 0, -28 },
  { 1982, 22, 28, 23, 1, -28 },
  { 2059, 23, 28, 23, 1, -28 },
  { 2140, 20, 28, 23, 2, -28 },
  { 2210, 23, 28, 23, 0, -28 },
  { 2291, 21, 28, 23, 1, -28 },
  { 2365, 22, 28, 23, 1, -28 },
  { 2442, 25, 28, 23, 1, -28 },
  { 2530, 18, 28, 23, 1, -28 },
  { 2593, 23, 28, 23, 0, -28 },
  { 2674, 23, 28, 23, 0, -28 },
  { 2755, 21, 28, 23, 1, -28 },
  { 2829, 22, 28, 23, 1, -28 },
  { 2906, 21, 33, 23, 1, -28 },
  { 2993, 22, 28, 23, 1, -28 },
  { 3070, 22, 28, 23, 1, -28 },
  { 3147, 22, 28, 23, 3, -28 },
  { 3224, 21, 28, 23, 2, -28 },
  { 3298, 22, 28, 23, 3, -28 },
  { 3375, 22, 28, 23, 3, -28 },
  { 3452, 26, 28, 23, -1, -28 },
  { 3543, 21, 28, 23, 4, -28 },
  { 3617, 23, 28, 23, 0, -28 },
  { 3698, 14, 38, 23, 5, -32 },
  { 3765, 10, 30, 23, 7, -28 },
  { 3803, 14, 38, 23, 5, -32 },
  { 3870, 15, 15, 23, 4, -28 },
  { 3899, 18, 4, 23, 0, 0 },
  { 3908, 8, 5, 23, 10, -28 },
  { 3913, 19, 21, 23, 1, -21 },
  { 3963, 19, 29, 23, 1, -29 },
  { 4032, 18, 21, 23, 2, -21 },
  { 4080, 21, 29, 23, 2, -29 },
  { 4157, 19, 21, 23, 2, -21 },
  { 4207, 21, 30, 23, 3, -30 },
  { 4286, 21, 29, 23, 1, -21 },
  { 4363, 20, 29, 23, 1, -29 },
  { 4436, 17, 29, 23, 2, -29 },
  { 4498, 18, 37, 23, 1, -29 },
  { 4582, 22, 29, 23, 1, -29 },
  { 4662, 17, 29, 23, 2, -29 },
  { 4724, 23, 21, 23, -1, -21 },
  { 4785, 20, 21, 23, 1, -21 },
  { 4838, 19, 21, 23, 2, -21 },
  { 4888, 21, 29, 23, -1, -21 },
  { 4965, 19, 29, 23, 2, -21 },
  { 5034, 19, 21, 23, 3, -21 },
  { 5084, 19, 21, 23, 2, -21 },
  { 5134, 18, 26, 23, 3, -26 },
  { 5193, 20, 21, 23, 2, -21 },
  { 5246, 20, 21, 23, 3, -21 },
  { 5299, 22, 21, 23, 2, -21 },
  { 5357, 23, 21, 23, 0, -21 },
  { 5418, 24, 29, 23, 0, -21 },
  { 5505, 21, 21, 23, 1, -21 },
  { 5561, 15, 37, 23, 6, -30 },
  { 5631, 9, 36, 23, 7, -28 },
  { 5672, 15, 37, 23, 4, -30 },
  { 5742, 22, 9, 23, 0, -16 },
};

const GFXfont RobotoMono_SemiBoldItalic39pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic39pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic39pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC39PT7B_H_
