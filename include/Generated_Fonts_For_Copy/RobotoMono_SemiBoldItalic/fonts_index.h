#pragma once

// Auto-generated by fontMaker.py
#include <TFT_eSPI.h>

struct FontEntry
{
  const GFXfont *font;
  uint16_t sizePt;
  const char *name;
};

// Includes are in all_fonts.h (include that before this file)
static const FontEntry kFonts[] = {
  { &RobotoMono_SemiBoldItalic6pt7b, 6, "RobotoMono_SemiBoldItalic6pt7b" },
  { &RobotoMono_SemiBoldItalic7pt7b, 7, "RobotoMono_SemiBoldItalic7pt7b" },
  { &RobotoMono_SemiBoldItalic8pt7b, 8, "RobotoMono_SemiBoldItalic8pt7b" },
  { &RobotoMono_SemiBoldItalic9pt7b, 9, "RobotoMono_SemiBoldItalic9pt7b" },
  { &RobotoMono_SemiBoldItalic10pt7b, 10, "RobotoMono_SemiBoldItalic10pt7b" },
  { &RobotoMono_SemiBoldItalic11pt7b, 11, "RobotoMono_SemiBoldItalic11pt7b" },
  { &RobotoMono_SemiBoldItalic12pt7b, 12, "RobotoMono_SemiBoldItalic12pt7b" },
  { &RobotoMono_SemiBoldItalic13pt7b, 13, "RobotoMono_SemiBoldItalic13pt7b" },
  { &RobotoMono_SemiBoldItalic14pt7b, 14, "RobotoMono_SemiBoldItalic14pt7b" },
  { &RobotoMono_SemiBoldItalic15pt7b, 15, "RobotoMono_SemiBoldItalic15pt7b" },
  { &RobotoMono_SemiBoldItalic16pt7b, 16, "RobotoMono_SemiBoldItalic16pt7b" },
  { &RobotoMono_SemiBoldItalic17pt7b, 17, "RobotoMono_SemiBoldItalic17pt7b" },
  { &RobotoMono_SemiBoldItalic18pt7b, 18, "RobotoMono_SemiBoldItalic18pt7b" },
  { &RobotoMono_SemiBoldItalic19pt7b, 19, "RobotoMono_SemiBoldItalic19pt7b" },
  { &RobotoMono_SemiBoldItalic20pt7b, 20, "RobotoMono_SemiBoldItalic20pt7b" },
  { &RobotoMono_SemiBoldItalic21pt7b, 21, "RobotoMono_SemiBoldItalic21pt7b" },
  { &RobotoMono_SemiBoldItalic22pt7b, 22, "RobotoMono_SemiBoldItalic22pt7b" },
  { &RobotoMono_SemiBoldItalic23pt7b, 23, "RobotoMono_SemiBoldItalic23pt7b" },
  { &RobotoMono_SemiBoldItalic24pt7b, 24, "RobotoMono_SemiBoldItalic24pt7b" },
  { &RobotoMono_SemiBoldItalic25pt7b, 25, "RobotoMono_SemiBoldItalic25pt7b" },
  { &RobotoMono_SemiBoldItalic26pt7b, 26, "RobotoMono_SemiBoldItalic26pt7b" },
  { &RobotoMono_SemiBoldItalic27pt7b, 27, "RobotoMono_SemiBoldItalic27pt7b" },
  { &RobotoMono_SemiBoldItalic28pt7b, 28, "RobotoMono_SemiBoldItalic28pt7b" },
  { &RobotoMono_SemiBoldItalic29pt7b, 29, "RobotoMono_SemiBoldItalic29pt7b" },
  { &RobotoMono_SemiBoldItalic30pt7b, 30, "RobotoMono_SemiBoldItalic30pt7b" },
  { &RobotoMono_SemiBoldItalic31pt7b, 31, "RobotoMono_SemiBoldItalic31pt7b" },
  { &RobotoMono_SemiBoldItalic32pt7b, 32, "RobotoMono_SemiBoldItalic32pt7b" },
  { &RobotoMono_SemiBoldItalic33pt7b, 33, "RobotoMono_SemiBoldItalic33pt7b" },
  { &RobotoMono_SemiBoldItalic34pt7b, 34, "RobotoMono_SemiBoldItalic34pt7b" },
  { &RobotoMono_SemiBoldItalic35pt7b, 35, "RobotoMono_SemiBoldItalic35pt7b" },
  { &RobotoMono_SemiBoldItalic36pt7b, 36, "RobotoMono_SemiBoldItalic36pt7b" },
  { &RobotoMono_SemiBoldItalic37pt7b, 37, "RobotoMono_SemiBoldItalic37pt7b" },
  { &RobotoMono_SemiBoldItalic38pt7b, 38, "RobotoMono_SemiBoldItalic38pt7b" },
  { &RobotoMono_SemiBoldItalic39pt7b, 39, "RobotoMono_SemiBoldItalic39pt7b" },
  { &RobotoMono_SemiBoldItalic40pt7b, 40, "RobotoMono_SemiBoldItalic40pt7b" },
  { &RobotoMono_SemiBoldItalic41pt7b, 41, "RobotoMono_SemiBoldItalic41pt7b" },
  { &RobotoMono_SemiBoldItalic42pt7b, 42, "RobotoMono_SemiBoldItalic42pt7b" },
  { &RobotoMono_SemiBoldItalic43pt7b, 43, "RobotoMono_SemiBoldItalic43pt7b" },
  { &RobotoMono_SemiBoldItalic44pt7b, 44, "RobotoMono_SemiBoldItalic44pt7b" },
  { &RobotoMono_SemiBoldItalic45pt7b, 45, "RobotoMono_SemiBoldItalic45pt7b" },
  { &RobotoMono_SemiBoldItalic46pt7b, 46, "RobotoMono_SemiBoldItalic46pt7b" },
  { &RobotoMono_SemiBoldItalic47pt7b, 47, "RobotoMono_SemiBoldItalic47pt7b" },
  { &RobotoMono_SemiBoldItalic48pt7b, 48, "RobotoMono_SemiBoldItalic48pt7b" },
  { &RobotoMono_SemiBoldItalic49pt7b, 49, "RobotoMono_SemiBoldItalic49pt7b" },
  { &RobotoMono_SemiBoldItalic50pt7b, 50, "RobotoMono_SemiBoldItalic50pt7b" },
  { &RobotoMono_SemiBoldItalic51pt7b, 51, "RobotoMono_SemiBoldItalic51pt7b" },
  { &RobotoMono_SemiBoldItalic52pt7b, 52, "RobotoMono_SemiBoldItalic52pt7b" },
  { &RobotoMono_SemiBoldItalic53pt7b, 53, "RobotoMono_SemiBoldItalic53pt7b" },
  { &RobotoMono_SemiBoldItalic54pt7b, 54, "RobotoMono_SemiBoldItalic54pt7b" },
  { &RobotoMono_SemiBoldItalic55pt7b, 55, "RobotoMono_SemiBoldItalic55pt7b" },
  { &RobotoMono_SemiBoldItalic56pt7b, 56, "RobotoMono_SemiBoldItalic56pt7b" },
  { &RobotoMono_SemiBoldItalic57pt7b, 57, "RobotoMono_SemiBoldItalic57pt7b" },
  { &RobotoMono_SemiBoldItalic58pt7b, 58, "RobotoMono_SemiBoldItalic58pt7b" },
  { &RobotoMono_SemiBoldItalic59pt7b, 59, "RobotoMono_SemiBoldItalic59pt7b" },
  { &RobotoMono_SemiBoldItalic60pt7b, 60, "RobotoMono_SemiBoldItalic60pt7b" },
  { &RobotoMono_SemiBoldItalic61pt7b, 61, "RobotoMono_SemiBoldItalic61pt7b" },
  { &RobotoMono_SemiBoldItalic62pt7b, 62, "RobotoMono_SemiBoldItalic62pt7b" },
  { &RobotoMono_SemiBoldItalic63pt7b, 63, "RobotoMono_SemiBoldItalic63pt7b" },
  { &RobotoMono_SemiBoldItalic64pt7b, 64, "RobotoMono_SemiBoldItalic64pt7b" },
  { &RobotoMono_SemiBoldItalic65pt7b, 65, "RobotoMono_SemiBoldItalic65pt7b" },
  { &RobotoMono_SemiBoldItalic66pt7b, 66, "RobotoMono_SemiBoldItalic66pt7b" },
  { &RobotoMono_SemiBoldItalic67pt7b, 67, "RobotoMono_SemiBoldItalic67pt7b" },
  { &RobotoMono_SemiBoldItalic68pt7b, 68, "RobotoMono_SemiBoldItalic68pt7b" },
  { &RobotoMono_SemiBoldItalic69pt7b, 69, "RobotoMono_SemiBoldItalic69pt7b" },
  { &RobotoMono_SemiBoldItalic70pt7b, 70, "RobotoMono_SemiBoldItalic70pt7b" },
  { &RobotoMono_SemiBoldItalic71pt7b, 71, "RobotoMono_SemiBoldItalic71pt7b" },
  { &RobotoMono_SemiBoldItalic72pt7b, 72, "RobotoMono_SemiBoldItalic72pt7b" },
};
static constexpr size_t kFontCount = sizeof(kFonts) / sizeof(kFonts[0]);
