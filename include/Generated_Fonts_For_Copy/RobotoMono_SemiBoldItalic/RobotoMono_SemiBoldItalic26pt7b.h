#ifndef _ROBOTOMONO_SEMIBOLDITALIC26PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0xF3, 0x8E, 0x38, 0xE3, 0x9E, 0x71, 0xC7, 0x1C, 0x00, 0x00,
  0x38, 0xE3, 0x80, 0x73, 0xB9, 0xDC, 0xCC, 0x66, 0x33, 0x1B, 0x9C, 0x01,
  0xCE, 0x03, 0x18, 0x06, 0x60, 0x18, 0xC0, 0x31, 0x87, 0xFF, 0xCF, 0xFF,
  0x83, 0x18, 0x0E, 0x60, 0x18, 0xC0, 0x33, 0x87, 0xFF, 0xCF, 0xFF, 0x83,
  0x38, 0x0E, 0x60, 0x18, 0xC0, 0x33, 0x80, 0xC6, 0x00, 0x00, 0xC0, 0x03,
  0x00, 0x1C, 0x03, 0xFC, 0x1F, 0xF8, 0x78, 0xE3, 0xC3, 0xCE, 0x0F, 0x3C,
  0x00, 0x70, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0x3C,
  0x1C, 0xF0, 0x71, 0xC1, 0xC7, 0xDF, 0x0F, 0xF8, 0x1F, 0x80, 0x18, 0x00,
  0x60, 0x03, 0x00, 0x38, 0x07, 0xC0, 0xEE, 0x0C, 0xE6, 0xCE, 0x6C, 0xCC,
  0xFD, 0x87, 0xB8, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xDC, 0x1B, 0xF3, 0x73,
  0x76, 0x36, 0x63, 0x26, 0x30, 0x7E, 0x03, 0xC0, 0x01, 0xC0, 0x0F, 0xE0,
  0x3F, 0xC0, 0x73, 0x80, 0xE3, 0x81, 0x8E, 0x03, 0xBC, 0x07, 0xF0, 0x0F,
  0xC0, 0x1E, 0x00, 0x7E, 0x39, 0xFC, 0x77, 0x9D, 0xCE, 0x3F, 0x9C, 0x3E,
  0x38, 0x7C, 0x79, 0xF0, 0xFF, 0xF0, 0x7E, 0xF0, 0x7F, 0xFD, 0xB0, 0x00,
  0x81, 0xC1, 0xC1, 0xC0, 0xE0, 0xE0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x03, 0x01,
  0x80, 0xE0, 0x38, 0x0C, 0x02, 0x00, 0x08, 0x06, 0x03, 0x80, 0xC0, 0x70,
  0x18, 0x0C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0E,
  0x07, 0x03, 0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x70, 0x20,
  0x00, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x86, 0x27, 0xBF, 0x7F, 0xFC, 0x3E,
  0x01, 0xE0, 0x1B, 0x81, 0xCC, 0x1C, 0x70, 0x41, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00,
  0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0x1C, 0xF3, 0x8E, 0x39, 0xCF,
  0x18, 0xFF, 0xFF, 0xF8, 0x77, 0xFE, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x07,
  0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0x07, 0x81, 0xFE, 0x3F, 0xE3, 0x8F,
  0x70, 0x77, 0x07, 0x70, 0x7F, 0x0F, 0xE3, 0xFE, 0x77, 0xFE, 0xFF, 0x8E,
  0xF0, 0xEE, 0x0E, 0xE0, 0xEE, 0x1C, 0xF3, 0xC7, 0xF8, 0x3F, 0x00, 0x03,
  0x8F, 0x9F, 0xDF, 0xEC, 0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x1E, 0x00, 0x01, 0xC0, 0x1F, 0xC1,
  0xFF, 0x87, 0x0E, 0x3C, 0x3C, 0xE0, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x7F, 0xFB, 0xFF, 0xCF, 0xFF, 0x00, 0x03, 0x80, 0x7F, 0x87, 0xFC, 0x78,
  0xF3, 0x83, 0xA0, 0x1C, 0x00, 0xE0, 0x0E, 0x07, 0xE0, 0x7E, 0x03, 0xF8,
  0x01, 0xE0, 0x07, 0x00, 0x3B, 0x81, 0xDC, 0x1C, 0xFB, 0xE3, 0xFE, 0x0F,
  0xE0, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x7E, 0x03, 0xB8, 0x1F, 0xE0,
  0x77, 0x03, 0x9C, 0x1C, 0x70, 0xE1, 0xC7, 0x8F, 0x1F, 0xFF, 0xFF, 0xFB,
  0xFF, 0xE0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x0F, 0xFC, 0x7F,
  0xE1, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0xFC, 0x0F, 0xF8, 0x7D,
  0xF0, 0x41, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x73, 0x81, 0xCF, 0x0F, 0x1E,
  0x78, 0x7F, 0xC0, 0x7E, 0x00, 0x00, 0x20, 0x3E, 0x07, 0xE0, 0xF8, 0x1E,
  0x03, 0xC0, 0x38, 0x07, 0x7C, 0x7F, 0xE7, 0xDF, 0x70, 0x7F, 0x07, 0xE0,
  0x7E, 0x07, 0xF0, 0x77, 0x0E, 0x79, 0xE3, 0xFC, 0x1F, 0x80, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x03,
  0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00,
  0x70, 0x07, 0x80, 0x00, 0x03, 0x80, 0x7F, 0x87, 0xFC, 0x78, 0xF3, 0x83,
  0x9C, 0x1C, 0xE0, 0xE7, 0x8E, 0x1F, 0xE0, 0x7E, 0x0F, 0xF8, 0xF1, 0xEF,
  0x07, 0x70, 0x3B, 0x81, 0xDE, 0x1E, 0xF9, 0xE3, 0xFE, 0x0F, 0xE0, 0x07,
  0x01, 0xFC, 0x3F, 0xE7, 0x8E, 0x70, 0xFF, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0xFF, 0x0E, 0x7F, 0xE7, 0xFE, 0x1E, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x7F,
  0x07, 0xE0, 0x78, 0x00, 0x38, 0xF7, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0xF3, 0xCF, 0x00, 0x0F, 0x0F, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x70, 0x70, 0xE0,
  0x00, 0x30, 0x0F, 0x07, 0xF1, 0xFE, 0x7F, 0x0F, 0x80, 0xF0, 0x0F, 0xE0,
  0x3F, 0x80, 0x7C, 0x01, 0xC0, 0x04, 0x3F, 0xFB, 0xFF, 0xDF, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF9, 0xFF, 0xDF, 0xFE, 0x20, 0x03, 0x80, 0x3E, 0x01,
  0xFC, 0x07, 0xF0, 0x0F, 0x01, 0xF0, 0xFF, 0x7F, 0x8F, 0xE0, 0xF0, 0x0C,
  0x00, 0x0F, 0x03, 0xFC, 0x7F, 0xE7, 0x0E, 0xF0, 0xF0, 0x0E, 0x00, 0xE0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x38, 0x03, 0x80, 0x38, 0x00, 0x07, 0xF0, 0x3F, 0xE1, 0xC1, 0x8C,
  0x23, 0x73, 0xED, 0x9D, 0xB6, 0xC4, 0xF3, 0x33, 0xDC, 0xCF, 0x63, 0x2D,
  0x8C, 0xB6, 0x66, 0xDF, 0xF3, 0x3B, 0x8C, 0x00, 0x38, 0x20, 0x7F, 0x80,
  0x7C, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0xC0, 0x1F, 0x80,
  0x77, 0x00, 0xEE, 0x03, 0x9C, 0x07, 0x38, 0x1C, 0x70, 0x38, 0x70, 0xFF,
  0xE1, 0xFF, 0xC7, 0xFF, 0x8E, 0x07, 0x3C, 0x0E, 0x70, 0x1D, 0xE0, 0x3C,
  0x1F, 0xF8, 0x3F, 0xF8, 0x70, 0xF8, 0xE0, 0x71, 0xC0, 0xE3, 0x83, 0xCF,
  0x07, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xF0, 0xE0, 0xF3, 0xC0, 0xE7, 0x81,
  0xCE, 0x07, 0x9C, 0x0E, 0x3F, 0xFC, 0x7F, 0xF1, 0xFF, 0x80, 0x03, 0xC0,
  0x3F, 0xC1, 0xFF, 0x8F, 0x0E, 0x38, 0x3D, 0xE0, 0x77, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x81, 0xEE, 0x07,
  0x3C, 0x3C, 0x79, 0xE0, 0xFF, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xF0,
  0x71, 0xE0, 0xE1, 0xE1, 0xC1, 0xC7, 0x83, 0x8F, 0x07, 0x1C, 0x0E, 0x38,
  0x1C, 0x70, 0x38, 0xE0, 0x73, 0xC1, 0xE7, 0x83, 0x8E, 0x0F, 0x1C, 0x3C,
  0x3F, 0xF0, 0x7F, 0xC1, 0xFE, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0xF0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF,
  0xE1, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x7F, 0xF8,
  0xFF, 0xF1, 0xFF, 0xE0, 0x1F, 0xFE, 0x7F, 0xF8, 0xF0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x7F, 0xF0, 0xFF, 0xE1, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x3F, 0xC1, 0xFF, 0x8F, 0x0E, 0x38, 0x3D, 0xE0,
  0x77, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x1F, 0xB8, 0xFE, 0xE0,
  0x7B, 0x81, 0xEF, 0x07, 0x1C, 0x1C, 0x7D, 0xF0, 0xFF, 0x81, 0xFC, 0x00,
  0x1E, 0x0E, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0xF1, 0xC1, 0xC7, 0x83, 0x8E,
  0x07, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xE0, 0xE3, 0xC1, 0xC7, 0x03,
  0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x3C, 0xF0, 0x71, 0xE0, 0xE0, 0x1F, 0xFC,
  0x7F, 0xE0, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0,
  0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0x73, 0x83, 0xCE, 0x0E, 0x3E, 0xF8, 0x7F, 0xC0,
  0xFE, 0x00, 0x1E, 0x0F, 0x8E, 0x0F, 0x07, 0x0F, 0x03, 0x8F, 0x01, 0xCF,
  0x00, 0xE7, 0x80, 0xF7, 0x80, 0x77, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF8, 0x0F, 0x9C, 0x07, 0x8F, 0x03, 0x87, 0x81, 0xC1, 0xC0, 0xE0, 0xF0,
  0x70, 0x38, 0x78, 0x1E, 0x00, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0x1F, 0x1F, 0x1E,
  0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x7E, 0x3B, 0x6E, 0x3B, 0xEC, 0x3B, 0xDC,
  0x3B, 0xDC, 0x3B, 0x9C, 0x3B, 0x9C, 0x73, 0x1C, 0x70, 0x38, 0x70, 0x38,
  0x70, 0x38, 0x70, 0x38, 0x70, 0x38, 0xE0, 0x78, 0x1E, 0x0E, 0x3C, 0x1C,
  0x78, 0x38, 0xF8, 0xF1, 0xF1, 0xC7, 0xE3, 0x8E, 0xC7, 0x1D, 0xCE, 0x3B,
  0x9C, 0x73, 0x78, 0xE7, 0xE3, 0xCF, 0xC7, 0x1F, 0x8E, 0x1F, 0x1C, 0x3E,
  0x38, 0x7C, 0xF0, 0x71, 0xE0, 0xE0, 0x03, 0x80, 0x3F, 0xC1, 0xFF, 0x0F,
  0x1E, 0x38, 0x39, 0xE0, 0xF7, 0x03, 0xDC, 0x0F, 0x70, 0x3F, 0xC0, 0xEE,
  0x03, 0xB8, 0x0E, 0xE0, 0x3B, 0x81, 0xEE, 0x07, 0x3C, 0x3C, 0x7F, 0xE0,
  0xFF, 0x01, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0xE3, 0xC3, 0xCE, 0x07, 0x38,
  0x1C, 0xE0, 0x73, 0x81, 0xDE, 0x0F, 0x7F, 0xF9, 0xFF, 0xC7, 0xFC, 0x1C,
  0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x3F, 0xC1, 0xFF, 0x0F, 0x1E, 0x38, 0x39, 0xE0, 0xF7, 0x03,
  0xDC, 0x0F, 0x70, 0x3F, 0xC0, 0xFF, 0x03, 0xB8, 0x0E, 0xE0, 0x3B, 0x81,
  0xEE, 0x07, 0x3C, 0x3C, 0x7F, 0xE0, 0xFF, 0x01, 0xFE, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0x80, 0x1F, 0xF8, 0x3F, 0xF8, 0x70, 0xF8, 0xE0, 0xF1, 0xC0,
  0xE3, 0x81, 0xCF, 0x07, 0x9C, 0x1E, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0x81,
  0xC7, 0x07, 0x8F, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x3C, 0x70, 0x79, 0xE0,
  0x70, 0x03, 0xC0, 0x3F, 0xC1, 0xFF, 0x8F, 0x0F, 0x38, 0x1C, 0xE0, 0x73,
  0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x3C, 0x00, 0x7B,
  0x80, 0xEE, 0x03, 0xBC, 0x1E, 0x7D, 0xF1, 0xFF, 0x81, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x3C, 0x1C, 0xE0,
  0x73, 0x81, 0xCE, 0x07, 0x38, 0x3D, 0xE0, 0xE7, 0x83, 0x9C, 0x0E, 0x70,
  0x39, 0xC0, 0xE7, 0x07, 0xBC, 0x1C, 0xF0, 0x73, 0xC1, 0xC7, 0x0F, 0x1E,
  0xF8, 0x3F, 0xC0, 0x7E, 0x00, 0xF0, 0x3F, 0xC0, 0xF7, 0x03, 0x9C, 0x1E,
  0x70, 0x71, 0xC3, 0xC7, 0x0E, 0x1E, 0x78, 0x79, 0xC0, 0xE7, 0x03, 0xB8,
  0x0E, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x1E, 0x00, 0x70,
  0x00, 0xE3, 0x1F, 0xCE, 0x3B, 0x9C, 0x77, 0x39, 0xCE, 0x73, 0x9D, 0xE7,
  0x3B, 0xCE, 0x77, 0xB8, 0xFF, 0x71, 0xF6, 0xE3, 0xED, 0x87, 0xDF, 0x0F,
  0x3E, 0x1E, 0x7C, 0x3C, 0xF0, 0x71, 0xE0, 0xE3, 0xC1, 0xC7, 0x00, 0x1E,
  0x07, 0xC3, 0xC3, 0xC0, 0x70, 0xE0, 0x1C, 0x78, 0x07, 0xBC, 0x00, 0xEE,
  0x00, 0x3F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x1D, 0xC0, 0x0F, 0x70, 0x07, 0x9E, 0x01, 0xE3, 0x80, 0xF0, 0xF0, 0x78,
  0x1C, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0xE0, 0x79, 0xE1, 0xE1, 0xC3, 0x83,
  0x8F, 0x07, 0x1C, 0x0F, 0x70, 0x0F, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x80, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF0,
  0x0F, 0xC3, 0xE0, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x03, 0xF0, 0xFC, 0x00, 0xE3, 0x8E, 0x18, 0x71,
  0xC7, 0x1C, 0x70, 0xC3, 0x8E, 0x38, 0xE3, 0x86, 0x1C, 0x71, 0xC7, 0x0F,
  0xC3, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x70,
  0x1C, 0x07, 0x01, 0xC3, 0xF0, 0xFC, 0x00, 0x07, 0x03, 0xC0, 0xF0, 0x7E,
  0x1B, 0x8E, 0x67, 0x19, 0xC7, 0xE1, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xE3, 0x8C, 0x70, 0x0F, 0xC1, 0xFE, 0x3F, 0xF7, 0x87, 0x00, 0x70, 0x07,
  0x3F, 0xF7, 0xFF, 0xF0, 0xFE, 0x0E, 0xE0, 0xEF, 0x3E, 0xFF, 0xE7, 0xEE,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xEF, 0x07,
  0xFC, 0x3F, 0xF3, 0xC3, 0x9C, 0x1E, 0xE0, 0xF7, 0x07, 0xB8, 0x39, 0xC1,
  0xDE, 0x0E, 0xF0, 0xF7, 0xDF, 0x3F, 0xF1, 0xDF, 0x00, 0x07, 0xC0, 0xFF,
  0x0F, 0xFC, 0x70, 0xE7, 0x07, 0xB8, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07,
  0x83, 0x9C, 0x3C, 0xF3, 0xC3, 0xFC, 0x0F, 0xC0, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0xFB, 0x87, 0xFE, 0x3F, 0xF9,
  0xE1, 0xE7, 0x07, 0x9C, 0x1C, 0xF0, 0x73, 0x81, 0xCE, 0x07, 0x3C, 0x3C,
  0xF0, 0xF1, 0xEF, 0x87, 0xFE, 0x0F, 0xB8, 0x07, 0xC0, 0xFF, 0x0F, 0xFC,
  0x70, 0xE7, 0x03, 0xB8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x1C,
  0x08, 0xF9, 0xE3, 0xFE, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1,
  0xE0, 0x0F, 0x00, 0x38, 0x07, 0xFF, 0x3F, 0xFC, 0xFF, 0xF0, 0x38, 0x01,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x07, 0xDC, 0x3F, 0xF1, 0xFF, 0xCF, 0x0F,
  0x38, 0x1C, 0xE0, 0xF7, 0x83, 0x9E, 0x0E, 0x70, 0x39, 0xE0, 0xE7, 0x87,
  0x8F, 0x7E, 0x3F, 0xF0, 0x7D, 0xC0, 0x07, 0x08, 0x3C, 0x71, 0xE3, 0xFF,
  0x03, 0xF8, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0x70, 0x01, 0xCF, 0x07, 0xFE, 0x3F, 0xF8, 0xF0, 0xF3, 0x83, 0xCE, 0x0F,
  0x38, 0x38, 0xE0, 0xE7, 0x83, 0x9C, 0x0E, 0x70, 0x39, 0xC1, 0xE7, 0x07,
  0xBC, 0x1C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x08, 0x00, 0x01, 0xFC, 0x3F,
  0xC3, 0xF8, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07,
  0x00, 0x70, 0x7F, 0xF7, 0xFE, 0xFF, 0xE0, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x20, 0x00, 0x1F, 0xC3, 0xF0, 0xFE, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70,
  0x1E, 0x3F, 0x87, 0xE0, 0x60, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x83, 0xCE, 0x1E, 0x38, 0xF1, 0xEF, 0x87,
  0x7C, 0x1F, 0xC0, 0x7F, 0x01, 0xFE, 0x0F, 0xB8, 0x3C, 0xF0, 0xE1, 0xC3,
  0x87, 0x8E, 0x0E, 0x38, 0x3C, 0x0F, 0xE1, 0xFE, 0x1F, 0xE0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x3B,
  0xB8, 0xFF, 0xF3, 0xFF, 0xDC, 0xE7, 0x73, 0x9D, 0xCE, 0x77, 0x39, 0xDC,
  0xE7, 0x73, 0x9F, 0x8C, 0x7E, 0x73, 0xB9, 0xCE, 0xE7, 0x3B, 0x9C, 0xE0,
  0x1C, 0xF0, 0x7F, 0xE3, 0xFF, 0x8F, 0x0F, 0x38, 0x3C, 0xE0, 0xF3, 0x83,
  0x8E, 0x0E, 0x78, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x1E, 0x70, 0x73, 0xC1,
  0xC0, 0x07, 0xC0, 0xFF, 0x0F, 0xFC, 0xF0, 0xE7, 0x07, 0xB8, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x77, 0x03, 0xBC, 0x3C, 0xF3, 0xC3, 0xFC, 0x0F, 0xC0,
  0x1D, 0xE0, 0x7F, 0xC1, 0xFF, 0x8F, 0x0E, 0x38, 0x3C, 0xE0, 0xF3, 0x83,
  0xCE, 0x0E, 0x78, 0x39, 0xE0, 0xE7, 0x87, 0x9F, 0x3C, 0x7F, 0xE1, 0xDF,
  0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x0F, 0xB8,
  0xFF, 0xCF, 0xFE, 0xF0, 0xF7, 0x07, 0xB8, 0x3B, 0xC1, 0xDE, 0x0E, 0xE0,
  0x77, 0x87, 0xBC, 0x3C, 0xF3, 0xC7, 0xFE, 0x1F, 0x70, 0x03, 0x80, 0x1C,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x1C, 0xF9, 0xFF, 0x8F, 0xFC, 0x7E, 0x23,
  0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x78, 0x00, 0x07, 0xC0, 0xFF, 0x8F, 0xBC, 0x70, 0xF7, 0x80,
  0x1E, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF0, 0x03, 0xB8, 0x1D, 0xE1, 0xE7,
  0xFE, 0x1F, 0xC0, 0x0F, 0x00, 0xE0, 0x0E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3E, 0xC1, 0xFC, 0x0F, 0xC0, 0x70, 0x7B, 0x83, 0x9C, 0x1D, 0xE0, 0xEE,
  0x07, 0x70, 0x7B, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x79, 0xEF,
  0xCF, 0xFC, 0x3E, 0xE0, 0xE0, 0x3F, 0x03, 0xFC, 0x1C, 0xE1, 0xC7, 0x0E,
  0x38, 0xE1, 0xC7, 0x06, 0x70, 0x3B, 0x81, 0xF8, 0x0F, 0xC0, 0x7C, 0x01,
  0xE0, 0x0E, 0x00, 0xE3, 0x8F, 0xC7, 0x3B, 0x8E, 0x77, 0x3C, 0xEE, 0x7B,
  0x9C, 0xF7, 0x1B, 0x6C, 0x36, 0xF8, 0x79, 0xF0, 0xF3, 0xC1, 0xE7, 0x83,
  0x8F, 0x07, 0x1C, 0x0E, 0x38, 0x00, 0x3C, 0x0E, 0x38, 0x38, 0x78, 0xF0,
  0x73, 0xC0, 0x7F, 0x00, 0xFC, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1D,
  0xC0, 0x73, 0x81, 0xE3, 0x87, 0x87, 0x1E, 0x07, 0x00, 0x38, 0x0F, 0x38,
  0x0E, 0x3C, 0x1E, 0x1C, 0x1C, 0x1C, 0x3C, 0x1C, 0x38, 0x1E, 0x70, 0x0E,
  0xF0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x40,
  0x00, 0x1F, 0xFC, 0xFF, 0xF3, 0xFF, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0xFE, 0x7F, 0xFB,
  0xFF, 0xE0, 0x01, 0xC0, 0xF0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x07, 0x03, 0xC3, 0xC0, 0xE0, 0x3E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x04, 0x00, 0x18, 0xC6,
  0x33, 0x98, 0xC6, 0x31, 0x8C, 0xE6, 0x31, 0x8C, 0x67, 0x31, 0x8C, 0x63,
  0x00, 0x0C, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x78, 0x0F, 0x03, 0xC1, 0xE0, 0xE0, 0x38, 0x0C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x0E, 0x07, 0x83, 0xC0, 0x40, 0x00, 0x3E, 0x0D, 0xFC,
  0x37, 0x7F, 0xF8, 0x7E, 0x00, 0xF0,
};

const GFXglyph RobotoMono_SemiBoldItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 6, 18, 15, 5, -18 },
  { 15, 9, 7, 15, 4, -20 },
  { 23, 15, 18, 15, 0, -18 },
  { 57, 14, 24, 15, 1, -21 },
  { 99, 12, 19, 15, 2, -19 },
  { 128, 15, 19, 15, 0, -19 },
  { 164, 3, 7, 15, 7, -20 },
  { 167, 9, 27, 15, 4, -21 },
  { 198, 9, 27, 15, 2, -21 },
  { 229, 13, 12, 15, 2, -18 },
  { 249, 13, 13, 15, 1, -15 },
  { 271, 6, 8, 15, 2, -3 },
  { 277, 11, 2, 15, 3, -9 },
  { 280, 5, 4, 15, 4, -4 },
  { 283, 14, 20, 15, 1, -18 },
  { 318, 12, 19, 15, 2, -19 },
  { 347, 9, 18, 15, 3, -18 },
  { 368, 14, 19, 15, 0, -19 },
  { 402, 13, 19, 15, 1, -19 },
  { 433, 14, 18, 15, 0, -18 },
  { 465, 14, 18, 15, 1, -18 },
  { 497, 12, 19, 15, 1, -19 },
  { 526, 13, 18, 15, 2, -18 },
  { 556, 13, 19, 15, 1, -19 },
  { 587, 12, 19, 15, 2, -19 },
  { 616, 6, 15, 15, 5, -15 },
  { 628, 8, 20, 15, 3, -15 },
  { 648, 12, 12, 15, 2, -14 },
  { 666, 13, 8, 15, 1, -12 },
  { 679, 12, 12, 15, 1, -14 },
  { 697, 12, 19, 15, 3, -19 },
  { 726, 14, 18, 15, 1, -18 },
  { 758, 15, 18, 15, -1, -18 },
  { 792, 15, 18, 15, 0, -18 },
  { 826, 14, 19, 15, 1, -19 },
  { 860, 15, 18, 15, 0, -18 },
  { 894, 15, 18, 15, 1, -18 },
  { 928, 15, 18, 15, 1, -18 },
  { 962, 14, 19, 15, 1, -19 },
  { 996, 15, 18, 15, 0, -18 },
  { 1030, 14, 18, 15, 1, -18 },
  { 1062, 14, 18, 15, 1, -18 },
  { 1094, 17, 18, 15, 0, -18 },
  { 1133, 12, 18, 15, 1, -18 },
  { 1160, 16, 18, 15, 0, -18 },
  { 1196, 15, 18, 15, 0, -18 },
  { 1230, 14, 19, 15, 1, -19 },
  { 1264, 14, 18, 15, 1, -18 },
  { 1296, 14, 22, 15, 1, -19 },
  { 1335, 15, 18, 15, 0, -18 },
  { 1369, 14, 19, 15, 1, -19 },
  { 1403, 15, 18, 15, 2, -18 },
  { 1437, 14, 18, 15, 1, -18 },
  { 1469, 14, 18, 15, 2, -18 },
  { 1501, 15, 18, 15, 2, -18 },
  { 1535, 18, 18, 15, -1, -18 },
  { 1576, 15, 18, 15, 2, -18 },
  { 1610, 15, 18, 15, 0, -18 },
  { 1644, 10, 25, 15, 3, -21 },
  { 1676, 6, 20, 15, 5, -18 },
  { 1691, 10, 25, 15, 3, -21 },
  { 1723, 10, 9, 15, 3, -18 },
  { 1735, 12, 3, 15, 0, 0 },
  { 1740, 5, 4, 15, 7, -19 },
  { 1743, 12, 14, 15, 1, -14 },
  { 1764, 13, 20, 15, 1, -20 },
  { 1797, 13, 14, 15, 1, -14 },
  { 1820, 14, 20, 15, 1, -20 },
  { 1855, 13, 14, 15, 1, -14 },
  { 1878, 14, 20, 15, 2, -20 },
  { 1913, 14, 19, 15, 0, -14 },
  { 1947, 14, 20, 15, 0, -20 },
  { 1982, 12, 19, 15, 1, -19 },
  { 2011, 11, 25, 15, 1, -19 },
  { 2046, 14, 20, 15, 1, -20 },
  { 2081, 12, 20, 15, 1, -20 },
  { 2111, 14, 14, 15, 0, -14 },
  { 2136, 14, 14, 15, 0, -14 },
  { 2161, 13, 14, 15, 1, -14 },
  { 2184, 14, 19, 15, 0, -14 },
  { 2218, 13, 19, 15, 1, -14 },
  { 2249, 13, 14, 15, 2, -14 },
  { 2272, 13, 14, 15, 1, -14 },
  { 2295, 12, 17, 15, 2, -17 },
  { 2321, 13, 14, 15, 2, -14 },
  { 2344, 13, 14, 15, 2, -14 },
  { 2367, 15, 14, 15, 1, -14 },
  { 2394, 15, 14, 15, 0, -14 },
  { 2421, 16, 20, 15, 0, -14 },
  { 2461, 14, 14, 15, 0, -14 },
  { 2486, 10, 25, 15, 4, -20 },
  { 2518, 5, 23, 15, 5, -18 },
  { 2533, 10, 25, 15, 2, -20 },
  { 2565, 14, 5, 15, 0, -10 },
};

const GFXfont RobotoMono_SemiBoldItalic26pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic26pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic26pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC26PT7B_H_
