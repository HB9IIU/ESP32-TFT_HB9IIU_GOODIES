#ifndef _ROBOTOMONO_SEMIBOLDITALIC53PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F,
  0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x7E, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x07,
  0xE0, 0x3F, 0x00, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xF3,
  0xC0, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3C, 0x0F,
  0x1E, 0x07, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0x81, 0xE0, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x01, 0xF0, 0x78,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0x80,
  0x00, 0x3C, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x07, 0x80, 0x00,
  0x3C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x03,
  0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x3C,
  0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x80, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x1F,
  0x00, 0x00, 0xF8, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC1, 0xF0,
  0x00, 0x0F, 0x83, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x1F, 0x00,
  0x00, 0xF8, 0x3C, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xE3, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F,
  0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x07,
  0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xFC,
  0x7E, 0x00, 0x1F, 0x87, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF8,
  0x07, 0xF8, 0x3F, 0xC1, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x1E, 0x0F, 0x81,
  0x87, 0x83, 0xE0, 0xF3, 0xE0, 0xF8, 0x7C, 0xF8, 0x3E, 0x3E, 0x3E, 0x0F,
  0x0F, 0x0F, 0x83, 0xC7, 0x83, 0xE1, 0xF3, 0xE0, 0x7F, 0xF8, 0xF0, 0x1F,
  0xFE, 0x78, 0x03, 0xFF, 0x3E, 0x00, 0x7F, 0x1F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x8F, 0xC0, 0x03, 0xC7, 0xFC, 0x01,
  0xF7, 0xFF, 0x80, 0xF9, 0xFF, 0xE0, 0x3C, 0xF8, 0xF8, 0x1E, 0x3E, 0x1F,
  0x0F, 0x8F, 0x07, 0xC3, 0xC7, 0xC1, 0xF1, 0xE1, 0xF0, 0x7C, 0xF8, 0x7C,
  0x1E, 0x04, 0x1F, 0x07, 0x80, 0x07, 0xC3, 0xE0, 0x00, 0xFD, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x1F, 0x80, 0x07, 0xF0,
  0xFC, 0x00, 0x3F, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x00,
  0xFC, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x1F, 0x87, 0xFF, 0xC0, 0xFC, 0x7F, 0x7F, 0x07, 0xE7,
  0xF1, 0xFC, 0x3E, 0x7F, 0x0F, 0xE3, 0xF3, 0xF8, 0x3F, 0x9F, 0xBF, 0x81,
  0xFD, 0xF9, 0xFC, 0x07, 0xFF, 0xCF, 0xE0, 0x3F, 0xFC, 0x7F, 0x00, 0xFF,
  0xE3, 0xF8, 0x03, 0xFE, 0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0x03, 0xFF, 0x03,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFD, 0xFC, 0x03, 0xFF, 0x07, 0xF0, 0x00, 0x80, 0x00, 0x00, 0x3F, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0xF8,
  0x00, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x80, 0x3C, 0x02, 0x38, 0x0F, 0x03, 0x8F, 0x83, 0xC3,
  0xE7, 0xF8, 0xE7, 0xF9, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7D, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x9F, 0x00, 0x0F, 0xC3, 0xE0,
  0x07, 0xE0, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x1E, 0x01,
  0xF0, 0x01, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFE, 0x80, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE1, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x87, 0xF0, 0xFC, 0x1F, 0x87, 0xF0, 0xFC, 0x3F, 0x87, 0xE1, 0xF8, 0x1E,
  0x01, 0x80, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF8, 0x08, 0x1F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFE, 0x7F, 0x04, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFE, 0x1F, 0xE0,
  0xFF, 0x03, 0xF8, 0x3F, 0x80, 0x7E, 0x1F, 0xC0, 0x1F, 0x87, 0xF0, 0x07,
  0xF1, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0,
  0x0F, 0xF3, 0xF0, 0x07, 0xFC, 0xFC, 0x07, 0xFF, 0x3F, 0x03, 0xFF, 0x9F,
  0xC3, 0xFF, 0xE7, 0xF1, 0xFF, 0xF9, 0xFD, 0xFC, 0xFE, 0x7E, 0xFE, 0x3F,
  0x9F, 0xFE, 0x0F, 0xE7, 0xFF, 0x03, 0xF3, 0xFF, 0x00, 0xFC, 0xFF, 0x80,
  0x3F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xF8, 0xFE,
  0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x87, 0xE0, 0x0F, 0xC1, 0xFC, 0x07, 0xF0,
  0x7F, 0x03, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0x87, 0xFF,
  0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xCF, 0xE7, 0x83, 0xF3,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xE3, 0xFE, 0x07, 0xF8,
  0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F,
  0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xE3, 0xFE, 0x07,
  0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0x7E,
  0x00, 0x7F, 0x87, 0xF0, 0x07, 0xF0, 0x7F, 0x81, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0xC0,
  0x03, 0xF3, 0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE1,
  0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x7E, 0x0F, 0xE0, 0x1F, 0xC1, 0xF8, 0x03,
  0xF0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xC0, 0x3F,
  0x83, 0xF8, 0x07, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x3C, 0x00, 0x0F, 0xDF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFC,
  0x07, 0xF0, 0x01, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x07,
  0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x7F, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x9F, 0xFC, 0x7F, 0xCF, 0xF8, 0x0F, 0xE7,
  0xF8, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x7F,
  0x7E, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xEF, 0xC0, 0x07,
  0xF7, 0xE0, 0x03, 0xF3, 0xF0, 0x03, 0xF9, 0xFC, 0x01, 0xFC, 0x7E, 0x01,
  0xFC, 0x3F, 0x83, 0xFE, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x7F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x07, 0xF8, 0xFF, 0x81, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x0F,
  0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xE0, 0x07,
  0xE0, 0xFE, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x81, 0xF8, 0x0F, 0xE0, 0x3F,
  0x83, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xE3, 0xFC, 0x0F, 0xF0,
  0x1F, 0x81, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE3,
  0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0x8F, 0xE0, 0x03, 0xF1, 0xFC, 0x00,
  0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF8, 0x07, 0xF0, 0x7F, 0x83, 0xFE, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F,
  0xF1, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F, 0x80, 0x7E, 0x7F, 0x00, 0x7F, 0x7F,
  0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x7F, 0x03, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x07, 0xFC, 0xFC, 0x00,
  0xF1, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0x00, 0x7E, 0x0F, 0xF0, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F,
  0xF0, 0xFF, 0x07, 0xE0, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x07, 0xE0, 0xFF, 0x0F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x0F, 0xF0, 0x7E,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x7E, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80,
  0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x10, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x0C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFE, 0x3F, 0xE3, 0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x00, 0x7F, 0x7E, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0xFC, 0x01, 0xF0, 0x07,
  0xC0, 0x03, 0xC0, 0x3E, 0x00, 0x07, 0x81, 0xF0, 0x18, 0x1E, 0x07, 0x83,
  0xFC, 0x38, 0x3C, 0x1F, 0xF8, 0xE1, 0xF0, 0xFF, 0xE3, 0x87, 0x87, 0xE7,
  0x8E, 0x1E, 0x3E, 0x1E, 0x3C, 0xF0, 0xF0, 0x70, 0xE3, 0xC7, 0xC3, 0xC3,
  0x9F, 0x1E, 0x0F, 0x0E, 0x78, 0xF8, 0x3C, 0x39, 0xE3, 0xC0, 0xE1, 0xE7,
  0x8F, 0x07, 0x87, 0x9E, 0x3C, 0x1E, 0x1E, 0xF0, 0xF0, 0x78, 0x73, 0xC3,
  0xC1, 0xE1, 0xCF, 0x1F, 0x0F, 0x0F, 0x3C, 0x3C, 0x3C, 0x38, 0xF0, 0xF1,
  0xF1, 0xE3, 0xC3, 0xFF, 0xFF, 0x0F, 0x0F, 0xF7, 0xF8, 0x1E, 0x1F, 0x9F,
  0xC0, 0x78, 0x3C, 0x3E, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x3F, 0x1F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xF1, 0xF8, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x1F,
  0xC1, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xC0,
  0x7F, 0x00, 0x7F, 0x00, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F,
  0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x1F, 0x9F, 0xC0,
  0x00, 0x7E, 0x7F, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x03, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0x00, 0x7F,
  0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xF0,
  0x7E, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF8, 0x3F,
  0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x07, 0xF8, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7E, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFE,
  0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xF0, 0x7E, 0x03,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xE3, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x00,
  0x7F, 0x0F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF3,
  0xF8, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xF8, 0xFE,
  0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x0F,
  0xF0, 0x3F, 0x81, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xC0, 0xFF, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x3F,
  0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00,
  0x3F, 0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F,
  0x1F, 0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0xFC, 0x3F,
  0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xF8, 0x00, 0x7F,
  0x0F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x3F,
  0x80, 0x3F, 0xC1, 0xFC, 0x03, 0xFC, 0x0F, 0xC0, 0x3F, 0xC0, 0x7E, 0x1F,
  0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xF0, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xE3,
  0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF1,
  0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x3F, 0xFE, 0x7E, 0x03, 0xFF, 0xEF, 0xE0, 0x3F, 0xFE, 0xFE, 0x07, 0xFF,
  0xCF, 0xE0, 0x7F, 0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE,
  0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01,
  0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0xFF, 0x83,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07,
  0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8,
  0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0,
  0x01, 0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x0F,
  0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0xC0, 0x07, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0x7F,
  0x00, 0x3F, 0x83, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x83,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x7F, 0xC0, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0x80, 0x1F,
  0xF0, 0x0F, 0xC0, 0x0F, 0xF8, 0x03, 0xF0, 0x03, 0xFC, 0x01, 0xFC, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x07, 0xE0,
  0x3F, 0xC0, 0x01, 0xF8, 0x1F, 0xE0, 0x00, 0x7E, 0x0F, 0xF0, 0x00, 0x3F,
  0x87, 0xFC, 0x00, 0x0F, 0xE3, 0xFE, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00,
  0xFC, 0x7F, 0x80, 0x00, 0x3F, 0x3F, 0xC0, 0x00, 0x1F, 0xDF, 0xE0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xCF, 0xE0, 0x00, 0x3F, 0xE3, 0xF8, 0x00, 0x0F, 0xF0,
  0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFC, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x01,
  0xFC, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xE0,
  0x0F, 0xE0, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F,
  0xE0, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x07,
  0xFC, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F,
  0xC0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x0F, 0xFE,
  0x07, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x7F, 0xF0, 0x3F, 0x78, 0xFF, 0xE0,
  0x7E, 0xF3, 0xFF, 0xC0, 0xFD, 0xE7, 0xDF, 0x81, 0xFB, 0xDF, 0xBF, 0x03,
  0xF7, 0xBE, 0x7C, 0x0F, 0xCF, 0xFD, 0xF8, 0x1F, 0x9F, 0xF3, 0xF0, 0x3F,
  0x3F, 0xE7, 0xE0, 0x7E, 0x7F, 0x8F, 0xC0, 0xFC, 0xFF, 0x1F, 0x81, 0xF8,
  0xFC, 0x7E, 0x07, 0xE1, 0xF8, 0xFC, 0x0F, 0xC3, 0xE1, 0xF8, 0x1F, 0x87,
  0xC3, 0xF0, 0x3F, 0x0F, 0x07, 0xE0, 0x7E, 0x1E, 0x1F, 0xC0, 0xFC, 0x00,
  0x3F, 0x03, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01,
  0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC,
  0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x7E, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x07,
  0xF0, 0x3F, 0xE0, 0x0F, 0xE0, 0x7F, 0xC0, 0x1F, 0x80, 0xFF, 0x80, 0x3F,
  0x01, 0xFF, 0x00, 0xFE, 0x03, 0xFF, 0x01, 0xFC, 0x0F, 0xFE, 0x03, 0xF8,
  0x1F, 0xFC, 0x07, 0xE0, 0x3F, 0xF8, 0x0F, 0xC0, 0x7F, 0xF8, 0x3F, 0x80,
  0xFD, 0xF0, 0x7F, 0x01, 0xFB, 0xE0, 0xFE, 0x07, 0xF7, 0xE1, 0xFC, 0x0F,
  0xE7, 0xC3, 0xF0, 0x1F, 0xCF, 0x87, 0xE0, 0x3F, 0x9F, 0x1F, 0xC0, 0x7E,
  0x3F, 0x3F, 0x80, 0xFC, 0x3E, 0x7F, 0x03, 0xF8, 0x7C, 0xFE, 0x07, 0xF0,
  0xF9, 0xF8, 0x0F, 0xE1, 0xFB, 0xF0, 0x1F, 0x81, 0xFF, 0xE0, 0x3F, 0x03,
  0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0x81, 0xFC, 0x0F, 0xFF, 0x03, 0xF8, 0x0F,
  0xFC, 0x07, 0xF0, 0x1F, 0xF8, 0x0F, 0xC0, 0x3F, 0xF0, 0x1F, 0x80, 0x3F,
  0xE0, 0x7F, 0x00, 0x7F, 0xC0, 0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x01, 0xFE,
  0x03, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xE7, 0xFC, 0x07, 0xF0,
  0x1F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xE1, 0xFC, 0x00, 0x7E,
  0x1F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF3, 0xF0,
  0x00, 0x7F, 0x3F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0xFC, 0xFE, 0x00, 0x0F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xCF,
  0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x87, 0xE0, 0x03, 0xF0, 0x7F, 0x00,
  0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC3, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0x00, 0x7F, 0x80, 0xFC, 0x00, 0xFE,
  0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC1,
  0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0xFE,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0x00,
  0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xE7, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x07,
  0xE1, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x3F,
  0x80, 0x07, 0xF3, 0xF0, 0x00, 0x7F, 0x3F, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xF7,
  0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFC,
  0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x87, 0xE0,
  0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC3, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0x00, 0xFF, 0x81, 0xFC, 0x00,
  0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x07, 0xF0, 0x7E, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xE0,
  0xFE, 0x00, 0x3F, 0x83, 0xF0, 0x01, 0xFE, 0x0F, 0xC0, 0x0F, 0xF0, 0x7F,
  0x00, 0x7F, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x07,
  0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x7E, 0x00, 0x3F, 0x81, 0xF8,
  0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0xFE, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0x1F, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F,
  0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0,
  0x07, 0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01,
  0xFC, 0x3F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0,
  0x7E, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC,
  0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x87, 0xF0, 0x01,
  0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF0,
  0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC,
  0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x03, 0xF0,
  0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x83, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x01, 0xFC, 0xFE, 0x00,
  0x3F, 0xC7, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x87, 0xF0, 0x07, 0xF0,
  0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x03, 0xF8,
  0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x07, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F,
  0x87, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF9, 0xFC,
  0x00, 0x1F, 0x9F, 0x80, 0x01, 0xFB, 0xF8, 0x00, 0x1F, 0xBF, 0x80, 0x01,
  0xFB, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x07, 0xC0, 0xFE, 0xFC, 0x0F, 0x81, 0xF9, 0xF8, 0x1F,
  0x03, 0xF3, 0xF0, 0x7E, 0x07, 0xE7, 0xE0, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8,
  0x3F, 0x1F, 0x83, 0xF0, 0x7E, 0x3F, 0x0F, 0xE0, 0xFC, 0x7E, 0x1F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x87, 0xE1, 0xF8, 0xFF, 0x0F, 0xC3, 0xF1, 0xFE, 0x3F,
  0x07, 0xE3, 0xFC, 0x7E, 0x0F, 0xCF, 0xF8, 0xFC, 0x1F, 0x9F, 0xF1, 0xF8,
  0x3F, 0x3D, 0xE7, 0xE0, 0x7E, 0x7B, 0xCF, 0xC0, 0xFD, 0xF7, 0x9F, 0x81,
  0xFB, 0xEF, 0x3E, 0x03, 0xF7, 0x9E, 0xFC, 0x07, 0xDF, 0x3D, 0xF8, 0x0F,
  0xBE, 0x7B, 0xF0, 0x1F, 0x78, 0xF7, 0xC0, 0x3F, 0xF1, 0xFF, 0x80, 0x7F,
  0xE3, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFE,
  0x1F, 0xF0, 0x07, 0xF8, 0x3F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0,
  0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x07,
  0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F,
  0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x01,
  0xF8, 0x3F, 0x80, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x01, 0xFC, 0xFF, 0x00,
  0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x07,
  0xFB, 0xF8, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0x03, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xDF, 0x80, 0x03, 0xFC, 0xFE, 0x00, 0x1F, 0xC7,
  0xF0, 0x01, 0xFE, 0x3F, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0xFE, 0x07, 0xF0,
  0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x3F,
  0x80, 0x3F, 0x83, 0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xE1, 0xFC, 0x00,
  0x3F, 0x1F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3F,
  0x7E, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x00,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0x78, 0x03, 0xF7, 0xC0,
  0x3E, 0x7C, 0x07, 0xE7, 0xC0, 0x7C, 0x7C, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E,
  0x1F, 0x03, 0xE3, 0xF0, 0x3E, 0x3E, 0x03, 0xF7, 0xE0, 0x1F, 0x7C, 0x01,
  0xFF, 0xC0, 0x1F, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFE, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F,
  0x83, 0xF0, 0x7C, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0x81,
  0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xE0, 0x7F, 0x3F, 0x80, 0x3F, 0xBF,
  0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xF3,
  0xF8, 0x07, 0xF9, 0xFC, 0x0F, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xDF, 0xC0, 0xFF, 0x8F, 0xE0, 0x04, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF0, 0x20, 0x00, 0x7E, 0x3F, 0xC0, 0x0F, 0xDF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF,
  0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0xFC, 0x00, 0xFE,
  0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0x80,
  0x0F, 0xE3, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xE3,
  0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xF1, 0xF8, 0x00,
  0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xF0, 0x0F, 0xE1, 0xFF, 0x03, 0xFC, 0x3F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xBF, 0xFE,
  0x07, 0xE1, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x7F, 0x83, 0xFC, 0x7F, 0x80, 0xFE, 0x3F, 0x80, 0x3F,
  0x3F, 0x80, 0x1F, 0xDF, 0x80, 0x0F, 0xEF, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x07, 0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x07, 0xF0, 0xFE, 0x07, 0xF8, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0x80, 0xFC,
  0x00, 0xFF, 0x1F, 0xC0, 0x3F, 0xFD, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0x80, 0x7F,
  0x87, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xE0, 0x03, 0xF8, 0xFE,
  0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07,
  0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F,
  0xC0, 0x07, 0xE0, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00,
  0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0xFF, 0x07, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xEF, 0xC0, 0x1F, 0xFC, 0xFC, 0x00, 0xFF,
  0x9F, 0x80, 0x00, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xE0, 0xFF, 0x03, 0xF8, 0x7F, 0x80, 0x7E, 0x1F, 0xC0, 0x1F, 0xCF,
  0xE0, 0x03, 0xF3, 0xF8, 0x00, 0xFD, 0xFC, 0x00, 0x3F, 0x7F, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x02, 0x07, 0xF8, 0x01, 0xC0, 0xFF, 0x01, 0xF8,
  0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x03, 0xFE, 0x3F, 0x00, 0xFF, 0xF3, 0xF0, 0x1F, 0xFF, 0xBF, 0x03, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xF8, 0x3F, 0xF0, 0xFF, 0x00, 0xFE,
  0x1F, 0xE0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8,
  0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xC3, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x0F,
  0xC3, 0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0xC3, 0xF0, 0x01, 0xFC, 0x3F,
  0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x83, 0xF8, 0x03,
  0xF8, 0x3F, 0x80, 0x7F, 0x81, 0xFE, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFB, 0xF0, 0x01, 0xFE,
  0x7F, 0x00, 0x02, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x01, 0x00, 0x0F, 0xE0,
  0x30, 0x01, 0xFE, 0x07, 0x80, 0x3F, 0xC0, 0x7F, 0x0F, 0xF8, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x10, 0x00, 0x7E, 0x3F, 0xE0,
  0x0F, 0xCF, 0xFE, 0x03, 0xFB, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xC1, 0xFF, 0x07, 0xFC, 0x3F, 0xC0, 0x3F, 0x87, 0xE0, 0x07, 0xF1,
  0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFC, 0x00,
  0x7F, 0x1F, 0x80, 0x0F, 0xE3, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x1F,
  0xC0, 0x07, 0xE3, 0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x8F, 0xC0, 0x07,
  0xF3, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0x8F, 0xE0, 0x03, 0xF1, 0xFC,
  0x00, 0xFE, 0x3F, 0x00, 0x1F, 0xC7, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7E,
  0x3F, 0x80, 0x0F, 0xC7, 0xF0, 0x03, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80,
  0x41, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xFC, 0x1F, 0x80, 0x3F, 0xC0, 0x7E,
  0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x80, 0x3F, 0x87,
  0xFC, 0x00, 0xFC, 0x3F, 0xE0, 0x03, 0xF1, 0xFF, 0x00, 0x1F, 0xCF, 0xF8,
  0x00, 0x7F, 0x7F, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0x1F, 0xC0, 0x03, 0xF8,
  0x7F, 0x80, 0x0F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xFC, 0x01, 0xFC, 0x07,
  0xF0, 0x07, 0xF0, 0x1F, 0xE0, 0x1F, 0x80, 0x3F, 0x80, 0x7E, 0x00, 0xFF,
  0x01, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xF0,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x01, 0x80, 0x40, 0x0F, 0xCF, 0xC7, 0xE0, 0x1F, 0x7F, 0xDF, 0xE0,
  0x3E, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83,
  0xF8, 0xFE, 0x3F, 0x07, 0xE1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x07, 0xE1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8,
  0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x7E, 0x1F, 0x83,
  0xF0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC1, 0xF8, 0x7E, 0x00, 0x00, 0x00, 0x20, 0x00, 0xFC, 0x7F, 0xC0,
  0x1F, 0x9F, 0xFC, 0x07, 0xE7, 0xFF, 0xC0, 0xFD, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x7F, 0x80, 0x7F, 0x0F, 0xE0, 0x0F, 0xE3,
  0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF1, 0xF8, 0x00,
  0xFE, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF1, 0xFC, 0x00, 0x7E, 0x3F,
  0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x0F,
  0xC7, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8,
  0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xE3, 0xF8, 0x00, 0xFC,
  0x7F, 0x00, 0x1F, 0x8F, 0xE0, 0x07, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0x07, 0xF8, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x1F,
  0x8F, 0xE0, 0x07, 0xF3, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x7E, 0x00,
  0x1F, 0xDF, 0x80, 0x07, 0xF7, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE,
  0x7E, 0x00, 0x3F, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE0, 0xFE, 0x07,
  0xF8, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x0F, 0xCF, 0xF8, 0x00, 0x7E, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F,
  0x00, 0xFE, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00,
  0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x83, 0xF0, 0x01, 0xFC,
  0x1F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF0, 0x7F,
  0x00, 0x3F, 0x83, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0xFC, 0x00,
  0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x03, 0xFE, 0x0F, 0xF8,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0x7F, 0xF8, 0x03, 0xF8, 0xFF, 0x80, 0x1F, 0xC0, 0x40, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x3F, 0xE3, 0xF0, 0x3F, 0xFC, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFE, 0x0F, 0xF8, 0xFE, 0x01, 0xFE,
  0x7F, 0x80, 0x3F, 0x9F, 0xC0, 0x0F, 0xE7, 0xE0, 0x03, 0xFB, 0xF8, 0x00,
  0xFC, 0xFE, 0x00, 0x3F, 0x3F, 0x80, 0x1F, 0xCF, 0xC0, 0x07, 0xF3, 0xF0,
  0x01, 0xFC, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3,
  0xF0, 0x03, 0xF8, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x1F,
  0xC3, 0xFC, 0x1F, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xF7, 0xF0, 0x0F, 0xF9, 0xF8, 0x00, 0x30, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x38, 0x07,
  0xF0, 0xFF, 0xC3, 0xF1, 0xFF, 0xE1, 0xF9, 0xFF, 0xE0, 0xFD, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFC, 0x04, 0x1F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFE,
  0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F,
  0x80, 0x0F, 0xCF, 0xE0, 0x03, 0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0xE7, 0xFE,
  0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x10, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0x1C, 0x00, 0x1F, 0xC0, 0x0F, 0xE3, 0xF0, 0x01, 0xF8,
  0x7E, 0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00,
  0x3F, 0x8F, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x8F,
  0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE,
  0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x3F,
  0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x03, 0xFC, 0x1F, 0xC1, 0xFF, 0x83, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xDF, 0x80, 0x7F, 0xF3, 0xF0,
  0x07, 0xF8, 0x7E, 0x00, 0x08, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x03, 0xF9, 0xF8, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0xC7, 0xE0, 0x03, 0xF8,
  0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0x3F, 0x00,
  0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x0F, 0x80, 0xFC, 0x01,
  0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F,
  0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xF1, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0x81, 0xFF, 0xE0, 0x7C,
  0x1F, 0xBF, 0x07, 0xE0, 0xFD, 0xF8, 0x3F, 0x07, 0xEF, 0xC1, 0xF8, 0x3E,
  0x7E, 0x1F, 0xC3, 0xF3, 0xF0, 0xFE, 0x1F, 0x9F, 0x8F, 0xF0, 0xF8, 0xF8,
  0x7F, 0x8F, 0xC7, 0xC3, 0xFC, 0x7E, 0x3E, 0x3D, 0xE3, 0xE1, 0xF1, 0xEF,
  0x3F, 0x0F, 0x8F, 0x79, 0xF8, 0x7C, 0xF3, 0xCF, 0x83, 0xE7, 0x9E, 0xFC,
  0x1F, 0x3C, 0xF7, 0xC0, 0xFB, 0xC7, 0xBE, 0x07, 0xDE, 0x3D, 0xF0, 0x3F,
  0xE1, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0x83,
  0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0xFE, 0x07, 0xF0,
  0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x01, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x01, 0xFE, 0x07, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0xFF, 0x00, 0x1F, 0x83, 0xFC, 0x00,
  0x3F, 0x8F, 0xF0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0xFF, 0x0F,
  0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x7F, 0x83, 0xF8, 0x00,
  0x3F, 0x80, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0x1F, 0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x03, 0xF0,
  0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F,
  0x03, 0xF8, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F,
  0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xC7, 0xFF, 0x80, 0x1E, 0x7F,
  0xFF, 0x01, 0xF3, 0xFF, 0xFC, 0x1F, 0xBF, 0x9F, 0xFB, 0xF9, 0xF0, 0x3F,
  0xFF, 0xCF, 0x00, 0xFF, 0xFC, 0xF8, 0x03, 0xFF, 0xE0, 0x40, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xC0,
};

const GFXglyph RobotoMono_SemiBoldItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 13, 38, 31, 9, -38 },
  { 63, 17, 14, 31, 9, -40 },
  { 93, 31, 38, 31, 0, -38 },
  { 241, 28, 49, 31, 2, -44 },
  { 413, 26, 39, 31, 3, -38 },
  { 540, 29, 39, 31, 1, -38 },
  { 682, 8, 14, 31, 13, -40 },
  { 696, 18, 54, 31, 8, -42 },
  { 818, 18, 54, 31, 4, -42 },
  { 940, 26, 27, 31, 4, -38 },
  { 1028, 27, 27, 31, 2, -31 },
  { 1120, 11, 16, 31, 5, -6 },
  { 1142, 22, 5, 31, 6, -19 },
  { 1156, 9, 10, 31, 9, -9 },
  { 1168, 28, 41, 31, 2, -38 },
  { 1312, 26, 39, 31, 3, -38 },
  { 1439, 18, 38, 31, 6, -38 },
  { 1525, 28, 38, 31, 0, -38 },
  { 1658, 28, 39, 31, 1, -38 },
  { 1795, 27, 38, 31, 1, -38 },
  { 1924, 28, 39, 31, 2, -38 },
  { 2061, 25, 39, 31, 2, -38 },
  { 2183, 27, 38, 31, 4, -38 },
  { 2312, 27, 39, 31, 2, -38 },
  { 2444, 24, 38, 31, 4, -38 },
  { 2558, 12, 32, 31, 10, -31 },
  { 2606, 16, 41, 31, 7, -31 },
  { 2688, 24, 25, 31, 4, -29 },
  { 2763, 26, 16, 31, 3, -24 },
  { 2815, 25, 24, 31, 2, -28 },
  { 2890, 24, 38, 31, 6, -38 },
  { 3004, 30, 37, 31, 1, -37 },
  { 3143, 30, 38, 31, -2, -38 },
  { 3286, 30, 38, 31, 1, -38 },
  { 3429, 28, 39, 31, 2, -38 },
  { 3566, 29, 38, 31, 1, -38 },
  { 3704, 31, 38, 31, 1, -38 },
  { 3852, 31, 38, 31, 1, -38 },
  { 4000, 28, 39, 31, 2, -38 },
  { 4137, 31, 38, 31, 0, -38 },
  { 4285, 28, 38, 31, 2, -38 },
  { 4418, 29, 39, 31, 2, -38 },
  { 4560, 34, 38, 31, 1, -38 },
  { 4722, 25, 38, 31, 1, -38 },
  { 4841, 31, 38, 31, 1, -38 },
  { 4989, 31, 38, 31, 0, -38 },
  { 5137, 28, 39, 31, 2, -38 },
  { 5274, 30, 38, 31, 1, -38 },
  { 5417, 28, 45, 31, 2, -38 },
  { 5575, 30, 38, 31, 1, -38 },
  { 5718, 29, 39, 31, 2, -38 },
  { 5860, 30, 38, 31, 4, -38 },
  { 6003, 29, 39, 31, 2, -38 },
  { 6145, 28, 38, 31, 5, -38 },
  { 6278, 31, 38, 31, 3, -38 },
  { 6426, 36, 38, 31, -2, -38 },
  { 6597, 29, 38, 31, 5, -38 },
  { 6735, 32, 38, 31, 0, -38 },
  { 6887, 20, 53, 31, 6, -44 },
  { 7020, 13, 41, 31, 10, -38 },
  { 7087, 19, 53, 31, 6, -44 },
  { 7213, 20, 20, 31, 6, -38 },
  { 7263, 24, 5, 31, 0, 0 },
  { 7278, 10, 7, 31, 14, -38 },
  { 7287, 25, 30, 31, 2, -29 },
  { 7381, 27, 41, 31, 1, -40 },
  { 7520, 25, 30, 31, 3, -29 },
  { 7614, 28, 41, 31, 3, -40 },
  { 7758, 26, 30, 31, 2, -29 },
  { 7856, 28, 41, 31, 5, -41 },
  { 8000, 28, 40, 31, 1, -29 },
  { 8140, 27, 40, 31, 1, -40 },
  { 8275, 23, 39, 31, 3, -39 },
  { 8388, 24, 50, 31, 1, -39 },
  { 8538, 30, 40, 31, 1, -40 },
  { 8688, 24, 40, 31, 2, -40 },
  { 8808, 31, 29, 31, -1, -29 },
  { 8921, 27, 29, 31, 1, -29 },
  { 9019, 26, 30, 31, 2, -29 },
  { 9117, 29, 40, 31, -1, -29 },
  { 9262, 26, 40, 31, 3, -29 },
  { 9392, 25, 29, 31, 5, -29 },
  { 9483, 26, 30, 31, 2, -29 },
  { 9581, 24, 36, 31, 5, -35 },
  { 9689, 27, 29, 31, 3, -28 },
  { 9787, 27, 28, 31, 4, -28 },
  { 9882, 29, 28, 31, 3, -28 },
  { 9984, 31, 28, 31, 0, -28 },
  { 10093, 33, 39, 31, 0, -28 },
  { 10254, 29, 28, 31, 1, -28 },
  { 10356, 20, 50, 31, 8, -41 },
  { 10481, 12, 49, 31, 9, -38 },
  { 10555, 20, 50, 31, 5, -41 },
  { 10680, 29, 11, 31, 0, -21 },
};

const GFXfont RobotoMono_SemiBoldItalic53pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic53pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic53pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC53PT7B_H_
