#ifndef _ROBOTOMONO_SEMIBOLDITALIC48PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0xFE, 0x0F,
  0xE0, 0x7E, 0x07, 0xC0, 0x3E, 0x1F, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E,
  0x7C, 0x1E, 0x7C, 0x3E, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C,
  0x70, 0x3C, 0xF0, 0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x78, 0x7C, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0,
  0x78, 0x00, 0x0F, 0x0F, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00,
  0x01, 0xE1, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x87, 0x80,
  0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x1E,
  0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07,
  0x87, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0xF0,
  0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF,
  0x3F, 0xC0, 0xFE, 0x07, 0xF0, 0xFE, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F,
  0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE7, 0xE0, 0x03,
  0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00,
  0x7E, 0x1F, 0xC0, 0x7F, 0x07, 0xFD, 0xFF, 0x83, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07,
  0x8F, 0x80, 0x1F, 0x0F, 0x06, 0x3C, 0x1E, 0x0F, 0x78, 0x3C, 0x3C, 0xF0,
  0x78, 0xF1, 0xE0, 0xF1, 0xE3, 0xC3, 0xC7, 0x87, 0xCF, 0x9E, 0x07, 0xFE,
  0x78, 0x0F, 0xFC, 0xF0, 0x07, 0xE3, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x04,
  0x00, 0x3C, 0xFF, 0x00, 0xF3, 0xFF, 0x01, 0xEF, 0xFE, 0x07, 0x9F, 0x3E,
  0x1E, 0x7C, 0x3C, 0x3C, 0xF0, 0x78, 0xF1, 0xE0, 0xF3, 0xC3, 0xC1, 0xE3,
  0x07, 0x83, 0xC0, 0x0F, 0x0F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x08, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0x3F, 0x00, 0x3F, 0x07, 0xC0, 0x0F, 0xC1, 0xF0, 0x03, 0xE0,
  0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0x87, 0xE0, 0x03,
  0xE3, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8,
  0x1F, 0x1F, 0xFF, 0x07, 0xCF, 0xEF, 0xC3, 0xF7, 0xF1, 0xF8, 0xFD, 0xF8,
  0x7F, 0x3E, 0xFE, 0x0F, 0xDF, 0xBF, 0x03, 0xFF, 0xCF, 0xC0, 0x7F, 0xF3,
  0xF0, 0x0F, 0xF8, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0xFE, 0x07, 0xF9, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xDF, 0xC0, 0x7F,
  0xC3, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x78, 0xF3, 0xE7, 0xCF, 0x9E, 0x3C,
  0x78, 0xF3, 0xE7, 0x80, 0x00, 0x03, 0x00, 0x03, 0x80, 0x07, 0xC0, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01,
  0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xE0,
  0x00, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x08, 0x0F, 0x01, 0x3C,
  0x1E, 0x0E, 0x7E, 0x3C, 0x7E, 0xFF, 0x77, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0x00, 0x07, 0xDF, 0x00, 0x1F, 0x1E, 0x00, 0x7C, 0x3E, 0x01, 0xF8, 0x3E,
  0x07, 0xE0, 0x7C, 0x07, 0x80, 0xF8, 0x02, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8,
  0x7E, 0x1F, 0x87, 0xC3, 0xF0, 0xF8, 0x7C, 0x3E, 0x03, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x7E, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0x7E, 0x08, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x81, 0xFE, 0x3F, 0x83, 0xF0, 0x3F, 0x0F, 0xC0, 0x3F,
  0x1F, 0x80, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3,
  0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0xDF, 0x80, 0xFF, 0xBF, 0x07, 0xFF, 0x7E,
  0x1F, 0xFE, 0xFC, 0xFD, 0xF9, 0xFB, 0xF3, 0xF3, 0xFF, 0x87, 0xEF, 0xFE,
  0x0F, 0xDF, 0xF0, 0x1F, 0xBF, 0xC0, 0x3F, 0x7F, 0x00, 0xFC, 0xFC, 0x01,
  0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F,
  0x0F, 0xC0, 0xFC, 0x1F, 0xE7, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x1F, 0x00, 0xFE, 0x07, 0xFE, 0x3F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFC, 0x7C, 0xE0, 0xFC, 0x80, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xE7, 0xFC,
  0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F,
  0xC7, 0xE0, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F,
  0xC7, 0xF8, 0x3F, 0x80, 0xFE, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87,
  0xE0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0x8F, 0xE0,
  0x0F, 0xC3, 0xF8, 0x1F, 0xE1, 0xFF, 0x3F, 0xE0, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xDF, 0x00, 0x0F, 0xDF, 0x80, 0x07,
  0xCF, 0xC0, 0x07, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x07, 0xE1, 0xF0, 0x07,
  0xE1, 0xF8, 0x03, 0xE0, 0xFC, 0x03, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x1F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0xC1, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFB, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x3F, 0xE7, 0xFC, 0x07, 0x80, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x7F, 0x1F,
  0xC0, 0x3F, 0x07, 0xE0, 0x3F, 0x83, 0xFE, 0x7F, 0x80, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x38, 0x03,
  0xF3, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F,
  0xC3, 0xFC, 0xFF, 0x03, 0xF9, 0xFC, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xC0,
  0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00,
  0xFC, 0xF8, 0x01, 0xF9, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xF0, 0x3F,
  0x07, 0xF9, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xF9, 0xFE, 0x0F,
  0xE0, 0x7F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x3F, 0x1F,
  0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x0F, 0x80, 0x7E, 0x0F, 0xC0, 0xFE, 0x0F,
  0xE1, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0x83, 0xF8, 0x7F, 0x01, 0xF8, 0x7E,
  0x00, 0xFC, 0xFE, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0x7F,
  0xDF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFC, 0x00, 0x7F,
  0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFF, 0x1F, 0xC3, 0xF8, 0x3F,
  0x9F, 0xC0, 0x7E, 0x7E, 0x01, 0xFB, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0xBF,
  0x00, 0x3E, 0xFC, 0x00, 0xFB, 0xF0, 0x03, 0xEF, 0xC0, 0x1F, 0xBF, 0x00,
  0x7E, 0xFC, 0x01, 0xFB, 0xF8, 0x0F, 0xEF, 0xF0, 0xFF, 0x9F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xBF, 0x00, 0xF8, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0x81, 0xF8, 0x7F, 0x8F, 0xF1,
  0xFE, 0x3F, 0xC7, 0xF8, 0x7E, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0xFC,
  0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xF8, 0x3F, 0x01, 0x00, 0x00, 0x70,
  0x01, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00,
  0x7E, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0,
  0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0C, 0x00,
  0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x10, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x3F, 0xE7, 0xF9, 0xFC, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x07, 0x01, 0xF0, 0x00, 0xF0,
  0x3C, 0x1E, 0x0E, 0x0F, 0x0F, 0xF1, 0xC3, 0xC3, 0xFF, 0x38, 0x78, 0xFF,
  0xE7, 0x9E, 0x3E, 0x38, 0xF3, 0xC7, 0x87, 0x1E, 0x71, 0xE0, 0xE3, 0xDE,
  0x3C, 0x3C, 0x73, 0xC7, 0x07, 0x8E, 0x71, 0xE0, 0xE1, 0xCE, 0x3C, 0x1C,
  0x3B, 0xC7, 0x87, 0x87, 0x78, 0xF0, 0xF1, 0xCF, 0x1C, 0x1C, 0x39, 0xE3,
  0x83, 0x87, 0x3C, 0x78, 0xF1, 0xC7, 0x8F, 0xFF, 0xF8, 0xF1, 0xFF, 0xFE,
  0x1E, 0x1F, 0xBF, 0x81, 0xC0, 0xC1, 0xC0, 0x3C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x01, 0x00, 0x0F, 0xE1, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xCF, 0x80,
  0x01, 0xF9, 0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0xC7, 0xC0, 0x03, 0xF0,
  0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00,
  0xFC, 0x07, 0xC0, 0x1F, 0x80, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x0F,
  0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFC, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xC0, 0x3F, 0x83, 0xF0,
  0x03, 0xF8, 0x7E, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC,
  0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x3F, 0x00,
  0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x03,
  0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x7E,
  0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xF1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3F,
  0x87, 0xE0, 0x1F, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x3F, 0x00, 0x7E, 0x1F,
  0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE3, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07,
  0xE3, 0xF0, 0x03, 0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0xC0, 0xFE, 0x03, 0xFD,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x03, 0xF8,
  0x3F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0x83,
  0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F,
  0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80,
  0x1F, 0xCF, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F,
  0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0xFC,
  0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x87, 0xE0, 0x1F, 0xC1, 0xF8, 0x0F,
  0xF0, 0xFE, 0x0F, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x01,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F,
  0xEF, 0xF8, 0x3F, 0x80, 0xFE, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x8F,
  0xC0, 0x0F, 0xCF, 0xC0, 0x03, 0xE7, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x03, 0xFF, 0xDF, 0x81, 0xFF, 0xEF, 0xC0, 0xFF,
  0xF7, 0xE0, 0x7F, 0xFB, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00,
  0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0,
  0x0F, 0xE3, 0xF8, 0x0F, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F,
  0x00, 0x3F, 0x03, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07,
  0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07,
  0xC0, 0x07, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xF8, 0x01, 0xF8, 0x1F, 0x80,
  0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x03, 0xF0, 0x03, 0xF0,
  0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xE0,
  0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E,
  0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xC0, 0x03,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0,
  0x1F, 0x83, 0xF0, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x03, 0xFE, 0x0F, 0xC0, 0x0F, 0xF0,
  0x1F, 0x80, 0x3F, 0xC0, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x01, 0xFC, 0x00,
  0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x1F, 0xC0, 0x07, 0xE0, 0x7F, 0x00, 0x0F,
  0xC1, 0xFE, 0x00, 0x1F, 0x87, 0xF8, 0x00, 0x3F, 0x1F, 0xE0, 0x00, 0x7E,
  0x7F, 0x80, 0x01, 0xF8, 0xFE, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0xFE,
  0x00, 0x07, 0xF8, 0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0x83, 0xF8,
  0x00, 0x7E, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x01, 0xF8, 0x07, 0xE0,
  0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0xC0,
  0x3F, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x7F, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80,
  0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x3F, 0xE0,
  0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0x87, 0xFE, 0x0F, 0xFC,
  0xFF, 0xC0, 0xFF, 0xCF, 0xFC, 0x0F, 0xBD, 0xF7, 0xC1, 0xFB, 0xDF, 0x7C,
  0x1F, 0xBF, 0xEF, 0xC1, 0xF3, 0xFE, 0xFC, 0x1F, 0x3F, 0xCF, 0x81, 0xF3,
  0xFC, 0xF8, 0x1F, 0x3F, 0x8F, 0x83, 0xF3, 0xF9, 0xF8, 0x3F, 0x3F, 0x1F,
  0x83, 0xF1, 0xF1, 0xF0, 0x3E, 0x1E, 0x1F, 0x03, 0xE1, 0xE1, 0xF0, 0x3E,
  0x1C, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03,
  0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x7E, 0x0F,
  0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00,
  0x7C, 0x0F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x3F,
  0x03, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x03, 0xFC, 0x07, 0xE0, 0x7F,
  0xC0, 0x7E, 0x07, 0xFC, 0x07, 0xE0, 0x7F, 0xC0, 0x7E, 0x07, 0xFE, 0x07,
  0xE0, 0x7F, 0xE0, 0x7E, 0x07, 0xFE, 0x0F, 0xC0, 0xFD, 0xE0, 0xFC, 0x0F,
  0xDF, 0x0F, 0xC0, 0xFD, 0xF0, 0xFC, 0x0F, 0xDF, 0x0F, 0xC0, 0xFC, 0xF0,
  0xFC, 0x1F, 0xCF, 0x9F, 0x81, 0xF8, 0xF9, 0xF8, 0x1F, 0x8F, 0x9F, 0x81,
  0xF8, 0x79, 0xF8, 0x1F, 0x87, 0xDF, 0x81, 0xF8, 0x7F, 0xF8, 0x3F, 0x07,
  0xFF, 0x03, 0xF0, 0x3F, 0xF0, 0x3F, 0x03, 0xFF, 0x03, 0xF0, 0x3F, 0xF0,
  0x3F, 0x01, 0xFF, 0x03, 0xF0, 0x1F, 0xE0, 0x7E, 0x01, 0xFE, 0x07, 0xE0,
  0x1F, 0xE0, 0x7E, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0xFE,
  0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F,
  0x81, 0xFC, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x3F, 0x8F, 0xC0, 0x0F, 0xCF,
  0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD,
  0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01,
  0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00,
  0x3F, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x1F, 0x83, 0xF8,
  0x1F, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xC0, 0x3F, 0x81, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x3F,
  0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0,
  0x03, 0xF0, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0x83, 0xE0, 0x07, 0xF0,
  0xFC, 0x01, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x3F,
  0x81, 0xFC, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xCF,
  0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xFB, 0xF0, 0x00, 0xFD,
  0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01,
  0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0x7E, 0x00,
  0x3F, 0x3F, 0x00, 0x3F, 0x9F, 0x80, 0x1F, 0x87, 0xE0, 0x1F, 0x83, 0xF8,
  0x1F, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x20,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xC0, 0x7F, 0x81, 0xF8, 0x03,
  0xF0, 0x7E, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F,
  0x00, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3F,
  0x87, 0xE0, 0x0F, 0xE0, 0xFC, 0x03, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0x7E, 0x0F, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x03,
  0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFE, 0x07,
  0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x87, 0xE0, 0x03,
  0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFC, 0xFF, 0x81, 0xFC, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x0F,
  0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xF1,
  0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xF0, 0x07, 0xF0, 0xFF, 0x01,
  0xFE, 0x0F, 0xFD, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x0F,
  0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0,
  0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F,
  0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x7E,
  0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00,
  0xFC, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0x87, 0xE0, 0x07, 0xE1, 0xF8,
  0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE3,
  0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x07, 0xE0, 0x1F,
  0xC1, 0xF8, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xF7, 0xFC, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03,
  0xF9, 0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0xC7, 0xE0,
  0x07, 0xE1, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0xFC,
  0x03, 0xF0, 0x7F, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x07, 0xC3,
  0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x07,
  0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x0F, 0x03, 0xF7, 0xC1, 0xF0,
  0x7E, 0x7C, 0x1F, 0x07, 0xE7, 0xC1, 0xF0, 0x7C, 0x7C, 0x3F, 0x07, 0xC7,
  0xC3, 0xF0, 0xFC, 0x7C, 0x3F, 0x0F, 0xC7, 0xC3, 0xF0, 0xF8, 0x7C, 0x7F,
  0x0F, 0x87, 0xC7, 0xF1, 0xF8, 0x7C, 0x7F, 0x1F, 0x07, 0xCF, 0xF1, 0xF0,
  0x7C, 0xFF, 0x1F, 0x07, 0xCF, 0xF3, 0xF0, 0x7D, 0xFF, 0x3E, 0x07, 0xDE,
  0xF3, 0xE0, 0x7D, 0xEF, 0x7E, 0x07, 0xDE, 0xF7, 0xC0, 0xFF, 0xCF, 0x7C,
  0x0F, 0xFC, 0xF7, 0xC0, 0xFB, 0xCF, 0xFC, 0x0F, 0xF8, 0xFF, 0x80, 0xFF,
  0x8F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xF0, 0x0F, 0xF0, 0xFF,
  0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x0F,
  0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F,
  0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x03, 0xF8, 0x01,
  0xFC, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x3F, 0x7F,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x01, 0xFC, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F,
  0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x1F,
  0x80, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F,
  0xEF, 0xC0, 0x03, 0xF9, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0xC3, 0xF0,
  0x07, 0xF0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x80, 0xFC, 0x07, 0xE0,
  0x1F, 0x81, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xE3,
  0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0x9F, 0x80, 0x01, 0xF3, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7B, 0xC0, 0x1F, 0x7C, 0x03,
  0xCF, 0x80, 0xF9, 0xF0, 0x3E, 0x1E, 0x07, 0xC3, 0xC1, 0xF0, 0x7C, 0x3E,
  0x0F, 0x8F, 0x80, 0xF1, 0xF0, 0x1E, 0x7C, 0x03, 0xFF, 0x00, 0x7C, 0x7F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xC1, 0xF0, 0x78, 0x3E, 0x00, 0x3F, 0x00,
  0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3,
  0xF8, 0x3F, 0x8F, 0xE0, 0x3F, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x23, 0xF0, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x9F, 0xF0, 0x3E, 0x3F, 0x80, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03,
  0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0xCF, 0xC0, 0x7F, 0x9F, 0xC3, 0xFE,
  0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFB, 0xF0, 0x3F, 0xE3, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC3, 0xC0,
  0x0F, 0xCF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x0F, 0xF0, 0xFE, 0x1F, 0xE0, 0x7F, 0x1F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F,
  0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x3F, 0x3F, 0x00, 0x3F,
  0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0xFC, 0x7F, 0x81, 0xFC,
  0x7F, 0xEF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFD, 0xFF, 0xE0,
  0xFC, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFC, 0x3F, 0x87,
  0xE0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x01, 0xF1, 0xF8, 0x03,
  0xE3, 0xF0, 0x0F, 0xC7, 0xF0, 0x3F, 0x87, 0xF9, 0xFE, 0x0F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x07, 0xC3, 0xF0,
  0x07, 0xFC, 0xFC, 0x07, 0xFF, 0xBF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x7F, 0x87, 0xFC, 0x3F, 0x80, 0xFE, 0x0F, 0xC0, 0x1F, 0x83, 0xF0,
  0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87,
  0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F,
  0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xE0, 0xFE, 0x01, 0xF8, 0x1F, 0x80,
  0x7E, 0x07, 0xF0, 0x7F, 0x81, 0xFF, 0x7F, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xDF, 0x00, 0x1F, 0xC7, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xE1, 0xFC, 0x1F, 0xC0, 0x7E, 0x3F, 0x80,
  0x7E, 0x3F, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x20, 0x7F, 0x00, 0xF0, 0x3F, 0xE7, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0xF3, 0xF0, 0x1F, 0xFE, 0xF8, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x83, 0xFC, 0x3F, 0xE1, 0xFE, 0x03, 0xF8, 0x7F, 0x00,
  0xFE, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC,
  0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0x87, 0xE0, 0x07, 0xE1,
  0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x07,
  0xE0, 0xFC, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xFB, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFE, 0xFC, 0x00, 0xFF, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x20, 0x03, 0xF8, 0x0C, 0x01, 0xFC,
  0x07, 0xC0, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC3, 0xE0, 0x0F, 0xCF, 0xF8, 0x0F, 0xDF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x1F, 0xF0, 0xFF, 0x1F, 0xC0, 0x3F, 0x1F,
  0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x3F,
  0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F,
  0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0xFC,
  0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x01, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x87, 0xE0, 0x1F,
  0xE0, 0xFC, 0x07, 0xF8, 0x1F, 0x81, 0xFE, 0x03, 0xF0, 0x7F, 0x80, 0x7C,
  0x1F, 0xE0, 0x1F, 0x87, 0xF8, 0x03, 0xF1, 0xFC, 0x00, 0x7E, 0x7F, 0x00,
  0x0F, 0xDF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0xFE, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x07, 0xE0, 0xFE, 0x00, 0xFC, 0x0F,
  0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x1F,
  0x80, 0x3F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7F, 0x00, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0x00, 0x07, 0x07, 0x80, 0x7D, 0xFC, 0xFC, 0x0F, 0xBF, 0xDF, 0xE0,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFC, 0xFF, 0x3F, 0x0F, 0x87,
  0xE3, 0xF0, 0xF8, 0x7C, 0x3F, 0x1F, 0x87, 0xC3, 0xE1, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0xC3, 0xE1, 0xF0, 0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xE1, 0xF0,
  0xF8, 0x7E, 0x3F, 0x0F, 0x87, 0xC3, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x87,
  0xC3, 0xE1, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0xC7, 0xE1, 0xF0, 0xFC, 0x7E,
  0x1F, 0x0F, 0x87, 0xE1, 0xF0, 0xF8, 0x7C, 0x3F, 0x0F, 0x87, 0xC3, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x8F, 0xC3, 0xE1, 0xF8, 0x00, 0x03, 0xE0, 0x0F,
  0xCF, 0xF8, 0x0F, 0x9F, 0xFC, 0x0F, 0xBF, 0xFE, 0x0F, 0xFF, 0xFF, 0x1F,
  0xF0, 0xFF, 0x1F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F,
  0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F,
  0x00, 0x3F, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x7E,
  0x00, 0xFC, 0x7C, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFC, 0x3F, 0x8F, 0xE0, 0x3F, 0x9F, 0x80,
  0x3F, 0x7F, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF3, 0xF0, 0x0F, 0xC7,
  0xE0, 0x3F, 0x8F, 0xF1, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0xFD, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0,
  0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F,
  0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F,
  0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF8, 0x7E, 0x00,
  0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xFE, 0x7F, 0x81, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x3F, 0x7F, 0xF8, 0x0F, 0xC7, 0xF8, 0x03, 0xF0, 0x30, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0x1F, 0x07,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xE1, 0xFF, 0x3F,
  0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xF8, 0x7E,
  0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0xDF, 0xF8, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFD, 0xF0, 0x07, 0xF3, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x0F, 0x8F, 0xFC, 0x3F,
  0x3F, 0xF8, 0x7E, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF,
  0x03, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F,
  0xC0, 0xFE, 0x1F, 0x80, 0x7E, 0x1F, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFE, 0x01, 0xFC, 0x7F,
  0x03, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E,
  0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFC,
  0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7C, 0x00, 0xFC,
  0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8,
  0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0xFE, 0x07, 0xF0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFD, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFB, 0xF0,
  0x1F, 0xE3, 0xE0, 0x01, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF8,
  0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0,
  0x3E, 0x07, 0xC0, 0x3E, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x1F, 0x1F, 0x80,
  0x1F, 0x1F, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x7E, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x3E, 0x0F,
  0xFE, 0x0F, 0x83, 0xEF, 0x83, 0xE0, 0xFB, 0xE1, 0xF8, 0x7E, 0xF8, 0x7E,
  0x1F, 0x3E, 0x1F, 0x87, 0xCF, 0x8F, 0xE3, 0xF3, 0xE3, 0xF8, 0xF8, 0xF9,
  0xFE, 0x3E, 0x3E, 0x7F, 0x9F, 0x0F, 0x9F, 0xE7, 0xC3, 0xEF, 0x79, 0xF0,
  0xFB, 0xDE, 0x78, 0x3C, 0xE7, 0xBE, 0x0F, 0x79, 0xEF, 0x83, 0xDE, 0x7B,
  0xC0, 0xF7, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFE, 0x03, 0xF8,
  0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03,
  0xF0, 0x3F, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x7E,
  0x00, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x03, 0xF8, 0x01, 0xF8, 0x3F,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF1,
  0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC0, 0xFC, 0x01, 0xFC, 0x0F, 0xE0,
  0x3F, 0x80, 0x7E, 0x07, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x03, 0xFC, 0x3F, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x7F, 0x03, 0xF0,
  0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01,
  0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xE0, 0x3F, 0x00, 0x0F, 0xC1, 0xFC,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x01, 0xF0, 0xFC, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0xFB, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x40,
  0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF0,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0x80, 0x00, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x3C, 0xFF, 0xF0, 0x0F, 0x1F, 0xFF, 0x01, 0xE7, 0xFF, 0xF8,
  0x7C, 0xF8, 0x7F, 0xFF, 0x9E, 0x03, 0xFF, 0xE7, 0x80, 0x3F, 0xF8, 0x10,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0x80,
};

const GFXglyph RobotoMono_SemiBoldItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 12, 34, 28, 8, -34 },
  { 52, 16, 12, 28, 8, -36 },
  { 76, 28, 34, 28, 0, -34 },
  { 195, 25, 45, 28, 2, -40 },
  { 336, 23, 36, 28, 3, -35 },
  { 440, 26, 36, 28, 1, -35 },
  { 557, 7, 12, 28, 12, -36 },
  { 568, 17, 49, 28, 7, -38 },
  { 673, 16, 49, 28, 4, -38 },
  { 771, 23, 24, 28, 4, -34 },
  { 840, 24, 25, 28, 2, -28 },
  { 915, 10, 15, 28, 4, -6 },
  { 934, 19, 4, 28, 6, -17 },
  { 944, 8, 9, 28, 8, -8 },
  { 953, 25, 37, 28, 2, -34 },
  { 1069, 23, 36, 28, 3, -35 },
  { 1173, 16, 34, 28, 6, -34 },
  { 1241, 25, 35, 28, 0, -35 },
  { 1351, 25, 36, 28, 1, -35 },
  { 1464, 25, 34, 28, 0, -34 },
  { 1571, 25, 35, 28, 2, -34 },
  { 1681, 23, 35, 28, 2, -34 },
  { 1782, 25, 34, 28, 3, -34 },
  { 1889, 24, 36, 28, 2, -35 },
  { 1997, 22, 35, 28, 4, -35 },
  { 2094, 11, 29, 28, 9, -28 },
  { 2134, 15, 37, 28, 6, -28 },
  { 2204, 23, 22, 28, 3, -26 },
  { 2268, 24, 15, 28, 2, -22 },
  { 2313, 23, 23, 28, 2, -26 },
  { 2380, 21, 35, 28, 6, -35 },
  { 2472, 27, 34, 28, 1, -34 },
  { 2587, 27, 34, 28, -2, -34 },
  { 2702, 27, 34, 28, 1, -34 },
  { 2817, 26, 36, 28, 2, -35 },
  { 2934, 26, 34, 28, 1, -34 },
  { 3045, 28, 34, 28, 1, -34 },
  { 3164, 28, 34, 28, 1, -34 },
  { 3283, 25, 36, 28, 2, -35 },
  { 3396, 28, 34, 28, 0, -34 },
  { 3515, 25, 34, 28, 2, -34 },
  { 3622, 26, 35, 28, 2, -34 },
  { 3736, 31, 34, 28, 1, -34 },
  { 3868, 23, 34, 28, 1, -34 },
  { 3966, 28, 34, 28, 1, -34 },
  { 4085, 28, 34, 28, 0, -34 },
  { 4204, 25, 36, 28, 2, -35 },
  { 4317, 27, 34, 28, 1, -34 },
  { 4432, 25, 41, 28, 2, -35 },
  { 4561, 27, 34, 28, 1, -34 },
  { 4676, 27, 36, 28, 1, -35 },
  { 4798, 28, 34, 28, 3, -34 },
  { 4917, 26, 35, 28, 2, -34 },
  { 5031, 26, 34, 28, 4, -34 },
  { 5142, 28, 34, 28, 3, -34 },
  { 5261, 32, 34, 28, -1, -34 },
  { 5397, 27, 34, 28, 4, -34 },
  { 5512, 29, 34, 28, 0, -34 },
  { 5636, 17, 48, 28, 6, -40 },
  { 5738, 12, 37, 28, 9, -34 },
  { 5794, 17, 48, 28, 6, -40 },
  { 5896, 19, 18, 28, 5, -34 },
  { 5939, 22, 5, 28, 0, 0 },
  { 5953, 9, 7, 28, 13, -35 },
  { 5961, 23, 27, 28, 2, -26 },
  { 6039, 24, 37, 28, 1, -36 },
  { 6150, 23, 27, 28, 2, -26 },
  { 6228, 26, 37, 28, 2, -36 },
  { 6349, 24, 27, 28, 2, -26 },
  { 6430, 26, 37, 28, 4, -37 },
  { 6551, 26, 36, 28, 1, -26 },
  { 6668, 24, 36, 28, 1, -36 },
  { 6776, 21, 35, 28, 2, -35 },
  { 6868, 22, 45, 28, 1, -35 },
  { 6992, 27, 36, 28, 1, -36 },
  { 7114, 22, 36, 28, 2, -36 },
  { 7213, 28, 26, 28, -1, -26 },
  { 7304, 24, 26, 28, 1, -26 },
  { 7382, 23, 27, 28, 2, -26 },
  { 7460, 26, 36, 28, -1, -26 },
  { 7577, 24, 36, 28, 2, -26 },
  { 7685, 23, 26, 28, 4, -26 },
  { 7760, 24, 27, 28, 2, -26 },
  { 7841, 22, 33, 28, 4, -32 },
  { 7932, 24, 26, 28, 3, -25 },
  { 8010, 24, 25, 28, 4, -25 },
  { 8085, 26, 25, 28, 3, -25 },
  { 8167, 28, 25, 28, 0, -25 },
  { 8255, 30, 35, 28, 0, -25 },
  { 8387, 26, 25, 28, 1, -25 },
  { 8469, 18, 46, 28, 7, -38 },
  { 8573, 11, 44, 28, 8, -34 },
  { 8634, 19, 46, 28, 4, -37 },
  { 8744, 27, 10, 28, 0, -19 },
};

const GFXfont RobotoMono_SemiBoldItalic48pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic48pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic48pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC48PT7B_H_
