#ifndef _ROBOTOMONO_SEMIBOLDITALIC47PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0x7C, 0x00, 0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0xFB, 0xE1, 0xF7, 0x83,
  0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x79, 0xE0, 0xF3, 0xC1, 0xE7,
  0x83, 0xC0, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x87,
  0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0xF0, 0x00,
  0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0x07, 0x87, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0,
  0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x1E, 0x00,
  0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xE0, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0xF0, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E,
  0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0xFC, 0x07, 0xE0,
  0xFC, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC7, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF1, 0xF8,
  0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xF3, 0xFE, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0x8F, 0x82, 0x1E, 0x0F, 0x06, 0x3C, 0x1E, 0x1E,
  0x78, 0x3C, 0x78, 0xF0, 0xF0, 0xE1, 0xE1, 0xE3, 0xC3, 0xC3, 0xCF, 0x07,
  0xFF, 0xBC, 0x07, 0xFE, 0x78, 0x07, 0xF9, 0xE0, 0x03, 0xC7, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x3F, 0x00, 0x79, 0xFF, 0x00, 0xF7, 0xFF, 0x03, 0xCF,
  0xBE, 0x0F, 0x3C, 0x3C, 0x1C, 0x78, 0x78, 0x78, 0xF0, 0xF1, 0xE1, 0xE1,
  0xE1, 0x83, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x1F, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0xFE, 0x3E, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0x83, 0xF0, 0x03,
  0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0x8F, 0xC0,
  0x03, 0xE7, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x7C, 0x7F,
  0xF8, 0x3F, 0x3F, 0xBF, 0x0F, 0x9F, 0xCF, 0xE3, 0xE7, 0xE1, 0xF9, 0xFB,
  0xF8, 0x3F, 0x7C, 0xFC, 0x0F, 0xFF, 0x3F, 0x01, 0xFF, 0x8F, 0xC0, 0x7F,
  0xE3, 0xF0, 0x0F, 0xF0, 0xFE, 0x03, 0xF8, 0x1F, 0xC7, 0xFE, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x7E, 0x03, 0xFF, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x3D, 0xF7, 0xDF, 0x79, 0xE7, 0xBE, 0xFB, 0xCF, 0x3C,
  0x00, 0x02, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x00, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x03, 0x03, 0xC0, 0xDF, 0x0E, 0x0F, 0x7F, 0x39,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC1, 0xFF, 0xF8, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xF7, 0x80, 0x0F, 0x9F, 0x00, 0x7C,
  0x3C, 0x03, 0xF0, 0xF8, 0x1F, 0x81, 0xF0, 0x3C, 0x07, 0xC0, 0x60, 0x1C,
  0x00, 0x80, 0x20, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0x87, 0xE1,
  0xF8, 0x7C, 0x3F, 0x0F, 0x87, 0xE1, 0xF0, 0xF8, 0x04, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x18, 0x7E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFC, 0x3F, 0x87,
  0xE0, 0x3F, 0x0F, 0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x7E, 0x00, 0xF8, 0xFC,
  0x01, 0xF9, 0xF0, 0x03, 0xF7, 0xE0, 0x1F, 0xCF, 0xC0, 0x7F, 0x9F, 0x83,
  0xFF, 0x3F, 0x0F, 0xFE, 0x7E, 0x7F, 0xFC, 0xF9, 0xF9, 0xFB, 0xF7, 0xE3,
  0xF7, 0xFF, 0x07, 0xCF, 0xFC, 0x1F, 0x9F, 0xE0, 0x3F, 0x3F, 0x80, 0x7E,
  0x7E, 0x00, 0xFC, 0xF8, 0x01, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7,
  0xE0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xE3, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0xFC, 0x07, 0xF8, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0x7F, 0x7E, 0xF0, 0xFD, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xC3, 0xF8, 0x3F, 0x80, 0xFC, 0x1F,
  0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0x83, 0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0x80,
  0x7E, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F,
  0x1F, 0x80, 0x3F, 0x87, 0xE0, 0x3F, 0x83, 0xFC, 0x7F, 0xC0, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xBF, 0x00, 0x0F, 0x9F,
  0x80, 0x0F, 0x8F, 0x80, 0x0F, 0xC7, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xC3,
  0xF0, 0x07, 0xC1, 0xF8, 0x07, 0xC0, 0xFC, 0x07, 0xE0, 0x7C, 0x07, 0xE0,
  0x7E, 0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x1F, 0x83, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF3, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x3F, 0x83, 0xF8, 0x01, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0xFE, 0x0F, 0xC0,
  0x7E, 0x07, 0xF8, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07,
  0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x3F, 0x80, 0xFD, 0xFF, 0x83,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF9, 0xFE, 0x07, 0xE7, 0xF0,
  0x1F, 0xDF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xE7, 0xC0, 0x1F, 0x9F,
  0x80, 0xFE, 0x7E, 0x07, 0xF0, 0xFE, 0x3F, 0x83, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0,
  0x7E, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x7E, 0x1F, 0x80,
  0x7E, 0x0F, 0x80, 0xFE, 0x0F, 0xC1, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x3F, 0xC7,
  0xF0, 0x3F, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x00,
  0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03,
  0xF8, 0xFE, 0x07, 0xF0, 0x7F, 0x9F, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F,
  0xC3, 0xF9, 0xFC, 0x0F, 0xCF, 0xC0, 0x3E, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xF7, 0xF0, 0x3F, 0x9F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFD, 0xF0, 0x1F, 0x9F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x1F, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0x00, 0x7E, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x3E, 0x07,
  0xF0, 0x7F, 0x8F, 0xF8, 0x7F, 0x07, 0xF0, 0x3E, 0x00, 0x00, 0x20, 0x01,
  0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xE0, 0x7F, 0x80, 0x7F, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8,
  0x03, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFC,
  0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x01, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x40, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0x18, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF7, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x07, 0xF0, 0xFC, 0x03, 0xF0, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x78, 0x00,
  0x38, 0x3C, 0x1F, 0x8F, 0x0E, 0x1F, 0xF9, 0xC7, 0x8F, 0xFC, 0x73, 0xC7,
  0xC7, 0x1C, 0xF1, 0xE1, 0xC7, 0x38, 0xF0, 0xF1, 0xDE, 0x3C, 0x38, 0x77,
  0x9E, 0x0E, 0x1D, 0xC7, 0x83, 0x8F, 0x71, 0xE1, 0xE3, 0xBC, 0x70, 0x70,
  0xEF, 0x1C, 0x1C, 0x3B, 0xC7, 0x07, 0x0E, 0xF1, 0xC3, 0xC7, 0x3C, 0x70,
  0xF1, 0xCF, 0x1F, 0xFC, 0xE3, 0xC7, 0xFF, 0xF8, 0xF0, 0xFD, 0xFC, 0x1C,
  0x1C, 0x3C, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x01, 0x00,
  0x0F, 0xE1, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x7E, 0xFC, 0x00, 0x0F, 0x9F, 0x80, 0x03, 0xF1, 0xF0, 0x00, 0x7E,
  0x3E, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x1F, 0x00,
  0x1F, 0x83, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x01,
  0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x07,
  0xE1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF3, 0xF0,
  0x00, 0x7E, 0xFE, 0x00, 0x07, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xF0,
  0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3,
  0xF0, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x3F,
  0x87, 0xE0, 0x7F, 0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xF0, 0x0F, 0xE0, 0xFC, 0x00, 0xFC, 0x3F,
  0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC,
  0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0xC7, 0xE0, 0x07, 0xE1, 0xF8, 0x07,
  0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0x83,
  0xF8, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x9F, 0x80,
  0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x04, 0xFC, 0x00, 0x7C,
  0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x3F,
  0x83, 0xFC, 0x7F, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFC, 0x7F, 0xE0,
  0x7E, 0x07, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F,
  0x87, 0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01,
  0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x3F, 0x3F, 0x00,
  0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xE3, 0xF0,
  0x03, 0xF1, 0xF0, 0x01, 0xF9, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E,
  0x00, 0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0xFE, 0x1F, 0x81, 0xFE, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFE, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0x83, 0xF8, 0x3F, 0x80, 0xFC, 0x3F, 0x80,
  0x3E, 0x1F, 0x80, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xFF, 0xBF, 0x03, 0xFF, 0x9F,
  0x81, 0xFF, 0xCF, 0xC0, 0xFF, 0xE7, 0xE0, 0xFF, 0xF3, 0xF0, 0x01, 0xF9,
  0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F,
  0x0F, 0xC0, 0x1F, 0x87, 0xF0, 0x1F, 0xC1, 0xFE, 0x7F, 0xE0, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3E, 0x03, 0xE0, 0x07,
  0xE0, 0x3E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07,
  0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0xC0, 0xFC, 0x00,
  0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0x80,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0x80, 0x1F, 0x01, 0xF8, 0x01, 0xF0,
  0x1F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0,
  0x03, 0xF0, 0x3F, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xE0, 0x3E, 0x00, 0x7E,
  0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E,
  0x00, 0x7C, 0x07, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x03, 0xF0,
  0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x83, 0xF8, 0x1F,
  0xC0, 0x7F, 0x9F, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x03,
  0xFC, 0x1F, 0x80, 0x1F, 0xC0, 0x7E, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0,
  0x07, 0xC0, 0x3F, 0x80, 0x3F, 0x01, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x03,
  0xF0, 0x7F, 0x80, 0x0F, 0xC3, 0xFC, 0x00, 0x3F, 0x1F, 0xE0, 0x00, 0xF8,
  0x7F, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x7E, 0xFE,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFB, 0xF0, 0x00,
  0x3F, 0xCF, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xE0, 0x07, 0xE0,
  0x1F, 0x80, 0x1F, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x03,
  0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xFC,
  0x1F, 0xE0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC7, 0xFE,
  0x07, 0xFC, 0x7B, 0xE0, 0x7F, 0xCF, 0xFE, 0x0F, 0xFC, 0xF7, 0xC0, 0xF9,
  0xFF, 0x7C, 0x0F, 0x9F, 0xE7, 0xC0, 0xF9, 0xFE, 0x7C, 0x0F, 0x9F, 0xCF,
  0xC0, 0xF9, 0xFC, 0xFC, 0x1F, 0x9F, 0xCF, 0x81, 0xF9, 0xF8, 0xF8, 0x1F,
  0x1F, 0x8F, 0x81, 0xF1, 0xF1, 0xF8, 0x1F, 0x1F, 0x1F, 0x83, 0xF0, 0xE1,
  0xF0, 0x3F, 0x00, 0x1F, 0x03, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03,
  0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xE0, 0x7E, 0x00,
  0x3E, 0x07, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xE0,
  0xFC, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x7E, 0x03,
  0xF8, 0x07, 0xE0, 0x3F, 0x80, 0x7E, 0x07, 0xF8, 0x07, 0xE0, 0x7F, 0xC0,
  0x7E, 0x07, 0xFC, 0x07, 0xE0, 0x7F, 0xC0, 0xFC, 0x07, 0xFC, 0x0F, 0xC0,
  0xFF, 0xE0, 0xFC, 0x0F, 0xFE, 0x0F, 0xC0, 0xFF, 0xE0, 0xFC, 0x0F, 0xDE,
  0x0F, 0x80, 0xFD, 0xF1, 0xF8, 0x0F, 0xDF, 0x1F, 0x81, 0xF8, 0xF1, 0xF8,
  0x1F, 0x8F, 0x1F, 0x81, 0xF8, 0xF9, 0xF8, 0x1F, 0x8F, 0x9F, 0x01, 0xF8,
  0x7B, 0xF0, 0x1F, 0x07, 0xFF, 0x03, 0xF0, 0x7F, 0xF0, 0x3F, 0x07, 0xFF,
  0x03, 0xF0, 0x3F, 0xF0, 0x3F, 0x03, 0xFE, 0x03, 0xF0, 0x3F, 0xE0, 0x3E,
  0x03, 0xFE, 0x07, 0xE0, 0x1F, 0xE0, 0x7E, 0x01, 0xFE, 0x07, 0xE0, 0x1F,
  0xE0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0x87, 0xF0, 0x3F, 0x01, 0xF8, 0x3F, 0x00,
  0x7E, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x07, 0xC7, 0xC0,
  0x03, 0xE7, 0xE0, 0x01, 0xF3, 0xF0, 0x00, 0xF9, 0xF8, 0x00, 0xFC, 0xFC,
  0x00, 0x7E, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF,
  0x80, 0x07, 0xEF, 0xC0, 0x03, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF9,
  0xF8, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x7E,
  0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x7F, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x7E, 0x07, 0xF8, 0x0F, 0xC0, 0x3F, 0x81, 0xF8,
  0x03, 0xF0, 0x3E, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xC1, 0xF8, 0x00, 0xF8,
  0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x00,
  0x3F, 0x87, 0xE0, 0x0F, 0xE0, 0xFC, 0x0F, 0xF8, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0x87,
  0xF0, 0x3F, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x1F, 0x80,
  0x0F, 0x8F, 0xC0, 0x07, 0xE7, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0,
  0x00, 0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x3F, 0x7E,
  0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7,
  0xE0, 0x01, 0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x3F,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x80, 0x07,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x07, 0xE0, 0xFF, 0x81, 0xF0, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00,
  0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x7E,
  0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xE1, 0xF8, 0x07, 0xF0,
  0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x07,
  0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7C, 0x00, 0xFC, 0x3F, 0x00, 0x3F,
  0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x81, 0xFE, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x3F, 0x00,
  0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0xC7,
  0xE0, 0x03, 0xF1, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x0F, 0xF9, 0xFF,
  0x81, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0xF8, 0x3E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0,
  0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x07,
  0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F,
  0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF8, 0x7E, 0x00,
  0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E,
  0x00, 0xFC, 0x1F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0,
  0xFC, 0x00, 0xF8, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x3F, 0x81, 0xF8, 0x1F,
  0xC0, 0x7F, 0x9F, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x03, 0xF1, 0xF8, 0x01, 0xFC, 0x7E, 0x00,
  0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E,
  0x01, 0xFC, 0x1F, 0x80, 0x7E, 0x03, 0xE0, 0x3F, 0x80, 0xFC, 0x0F, 0xC0,
  0x3F, 0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x3F,
  0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF1, 0xF8, 0x00, 0x7C,
  0x7E, 0x00, 0x1F, 0x3F, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x1F, 0x07,
  0xEF, 0x83, 0xE0, 0xF9, 0xF0, 0x7C, 0x1F, 0x3E, 0x1F, 0x87, 0xE7, 0xC3,
  0xF0, 0xF8, 0xF8, 0x7E, 0x1F, 0x1F, 0x1F, 0xC3, 0xE3, 0xE3, 0xF8, 0xFC,
  0x7C, 0x7F, 0x1F, 0x0F, 0x8F, 0xE3, 0xE1, 0xF3, 0xFC, 0xFC, 0x3E, 0x7F,
  0x9F, 0x07, 0xCF, 0xF3, 0xE0, 0xFB, 0xDE, 0x7C, 0x1F, 0x7B, 0xDF, 0x87,
  0xCF, 0x7B, 0xE0, 0xFB, 0xEF, 0x7C, 0x1F, 0x79, 0xEF, 0x83, 0xEF, 0x3F,
  0xE0, 0x7D, 0xE7, 0xFC, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0x3F,
  0xE3, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFC,
  0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC,
  0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0x80,
  0x00, 0x07, 0xF0, 0x01, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x07, 0xE0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x7E, 0x00, 0x1F, 0x81, 0xFC,
  0x00, 0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x3F, 0x80,
  0x00, 0xFC, 0xFE, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x7F, 0x3E, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7E, 0x03,
  0xF0, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x3F, 0x80, 0x0F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F,
  0xDF, 0x80, 0x07, 0xE7, 0xE0, 0x03, 0xF8, 0xFC, 0x01, 0xFC, 0x3F, 0x00,
  0x7E, 0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x1F,
  0x83, 0xF8, 0x07, 0xE0, 0xFC, 0x00, 0xF8, 0x7E, 0x00, 0x3F, 0x1F, 0x80,
  0x0F, 0xCF, 0xC0, 0x03, 0xF7, 0xE0, 0x00, 0x7D, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0xF8, 0x1F, 0x03,
  0xE0, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF8, 0x3F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x01,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8,
  0x01, 0xFF, 0x00, 0x7B, 0xC0, 0x3E, 0xF0, 0x0F, 0x3C, 0x07, 0xCF, 0x01,
  0xE3, 0xE0, 0xF8, 0xF8, 0x7C, 0x1E, 0x1F, 0x07, 0x8F, 0x81, 0xF3, 0xE0,
  0x7D, 0xF0, 0x1F, 0xF8, 0x03, 0xC0, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x0F, 0x83, 0xF0,
  0x7C, 0x0F, 0x81, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x1F, 0xC3, 0xF8, 0xFE, 0x07, 0xF3, 0xF0, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0xFF, 0x83, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF9, 0xFF, 0xC7, 0xE7, 0xF0, 0x1F, 0xBF, 0x00, 0x7E,
  0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xCF, 0x80, 0x3F, 0x3F, 0x01, 0xFC, 0xFE,
  0x1F, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFE, 0xFC, 0x1F, 0xE3,
  0xF0, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xCF, 0xE0, 0x0F, 0xDF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0xE0,
  0xFE, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x00,
  0x3F, 0x1F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00,
  0x3E, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0xFC, 0x7E, 0x00, 0xFC, 0x7F, 0x01, 0xF8, 0x7F, 0xCF, 0xF8, 0x7F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE0, 0xFD, 0xFF, 0xC0, 0xF8, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC3, 0xF8, 0x1F, 0x8F, 0xE0, 0x1F, 0x1F, 0x80, 0x3E,
  0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0x83, 0xF8,
  0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x0F, 0xE3, 0xF0, 0x0F, 0xFE, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F,
  0xC0, 0x1F, 0x87, 0xE0, 0x07, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC,
  0x1F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00,
  0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0x7E,
  0x03, 0xF8, 0x1F, 0x81, 0xFE, 0x07, 0xF9, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0x7C, 0x00, 0xFF, 0x3F, 0x00, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC3, 0xF8, 0x1F, 0x8F, 0xE0, 0x1F, 0x1F, 0x80, 0x3F, 0x7E, 0x00, 0x7E,
  0xFC, 0x00, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x01, 0x83, 0xF8, 0x07, 0x83, 0xFC, 0x7F, 0x87, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x8F, 0x80, 0xFF, 0xEF, 0xC0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0x03, 0xF8, 0x7F, 0x00,
  0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0,
  0x0F, 0x87, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8,
  0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x0F,
  0xC0, 0x3F, 0x07, 0xE0, 0x3F, 0x83, 0xFE, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x04, 0x00, 0x7E, 0x03, 0x00, 0x7F, 0x03, 0xE0, 0xFF,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC7, 0xF0, 0x0F, 0xDF, 0xF8, 0x0F, 0xBF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x1F, 0xE0, 0x7F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F,
  0x80, 0x3F, 0x1F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3E, 0x3F,
  0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7C,
  0x00, 0xFC, 0x7C, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xF8, 0xFC,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x01, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x80,
  0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x03, 0xFC, 0x3F, 0x01, 0xFE, 0x0F, 0xC0, 0xFF, 0x03, 0xE0, 0x7F, 0x80,
  0xF8, 0x3F, 0xC0, 0x7E, 0x1F, 0xC0, 0x1F, 0x8F, 0xE0, 0x07, 0xE7, 0xF0,
  0x01, 0xFB, 0xF8, 0x00, 0x7D, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F,
  0xE7, 0xF0, 0x07, 0xF0, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x7E, 0x07, 0xE0,
  0x1F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0xE0, 0xFC, 0x01,
  0xF8, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xE0, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x01, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xDF, 0x8F, 0x81, 0xF7, 0xFB, 0xF8, 0x3F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0xFC, 0x3E, 0x1F, 0x1F, 0x8F, 0xC3, 0xE3, 0xE1,
  0xF0, 0xFC, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x7E, 0x1F, 0x0F, 0x8F, 0x87, 0xE1, 0xF1, 0xF0, 0xF8, 0x7E, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF1, 0xF8, 0x7C, 0x3E, 0x3F, 0x0F, 0x87, 0xC7,
  0xC3, 0xF0, 0xF8, 0xF8, 0x7C, 0x3F, 0x1F, 0x0F, 0x87, 0xE3, 0xE1, 0xF0,
  0xF8, 0xFC, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xF0, 0x0F, 0x9F, 0xF8, 0x0F,
  0xBF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xE0, 0x7F, 0x1F,
  0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x3F, 0x3F,
  0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F,
  0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x7E,
  0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x03,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xF0,
  0x3F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00,
  0xFD, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x03, 0xF1,
  0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0x87, 0xF8, 0xFF, 0x07, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x03,
  0xF3, 0xF8, 0x00, 0xFB, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x81, 0xFE, 0x0F, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x80,
  0x7E, 0x07, 0xE0, 0x0F, 0xC1, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F,
  0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8,
  0x3E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xC1, 0xF8, 0x07,
  0xF0, 0x7F, 0x01, 0xF8, 0x1F, 0xF1, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x80, 0xFD, 0xFF, 0xC0, 0x3F, 0x3F, 0xE0, 0x0F, 0xC0, 0x80, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x1F, 0x03, 0xFF, 0xBF, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xC0, 0xFE, 0x3F,
  0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0x7E,
  0x00, 0xFC, 0x7C, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x7E,
  0x01, 0xF8, 0x7E, 0x07, 0xF8, 0x7F, 0x9F, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xF3, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x0F, 0xC3, 0xFE, 0x1F, 0x9F, 0xF8, 0x3F, 0x7F, 0xF0, 0x7D,
  0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE1, 0xFE, 0x1F, 0xC3, 0xF0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80,
  0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xF9, 0xF8, 0x01, 0xF3, 0xF0, 0x03, 0xE7, 0xE0, 0x0F, 0xC7,
  0xF0, 0x3F, 0x8F, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x00, 0x40, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x01, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xFE, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xE0,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC,
  0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xE0, 0x07, 0xCF, 0xC0, 0x1F, 0x9F, 0x80,
  0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF0, 0x03,
  0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7E,
  0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7,
  0xE0, 0x3F, 0x8F, 0xF3, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFE, 0xF8, 0x1F,
  0xF9, 0xF0, 0x1F, 0xE3, 0xE0, 0x02, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x1F, 0x8F, 0x80,
  0x3F, 0x1F, 0x00, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x07, 0xE0, 0x7C, 0x0F,
  0xC0, 0xF8, 0x3F, 0x01, 0xF0, 0x7C, 0x03, 0xE1, 0xF8, 0x07, 0xE3, 0xE0,
  0x07, 0xCF, 0xC0, 0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0xF8, 0x00,
  0x3D, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x3C, 0x0F, 0xFC,
  0x1E, 0x07, 0xFE, 0x0F, 0x07, 0xFF, 0x0F, 0x83, 0xEF, 0x87, 0xC1, 0xF7,
  0xC3, 0xE1, 0xF3, 0xE3, 0xF0, 0xF9, 0xF1, 0xF8, 0x7C, 0xF9, 0xFC, 0x7C,
  0x78, 0xFF, 0x3E, 0x3C, 0x77, 0x9F, 0x1E, 0x7B, 0xDF, 0x0F, 0x3D, 0xEF,
  0x87, 0x9C, 0xF7, 0xC3, 0xDE, 0x7B, 0xC1, 0xEE, 0x3F, 0xE0, 0xFF, 0x1F,
  0xF0, 0x7F, 0x8F, 0xF0, 0x3F, 0x87, 0xF8, 0x1F, 0xC3, 0xFC, 0x0F, 0xE1,
  0xFC, 0x07, 0xE0, 0xFE, 0x03, 0xF0, 0x7E, 0x01, 0xF0, 0x3F, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x07, 0xE0,
  0x1F, 0xC0, 0x3F, 0x03, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0xFC, 0xFE, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xBF, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0x1F,
  0x80, 0x1F, 0xC0, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x07,
  0xF0, 0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x7E,
  0x00, 0x1F, 0x83, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x07, 0xF0,
  0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07,
  0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x07, 0xC7,
  0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xC0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E,
  0x00, 0x01, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x7F,
  0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x81, 0xFF, 0xC0, 0x3C, 0xFF, 0xF8,
  0x1F, 0x7F, 0xFF, 0x0F, 0x9F, 0x0F, 0xFF, 0xE7, 0x81, 0xFF, 0xFB, 0xC0,
  0x3F, 0xFC, 0x70, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x00,
};

const GFXglyph RobotoMono_SemiBoldItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 12, 33, 28, 8, -33 },
  { 51, 15, 12, 28, 8, -35 },
  { 74, 28, 33, 28, 0, -33 },
  { 190, 25, 44, 28, 2, -39 },
  { 328, 23, 35, 28, 3, -34 },
  { 429, 26, 35, 28, 1, -34 },
  { 543, 6, 12, 28, 12, -35 },
  { 552, 16, 48, 28, 7, -37 },
  { 648, 16, 48, 28, 4, -37 },
  { 744, 22, 23, 28, 4, -33 },
  { 808, 23, 25, 28, 2, -28 },
  { 880, 10, 14, 28, 4, -5 },
  { 898, 19, 5, 28, 6, -17 },
  { 910, 8, 8, 28, 8, -8 },
  { 918, 24, 36, 28, 2, -33 },
  { 1026, 23, 35, 28, 3, -34 },
  { 1127, 15, 33, 28, 6, -33 },
  { 1189, 25, 34, 28, 0, -34 },
  { 1296, 25, 35, 28, 1, -34 },
  { 1406, 25, 33, 28, 0, -33 },
  { 1510, 25, 34, 28, 2, -33 },
  { 1617, 22, 35, 28, 2, -34 },
  { 1714, 24, 33, 28, 3, -33 },
  { 1813, 24, 35, 28, 2, -34 },
  { 1918, 21, 34, 28, 4, -34 },
  { 2008, 12, 27, 28, 8, -27 },
  { 2049, 15, 36, 28, 6, -27 },
  { 2117, 22, 21, 28, 3, -25 },
  { 2175, 24, 15, 28, 2, -22 },
  { 2220, 22, 22, 28, 2, -25 },
  { 2281, 20, 34, 28, 6, -34 },
  { 2366, 26, 33, 28, 1, -33 },
  { 2474, 27, 33, 28, -2, -33 },
  { 2586, 26, 33, 28, 1, -33 },
  { 2694, 25, 35, 28, 2, -34 },
  { 2804, 25, 33, 28, 1, -33 },
  { 2908, 27, 33, 28, 1, -33 },
  { 3020, 27, 33, 28, 1, -33 },
  { 3132, 25, 35, 28, 2, -34 },
  { 3242, 28, 33, 28, 0, -33 },
  { 3358, 25, 33, 28, 2, -33 },
  { 3462, 26, 34, 28, 2, -33 },
  { 3573, 30, 33, 28, 1, -33 },
  { 3697, 22, 33, 28, 1, -33 },
  { 3788, 28, 33, 28, 0, -33 },
  { 3904, 28, 33, 28, 0, -33 },
  { 4020, 25, 35, 28, 2, -34 },
  { 4130, 27, 33, 28, 1, -33 },
  { 4242, 25, 40, 28, 2, -34 },
  { 4367, 26, 33, 28, 1, -33 },
  { 4475, 26, 34, 28, 1, -34 },
  { 4586, 27, 33, 28, 3, -33 },
  { 4698, 26, 34, 28, 2, -33 },
  { 4809, 26, 33, 28, 4, -33 },
  { 4917, 27, 33, 28, 3, -33 },
  { 5029, 31, 33, 28, -1, -33 },
  { 5157, 26, 33, 28, 4, -33 },
  { 5265, 28, 33, 28, 0, -33 },
  { 5381, 17, 47, 28, 6, -39 },
  { 5481, 11, 36, 28, 9, -33 },
  { 5531, 17, 47, 28, 6, -39 },
  { 5631, 18, 17, 28, 5, -33 },
  { 5670, 21, 5, 28, 0, 0 },
  { 5684, 10, 6, 28, 12, -34 },
  { 5692, 22, 25, 28, 2, -25 },
  { 5761, 24, 36, 28, 1, -35 },
  { 5869, 23, 26, 28, 2, -25 },
  { 5944, 26, 35, 28, 2, -35 },
  { 6058, 23, 25, 28, 2, -25 },
  { 6130, 25, 36, 28, 4, -36 },
  { 6243, 25, 35, 28, 1, -25 },
  { 6353, 24, 35, 28, 1, -35 },
  { 6458, 21, 35, 28, 2, -35 },
  { 6550, 22, 45, 28, 1, -35 },
  { 6674, 26, 35, 28, 1, -35 },
  { 6788, 21, 35, 28, 2, -35 },
  { 6880, 27, 25, 28, -1, -25 },
  { 6965, 24, 25, 28, 1, -25 },
  { 7040, 23, 26, 28, 2, -25 },
  { 7115, 26, 35, 28, -1, -25 },
  { 7229, 24, 35, 28, 2, -25 },
  { 7334, 23, 25, 28, 4, -25 },
  { 7406, 23, 26, 28, 2, -25 },
  { 7481, 21, 32, 28, 4, -31 },
  { 7565, 23, 26, 28, 3, -25 },
  { 7640, 23, 25, 28, 4, -25 },
  { 7712, 25, 25, 28, 3, -25 },
  { 7791, 28, 25, 28, 0, -25 },
  { 7879, 29, 35, 28, 0, -25 },
  { 8006, 25, 25, 28, 1, -25 },
  { 8085, 18, 45, 28, 7, -37 },
  { 8187, 11, 42, 28, 8, -33 },
  { 8245, 19, 45, 28, 4, -37 },
  { 8352, 26, 10, 28, 0, -19 },
};

const GFXfont RobotoMono_SemiBoldItalic47pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic47pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic47pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC47PT7B_H_
