#ifndef _ROBOTOMONO_SEMIBOLDITALIC46PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x0F, 0xC1, 0xFC, 0x3F, 0x87, 0xE0, 0x7C, 0x00, 0x3C,
  0x3E, 0x78, 0x7D, 0xF0, 0xF3, 0xE1, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x0F,
  0x3C, 0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0x80, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0xF0, 0xF0, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0,
  0xF0, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0x83, 0x80, 0x3F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x1E,
  0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07,
  0x87, 0x80, 0x00, 0xF0, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x07, 0x87, 0x80, 0x00, 0xE0,
  0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x00, 0xE0, 0xF0, 0x00,
  0x3C, 0x1C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xE0, 0xF0, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xE0, 0x7E, 0x0F,
  0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x3F, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0x7E,
  0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7F, 0x8F, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0x7C, 0x00, 0xF8, 0xF0,
  0x23, 0xC3, 0xC1, 0xEF, 0x0F, 0x0F, 0x3C, 0x3C, 0x38, 0xF0, 0xF1, 0xE3,
  0xC3, 0xCF, 0x0F, 0x9E, 0x78, 0x1F, 0xF9, 0xE0, 0x7F, 0xCF, 0x00, 0x7C,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0xF0, 0x03, 0xCF, 0xF0, 0x0E, 0x7F, 0xE0,
  0x7B, 0xFF, 0xC3, 0xCF, 0x0F, 0x0E, 0x3C, 0x3C, 0x78, 0xF0, 0xF3, 0xC7,
  0x83, 0xC6, 0x1E, 0x0F, 0x08, 0x78, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0x87, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xC0,
  0xF8, 0x03, 0xE0, 0xFC, 0x01, 0xF8, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xFE, 0x07, 0xC7, 0xFF, 0x83, 0xE7, 0xFF, 0xC1, 0xF7,
  0xF3, 0xF1, 0xFB, 0xF0, 0xFC, 0xFB, 0xF0, 0x7E, 0xFD, 0xF8, 0x1F, 0xFC,
  0xFC, 0x0F, 0xFE, 0x7E, 0x03, 0xFE, 0x3F, 0x01, 0xFE, 0x1F, 0x80, 0x7F,
  0x0F, 0xF1, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFD,
  0xFC, 0x0F, 0xF8, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7D, 0xF7, 0xDE, 0x79,
  0xEF, 0xBE, 0xF3, 0xCF, 0x3C, 0x00, 0x02, 0x00, 0x06, 0x00, 0x1E, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03,
  0x80, 0x01, 0x00, 0x01, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x03, 0xF0, 0x07,
  0xC0, 0x0F, 0x00, 0x18, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x04, 0x03,
  0x80, 0x5C, 0x0E, 0x0E, 0x7C, 0x38, 0xFB, 0xFC, 0xEF, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0x00, 0x0F, 0x9E, 0x00, 0x7C, 0x7C, 0x03, 0xF0, 0xF0, 0x1F, 0x83,
  0xE0, 0x7C, 0x0F, 0xC0, 0x60, 0x1C, 0x00, 0x80, 0x60, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E,
  0x0F, 0x87, 0xE1, 0xF0, 0x7C, 0x3F, 0x0F, 0x87, 0xC3, 0xF0, 0x78, 0x04,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07,
  0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0x07,
  0xE1, 0xF8, 0x0F, 0xC7, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3,
  0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x03, 0xFD, 0xF8, 0x1F, 0xF7, 0xE1,
  0xFF, 0xDF, 0x0F, 0xFE, 0x7C, 0xFC, 0xFB, 0xF7, 0xE7, 0xEF, 0xFE, 0x1F,
  0xBF, 0xF0, 0x7E, 0xFF, 0x01, 0xFB, 0xF8, 0x07, 0xCF, 0x80, 0x1F, 0x3E,
  0x00, 0xFC, 0xF8, 0x03, 0xF3, 0xE0, 0x0F, 0x8F, 0xC0, 0x7E, 0x3F, 0x03,
  0xF0, 0x7E, 0x1F, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x0F, 0x00, 0x7F,
  0x03, 0xFE, 0x0F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7C, 0x7E,
  0x70, 0x7C, 0x80, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x07, 0xF0, 0x7F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F,
  0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0x3F,
  0x0F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xF8, 0xFC, 0x01, 0xF8,
  0x7E, 0x03, 0xF8, 0x7F, 0x8F, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0xF8, 0xFC, 0x01, 0xF0, 0xFC, 0x03, 0xE0, 0xF8, 0x07, 0xE0, 0xF8,
  0x0F, 0xC1, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x01, 0xF8, 0x3E, 0x01, 0xF0,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x3F, 0x87, 0xF8, 0x06, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0x7E, 0x07, 0xF0,
  0x7F, 0x0F, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xC0,
  0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x7F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC3, 0x80, 0x3F, 0x7F, 0xC0, 0xFB, 0xFF, 0x87, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFC, 0x7F, 0x83, 0xF9, 0xFC, 0x07, 0xE7, 0xE0, 0x1F, 0xBF, 0x00,
  0x3E, 0xFC, 0x00, 0xFB, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0xBF, 0x00, 0x7E,
  0xFC, 0x01, 0xF9, 0xF0, 0x07, 0xE7, 0xE0, 0x3F, 0x1F, 0x81, 0xFC, 0x3F,
  0x8F, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFC, 0x1F,
  0xC3, 0xF0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC,
  0x7E, 0x01, 0xF8, 0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xFC, 0x7F, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC1, 0xF8, 0x1F, 0x87, 0xE0, 0x1F, 0x8F, 0x80, 0x3F, 0x3F, 0x00,
  0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x0F,
  0xC7, 0xF0, 0x3F, 0x87, 0xF1, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xC1,
  0xF8, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x7E, 0x00, 0xFB, 0xF0, 0x07, 0xDF,
  0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x07,
  0xEF, 0xC0, 0x3F, 0x7E, 0x03, 0xFB, 0xFC, 0x7F, 0xCF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xF9, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x03, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0xFE, 0x0F, 0xE1, 0xFF, 0x0F, 0xE0, 0xFE, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0x7F, 0x07, 0xE0, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x07, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xFC,
  0x01, 0xE0, 0x01, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xC0, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x3E, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xE0, 0x7E,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x01, 0xF8, 0x1F,
  0x00, 0xF8, 0x01, 0xC0, 0x78, 0x00, 0x78, 0x3C, 0x0E, 0x0E, 0x0F, 0x0F,
  0xE3, 0x87, 0x8F, 0xFC, 0xE1, 0xC7, 0xFF, 0x38, 0xF1, 0xE3, 0xCE, 0x38,
  0xF0, 0xE3, 0x9E, 0x3C, 0x38, 0xE7, 0x9E, 0x0E, 0x39, 0xC7, 0x87, 0x8E,
  0x71, 0xE1, 0xC3, 0xBC, 0x70, 0x70, 0xEF, 0x3C, 0x1C, 0x73, 0xCF, 0x0F,
  0x1C, 0xF3, 0xC3, 0x87, 0x38, 0xF0, 0xE3, 0x8F, 0x1E, 0xF8, 0xE3, 0xC7,
  0xFF, 0xF0, 0xF1, 0xFD, 0xF8, 0x3C, 0x3C, 0x7C, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC1, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x7C, 0xF8, 0x00,
  0x3F, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0x7C,
  0x00, 0x7C, 0x1F, 0x00, 0x3F, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x07, 0xE0,
  0x7C, 0x01, 0xF0, 0x1F, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0xF8,
  0x7E, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0x8F, 0xC0, 0x03, 0xF3, 0xF0, 0x00,
  0xFD, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x83, 0xF0, 0x1F, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x3E, 0x0F, 0xC0,
  0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F,
  0x80, 0x3F, 0x07, 0xE0, 0x3F, 0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xF0, 0x3F, 0xE0, 0xFC, 0x01,
  0xF8, 0x3F, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8,
  0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xE1,
  0xF0, 0x07, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F,
  0xE0, 0x7E, 0x1F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x1F, 0x3F,
  0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC,
  0x01, 0xF8, 0x7C, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x7F, 0x8F, 0xF0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7E, 0x0F, 0xF0, 0x3F, 0x01, 0xF8,
  0x1F, 0x80, 0xFE, 0x0F, 0xC0, 0x3F, 0x07, 0xC0, 0x1F, 0x87, 0xE0, 0x07,
  0xC3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00,
  0x7E, 0x3E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0,
  0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xE0, 0x03, 0xF1, 0xF0, 0x03, 0xF1, 0xF8,
  0x01, 0xF8, 0xFC, 0x01, 0xFC, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x1F,
  0x00, 0xFE, 0x1F, 0x81, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xE0, 0x7E,
  0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x1F, 0x3F, 0x00, 0x1F,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x0F, 0xFE, 0xFC, 0x0F, 0xFE,
  0xFC, 0x0F, 0xFE, 0xFC, 0x1F, 0xFE, 0xFC, 0x1F, 0xFC, 0xFC, 0x00, 0x7C,
  0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC,
  0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x3F, 0x8F, 0xF8, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x81, 0xF0,
  0x03, 0xF0, 0x7E, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0x81, 0xF8, 0x03, 0xF0,
  0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x01, 0xF8, 0x3F, 0x00,
  0x3E, 0x07, 0xE0, 0x07, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x00, 0x3F, 0x03,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0x80, 0x1F, 0x81, 0xF0, 0x03, 0xF0, 0x7E,
  0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E,
  0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3E, 0x07, 0xE0,
  0x07, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x00, 0x3F, 0x03, 0xE0, 0x07, 0xE0,
  0xFC, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE1, 0xF0, 0x03, 0xF0, 0xF8, 0x01,
  0xF8, 0x7C, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFE, 0x07, 0xF1,
  0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x3F, 0x00,
  0x3F, 0x81, 0xF8, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x80, 0x7C, 0x03, 0xF8,
  0x07, 0xE0, 0x3F, 0x80, 0x3F, 0x03, 0xF8, 0x01, 0xF8, 0x3F, 0xC0, 0x0F,
  0xC3, 0xFC, 0x00, 0x7C, 0x1F, 0xC0, 0x03, 0xE1, 0xFC, 0x00, 0x3F, 0x1F,
  0xC0, 0x01, 0xF9, 0xFC, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFC, 0xFC, 0x00, 0x1F, 0xC7,
  0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x03, 0xF0,
  0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFE, 0x00, 0xF8, 0x03, 0xF0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0x80,
  0x0F, 0xC0, 0xFC, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xE0,
  0x3F, 0x81, 0xFE, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC,
  0x3F, 0xE0, 0x7F, 0xC7, 0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0xCF, 0xFC,
  0x0F, 0xBC, 0xF7, 0xC0, 0xFB, 0xDF, 0x7C, 0x0F, 0xBD, 0xEF, 0xC0, 0xFB,
  0xFE, 0xF8, 0x0F, 0x9F, 0xCF, 0x80, 0xF9, 0xFC, 0xF8, 0x1F, 0x9F, 0x8F,
  0x81, 0xF1, 0xF9, 0xF8, 0x1F, 0x1F, 0x1F, 0x81, 0xF1, 0xF1, 0xF0, 0x1F,
  0x1E, 0x1F, 0x03, 0xF1, 0xE1, 0xF0, 0x3F, 0x1C, 0x1F, 0x03, 0xE0, 0x03,
  0xF0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x07,
  0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xE0, 0x7C, 0x00,
  0x7C, 0x07, 0xC0, 0x07, 0xC0, 0xFC, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x07,
  0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xFC, 0x03, 0xF0, 0x7F,
  0x80, 0x7C, 0x0F, 0xF0, 0x1F, 0x81, 0xFE, 0x03, 0xF0, 0x3F, 0xE0, 0x7E,
  0x07, 0xFC, 0x0F, 0xC0, 0xFF, 0x81, 0xF8, 0x3F, 0xF0, 0x3E, 0x07, 0xFF,
  0x0F, 0xC0, 0xFF, 0xE1, 0xF8, 0x1F, 0xBC, 0x3F, 0x03, 0xE7, 0xC7, 0xE0,
  0xFC, 0xF8, 0xF8, 0x1F, 0x9F, 0x1F, 0x03, 0xF1, 0xE7, 0xE0, 0x7E, 0x3E,
  0xFC, 0x0F, 0xC7, 0xDF, 0x81, 0xF0, 0x7B, 0xF0, 0x7E, 0x0F, 0x7C, 0x0F,
  0xC1, 0xFF, 0x81, 0xF8, 0x3F, 0xF0, 0x3F, 0x03, 0xFE, 0x07, 0xC0, 0x7F,
  0xC0, 0xF8, 0x0F, 0xF8, 0x3F, 0x01, 0xFE, 0x07, 0xE0, 0x1F, 0xC0, 0xFC,
  0x03, 0xF8, 0x1F, 0x80, 0x7F, 0x03, 0xE0, 0x0F, 0xE0, 0xFC, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0x7E, 0x1F, 0x80,
  0x3E, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00,
  0x3F, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0xFC, 0xFC, 0x00,
  0xFC, 0xFC, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0x7E, 0x07,
  0xF0, 0x7F, 0x9F, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01,
  0xF8, 0x0F, 0xE0, 0x7C, 0x01, 0xF8, 0x1F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F,
  0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0x80,
  0x0F, 0xC7, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF8, 0x7E, 0x03, 0xFC, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xE0,
  0xFE, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00,
  0x3F, 0x3E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xF8, 0x00,
  0x7E, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01,
  0xF8, 0xFC, 0x03, 0xF8, 0x7E, 0x07, 0xF0, 0x7F, 0x9F, 0xE0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x40, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xF0, 0x1F, 0xE0,
  0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0x83, 0xF0, 0x03,
  0xF0, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0,
  0x0F, 0xE1, 0xF8, 0x07, 0xF0, 0x7C, 0x07, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x0F, 0x81, 0xF8, 0x03, 0xE0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x81, 0xF0, 0x07, 0xE0, 0x7C,
  0x01, 0xF8, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0,
  0xFC, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFC, 0x0F, 0xE0,
  0xFE, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x03,
  0xF0, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0xF8, 0xFC, 0x00,
  0x3E, 0x1F, 0x00, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xFC, 0x03, 0xF8, 0x3F,
  0xC3, 0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0x87, 0xE0, 0x0F, 0xC3, 0xE0,
  0x07, 0xE1, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xF8, 0x7E,
  0x00, 0x7C, 0x3F, 0x00, 0x7E, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x8F,
  0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xC3, 0xF0, 0x03, 0xE1, 0xF8, 0x03, 0xF0,
  0xF8, 0x01, 0xF8, 0x7C, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3E,
  0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xC0, 0x0F, 0xC3, 0xE0, 0x07,
  0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00,
  0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xF9, 0xFE, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x0F,
  0xDF, 0x80, 0x0F, 0xE7, 0xE0, 0x07, 0xE3, 0xF0, 0x07, 0xF1, 0xF8, 0x03,
  0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80,
  0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x7E, 0x01, 0xF0, 0x3F, 0x00, 0xFC,
  0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x8F, 0xC0, 0x0F,
  0xC7, 0xE0, 0x03, 0xE3, 0xE0, 0x01, 0xF3, 0xF0, 0x00, 0xF9, 0xF0, 0x00,
  0x7D, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C,
  0x1E, 0x07, 0xDF, 0x07, 0x81, 0xF7, 0xC1, 0xE0, 0xFD, 0xF0, 0xF8, 0x3E,
  0x7C, 0x3E, 0x0F, 0x9F, 0x0F, 0x87, 0xE7, 0xC7, 0xE1, 0xF1, 0xF1, 0xF8,
  0x7C, 0x7C, 0x7E, 0x1F, 0x1F, 0x3F, 0x8F, 0xC7, 0xCF, 0xE3, 0xE1, 0xF3,
  0xF8, 0xF8, 0xF8, 0xFE, 0x3E, 0x3E, 0x7B, 0x9F, 0x0F, 0x9E, 0xE7, 0xC3,
  0xE7, 0xB9, 0xF0, 0xFB, 0xCE, 0x7C, 0x3E, 0xF3, 0xBE, 0x0F, 0xBC, 0xEF,
  0x83, 0xFE, 0x3B, 0xE0, 0xFF, 0x8F, 0xF0, 0x3F, 0xE3, 0xFC, 0x0F, 0xF8,
  0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xE0, 0x3F, 0xC3, 0xF8, 0x0F,
  0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0x03, 0xF0,
  0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x07,
  0xF0, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x80, 0x7E,
  0x01, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x80, 0x0F, 0xC1,
  0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7C, 0x3F, 0x80, 0x01, 0xF9, 0xFC,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xDF,
  0x80, 0x00, 0xFE, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0xC3, 0xF0,
  0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0xC0, 0x7E, 0x00,
  0xFE, 0x00, 0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xE7, 0xE0, 0x03,
  0xF1, 0xF8, 0x01, 0xFC, 0x3E, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x03, 0xF0,
  0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x1F, 0x03, 0xF8, 0x07, 0xE0, 0xFC, 0x01,
  0xF8, 0x7E, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0x8F, 0xC0, 0x03, 0xF7, 0xE0,
  0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF,
  0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x0F, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0x7C, 0x07, 0xCF, 0x01,
  0xE3, 0xC0, 0xF8, 0xF0, 0x7C, 0x3E, 0x1F, 0x0F, 0x8F, 0x81, 0xE3, 0xE0,
  0x79, 0xF0, 0x1E, 0x78, 0x07, 0xFE, 0x01, 0xF0, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0xFE, 0x1F,
  0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xF8, 0x1F, 0x87, 0xE0,
  0x3F, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x01, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xE0, 0x3E,
  0x3F, 0x00, 0x7C, 0x7E, 0x01, 0xF8, 0xF8, 0x03, 0xF1, 0xF0, 0x07, 0xE3,
  0xF0, 0x1F, 0xC7, 0xF0, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F,
  0xFE, 0xF8, 0x0F, 0xF1, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x1E,
  0x00, 0x7E, 0xFF, 0x80, 0xFB, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x0F, 0xF0, 0x7E, 0x1F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8,
  0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F,
  0x80, 0x3F, 0x3E, 0x00, 0x7E, 0x7C, 0x00, 0xF9, 0xF8, 0x03, 0xF3, 0xF0,
  0x07, 0xE7, 0xE0, 0x1F, 0xCF, 0xE0, 0x7F, 0x1F, 0xF1, 0xFC, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE1, 0xFB, 0xFF, 0x83, 0xE3, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x7F, 0x07, 0xE3, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0x3E,
  0x00, 0x7D, 0xF8, 0x01, 0xF7, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x09,
  0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x80, 0xFC, 0x7F, 0x0F, 0xE0, 0xFF,
  0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x1E, 0x0F, 0x80,
  0x7F, 0xCF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0x3F, 0x83, 0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x3F,
  0x0F, 0xC0, 0x1F, 0x87, 0xC0, 0x0F, 0xC3, 0xE0, 0x07, 0xC3, 0xF0, 0x03,
  0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00,
  0x7E, 0x1F, 0x80, 0x3E, 0x07, 0xC0, 0x3F, 0x03, 0xF0, 0x3F, 0x81, 0xFE,
  0x7F, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFD, 0xF0, 0x03,
  0xFC, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xF8, 0x3F, 0x0F, 0xE0, 0x3F, 0x1F,
  0x80, 0x3E, 0x7E, 0x00, 0x7C, 0xFC, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x01, 0x03, 0xF8, 0x07,
  0x03, 0xF8, 0x7F, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xFC, 0x18, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x80,
  0x7F, 0xCF, 0x80, 0xFF, 0xF7, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0x7F, 0x07, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0x3E,
  0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xC0, 0x0F, 0xC7, 0xE0, 0x07,
  0xE3, 0xF0, 0x03, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00,
  0xFC, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x7F, 0x03, 0xFC,
  0x7F, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07,
  0xF9, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x04, 0x00, 0x7E, 0x07,
  0x00, 0x7E, 0x03, 0xE0, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x0F, 0x00, 0x7C, 0x7F, 0x80, 0xFB, 0xFF, 0x81,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xF0, 0x7F, 0x1F, 0xC0, 0x7E, 0x3F,
  0x00, 0xFC, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF3, 0xF0, 0x07, 0xE7, 0xE0,
  0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3E, 0x00, 0x7C, 0x7C, 0x00,
  0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F,
  0x9F, 0x00, 0x3E, 0x7E, 0x00, 0x7C, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3,
  0xF0, 0x07, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x0F, 0xFF,
  0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x04,
  0x3F, 0x01, 0xFE, 0x0F, 0xC0, 0xFF, 0x03, 0xE0, 0x7F, 0x80, 0xF8, 0x3F,
  0xC0, 0x7E, 0x1F, 0xC0, 0x1F, 0x8F, 0xE0, 0x07, 0xE7, 0xF0, 0x01, 0xF3,
  0xF8, 0x00, 0x7D, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xE7, 0xE0,
  0x07, 0xF1, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xE0, 0x1F, 0x81,
  0xF8, 0x07, 0xC0, 0x7F, 0x01, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF8, 0x3F,
  0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0xC0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x01, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFC, 0x00, 0x0F, 0x07, 0x01, 0xF3, 0xF3, 0xF0, 0x3E, 0xFE, 0xFF,
  0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0x9F, 0xCF, 0xC3, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7E, 0x3F,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7E, 0x3F, 0x1F, 0x0F, 0xC7, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0xFC,
  0x7E, 0x3F, 0x00, 0x00, 0x03, 0xC0, 0x1F, 0x1F, 0xE0, 0x3E, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xE3, 0xFC, 0x1F, 0xC7, 0xF0, 0x1F, 0x8F,
  0xC0, 0x3F, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8,
  0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0x80, 0x1F, 0x1F, 0x00,
  0x3E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07,
  0xE7, 0xC0, 0x0F, 0x9F, 0x80, 0x1F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC,
  0xFC, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0x0F, 0xE3, 0xF8, 0x0F, 0xCF, 0xC0,
  0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x01, 0xF7, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0x9F, 0x81, 0xFC, 0x7F, 0x0F,
  0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xF3, 0xFE, 0x00, 0xFB, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xC3, 0xF8, 0x1F, 0xC0,
  0xFE, 0x0F, 0xC0, 0x3F, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0xC3, 0xF0,
  0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3E,
  0x00, 0x7E, 0x1F, 0x00, 0x3E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87,
  0xE0, 0x1F, 0x83, 0xF8, 0x1F, 0xC1, 0xFE, 0x1F, 0xC0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0x7E, 0xFF, 0xE0, 0x3F, 0x3F, 0xC0, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0xFE, 0x7C, 0x1F, 0xFE, 0xF8, 0x7F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0x3F, 0x1F, 0x80,
  0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xE0, 0x07,
  0xCF, 0xC0, 0x0F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC,
  0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0xC3, 0xF0, 0x3F, 0x87,
  0xF0, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFD, 0xF0, 0x0F,
  0xF3, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x3F, 0x1F, 0xF0, 0xF9, 0xFF,
  0xC3, 0xEF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0x80, 0x87,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFF, 0xC3, 0xF0, 0x1F, 0x8F, 0xC0, 0x1F, 0x1F, 0x80, 0x3F,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xF9, 0xF0, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xC7, 0xE0,
  0x3F, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x8E,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xF8, 0xF8, 0x03, 0xF1, 0xF0,
  0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3E, 0x3F, 0x00,
  0x7C, 0x7C, 0x01, 0xF8, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F,
  0xCF, 0xC0, 0x1F, 0x1F, 0x80, 0x3E, 0x3E, 0x00, 0xFC, 0x7C, 0x01, 0xF8,
  0xF8, 0x03, 0xF1, 0xF8, 0x0F, 0xE3, 0xF0, 0x3F, 0x87, 0xF1, 0xFF, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0x7C, 0x0F, 0xFC, 0xF8, 0x0F, 0xF3, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x7F, 0x7C, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0x7E,
  0x00, 0xFC, 0x7E, 0x00, 0xF8, 0x3E, 0x01, 0xF8, 0x3E, 0x01, 0xF0, 0x3E,
  0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x1F, 0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x1F,
  0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x80, 0x0F, 0x9F, 0x00, 0x0F,
  0xBE, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x3C, 0x1F, 0xFC, 0x3E, 0x0F, 0xBE, 0x1F, 0x07, 0xDF,
  0x0F, 0x87, 0xCF, 0x0F, 0xC3, 0xE7, 0x87, 0xE1, 0xF3, 0xC3, 0xF1, 0xF1,
  0xE3, 0xF8, 0xF8, 0xF1, 0xFC, 0x7C, 0x78, 0xEE, 0x7C, 0x3C, 0xF7, 0x3E,
  0x1E, 0x73, 0x9F, 0x0F, 0x79, 0xCF, 0x07, 0xBC, 0xEF, 0x83, 0xDC, 0x77,
  0xC1, 0xFE, 0x3B, 0xC0, 0xFF, 0x1F, 0xE0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87,
  0xF0, 0x1F, 0x83, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xE0,
  0x7E, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x03, 0xF8,
  0x0F, 0x80, 0xFE, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x03, 0xF1,
  0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFB, 0xE0, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x87, 0xE0, 0x0F, 0xE0, 0xFC,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0x87, 0xF0,
  0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x0F,
  0xE0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0xC0, 0x7C, 0x01, 0xF8, 0x07,
  0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x3E, 0x07,
  0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00,
  0x1F, 0x3F, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x07,
  0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF8, 0x0F, 0xF8,
  0x07, 0xF0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x00, 0x01, 0x80, 0x00, 0x78, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x01, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xFC, 0x03, 0xCF, 0xFF, 0x01, 0xEF, 0xFF, 0xC1, 0xF7, 0xE7,
  0xF9, 0xFB, 0xC0, 0xFF, 0xFB, 0xE0, 0x3F, 0xFD, 0xE0, 0x0F, 0xFC, 0x00,
  0x01, 0xFC, 0x00,
};

const GFXglyph RobotoMono_SemiBoldItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 11, 33, 27, 8, -33 },
  { 47, 15, 12, 27, 8, -35 },
  { 70, 27, 33, 27, 0, -33 },
  { 182, 24, 43, 27, 2, -38 },
  { 311, 22, 34, 27, 3, -33 },
  { 405, 25, 34, 27, 1, -33 },
  { 512, 6, 12, 27, 12, -35 },
  { 521, 16, 47, 27, 7, -37 },
  { 615, 15, 46, 27, 4, -36 },
  { 702, 22, 23, 27, 4, -33 },
  { 766, 23, 24, 27, 2, -27 },
  { 835, 10, 14, 27, 4, -5 },
  { 853, 18, 5, 27, 6, -17 },
  { 865, 8, 7, 27, 8, -7 },
  { 872, 24, 36, 27, 2, -33 },
  { 980, 22, 34, 27, 3, -33 },
  { 1074, 16, 33, 27, 5, -33 },
  { 1140, 24, 33, 27, 0, -33 },
  { 1239, 24, 34, 27, 1, -33 },
  { 1341, 24, 33, 27, 0, -33 },
  { 1440, 24, 34, 27, 2, -33 },
  { 1542, 22, 34, 27, 2, -33 },
  { 1636, 24, 33, 27, 3, -33 },
  { 1735, 23, 34, 27, 2, -33 },
  { 1833, 21, 33, 27, 3, -33 },
  { 1920, 12, 26, 27, 8, -26 },
  { 1959, 14, 35, 27, 6, -26 },
  { 2021, 22, 21, 27, 3, -25 },
  { 2079, 23, 14, 27, 2, -21 },
  { 2120, 22, 22, 27, 2, -25 },
  { 2181, 20, 33, 27, 6, -33 },
  { 2264, 26, 33, 27, 1, -33 },
  { 2372, 26, 33, 27, -2, -33 },
  { 2480, 26, 33, 27, 1, -33 },
  { 2588, 24, 34, 27, 2, -33 },
  { 2690, 25, 33, 27, 1, -33 },
  { 2794, 27, 33, 27, 1, -33 },
  { 2906, 27, 33, 27, 1, -33 },
  { 3018, 24, 34, 27, 2, -33 },
  { 3120, 27, 33, 27, 0, -33 },
  { 3232, 24, 33, 27, 2, -33 },
  { 3331, 25, 34, 27, 2, -33 },
  { 3438, 29, 33, 27, 1, -33 },
  { 3558, 22, 33, 27, 1, -33 },
  { 3649, 28, 33, 27, 0, -33 },
  { 3765, 27, 33, 27, 0, -33 },
  { 3877, 24, 34, 27, 2, -33 },
  { 3979, 26, 33, 27, 1, -33 },
  { 4087, 24, 39, 27, 2, -33 },
  { 4204, 26, 33, 27, 1, -33 },
  { 4312, 26, 33, 27, 1, -33 },
  { 4420, 26, 33, 27, 3, -33 },
  { 4528, 25, 34, 27, 2, -33 },
  { 4635, 25, 33, 27, 4, -33 },
  { 4739, 26, 33, 27, 3, -33 },
  { 4847, 30, 33, 27, -1, -33 },
  { 4971, 26, 33, 27, 4, -33 },
  { 5079, 27, 33, 27, 0, -33 },
  { 5191, 16, 45, 27, 6, -38 },
  { 5281, 11, 36, 27, 9, -33 },
  { 5331, 17, 45, 27, 5, -38 },
  { 5427, 18, 18, 27, 5, -33 },
  { 5468, 21, 5, 27, 0, 0 },
  { 5482, 9, 6, 27, 12, -33 },
  { 5489, 23, 25, 27, 1, -25 },
  { 5561, 23, 36, 27, 1, -35 },
  { 5665, 22, 26, 27, 2, -25 },
  { 5737, 25, 35, 27, 2, -35 },
  { 5847, 23, 25, 27, 2, -25 },
  { 5919, 25, 36, 27, 4, -36 },
  { 6032, 25, 35, 27, 1, -25 },
  { 6142, 23, 35, 27, 1, -35 },
  { 6243, 20, 34, 27, 2, -34 },
  { 6328, 21, 44, 27, 1, -34 },
  { 6444, 26, 35, 27, 1, -35 },
  { 6558, 21, 35, 27, 2, -35 },
  { 6650, 27, 25, 27, -1, -25 },
  { 6735, 23, 25, 27, 1, -25 },
  { 6807, 22, 26, 27, 2, -25 },
  { 6879, 25, 34, 27, -1, -25 },
  { 6986, 23, 34, 27, 2, -25 },
  { 7084, 22, 25, 27, 4, -25 },
  { 7153, 23, 26, 27, 2, -25 },
  { 7228, 21, 31, 27, 4, -30 },
  { 7310, 23, 25, 27, 3, -24 },
  { 7382, 24, 24, 27, 3, -24 },
  { 7454, 25, 24, 27, 3, -24 },
  { 7529, 27, 24, 27, 0, -24 },
  { 7610, 28, 34, 27, 0, -24 },
  { 7729, 25, 24, 27, 1, -24 },
  { 7804, 17, 44, 27, 7, -36 },
  { 7898, 10, 42, 27, 8, -33 },
  { 7951, 18, 44, 27, 4, -36 },
  { 8050, 25, 9, 27, 0, -18 },
};

const GFXfont RobotoMono_SemiBoldItalic46pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic46pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic46pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC46PT7B_H_
