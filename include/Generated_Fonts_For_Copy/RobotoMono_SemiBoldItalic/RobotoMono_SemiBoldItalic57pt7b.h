#ifndef _ROBOTOMONO_SEMIBOLDITALIC57PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x07, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7E,
  0x00, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x3F, 0x7E, 0x0F,
  0x9F, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x07, 0xCF,
  0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0x8F, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x03, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x1F,
  0x07, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x00, 0x3C, 0x0F, 0x80, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x03, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F,
  0x00, 0x3F, 0x83, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80,
  0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x08, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0,
  0x7F, 0x80, 0x7F, 0xC1, 0xFF, 0x87, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xC1, 0xF0, 0x10, 0x7C, 0x1F,
  0x03, 0xC7, 0xC1, 0xF0, 0x7C, 0x7C, 0x1F, 0x07, 0x87, 0xC1, 0xF0, 0xF8,
  0x78, 0x1F, 0x1F, 0x07, 0xC1, 0xF3, 0xE0, 0x7C, 0x3E, 0x3E, 0x07, 0xFF,
  0xE7, 0xC0, 0x3F, 0xFC, 0xF8, 0x03, 0xFF, 0x8F, 0x00, 0x1F, 0xF1, 0xF0,
  0x00, 0x38, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x7F, 0x00, 0x07, 0x8F, 0xFC, 0x00, 0xF9, 0xFF, 0xE0,
  0x1F, 0x3F, 0xFE, 0x03, 0xE7, 0xE3, 0xF0, 0x3E, 0x7C, 0x1F, 0x07, 0xC7,
  0xC1, 0xF0, 0xF8, 0x78, 0x1F, 0x0F, 0x0F, 0x81, 0xF1, 0xF0, 0xF8, 0x1F,
  0x0E, 0x0F, 0x81, 0xF0, 0x20, 0xF8, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x01,
  0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x0F,
  0xC0, 0xFE, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x7F,
  0x3F, 0xC0, 0x00, 0x7E, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0x87, 0xFF, 0xF0,
  0x3F, 0x1F, 0xEF, 0xE0, 0x7E, 0x7F, 0x8F, 0xE1, 0xFD, 0xFE, 0x1F, 0xE3,
  0xF3, 0xF8, 0x1F, 0xCF, 0xE7, 0xF0, 0x3F, 0xDF, 0xDF, 0xE0, 0x3F, 0xFF,
  0x3F, 0x80, 0x7F, 0xFE, 0x7F, 0x00, 0x7F, 0xF8, 0xFE, 0x00, 0x7F, 0xE1,
  0xFE, 0x00, 0xFF, 0x83, 0xFC, 0x03, 0xFF, 0x03, 0xFE, 0x1F, 0xFE, 0x07,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xF3, 0xF8, 0x03, 0xFF, 0x87, 0xF8, 0x00, 0x60, 0x00, 0x00, 0x1F,
  0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C,
  0x78, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x20, 0x0F, 0x80, 0x47, 0x01, 0xE0, 0x39,
  0xFC, 0x3C, 0x3F, 0x3F, 0xE7, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x7E, 0x7C,
  0x00, 0x1F, 0x87, 0xC0, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x0F, 0x80, 0x7F,
  0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0x78, 0x03, 0xC0, 0x06, 0x00, 0x70,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x7E, 0x0F,
  0xE0, 0x3C, 0x01, 0x80, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x80, 0x3E, 0x1F,
  0xCF, 0xFB, 0xFE, 0xFF, 0xFF, 0xEF, 0xFB, 0xFE, 0x7F, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x00, 0xFE,
  0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF1, 0xFC,
  0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F,
  0xF3, 0xF8, 0x03, 0xFF, 0x3F, 0x80, 0x7F, 0xF3, 0xF8, 0x1F, 0xFF, 0x3F,
  0x83, 0xFF, 0xE3, 0xF8, 0xFF, 0xFE, 0x7F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF8,
  0xFE, 0x7F, 0xFE, 0x0F, 0xE7, 0xFF, 0xC0, 0xFE, 0x7F, 0xF8, 0x1F, 0xC7,
  0xFE, 0x01, 0xFC, 0x7F, 0xC0, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0xFE, 0x00,
  0x1F, 0xCF, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x87, 0xE0, 0x03, 0xF8,
  0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x80, 0xFE, 0x03, 0xFC,
  0x3F, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x1F, 0xFC, 0x1F,
  0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xDF, 0xFF, 0xF3, 0xFC,
  0xFE, 0x7C, 0x1F, 0xCC, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F,
  0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xE0,
  0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x07,
  0xF0, 0x7F, 0x00, 0x1F, 0xC2, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x3F, 0xC0, 0x03, 0xF8, 0x7F,
  0x00, 0x1F, 0xE1, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xFC, 0x0F, 0xF8,
  0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0xFE, 0xFE,
  0x00, 0x0F, 0xE7, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x7E, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0,
  0x7F, 0x00, 0x3F, 0x03, 0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xF8, 0x03, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E,
  0x08, 0x00, 0x01, 0xFB, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x7F,
  0xC0, 0x0F, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x8F, 0xE0,
  0x01, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0xC1, 0xFC, 0x00,
  0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0xFE, 0x7F, 0xE0,
  0x3F, 0x7F, 0xFE, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFE, 0x7F, 0xE0, 0xFF, 0xBF, 0xE0, 0x0F, 0xEF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03,
  0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x9F, 0xC0, 0x1F, 0xC7, 0xF8,
  0x1F, 0xF1, 0xFF, 0x8F, 0xF8, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x07,
  0xF8, 0x07, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xC0,
  0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x83, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x1F,
  0xC0, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x03, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F,
  0xC1, 0xFC, 0x00, 0xFE, 0x1F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0xFC, 0x7F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x1F, 0xE0,
  0x03, 0xF8, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x1F,
  0xE0, 0xFF, 0xC7, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF,
  0x07, 0xF8, 0x7F, 0x00, 0xFE, 0x3F, 0xC0, 0x1F, 0xCF, 0xE0, 0x07, 0xF7,
  0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x07, 0xF7, 0xF0, 0x03, 0xFD, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x7F, 0xDF,
  0xF0, 0x7F, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xEF, 0xC0, 0x7F, 0xF7, 0xF0, 0x03, 0xE1, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xE0, 0x7F, 0xC3, 0xFF,
  0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC1, 0xFE, 0x03, 0xF0, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x7F,
  0x81, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x07, 0xF8, 0x0F,
  0xC0, 0x04, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x40, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF9, 0xFF, 0x03, 0xFC,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x01,
  0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1E, 0x03, 0xE0, 0x7C, 0x1E, 0x07,
  0xC1, 0xFF, 0x0E, 0x0F, 0x87, 0xFF, 0x8F, 0x0F, 0x0F, 0xFF, 0x8F, 0x1F,
  0x0F, 0xC7, 0x8F, 0x1E, 0x1F, 0x0F, 0x0F, 0x3E, 0x1E, 0x0F, 0x0F, 0x3E,
  0x3E, 0x0F, 0x0F, 0x3C, 0x3C, 0x0F, 0x0F, 0x7C, 0x7C, 0x1E, 0x0F, 0x7C,
  0x7C, 0x1E, 0x1E, 0x78, 0x78, 0x1E, 0x1E, 0x78, 0xF8, 0x1E, 0x1E, 0x78,
  0xF8, 0x3E, 0x1E, 0xF8, 0xF8, 0x3C, 0x1C, 0xF8, 0xF8, 0x3C, 0x3C, 0xF8,
  0xF8, 0x3C, 0x3C, 0xF8, 0xF8, 0x7C, 0x38, 0xF8, 0xF8, 0xFC, 0x78, 0xF8,
  0xFF, 0xFF, 0xF0, 0xF8, 0x7F, 0xFF, 0xF0, 0x78, 0x7F, 0xBF, 0xE0, 0x78,
  0x3F, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x10, 0x00, 0x1F, 0xC0, 0x70, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xFB, 0xF0, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x07, 0xF3, 0xF0, 0x00,
  0x07, 0xF3, 0xF0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xE3, 0xF0, 0x00,
  0x0F, 0xC3, 0xF8, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x1F, 0x83, 0xF8, 0x00,
  0x3F, 0x81, 0xF8, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00,
  0x7F, 0x01, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x01,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x0F,
  0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x7F,
  0x80, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x01,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03,
  0xF8, 0x1F, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x07,
  0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x0F,
  0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xFC, 0x0F, 0xE0, 0x7F, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x0F, 0xF0, 0x1F,
  0xC0, 0x03, 0xF8, 0x3F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x3F,
  0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x3F,
  0x80, 0x03, 0xF8, 0x7F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF8, 0x7F,
  0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0x81, 0xFE, 0x03, 0xFC,
  0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x80,
  0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x1F,
  0xC0, 0x01, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x80, 0xFE, 0x01, 0xFF, 0x01, 0xFF,
  0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFE, 0x1F, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF0, 0x07,
  0xF8, 0x0F, 0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x0F, 0xF0, 0x3F, 0x80, 0x0F,
  0xE0, 0x7F, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC,
  0x3F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F,
  0xC0, 0x03, 0xFC, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFE, 0x1F, 0xE0,
  0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0xC0, 0xFE, 0x00,
  0xFF, 0x81, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0x81, 0xFE,
  0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xE0, 0x03, 0xF8,
  0x3F, 0x80, 0x07, 0xF0, 0xFF, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x1F, 0xFF, 0x8F, 0xE0, 0x3F, 0xFF, 0x1F, 0xC0,
  0x7F, 0xFE, 0x3F, 0x80, 0xFF, 0xFC, 0x7F, 0x01, 0xFF, 0xF9, 0xFE, 0x07,
  0xFF, 0xE3, 0xFC, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x3F, 0x8F, 0xF0, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x07,
  0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x7F,
  0x81, 0xFF, 0x8F, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07,
  0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0,
  0x01, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x1F,
  0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0,
  0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80,
  0x7F, 0xE3, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xC0, 0x03,
  0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0x80, 0x07, 0xFC, 0x03, 0xF8,
  0x00, 0xFF, 0x80, 0x3F, 0x80, 0x1F, 0xF0, 0x03, 0xF8, 0x03, 0xFE, 0x00,
  0x3F, 0x80, 0x7F, 0xC0, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0x01, 0xFF,
  0x00, 0x07, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0x07, 0xFC, 0x00, 0x07, 0xF0,
  0x7F, 0x80, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00,
  0xFE, 0x3F, 0xE0, 0x00, 0x0F, 0xE7, 0xFC, 0x00, 0x00, 0xFE, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFD, 0xFC, 0x00, 0x03, 0xFF, 0x9F, 0xE0,
  0x00, 0x3F, 0xF1, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x07,
  0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F,
  0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F,
  0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0xC3,
  0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0xC0, 0x7F, 0xF1, 0xF7, 0xE0, 0x7F, 0x7D,
  0xFB, 0xF0, 0x3F, 0xBE, 0xF9, 0xF8, 0x1F, 0x9F, 0xFD, 0xFC, 0x0F, 0xCF,
  0xFC, 0xFE, 0x07, 0xE7, 0xFE, 0x7E, 0x03, 0xF3, 0xFE, 0x3F, 0x03, 0xF9,
  0xFF, 0x1F, 0x81, 0xFC, 0xFF, 0x1F, 0xC0, 0xFC, 0x7F, 0x8F, 0xE0, 0x7E,
  0x1F, 0xC7, 0xE0, 0x3F, 0x0F, 0xC3, 0xF0, 0x3F, 0x87, 0xE1, 0xF8, 0x1F,
  0xC3, 0xE1, 0xFC, 0x0F, 0xE1, 0xF0, 0xFE, 0x07, 0xF0, 0xF0, 0x7F, 0x03,
  0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x0F, 0xC0,
  0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x03, 0xF8,
  0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x3F, 0x80, 0xFF, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x3F,
  0xE0, 0x07, 0xF0, 0x1F, 0xF0, 0x03, 0xF8, 0x1F, 0xF8, 0x03, 0xFC, 0x0F,
  0xFC, 0x01, 0xFC, 0x07, 0xFF, 0x00, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0x01,
  0xFF, 0xC0, 0x3F, 0x80, 0xFF, 0xE0, 0x1F, 0xC0, 0xFF, 0xF8, 0x1F, 0xE0,
  0x7F, 0xFC, 0x0F, 0xE0, 0x3F, 0xBE, 0x07, 0xF0, 0x1F, 0xDF, 0x83, 0xF8,
  0x0F, 0xEF, 0xC1, 0xFC, 0x07, 0xF7, 0xE1, 0xFE, 0x07, 0xF9, 0xF0, 0xFE,
  0x03, 0xF8, 0xFC, 0x7F, 0x01, 0xFC, 0x7E, 0x3F, 0x80, 0xFE, 0x3F, 0x1F,
  0xC0, 0x7F, 0x0F, 0x8F, 0xE0, 0x3F, 0x87, 0xEF, 0xF0, 0x3F, 0xC3, 0xF7,
  0xF0, 0x1F, 0xC0, 0xFB, 0xF8, 0x0F, 0xE0, 0x7D, 0xFC, 0x07, 0xF0, 0x3F,
  0xFE, 0x03, 0xF8, 0x1F, 0xFF, 0x01, 0xFC, 0x07, 0xFF, 0x81, 0xFC, 0x03,
  0xFF, 0x80, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0x00, 0xFF, 0xE0, 0x3F, 0x80,
  0x3F, 0xF0, 0x1F, 0xC0, 0x1F, 0xF8, 0x1F, 0xE0, 0x0F, 0xFC, 0x0F, 0xE0,
  0x07, 0xFC, 0x07, 0xF0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0, 0xFF, 0x01, 0xFE,
  0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE1, 0xFE, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFD,
  0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0x7F,
  0x00, 0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0xBF, 0xC0,
  0x00, 0xFE, 0xFF, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xEF, 0xE0, 0x00,
  0x7F, 0x3F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF8, 0x7F, 0x00, 0x1F, 0xC1,
  0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xE0, 0x1F, 0xF8, 0x07, 0xF0, 0x03, 0xFE, 0x03, 0xF8, 0x00, 0xFF, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC,
  0x0F, 0xE0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF,
  0x03, 0xF8, 0x00, 0xFF, 0x81, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xE0, 0xFF, 0x81, 0xFE, 0x01, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80,
  0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x01,
  0xFC, 0xFF, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F,
  0x3F, 0x80, 0x01, 0xFD, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xF7, 0xF0,
  0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0xFF, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8,
  0x7F, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xFC, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x63,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x80,
  0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x03, 0xF8, 0x0F, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0xFF,
  0x07, 0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFF,
  0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xFC,
  0x0F, 0xE0, 0x07, 0xFC, 0x0F, 0xE0, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x80,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0xC0,
  0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xE0,
  0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xF0,
  0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x03,
  0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F,
  0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF8,
  0xFF, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x81,
  0xFF, 0x8F, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0x7F,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80,
  0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03,
  0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC,
  0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x0F,
  0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0x7F,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0xFE, 0x01, 0xFE,
  0x07, 0xFC, 0x03, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0xFB, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x7F, 0x8F, 0xE0, 0x00, 0xFF, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x07,
  0xF8, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F,
  0x03, 0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0xFF, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x01,
  0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F,
  0xE3, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x01, 0xFB,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7E, 0x03, 0xE0,
  0x3F, 0x7E, 0x07, 0xE0, 0x7F, 0x7E, 0x07, 0xE0, 0x7F, 0x7E, 0x07, 0xE0,
  0x7E, 0x7E, 0x0F, 0xE0, 0x7E, 0x7E, 0x0F, 0xE0, 0xFE, 0x7E, 0x0F, 0xE0,
  0xFE, 0x7E, 0x0F, 0xE0, 0xFC, 0xFE, 0x1F, 0xE1, 0xFC, 0xFE, 0x1F, 0xE1,
  0xFC, 0xFE, 0x1F, 0xE1, 0xF8, 0xFE, 0x3F, 0xE1, 0xF8, 0xFE, 0x3F, 0xE3,
  0xF8, 0xFE, 0x3F, 0xE3, 0xF8, 0xFE, 0x7F, 0xE3, 0xF0, 0xFC, 0x7F, 0xE3,
  0xF0, 0xFC, 0x7F, 0xE7, 0xF0, 0xFC, 0xFF, 0xE7, 0xE0, 0xFC, 0xFB, 0xE7,
  0xE0, 0xFC, 0xFB, 0xEF, 0xE0, 0xFC, 0xFB, 0xEF, 0xC0, 0xFD, 0xF3, 0xEF,
  0xC0, 0xFD, 0xF3, 0xEF, 0xC0, 0xFD, 0xF3, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF,
  0x80, 0xFF, 0xE3, 0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0x80, 0xFF, 0xC3, 0xFF,
  0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0x83, 0xFF,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0xFC, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xF8,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x80,
  0x00, 0x7F, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x03, 0xF8,
  0x7F, 0x80, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x01,
  0xFE, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x81, 0xFC,
  0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xF0,
  0x00, 0x7F, 0x80, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFC,
  0x7F, 0x80, 0x07, 0xF8, 0x3F, 0x80, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xF0,
  0x3F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0,
  0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x80, 0x0F, 0xE0, 0x7F, 0x00,
  0x0F, 0xE0, 0xFF, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x07, 0xF3, 0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x03, 0xF7, 0xF0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x40, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x08, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F,
  0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xEF, 0xC0, 0x1F, 0x3F, 0x00, 0xFC, 0x7C,
  0x03, 0xE1, 0xF0, 0x1F, 0x87, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x3E, 0x1F,
  0x80, 0xF8, 0x7E, 0x03, 0xE3, 0xF0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x00,
  0x7F, 0xF0, 0x01, 0xF0, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0,
  0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0xFF,
  0x00, 0xFF, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC7, 0xFE, 0x03, 0xF9,
  0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xEF, 0xF0, 0x03, 0xF9, 0xFC, 0x00,
  0x7F, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x9F,
  0xF0, 0x7F, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFB,
  0xF0, 0x3F, 0xFE, 0x7F, 0x03, 0xFF, 0x0F, 0xE0, 0x06, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x03, 0x80, 0x03, 0xF8,
  0xFF, 0x80, 0x1F, 0xDF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0x8F, 0xFC, 0x1F, 0xF0, 0x1F, 0xE0,
  0xFF, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC,
  0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8,
  0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC,
  0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0xC7, 0xFC, 0x03,
  0xFC, 0x3F, 0xF8, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7E, 0xFF, 0xFE, 0x07, 0xF3, 0xFF, 0xE0, 0x3F, 0x87, 0xFC, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03,
  0xFE, 0x1F, 0xF0, 0xFF, 0x00, 0xFE, 0x3F, 0xC0, 0x1F, 0xC7, 0xF0, 0x01,
  0xFD, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x03, 0xF8,
  0x7F, 0x00, 0xFF, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x01, 0xE0, 0x7F, 0x00, 0x1F, 0xF8, 0xFE, 0x00, 0x7F, 0xF9,
  0xFC, 0x03, 0xFF, 0xFB, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xE1, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFE,
  0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xF0,
  0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x3F,
  0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xFC, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0xFC, 0x00, 0x1F, 0xF1,
  0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x00, 0xFE, 0x1F, 0xE0,
  0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x3F, 0xC0, 0x03, 0xF3, 0xF8, 0x00, 0x3F,
  0x3F, 0x80, 0x03, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x02, 0x03, 0xF8, 0x00, 0x70, 0x3F, 0xC0, 0x1F, 0x03, 0xFF, 0x07,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0x00,
  0x40, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x7F, 0xF1, 0xFC, 0x01, 0xFF, 0xF3, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0x87, 0xFF, 0x03, 0xFC,
  0x03, 0xFE, 0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x80,
  0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0xFF, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07,
  0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F,
  0x83, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8,
  0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFB, 0xF8, 0x00, 0x7F, 0xC7, 0xF0, 0x00, 0x0C, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x40, 0x01, 0xFC, 0x01, 0xC0,
  0x07, 0xF8, 0x07, 0xE0, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0x03, 0xC0, 0x03, 0xF8, 0x7F, 0xC0, 0x1F, 0xCF, 0xFF,
  0x00, 0xFE, 0xFF, 0xFC, 0x07, 0xEF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x83,
  0xFF, 0x87, 0xFE, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF0,
  0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x03,
  0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE1,
  0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03,
  0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1,
  0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x07, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0x07, 0xF0,
  0x07, 0xFC, 0x07, 0xF0, 0x0F, 0xF8, 0x07, 0xF0, 0x1F, 0xF0, 0x07, 0xF0,
  0x3F, 0xE0, 0x0F, 0xE0, 0x7F, 0xC0, 0x0F, 0xE0, 0xFF, 0x80, 0x0F, 0xE1,
  0xFF, 0x00, 0x0F, 0xE3, 0xFE, 0x00, 0x0F, 0xE7, 0xFC, 0x00, 0x0F, 0xEF,
  0xF8, 0x00, 0x1F, 0xDF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xF3, 0xF8, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x00,
  0x7F, 0x80, 0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0xC0, 0xFE, 0x00,
  0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF8, 0x00, 0x10, 0xC0, 0x38, 0x03, 0xF3, 0xF8, 0x7F, 0x01, 0xFB,
  0xFE, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xCF, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE1, 0xFC, 0x1F, 0x83, 0xF0, 0xFE, 0x1F, 0xC1, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x07, 0xE0, 0xFE, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xE0, 0xFC, 0x1F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF0, 0x7F, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xF0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7F, 0x07, 0xE0, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0x83, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x3F, 0x87, 0xE0, 0xFC,
  0x1F, 0x87, 0xF0, 0x7E, 0x0F, 0xC3, 0xF8, 0x7F, 0x07, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x3F, 0x8F, 0xFC, 0x01, 0xF8, 0xFF, 0xF0, 0x0F, 0xCF, 0xFF,
  0xC0, 0x7E, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0x7F, 0xE1,
  0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01,
  0xFC, 0x7F, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF1,
  0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x01,
  0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8,
  0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC,
  0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xE3, 0xFC,
  0x00, 0xFF, 0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7F,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xFE, 0x7F, 0x00, 0x1F, 0xC7,
  0xF8, 0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x83, 0xFE, 0x1F, 0xF0, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x03,
  0xF9, 0xFF, 0x80, 0x07, 0xF7, 0xFF, 0x80, 0x0F, 0xDF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xE3, 0xFF, 0x01, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xFC, 0x0F, 0xE0,
  0x07, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x01,
  0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFE,
  0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xF0, 0x3F, 0xF8, 0x7F, 0xC0,
  0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07,
  0xFB, 0xFF, 0xE0, 0x0F, 0xE1, 0xFF, 0x00, 0x1F, 0xC0, 0x70, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFC,
  0x3F, 0x01, 0xFF, 0xF7, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x1F, 0xF8, 0x7F, 0xE3, 0xFE, 0x01, 0xFE, 0x3F, 0xC0,
  0x1F, 0xE3, 0xF8, 0x00, 0xFE, 0x7F, 0x80, 0x0F, 0xE7, 0xF0, 0x00, 0xFE,
  0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xE0,
  0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F,
  0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE,
  0x00, 0x3F, 0x8F, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xFC, 0x3F,
  0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00,
  0xFF, 0xF7, 0xE0, 0x07, 0xFC, 0xFE, 0x00, 0x06, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0xFE, 0x1F, 0xFC, 0x1F, 0xC7, 0xFF, 0x83,
  0xF3, 0xFF, 0xF0, 0x7E, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFE, 0x7C, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0xFE,
  0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xCF,
  0x00, 0x00, 0xFC, 0xFE, 0x00, 0x0F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00,
  0x1F, 0xC7, 0xF8, 0x07, 0xFC, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0xF0, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0xFE, 0x00,
  0x3F, 0xC7, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F,
  0x0F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x3F,
  0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F,
  0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x3F,
  0x80, 0x0F, 0xF1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x80,
  0x1F, 0xC1, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC7, 0xFF,
  0x83, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xEF, 0xC0, 0x7F, 0xFE, 0x7E, 0x01,
  0xFF, 0xE7, 0xF0, 0x03, 0xFE, 0x3F, 0x80, 0x07, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x07, 0xFB, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC, 0xFE, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x7F,
  0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x07,
  0xE0, 0x1F, 0xC0, 0x3F, 0x01, 0xFC, 0x01, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0,
  0xFE, 0x00, 0x3F, 0x07, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x7E, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x07, 0xC0, 0x7F, 0xF8, 0x0F, 0x81, 0xFF, 0xF0, 0x3F, 0x03, 0xF7,
  0xE0, 0x7E, 0x07, 0xEF, 0xC0, 0xFC, 0x1F, 0xDF, 0x83, 0xF8, 0x3F, 0x3F,
  0x07, 0xF0, 0x7E, 0x7E, 0x0F, 0xE0, 0xFC, 0xFC, 0x3F, 0xC3, 0xF1, 0xF8,
  0x7F, 0x87, 0xE3, 0xF1, 0xFF, 0x0F, 0xC7, 0xE3, 0xDE, 0x3F, 0x0F, 0xC7,
  0xBC, 0x7E, 0x1F, 0x9F, 0x78, 0xFC, 0x3F, 0x3C, 0xF3, 0xF0, 0x7E, 0x79,
  0xE7, 0xE0, 0xFD, 0xF3, 0xCF, 0xC1, 0xFB, 0xC7, 0xBF, 0x03, 0xF7, 0x8F,
  0x7E, 0x07, 0xFF, 0x1E, 0xF8, 0x0F, 0xFC, 0x3D, 0xF0, 0x1F, 0xF8, 0x7F,
  0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x83, 0xFE,
  0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0xC0, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xF0,
  0x07, 0xF8, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x07,
  0xF0, 0xFF, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x3F, 0xBF, 0xE0, 0x00,
  0x0F, 0xEF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0x7F, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x07, 0xFC, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xF0,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x07, 0xF8, 0x1F, 0xC0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x7F,
  0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x7F,
  0x80, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0xFF, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x1F, 0xCF, 0xF0, 0x00,
  0x01, 0xF9, 0xFC, 0x00, 0x00, 0x3F, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x04, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0x7C, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0x1F, 0xFF, 0x80, 0x3E,
  0x3F, 0xFF, 0xC0, 0x3E, 0x3F, 0xFF, 0xF0, 0x7E, 0x7F, 0x1F, 0xFF, 0xFC,
  0x7E, 0x07, 0xFF, 0xFC, 0x7C, 0x03, 0xFF, 0xF8, 0xF8, 0x01, 0xFF, 0xF8,
  0x18, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
};

const GFXglyph RobotoMono_SemiBoldItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 14, 41, 33, 10, -41 },
  { 73, 18, 15, 33, 10, -43 },
  { 107, 34, 41, 33, 0, -41 },
  { 282, 30, 53, 33, 3, -47 },
  { 481, 28, 42, 33, 3, -41 },
  { 628, 31, 42, 33, 1, -41 },
  { 791, 8, 15, 33, 14, -43 },
  { 806, 19, 58, 33, 9, -45 },
  { 944, 19, 58, 33, 5, -45 },
  { 1082, 27, 29, 33, 5, -41 },
  { 1180, 28, 30, 33, 3, -34 },
  { 1285, 12, 18, 33, 5, -7 },
  { 1312, 23, 6, 33, 7, -21 },
  { 1330, 10, 10, 33, 10, -9 },
  { 1343, 30, 44, 33, 2, -41 },
  { 1508, 28, 42, 33, 3, -41 },
  { 1655, 19, 41, 33, 7, -41 },
  { 1753, 30, 41, 33, 0, -41 },
  { 1907, 30, 42, 33, 1, -41 },
  { 2065, 29, 41, 33, 1, -41 },
  { 2214, 30, 42, 33, 2, -41 },
  { 2372, 26, 42, 33, 3, -41 },
  { 2509, 29, 41, 33, 4, -41 },
  { 2658, 29, 42, 33, 2, -41 },
  { 2811, 26, 41, 33, 4, -41 },
  { 2945, 14, 33, 33, 10, -32 },
  { 3003, 17, 43, 33, 8, -32 },
  { 3095, 26, 27, 33, 4, -31 },
  { 3183, 28, 18, 33, 3, -26 },
  { 3246, 27, 27, 33, 2, -31 },
  { 3338, 25, 41, 33, 7, -41 },
  { 3467, 32, 40, 33, 1, -40 },
  { 3627, 32, 41, 33, -2, -41 },
  { 3791, 32, 41, 33, 1, -41 },
  { 3955, 31, 42, 33, 2, -41 },
  { 4118, 31, 41, 33, 1, -41 },
  { 4277, 33, 41, 33, 1, -41 },
  { 4447, 33, 41, 33, 1, -41 },
  { 4617, 31, 42, 33, 2, -41 },
  { 4780, 33, 41, 33, 1, -41 },
  { 4950, 30, 41, 33, 2, -41 },
  { 5104, 32, 42, 33, 2, -41 },
  { 5272, 36, 41, 33, 1, -41 },
  { 5457, 27, 41, 33, 1, -41 },
  { 5596, 33, 41, 33, 1, -41 },
  { 5766, 33, 41, 33, 1, -41 },
  { 5936, 30, 42, 33, 2, -41 },
  { 6094, 33, 41, 33, 1, -41 },
  { 6264, 30, 48, 33, 2, -41 },
  { 6444, 32, 41, 33, 1, -41 },
  { 6608, 31, 42, 33, 2, -41 },
  { 6771, 32, 41, 33, 4, -41 },
  { 6935, 31, 42, 33, 3, -41 },
  { 7098, 31, 41, 33, 5, -41 },
  { 7257, 32, 41, 33, 4, -41 },
  { 7421, 38, 41, 33, -2, -41 },
  { 7616, 32, 41, 33, 5, -41 },
  { 7780, 34, 41, 33, 0, -41 },
  { 7955, 20, 56, 33, 7, -47 },
  { 8095, 13, 44, 33, 11, -41 },
  { 8167, 20, 56, 33, 7, -47 },
  { 8307, 22, 22, 33, 6, -41 },
  { 8368, 26, 6, 33, 0, 0 },
  { 8388, 11, 8, 33, 15, -41 },
  { 8399, 27, 32, 33, 2, -31 },
  { 8507, 29, 44, 33, 1, -43 },
  { 8667, 27, 32, 33, 3, -31 },
  { 8775, 31, 44, 33, 3, -43 },
  { 8946, 28, 32, 33, 2, -31 },
  { 9058, 30, 44, 33, 5, -44 },
  { 9223, 31, 43, 33, 1, -31 },
  { 9390, 29, 43, 33, 1, -43 },
  { 9546, 25, 42, 33, 3, -42 },
  { 9678, 26, 54, 33, 1, -42 },
  { 9854, 32, 43, 33, 1, -43 },
  { 10026, 26, 43, 33, 2, -43 },
  { 10166, 33, 31, 33, -1, -31 },
  { 10294, 29, 31, 33, 1, -31 },
  { 10407, 28, 32, 33, 2, -31 },
  { 10519, 31, 43, 33, -1, -31 },
  { 10686, 28, 43, 33, 3, -31 },
  { 10837, 27, 31, 33, 5, -31 },
  { 10942, 28, 32, 33, 2, -31 },
  { 11054, 26, 38, 33, 5, -37 },
  { 11178, 29, 31, 33, 3, -30 },
  { 11291, 29, 30, 33, 4, -30 },
  { 11400, 31, 30, 33, 3, -30 },
  { 11517, 34, 30, 33, 0, -30 },
  { 11645, 35, 42, 33, 0, -30 },
  { 11829, 31, 30, 33, 1, -30 },
  { 11946, 22, 55, 33, 8, -45 },
  { 12098, 13, 52, 33, 10, -41 },
  { 12183, 22, 54, 33, 5, -44 },
  { 12332, 32, 12, 33, 0, -23 },
};

const GFXfont RobotoMono_SemiBoldItalic57pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic57pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic57pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC57PT7B_H_
