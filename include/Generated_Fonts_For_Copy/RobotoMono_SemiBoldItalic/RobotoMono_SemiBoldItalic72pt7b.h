#ifndef _ROBOTOMONO_SEMIBOLDITALIC72PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F,
  0xC0, 0x01, 0x80, 0x00, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0,
  0x7E, 0x1F, 0x80, 0xFE, 0x1F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80,
  0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x01,
  0xFC, 0x7F, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01,
  0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x1F, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x03,
  0xFF, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x3F, 0xC1,
  0xFF, 0x00, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x03, 0xF8,
  0x1F, 0x80, 0x60, 0x7E, 0x03, 0xF0, 0x0F, 0x0F, 0xC0, 0x7E, 0x03, 0xF1,
  0xF8, 0x0F, 0xC0, 0xFC, 0x3F, 0x01, 0xF8, 0x3F, 0x07, 0xE0, 0x3F, 0x07,
  0xE1, 0xFC, 0x0F, 0xE1, 0xF8, 0x3F, 0x81, 0xF8, 0x7E, 0x03, 0xF0, 0x3F,
  0x0F, 0xC0, 0x7F, 0x0F, 0xE3, 0xF0, 0x0F, 0xFF, 0xF8, 0xFC, 0x00, 0xFF,
  0xFF, 0x3F, 0x00, 0x1F, 0xFF, 0xC7, 0xE0, 0x01, 0xFF, 0xF1, 0xF8, 0x00,
  0x0F, 0xF8, 0x7E, 0x00, 0x00, 0x30, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0xFC, 0x3F, 0xF0,
  0x00, 0x1F, 0x8F, 0xFF, 0x00, 0x07, 0xE3, 0xFF, 0xF0, 0x01, 0xF8, 0xFF,
  0xFF, 0x00, 0x7F, 0x3F, 0xFF, 0xE0, 0x0F, 0xC7, 0xE0, 0xFE, 0x03, 0xF1,
  0xFC, 0x1F, 0xC0, 0xFC, 0x3F, 0x01, 0xF8, 0x1F, 0x87, 0xE0, 0x3F, 0x07,
  0xE0, 0xFC, 0x07, 0xE1, 0xF8, 0x1F, 0x80, 0xFC, 0x7F, 0x07, 0xF0, 0x1F,
  0x83, 0xC0, 0xFE, 0x07, 0xF0, 0x10, 0x1F, 0xC0, 0xFC, 0x00, 0x03, 0xF8,
  0x1F, 0x80, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFD, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0xFF, 0x80, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x00, 0x7F, 0x83,
  0xFE, 0x00, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x00, 0x3F, 0xDF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0xFE, 0x0F, 0xFC, 0xFF, 0x81, 0xFE,
  0x1F, 0xF8, 0xFF, 0xC1, 0xFE, 0x3F, 0xF0, 0x7F, 0xC3, 0xFE, 0x3F, 0xE0,
  0x7F, 0xE3, 0xFC, 0x7F, 0xE0, 0x3F, 0xE7, 0xFC, 0x7F, 0xC0, 0x3F, 0xF7,
  0xFC, 0x7F, 0xC0, 0x1F, 0xFF, 0xF8, 0x7F, 0xC0, 0x0F, 0xFF, 0xF8, 0x7F,
  0xC0, 0x0F, 0xFF, 0xF0, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x7F, 0xC0, 0x07,
  0xFF, 0xC0, 0x7F, 0xC0, 0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0xFE, 0x1F, 0xF0, 0x00,
  0xFF, 0xF8, 0x1F, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0xC7, 0xF1,
  0xFC, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x1F, 0xC7, 0xF1, 0xFC,
  0x7F, 0x1F, 0x87, 0xE1, 0xF8, 0xFE, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x04, 0x00, 0x3E, 0x00, 0x11, 0xC0, 0x0F,
  0x80, 0x18, 0xFC, 0x07, 0xE0, 0x3F, 0x3F, 0xC1, 0xF8, 0x3F, 0xDF, 0xFC,
  0x7C, 0x7F, 0xF7, 0xFF, 0xDF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0xFE, 0x7E,
  0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xE0,
  0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x07, 0xF8, 0x07, 0xF0, 0x03, 0xFE,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0x80, 0x0F, 0xC0, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFE,
  0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x03,
  0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF0,
  0x03, 0xC0, 0x01, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xC0, 0x02, 0x00, 0xFE, 0x0F, 0xF8,
  0xFF, 0xE7, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0x9F,
  0xF8, 0x7F, 0x80, 0x70, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xC0, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x7F, 0x80, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00,
  0x0F, 0xF8, 0x7F, 0x80, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xE3, 0xFE,
  0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0xF1,
  0xFE, 0x00, 0x3F, 0xFE, 0x7F, 0xC0, 0x0F, 0xFF, 0xCF, 0xF8, 0x07, 0xFF,
  0xF9, 0xFF, 0x01, 0xFF, 0xFE, 0x3F, 0xE0, 0xFF, 0xFF, 0xC7, 0xFC, 0x3F,
  0xEF, 0xF8, 0xFF, 0x1F, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0x3F, 0xE7, 0xFF,
  0xFF, 0x07, 0xFC, 0xFF, 0xFF, 0x80, 0xFF, 0x1F, 0xFF, 0xE0, 0x3F, 0xE3,
  0xFF, 0xF0, 0x07, 0xFC, 0x7F, 0xFC, 0x00, 0xFF, 0x8F, 0xFE, 0x00, 0x1F,
  0xF3, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0x8F, 0xF8, 0x00,
  0x1F, 0xF1, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0xC3, 0xFC,
  0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x81,
  0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xF7, 0xFC,
  0xFF, 0x87, 0xFC, 0xFC, 0x07, 0xF8, 0xE0, 0x0F, 0xF8, 0x80, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x00,
  0xFF, 0xC0, 0xFF, 0xC0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x1F,
  0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x04, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE3,
  0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF,
  0xC0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00,
  0x7F, 0xDF, 0xE0, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xF8,
  0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x03, 0xFE,
  0x1F, 0xE0, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x1F,
  0xE0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x07, 0xF8, 0x00,
  0x7F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x70, 0x00, 0x00, 0x3F, 0xDF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0x1F, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F,
  0xE0, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x0F,
  0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x83, 0xF8, 0x00, 0x7F, 0xC7,
  0xFF, 0x80, 0x1F, 0xF3, 0xFF, 0xF8, 0x07, 0xFB, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xE3, 0xFF, 0xC3, 0xFF, 0xC0, 0x3F, 0xF9, 0xFF, 0xE0, 0x07, 0xFE,
  0x7F, 0xF0, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x0F,
  0xF9, 0xFF, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xDF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x80,
  0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x0F, 0xF9, 0xFF,
  0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0xC3,
  0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xBF, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x01,
  0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF9, 0xFF, 0xE0, 0x1F, 0xFC,
  0x03, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x0F,
  0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x80,
  0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x7F,
  0xE0, 0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xBF, 0xFC, 0x0F, 0xFE, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0x87,
  0xFC, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x0F, 0xF9,
  0xFF, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFF,
  0x7F, 0xC0, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x3F,
  0xEF, 0xF0, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x07,
  0xFD, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xC0, 0x01,
  0xFF, 0xBF, 0xF0, 0x01, 0xFF, 0x9F, 0xFC, 0x01, 0xFF, 0xC7, 0xFF, 0x03,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFB, 0xFE, 0x00, 0xFF,
  0xF9, 0xFE, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x3F, 0x80, 0x1F, 0xF0,
  0x0F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFE, 0x07,
  0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x01, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x3F,
  0xC0, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x04, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFE, 0x7F, 0xF0, 0x0F, 0xFE, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0xF0, 0x3E, 0x03,
  0xF0, 0x3F, 0xFC, 0x3E, 0x07, 0xE0, 0x7F, 0xFE, 0x3E, 0x0F, 0xC1, 0xFF,
  0xFE, 0x3E, 0x0F, 0xC1, 0xFF, 0xFE, 0x3E, 0x1F, 0x83, 0xFC, 0x7C, 0x3E,
  0x1F, 0x87, 0xF0, 0x7C, 0x1E, 0x3F, 0x07, 0xE0, 0x7C, 0x1E, 0x3F, 0x0F,
  0xC0, 0x7C, 0x3E, 0x3E, 0x0F, 0xC0, 0xF8, 0x3E, 0x7E, 0x1F, 0x80, 0xF8,
  0x3E, 0x7E, 0x1F, 0x80, 0xF8, 0x3E, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x7C,
  0x3F, 0x01, 0xF0, 0x3E, 0xFC, 0x3F, 0x01, 0xF0, 0x3E, 0xFC, 0x3F, 0x01,
  0xF0, 0x3C, 0xFC, 0x3F, 0x01, 0xF0, 0x7C, 0xF8, 0x3E, 0x03, 0xF0, 0x7C,
  0xF8, 0x3E, 0x03, 0xE0, 0x7C, 0xF8, 0x3E, 0x03, 0xE0, 0x78, 0xF8, 0x3E,
  0x03, 0xE0, 0xF8, 0xF8, 0x3E, 0x07, 0xE0, 0xF0, 0xF8, 0x3F, 0x0F, 0xE1,
  0xF0, 0xF8, 0x3F, 0x1F, 0xE3, 0xE0, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xF8,
  0x3F, 0xFF, 0xFF, 0xC0, 0xF8, 0x1F, 0xFB, 0xFF, 0x80, 0xFC, 0x0F, 0xF1,
  0xFF, 0x00, 0xFC, 0x07, 0xC0, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0x00, 0x00, 0x1F, 0xF0, 0x0F, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x00, 0x7F, 0x9F, 0xE0,
  0x00, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00,
  0x3F, 0xE3, 0xFC, 0x00, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x1F, 0xE0,
  0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x03,
  0xFE, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x07,
  0xF8, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x3F,
  0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xF8, 0x1F,
  0xF8, 0x00, 0x3F, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xE0,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x07, 0xFC,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x7F, 0xC7, 0xFC, 0x00,
  0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x01, 0xFF, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xF8,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x81, 0xFF,
  0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x07,
  0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00,
  0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0xFF, 0x81,
  0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0xFF,
  0x87, 0xFC, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F,
  0xC1, 0xFF, 0x80, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFF, 0x07, 0xFC,
  0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F,
  0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xFF, 0x01, 0xFF,
  0x00, 0x7F, 0xFC, 0x03, 0xFE, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00,
  0xFF, 0x81, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x01,
  0xFF, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x01, 0xFF, 0xFF, 0x1F, 0xF0, 0x07, 0xFF, 0xFC, 0x7F, 0xC0,
  0x3F, 0xFF, 0xF3, 0xFE, 0x00, 0xFF, 0xFF, 0xCF, 0xF8, 0x03, 0xFF, 0xFF,
  0x3F, 0xE0, 0x0F, 0xFF, 0xF8, 0xFF, 0x80, 0x3F, 0xFF, 0xE3, 0xFE, 0x00,
  0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0xFF, 0x80, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x01, 0xFF, 0x8F, 0xF8, 0x00,
  0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00,
  0x7F, 0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x7F, 0xC0,
  0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x03,
  0xFC, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x40, 0x00, 0x7F, 0xC0, 0x7F, 0x80,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0xFF,
  0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x7F,
  0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x0F,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFC,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xE0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x81, 0xFF,
  0xC0, 0x00, 0x03, 0xFE, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xE3, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF7, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF9, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC7, 0xFE, 0x00, 0x00, 0x1F, 0xFE,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0x7F, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0xFF, 0xFC, 0x03, 0xFD, 0xF8, 0x7F, 0xFF, 0x00, 0xFF, 0x7E,
  0x1F, 0xFF, 0xC0, 0x3F, 0xDF, 0x8F, 0xEF, 0xF0, 0x0F, 0xF7, 0xE3, 0xFB,
  0xFC, 0x03, 0xFD, 0xF9, 0xFD, 0xFE, 0x00, 0xFF, 0x7E, 0x7F, 0x7F, 0x80,
  0x7F, 0x9F, 0xBF, 0x9F, 0xE0, 0x1F, 0xE7, 0xEF, 0xE7, 0xF8, 0x07, 0xF9,
  0xFF, 0xF1, 0xFE, 0x01, 0xFE, 0x7F, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xFE,
  0x3F, 0xC0, 0x1F, 0xE3, 0xFF, 0x8F, 0xF0, 0x0F, 0xF0, 0xFF, 0xC3, 0xFC,
  0x03, 0xFC, 0x3F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0x3F,
  0xC3, 0xFE, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x3F,
  0xC1, 0xFE, 0x01, 0xFF, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x81, 0xF8, 0x1F,
  0xE0, 0x1F, 0xE0, 0x7E, 0x0F, 0xF8, 0x07, 0xF8, 0x1F, 0x03, 0xFC, 0x01,
  0xFE, 0x07, 0xC0, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x3F, 0xE0,
  0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x0F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x7F,
  0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00,
  0x1F, 0xF0, 0x0F, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xF8,
  0x07, 0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFF, 0xC0, 0x03, 0xFE, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x00,
  0x7F, 0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xE0,
  0x1F, 0xFF, 0xC0, 0x1F, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xF8, 0x07, 0xFF,
  0xF8, 0x07, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0xFE, 0x03,
  0xFE, 0x01, 0xFF, 0x7F, 0x01, 0xFF, 0x00, 0xFF, 0xBF, 0xC0, 0xFF, 0x80,
  0x7F, 0xCF, 0xE0, 0x7F, 0xC0, 0x3F, 0xE7, 0xF0, 0x3F, 0xE0, 0x1F, 0xF3,
  0xF8, 0x3F, 0xF0, 0x1F, 0xF0, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0x0F,
  0xF8, 0x07, 0xFC, 0x3F, 0x87, 0xFC, 0x03, 0xFE, 0x1F, 0xC3, 0xFE, 0x01,
  0xFF, 0x07, 0xF1, 0xFF, 0x00, 0xFF, 0x83, 0xF9, 0xFF, 0x00, 0xFF, 0x81,
  0xFC, 0xFF, 0x80, 0x7F, 0xC0, 0xFE, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xBF,
  0xE0, 0x1F, 0xF0, 0x1F, 0xDF, 0xF0, 0x0F, 0xF8, 0x0F, 0xEF, 0xF8, 0x07,
  0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFE, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0x7F, 0xC0, 0x0F, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFF, 0xC0, 0x3F,
  0xE0, 0x03, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0xF0, 0x0F, 0xF8, 0x00,
  0x7F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xFE,
  0x03, 0xFE, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFE,
  0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xE1, 0xFF, 0x80,
  0x00, 0xFF, 0x87, 0xFC, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x07, 0xF8,
  0xFF, 0x80, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00,
  0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x3F, 0xE7,
  0xFC, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00,
  0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0xFF, 0x9F,
  0xF0, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00,
  0x7F, 0xCF, 0xF8, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0xFF,
  0x80, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x03,
  0xFE, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x3F, 0xE3, 0xFE,
  0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x7F, 0x80, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xFC,
  0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xFE,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0x03, 0xFF, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFE,
  0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xFC, 0x0F, 0xF8,
  0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x01, 0xFF, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x7F,
  0xCF, 0xF8, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0xFF, 0x80,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x03, 0xFF,
  0x7F, 0xC0, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00,
  0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x0F, 0xFB,
  0xFE, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0xFF, 0x80, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x7F, 0xCF,
  0xF8, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00,
  0x3F, 0xE3, 0xFE, 0x00, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x07, 0xFC, 0x3F,
  0xE0, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07,
  0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F,
  0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0x8F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F,
  0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x1F, 0xF8,
  0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x3F, 0xF0,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFD, 0xFF,
  0x00, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x01,
  0xFF, 0x8F, 0xF8, 0x00, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFE, 0x03,
  0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00,
  0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x80,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x0F, 0xF0,
  0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x80,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x01, 0xFF,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x7F, 0xC0,
  0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00, 0x1F,
  0xE7, 0xFC, 0x00, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x00, 0x7F, 0xBF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x7F, 0x00, 0xFF, 0xBF, 0xC0, 0x3F, 0x80, 0x7F, 0x9F, 0xE0, 0x3F, 0xC0,
  0x3F, 0xCF, 0xF0, 0x1F, 0xE0, 0x3F, 0xE7, 0xF8, 0x0F, 0xF0, 0x1F, 0xE3,
  0xFC, 0x07, 0xF8, 0x0F, 0xF1, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x3F, 0xC1, 0xFF, 0x81,
  0xFE, 0x1F, 0xE0, 0xFF, 0xC0, 0xFF, 0x0F, 0xF0, 0x7F, 0xE0, 0xFF, 0x07,
  0xF8, 0x7F, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F,
  0xFC, 0x3F, 0xE0, 0xFE, 0x0F, 0xFE, 0x1F, 0xE0, 0x7F, 0x0F, 0xFF, 0x0F,
  0xF0, 0x7F, 0x87, 0xFF, 0x87, 0xF8, 0x3F, 0xC3, 0xFF, 0xC7, 0xF8, 0x1F,
  0xE3, 0xFF, 0xE3, 0xFC, 0x0F, 0xF1, 0xFB, 0xF1, 0xFE, 0x07, 0xF8, 0xFD,
  0xF8, 0xFF, 0x03, 0xFC, 0xFE, 0xFC, 0xFF, 0x01, 0xFE, 0x7E, 0x7E, 0x7F,
  0x80, 0xFF, 0x3F, 0x3F, 0x3F, 0xC0, 0x7F, 0x9F, 0x9F, 0xBF, 0xC0, 0x3F,
  0xDF, 0xCF, 0xDF, 0xE0, 0x1F, 0xEF, 0xC7, 0xEF, 0xF0, 0x0F, 0xF7, 0xE3,
  0xF7, 0xF8, 0x07, 0xFF, 0xF1, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x3F, 0xFE, 0x00, 0x7F,
  0xFC, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x81, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x0F,
  0xFE, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x1F,
  0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x7F, 0xC0,
  0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F,
  0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xFE, 0x00,
  0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x07, 0xF8,
  0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x3F, 0xF0,
  0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0xFE, 0x3F, 0x80,
  0x1F, 0xE3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0xC3, 0xF8, 0x03, 0xF8,
  0x1F, 0x80, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC,
  0x1F, 0xE0, 0x0F, 0xC1, 0xFC, 0x00, 0xFE, 0x3F, 0xC0, 0x0F, 0xE3, 0xF8,
  0x00, 0xFE, 0x7F, 0x80, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xC1, 0xFF, 0x03, 0xFE, 0x07,
  0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xF8, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFC, 0x1F, 0xFE, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF,
  0x87, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF,
  0x0F, 0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xE0, 0x00,
  0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xE0,
  0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x07, 0xFE, 0x3F,
  0xF0, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xF8, 0x7F, 0xFC, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x9F, 0xF0, 0x0F, 0xFF, 0xE3, 0xFE, 0x00, 0x7F,
  0xF0, 0x7F, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x7C, 0x00, 0x03, 0xFE, 0x3F, 0xF8, 0x00,
  0x3F, 0xCF, 0xFF, 0xE0, 0x03, 0xFD, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03,
  0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF0,
  0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xF1,
  0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x01,
  0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x03, 0xFE, 0x3F, 0xE0,
  0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x0F,
  0xF8, 0x7F, 0xE0, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xF8,
  0x07, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xF3, 0xFF, 0xFF,
  0x00, 0xFF, 0x1F, 0xFF, 0xE0, 0x0F, 0xF0, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x00,
  0x0F, 0xF8, 0xFF, 0xC0, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0x9F, 0xF0,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE3, 0xFE, 0x00,
  0x07, 0xF8, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0x87, 0xFC,
  0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xF8, 0x07, 0xFC, 0x00,
  0x0F, 0xFE, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0x3F, 0xE0, 0x03, 0xFF, 0xFF,
  0x7F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0x03, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0x80,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF7,
  0xF8, 0x00, 0x3F, 0xFF, 0xDF, 0xE0, 0x00, 0x3F, 0xFF, 0x3F, 0xC0, 0x00,
  0x3F, 0xF8, 0x7F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x00,
  0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0x0F, 0xFC,
  0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xCF,
  0xF8, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0x00, 0xFF, 0xC0, 0x00, 0x70, 0x0F, 0xFC, 0x00,
  0x1F, 0x01, 0xFF, 0xE0, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x08, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x83, 0xFC,
  0x00, 0x3F, 0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0xFF, 0xDF, 0xF0, 0x03, 0xFF,
  0xFF, 0xBF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0xFF,
  0x80, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x03,
  0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x9F, 0xF0, 0x00, 0x0F, 0xFC, 0x3F, 0xE0,
  0x00, 0x07, 0xE0, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x20, 0x00, 0x0F, 0xFC, 0x00, 0x60, 0x00, 0x3F, 0xF0,
  0x01, 0xE0, 0x00, 0xFF, 0xE0, 0x07, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xF8,
  0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x3E, 0x00, 0x01, 0xFE, 0x0F, 0xFE, 0x00, 0x0F, 0xF0, 0xFF,
  0xFC, 0x00, 0x7F, 0x9F, 0xFF, 0xF0, 0x07, 0xFD, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xF0,
  0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00,
  0x3F, 0xE1, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x7F,
  0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x3F,
  0xE1, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0xC0,
  0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x80,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x04, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0x00,
  0x0F, 0xF8, 0x0F, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xFF, 0x00, 0x03, 0xFC,
  0x0F, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0x8F, 0xFE, 0x00, 0x00, 0x7F, 0xCF, 0xFE, 0x00, 0x00,
  0x3F, 0xEF, 0xFE, 0x00, 0x00, 0x1F, 0xEF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFD,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x7F, 0xC0, 0x00, 0x1F, 0xFC, 0x3F, 0xF0,
  0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x07,
  0xFC, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x1F,
  0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x00,
  0x0F, 0xFE, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x02, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xFE, 0x3F, 0xC1,
  0xFE, 0x00, 0xFF, 0x3F, 0xF1, 0xFF, 0x80, 0x7F, 0xBF, 0xFD, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFE, 0x3F, 0xF0,
  0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x7F, 0xC0,
  0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x81,
  0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x83,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC3, 0xFE, 0x0F, 0xF8, 0x1F, 0xE1, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x07,
  0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x1F,
  0xE0, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x1F,
  0xE1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x7F,
  0x81, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F,
  0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F,
  0x87, 0xF8, 0x1F, 0xE0, 0x7F, 0xC3, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0xF0, 0x00, 0x7F, 0x8F, 0xFF,
  0xE0, 0x03, 0xFC, 0xFF, 0xFF, 0x80, 0x3F, 0xCF, 0xFF, 0xFE, 0x01, 0xFE,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x80,
  0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x01,
  0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0x83, 0xFE,
  0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFF,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0xC3, 0xFE, 0x00,
  0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x07,
  0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x03,
  0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x03, 0xFE,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xE0, 0x01, 0xFF,
  0x0F, 0xF8, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00,
  0x7F, 0xCF, 0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0xC0,
  0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00,
  0x7F, 0xDF, 0xF0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0xC0,
  0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xFE, 0x1F,
  0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFF, 0x0F, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0xFF, 0x00, 0x03, 0xFD,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x1F,
  0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0xC0,
  0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0x80,
  0x1F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0x7F, 0xFF, 0xE0, 0x03, 0xFE, 0x7F, 0xFF, 0x00,
  0x07, 0xFC, 0x3F, 0xF8, 0x00, 0x1F, 0xF0, 0x07, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x7F, 0xC0, 0x0F, 0xFF, 0xE3, 0xFC, 0x01, 0xFF, 0xFF,
  0x9F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xF0,
  0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xE0,
  0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x80,
  0x00, 0xFF, 0x83, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x01,
  0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xBF, 0xC0, 0x01, 0xFF,
  0xF9, 0xFE, 0x00, 0x07, 0xFF, 0x0F, 0xF0, 0x00, 0x03, 0xC0, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xC0,
  0xFF, 0xFC, 0x07, 0xF8, 0x7F, 0xFF, 0x00, 0xFF, 0x1F, 0xFF, 0xE0, 0x3F,
  0xE7, 0xFF, 0xFC, 0x07, 0xFD, 0xFF, 0xFF, 0x80, 0xFF, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x81,
  0xE0, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE1,
  0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x1F,
  0xF0, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xCF, 0xF8,
  0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xE3,
  0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x60,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x03, 0xFE,
  0x1F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00,
  0x3F, 0xE1, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xFC,
  0x3F, 0xE0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x87, 0xFC,
  0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01,
  0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0xE0,
  0x7F, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFB, 0xFC, 0x01, 0xFF,
  0xFF, 0x3F, 0xC0, 0x0F, 0xFF, 0xC3, 0xFC, 0x00, 0x3F, 0xF8, 0x3F, 0xC0,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFB, 0xFC, 0x00,
  0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00, 0x7F, 0xC7,
  0xFC, 0x00, 0x07, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x03,
  0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0xFF,
  0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x07, 0xFC,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0,
  0x1F, 0xE0, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0xFF, 0x80, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F,
  0xC0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x00, 0x7F, 0x1F, 0xF0, 0x00, 0x03, 0xF8, 0xFF, 0x00,
  0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x07, 0xFB,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xFC,
  0x03, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xF0, 0x1F, 0xEF, 0xF0, 0x1F, 0xE0,
  0x3F, 0xDF, 0xE0, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x81, 0xFE, 0x7F,
  0x81, 0xFF, 0x03, 0xFC, 0xFF, 0x07, 0xFE, 0x07, 0xF1, 0xFE, 0x0F, 0xFC,
  0x1F, 0xE3, 0xFC, 0x1F, 0xF8, 0x3F, 0xC7, 0xF8, 0x7F, 0xF0, 0x7F, 0x0F,
  0xF0, 0xFF, 0xE1, 0xFE, 0x1F, 0xC1, 0xFF, 0xC3, 0xFC, 0x3F, 0x87, 0xFF,
  0x87, 0xF0, 0x7F, 0x0F, 0xFF, 0x1F, 0xE0, 0xFE, 0x1F, 0x7E, 0x3F, 0xC1,
  0xFC, 0x7E, 0x7C, 0x7F, 0x03, 0xF8, 0xF8, 0xF9, 0xFE, 0x07, 0xF3, 0xF1,
  0xF3, 0xFC, 0x0F, 0xE7, 0xE3, 0xE7, 0xF0, 0x1F, 0xCF, 0x87, 0xCF, 0xE0,
  0x3F, 0xBF, 0x0F, 0xBF, 0x80, 0x7F, 0x7E, 0x1F, 0x7F, 0x00, 0xFE, 0xF8,
  0x3E, 0xFE, 0x01, 0xFF, 0xF0, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x81,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xDF, 0xF8, 0x00, 0x00, 0x7F, 0xF1, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0x01, 0xFE, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF1, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xE7, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3E, 0x0F, 0xFF, 0xF8,
  0x00, 0x3F, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0x1F, 0xFF, 0xFE, 0x00, 0x7E,
  0x3F, 0xFF, 0xFF, 0x00, 0xFE, 0x3F, 0xFF, 0xFF, 0xC3, 0xFE, 0x7F, 0x81,
  0xFF, 0xFF, 0xFC, 0x7F, 0x00, 0x7F, 0xFF, 0xFC, 0x7E, 0x00, 0x3F, 0xFF,
  0xF8, 0x7E, 0x00, 0x1F, 0xFF, 0xF8, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x02,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x0C, 0x00,
};

const GFXglyph RobotoMono_SemiBoldItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 42, 0, -1 },
  { 1, 17, 52, 42, 13, -51 },
  { 112, 24, 18, 42, 12, -54 },
  { 166, 42, 51, 42, 0, -51 },
  { 434, 38, 66, 42, 3, -59 },
  { 748, 35, 53, 42, 4, -52 },
  { 980, 40, 53, 42, 1, -52 },
  { 1245, 10, 19, 42, 18, -54 },
  { 1269, 24, 73, 42, 11, -57 },
  { 1488, 24, 73, 42, 6, -57 },
  { 1707, 34, 36, 42, 6, -51 },
  { 1860, 36, 37, 42, 3, -42 },
  { 2027, 15, 22, 42, 7, -8 },
  { 2069, 29, 7, 42, 9, -26 },
  { 2095, 13, 13, 42, 12, -12 },
  { 2117, 37, 55, 42, 3, -51 },
  { 2372, 35, 53, 42, 4, -52 },
  { 2604, 24, 51, 42, 9, -51 },
  { 2757, 38, 52, 42, 0, -52 },
  { 3004, 37, 53, 42, 2, -52 },
  { 3250, 37, 51, 42, 1, -51 },
  { 3486, 38, 52, 42, 3, -51 },
  { 3733, 34, 53, 42, 3, -52 },
  { 3959, 37, 51, 42, 5, -51 },
  { 4195, 36, 53, 42, 3, -52 },
  { 4434, 33, 52, 42, 5, -52 },
  { 4649, 18, 42, 42, 13, -41 },
  { 4744, 22, 55, 42, 10, -41 },
  { 4896, 33, 33, 42, 5, -39 },
  { 5033, 36, 22, 42, 4, -33 },
  { 5132, 34, 34, 42, 3, -39 },
  { 5277, 31, 53, 42, 9, -52 },
  { 5483, 40, 51, 42, 2, -51 },
  { 5738, 41, 51, 42, -3, -51 },
  { 6000, 41, 51, 42, 1, -51 },
  { 6262, 38, 53, 42, 3, -52 },
  { 6514, 39, 51, 42, 1, -51 },
  { 6763, 41, 51, 42, 2, -51 },
  { 7025, 42, 51, 42, 2, -51 },
  { 7293, 38, 53, 42, 3, -52 },
  { 7545, 41, 51, 42, 1, -51 },
  { 7807, 38, 51, 42, 3, -51 },
  { 8050, 40, 52, 42, 2, -51 },
  { 8310, 46, 51, 42, 1, -51 },
  { 8604, 34, 51, 42, 2, -51 },
  { 8821, 42, 51, 42, 1, -51 },
  { 9089, 41, 51, 42, 1, -51 },
  { 9351, 38, 53, 42, 3, -52 },
  { 9603, 40, 51, 42, 2, -51 },
  { 9858, 38, 61, 42, 3, -52 },
  { 10148, 41, 51, 42, 1, -51 },
  { 10410, 40, 53, 42, 2, -52 },
  { 10675, 41, 51, 42, 5, -51 },
  { 10937, 40, 52, 42, 3, -51 },
  { 11197, 39, 51, 42, 6, -51 },
  { 11446, 41, 51, 42, 5, -51 },
  { 11708, 48, 51, 42, -2, -51 },
  { 12014, 40, 51, 42, 7, -51 },
  { 12269, 43, 51, 42, 0, -51 },
  { 12544, 26, 71, 42, 9, -59 },
  { 12775, 18, 55, 42, 13, -51 },
  { 12899, 26, 71, 42, 9, -59 },
  { 13130, 28, 27, 42, 8, -51 },
  { 13225, 33, 7, 42, 0, 0 },
  { 13254, 14, 10, 42, 19, -52 },
  { 13272, 35, 40, 42, 2, -39 },
  { 13447, 36, 55, 42, 2, -54 },
  { 13695, 34, 40, 42, 4, -39 },
  { 13865, 39, 55, 42, 3, -54 },
  { 14134, 35, 40, 42, 3, -39 },
  { 14309, 39, 56, 42, 6, -56 },
  { 14582, 39, 54, 42, 1, -39 },
  { 14846, 37, 54, 42, 1, -54 },
  { 15096, 31, 53, 42, 4, -53 },
  { 15302, 33, 68, 42, 2, -53 },
  { 15583, 41, 54, 42, 1, -54 },
  { 15860, 33, 54, 42, 3, -54 },
  { 16083, 41, 39, 42, -1, -39 },
  { 16283, 37, 39, 42, 1, -39 },
  { 16464, 35, 40, 42, 3, -39 },
  { 16639, 39, 54, 42, -1, -39 },
  { 16903, 37, 54, 42, 3, -39 },
  { 17153, 35, 39, 42, 6, -39 },
  { 17324, 35, 40, 42, 3, -39 },
  { 17499, 33, 48, 42, 6, -47 },
  { 17697, 36, 39, 42, 4, -38 },
  { 17873, 37, 38, 42, 5, -38 },
  { 18049, 39, 38, 42, 4, -38 },
  { 18235, 43, 38, 42, 0, -38 },
  { 18440, 45, 53, 42, 0, -38 },
  { 18739, 39, 38, 42, 1, -38 },
  { 18925, 28, 69, 42, 10, -56 },
  { 19167, 16, 65, 42, 13, -51 },
  { 19297, 27, 69, 42, 7, -56 },
  { 19530, 40, 16, 42, 0, -29 },
};

const GFXfont RobotoMono_SemiBoldItalic72pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic72pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic72pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC72PT7B_H_
