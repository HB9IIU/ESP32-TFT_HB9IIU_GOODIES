#ifndef _UBUNTUMONO_BOLD20PT7B_H_
#define _UBUNTUMONO_BOLD20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Bold.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Bold20pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x60, 0x66, 0xCF, 0x3C, 0xF3, 0xCF, 0x30,
  0x19, 0x86, 0x61, 0xBB, 0xFF, 0xFF, 0xCC, 0xC3, 0x33, 0xFF, 0xFF, 0xD9,
  0x86, 0x61, 0x98, 0x18, 0x18, 0x3F, 0x7F, 0xE0, 0xE0, 0xF0, 0x7C, 0x3F,
  0x07, 0x03, 0x83, 0xFF, 0x7C, 0x18, 0x18, 0x70, 0xFC, 0x6F, 0xB3, 0x6C,
  0xF6, 0x1F, 0x00, 0xF8, 0x6F, 0x36, 0xCD, 0xF6, 0x7F, 0x0E, 0x1C, 0x0F,
  0x86, 0x71, 0xD8, 0x3E, 0x0E, 0x67, 0xD9, 0xBE, 0xE7, 0x98, 0xC7, 0xF8,
  0xF6, 0xFF, 0xF0, 0x08, 0x73, 0xDC, 0x63, 0x8C, 0x30, 0xC3, 0x0C, 0x38,
  0x61, 0xC3, 0x87, 0x0C, 0x43, 0x87, 0x0E, 0x18, 0x70, 0xC3, 0x0C, 0x30,
  0xC7, 0x18, 0xE7, 0x38, 0x40, 0x18, 0xDB, 0xFF, 0x7E, 0x3C, 0x7E, 0x76,
  0x24, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x6F, 0xF7, 0x2E,
  0x80, 0xFF, 0xF0, 0x6F, 0xF6, 0x07, 0x07, 0x06, 0x0E, 0x0E, 0x0C, 0x1C,
  0x1C, 0x18, 0x38, 0x38, 0x30, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0x3C, 0x7E,
  0xE7, 0xC3, 0xC3, 0xDB, 0xDB, 0xC3, 0xC3, 0xE7, 0x7E, 0x3C, 0x0C, 0x3C,
  0xFC, 0xFC, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x7F, 0x7F, 0x7C, 0xFE,
  0x47, 0x07, 0x06, 0x0E, 0x1C, 0x38, 0x70, 0xE0, 0xFF, 0xFF, 0x7C, 0xFE,
  0x06, 0x07, 0x06, 0x3E, 0x3E, 0x07, 0x03, 0x87, 0xFE, 0xFC, 0x0E, 0x07,
  0x07, 0x86, 0xC6, 0x63, 0x33, 0x19, 0xFF, 0xFF, 0x83, 0x01, 0x80, 0xC0,
  0x7E, 0x7E, 0x60, 0x60, 0x7C, 0x7E, 0x0F, 0x07, 0x07, 0x07, 0xFE, 0xFC,
  0x0E, 0x3E, 0x78, 0x60, 0xFC, 0xFE, 0xE7, 0xC3, 0xC3, 0xE7, 0x7E, 0x3C,
  0xFF, 0xFF, 0x07, 0x0E, 0x0C, 0x1C, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30,
  0x3C, 0x7E, 0xE7, 0xC3, 0xE7, 0x7E, 0x7E, 0xE7, 0xC3, 0xC3, 0xFF, 0x7E,
  0x3C, 0x7E, 0xE7, 0xC3, 0xC3, 0xE7, 0x7F, 0x3F, 0x06, 0x1E, 0x7C, 0x70,
  0x6F, 0xF6, 0x00, 0x6F, 0xF6, 0x33, 0xDE, 0x60, 0x00, 0xCF, 0x79, 0xCD,
  0xE4, 0x00, 0x03, 0x0F, 0x7E, 0xF0, 0xF0, 0x7E, 0x0F, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0xF0, 0x7E, 0x0F, 0x0F, 0x7E, 0xF0, 0xC0,
  0x7C, 0x7E, 0x47, 0x07, 0x07, 0x0E, 0x1C, 0x38, 0x38, 0x00, 0x38, 0x38,
  0x1E, 0x1F, 0xDC, 0x6C, 0x36, 0x7E, 0x7F, 0x77, 0xB3, 0xD9, 0xEE, 0xDB,
  0xEC, 0xF7, 0x01, 0xFC, 0x3E, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x33, 0x0C,
  0xC3, 0x31, 0xFE, 0x7F, 0x98, 0x66, 0x1B, 0x87, 0xFC, 0xFE, 0xE7, 0xE7,
  0xE7, 0xFE, 0xFE, 0xE3, 0xE3, 0xE3, 0xFF, 0xFE, 0x1F, 0x7F, 0xE1, 0xE0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0xE1, 0x7F, 0x3E, 0xFC, 0xFE, 0xE7, 0xE3,
  0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE7, 0xFE, 0xF8, 0xFF, 0xFF, 0xE0, 0xE0,
  0xE0, 0xFE, 0xFE, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0,
  0xE0, 0xFE, 0xFE, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x1F, 0x7F, 0xE1, 0xE0,
  0xC0, 0xC0, 0xC3, 0xC3, 0xC3, 0xE3, 0x7F, 0x3F, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xFF, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xFF, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x7F, 0x7F, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x47, 0xFE, 0x7C, 0xC7, 0x63, 0xB3, 0x9B,
  0x8D, 0x87, 0xC3, 0xE1, 0xB8, 0xCE, 0x63, 0xB1, 0xD8, 0x70, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0x61, 0x9C,
  0xE7, 0x39, 0xCE, 0x7F, 0x9F, 0xE6, 0xD9, 0xB6, 0x61, 0x98, 0x66, 0x1B,
  0x87, 0xC3, 0xE3, 0xE3, 0xF3, 0xF3, 0xDB, 0xDB, 0xCF, 0xC7, 0xC7, 0xC7,
  0xC3, 0x3C, 0x7E, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE7, 0x7E,
  0x3C, 0xFC, 0xFF, 0xE7, 0xE3, 0xE3, 0xE7, 0xFF, 0xFC, 0xE0, 0xE0, 0xE0,
  0xE0, 0x3C, 0x7E, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE7, 0x7E,
  0x3C, 0x1C, 0x0F, 0x07, 0xFC, 0x7F, 0x39, 0xDC, 0xEE, 0x77, 0x3B, 0xF9,
  0xF8, 0xEE, 0x73, 0x39, 0xDC, 0x70, 0x3E, 0x7E, 0xE2, 0xC0, 0xF0, 0x7C,
  0x3F, 0x07, 0x03, 0x87, 0xFF, 0x7C, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE7, 0xFF, 0x3C, 0xE1, 0xD8, 0x66,
  0x19, 0x86, 0x73, 0x8C, 0xC3, 0x30, 0xCC, 0x1E, 0x07, 0x81, 0xE0, 0x30,
  0xE1, 0xD8, 0x66, 0x19, 0x86, 0x6D, 0x9B, 0x67, 0xF9, 0xFE, 0x73, 0x9C,
  0xE7, 0x39, 0x86, 0x61, 0x9C, 0xE3, 0x30, 0xFC, 0x1E, 0x03, 0x01, 0xE0,
  0x7C, 0x3B, 0x1C, 0xE7, 0x1B, 0x87, 0xE1, 0xD8, 0x67, 0x38, 0xCC, 0x3B,
  0x07, 0x81, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF, 0x07,
  0x0E, 0x1C, 0x1C, 0x38, 0x30, 0x70, 0x60, 0xFF, 0xFF, 0xFF, 0xFE, 0x38,
  0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x3F, 0xFC, 0xE0, 0xE0,
  0x60, 0x70, 0x70, 0x30, 0x38, 0x38, 0x18, 0x1C, 0x1C, 0x0C, 0x0E, 0x0E,
  0x06, 0x07, 0x07, 0xFF, 0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xFF, 0xFC, 0x0C, 0x07, 0x83, 0xF1, 0xCE, 0x71, 0x98, 0x60,
  0xFF, 0xFF, 0xF0, 0x4E, 0x71, 0x7C, 0x7E, 0x07, 0x7F, 0xFF, 0xC7, 0xC7,
  0xFF, 0x7F, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFE, 0xFF, 0xE7, 0xE3, 0xE3,
  0xE3, 0xE7, 0xFE, 0xFC, 0x3F, 0x7F, 0xE0, 0xE0, 0xC0, 0xE0, 0xE0, 0x7F,
  0x3F, 0x07, 0x07, 0x07, 0x07, 0x07, 0x7F, 0xFF, 0xE7, 0xC7, 0xC7, 0xC7,
  0xE7, 0xFF, 0x3F, 0x3C, 0x7E, 0xE7, 0xC3, 0xFF, 0xFF, 0xC0, 0x7F, 0x3F,
  0x0F, 0x8F, 0xCE, 0x06, 0x03, 0x07, 0xFB, 0xFC, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0x3F, 0xFF, 0xE7, 0xC7, 0xC7, 0xE7, 0xFF, 0x7F,
  0x07, 0x87, 0xFE, 0xFC, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFC, 0xFE, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0x38, 0x38, 0x00, 0xF8, 0xF8, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x18, 0x1F, 0x0F, 0x0E, 0x1C, 0x03, 0xF7,
  0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xD3, 0xFE, 0x78, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x3B, 0xB9, 0xD8, 0xF8, 0x7C, 0x3F, 0x1D,
  0xCE, 0x77, 0x18, 0xF8, 0xF8, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x1F, 0x0F, 0xFF, 0xFF, 0xDB, 0xDB, 0xDB, 0xDB, 0xC3,
  0xC3, 0xC3, 0xFC, 0xFE, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0x3C,
  0x7E, 0xE7, 0xC3, 0xC3, 0xC3, 0xE7, 0x7E, 0x3C, 0xFC, 0xFE, 0xE7, 0xE3,
  0xE3, 0xE3, 0xE7, 0xFF, 0xFE, 0xE0, 0xE0, 0xE0, 0x3F, 0x7F, 0xE7, 0xC7,
  0xC7, 0xC7, 0xE7, 0xFF, 0x7F, 0x07, 0x07, 0x07, 0x7F, 0xFF, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC0, 0x3E, 0x7E, 0xE0, 0xF0, 0x7E, 0x0F, 0x87, 0xFF,
  0x7C, 0x30, 0x30, 0x30, 0xFF, 0xFF, 0x30, 0x30, 0x30, 0x30, 0x38, 0x3F,
  0x1F, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0x7F, 0x3F, 0xE1, 0xD8,
  0x67, 0x39, 0xCC, 0x33, 0x0F, 0xC1, 0xE0, 0x78, 0x0C, 0x00, 0xC0, 0xF0,
  0x3C, 0xCD, 0x32, 0x7F, 0x9F, 0xE7, 0x79, 0xCE, 0x33, 0x00, 0x61, 0x8C,
  0xC3, 0xF0, 0x78, 0x0E, 0x07, 0x83, 0x31, 0xCE, 0x61, 0x80, 0x61, 0xB8,
  0xCC, 0xE6, 0x63, 0xB0, 0xD8, 0x78, 0x1C, 0x0E, 0x0E, 0x1E, 0x1E, 0x00,
  0x7F, 0x7F, 0x0E, 0x1C, 0x38, 0x30, 0x70, 0xFF, 0xFF, 0x1F, 0x1F, 0x38,
  0x38, 0x38, 0x38, 0x38, 0xF0, 0xF0, 0x38, 0x38, 0x38, 0x38, 0x38, 0x18,
  0x1F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0xF8, 0x18, 0x1C, 0x1C,
  0x1C, 0x1C, 0x0F, 0x0F, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0xF8, 0xF0,
  0x38, 0xDF, 0xEC, 0x70,
};

const GFXglyph UbuntuMono_Bold20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 12, 10, 3, -12 },
  { 7, 6, 6, 10, 2, -14 },
  { 12, 10, 12, 10, 0, -12 },
  { 27, 8, 16, 10, 1, -14 },
  { 43, 10, 12, 10, 0, -12 },
  { 58, 10, 12, 10, 0, -12 },
  { 73, 2, 6, 10, 4, -14 },
  { 75, 6, 17, 10, 2, -14 },
  { 88, 6, 17, 10, 2, -14 },
  { 101, 8, 8, 10, 1, -12 },
  { 109, 8, 8, 10, 1, -9 },
  { 117, 4, 7, 10, 3, -4 },
  { 121, 6, 2, 10, 2, -6 },
  { 123, 4, 4, 10, 3, -4 },
  { 125, 8, 17, 10, 1, -14 },
  { 142, 8, 12, 10, 1, -12 },
  { 154, 8, 12, 10, 1, -12 },
  { 166, 8, 12, 10, 1, -12 },
  { 178, 8, 12, 10, 1, -12 },
  { 190, 9, 12, 10, 1, -12 },
  { 204, 8, 12, 10, 1, -12 },
  { 216, 8, 12, 10, 1, -12 },
  { 228, 8, 12, 10, 1, -12 },
  { 240, 8, 12, 10, 1, -12 },
  { 252, 8, 12, 10, 1, -12 },
  { 264, 4, 10, 10, 3, -10 },
  { 269, 5, 13, 10, 2, -10 },
  { 278, 8, 8, 10, 1, -9 },
  { 286, 8, 6, 10, 1, -8 },
  { 292, 8, 8, 10, 1, -9 },
  { 300, 8, 12, 10, 1, -12 },
  { 312, 9, 15, 10, 0, -12 },
  { 329, 10, 12, 10, 0, -12 },
  { 344, 8, 12, 10, 1, -12 },
  { 356, 8, 12, 10, 1, -12 },
  { 368, 8, 12, 10, 1, -12 },
  { 380, 8, 12, 10, 1, -12 },
  { 392, 8, 12, 10, 1, -12 },
  { 404, 8, 12, 10, 1, -12 },
  { 416, 8, 12, 10, 1, -12 },
  { 428, 8, 12, 10, 1, -12 },
  { 440, 8, 12, 10, 1, -12 },
  { 452, 9, 12, 10, 1, -12 },
  { 466, 8, 12, 10, 1, -12 },
  { 478, 10, 12, 10, 0, -12 },
  { 493, 8, 12, 10, 1, -12 },
  { 505, 8, 12, 10, 1, -12 },
  { 517, 8, 12, 10, 1, -12 },
  { 529, 8, 15, 10, 1, -12 },
  { 544, 9, 12, 10, 1, -12 },
  { 558, 8, 12, 10, 1, -12 },
  { 570, 10, 12, 10, 0, -12 },
  { 585, 8, 12, 10, 1, -12 },
  { 597, 10, 12, 10, 0, -12 },
  { 612, 10, 12, 10, 0, -12 },
  { 627, 10, 12, 10, 0, -12 },
  { 642, 10, 12, 10, 0, -12 },
  { 657, 8, 12, 10, 1, -12 },
  { 669, 6, 17, 10, 2, -14 },
  { 682, 8, 17, 10, 1, -14 },
  { 699, 6, 17, 10, 2, -14 },
  { 712, 10, 6, 10, 0, -12 },
  { 720, 10, 2, 10, 0, 1 },
  { 723, 4, 4, 10, 3, -14 },
  { 725, 8, 9, 10, 1, -9 },
  { 734, 8, 14, 10, 1, -14 },
  { 748, 8, 9, 10, 1, -9 },
  { 757, 8, 14, 10, 1, -14 },
  { 771, 8, 9, 10, 1, -9 },
  { 780, 9, 14, 10, 1, -14 },
  { 796, 8, 12, 10, 1, -9 },
  { 808, 8, 14, 10, 1, -14 },
  { 822, 8, 14, 10, 1, -14 },
  { 836, 7, 17, 10, 1, -14 },
  { 851, 9, 14, 10, 1, -14 },
  { 867, 8, 14, 10, 1, -14 },
  { 881, 8, 9, 10, 1, -9 },
  { 890, 8, 9, 10, 1, -9 },
  { 899, 8, 9, 10, 1, -9 },
  { 908, 8, 12, 10, 1, -9 },
  { 920, 8, 12, 10, 1, -9 },
  { 932, 7, 9, 10, 2, -9 },
  { 940, 8, 9, 10, 1, -9 },
  { 949, 8, 12, 10, 1, -12 },
  { 961, 8, 9, 10, 1, -9 },
  { 970, 10, 9, 10, 0, -9 },
  { 982, 10, 9, 10, 0, -9 },
  { 994, 10, 9, 10, 0, -9 },
  { 1006, 9, 12, 10, 0, -9 },
  { 1020, 8, 9, 10, 1, -9 },
  { 1029, 8, 17, 10, 1, -14 },
  { 1046, 2, 17, 10, 4, -14 },
  { 1051, 8, 17, 10, 1, -14 },
  { 1068, 10, 3, 10, 0, -7 },
};

const GFXfont UbuntuMono_Bold20pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Bold20pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Bold20pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _UBUNTUMONO_BOLD20PT7B_H_
