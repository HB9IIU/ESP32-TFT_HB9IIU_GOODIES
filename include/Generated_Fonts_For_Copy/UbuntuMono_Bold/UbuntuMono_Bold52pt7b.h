#ifndef _UBUNTUMONO_BOLD52PT7B_H_
#define _UBUNTUMONO_BOLD52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Bold.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Bold52pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0xFC, 0x3F,
  0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFB, 0xF0,
  0xFD, 0xF8, 0x7E, 0xFC, 0x3F, 0x7E, 0x1F, 0xBF, 0x07, 0xDF, 0x03, 0xE7,
  0x81, 0xF3, 0xC0, 0xF1, 0xE0, 0x78, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7C,
  0x01, 0xF8, 0x7C, 0x01, 0xF0, 0xFC, 0x01, 0xF0, 0xFC, 0x01, 0xF0, 0xF8,
  0x03, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC3, 0xF0,
  0x07, 0xC3, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0xC3, 0xE0, 0x0F, 0xC3, 0xE0,
  0x0F, 0x83, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0x80,
  0x1F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3E, 0x1F, 0x80,
  0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0xFF,
  0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xF8, 0x0F,
  0x1F, 0xC0, 0x04, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x60,
  0x01, 0xFD, 0xF0, 0x0F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xF0, 0x01, 0xF3, 0xFE, 0x00, 0xF9, 0xFF, 0x80, 0x3C,
  0x79, 0xF0, 0x1F, 0x1E, 0x3C, 0x0F, 0x87, 0x8F, 0x03, 0xC1, 0xE3, 0xC1,
  0xF0, 0x78, 0xF0, 0xF8, 0x1E, 0x3C, 0x3C, 0x07, 0x8F, 0x1F, 0x01, 0xE7,
  0xCF, 0x80, 0x7F, 0xE3, 0xC0, 0x0F, 0xF9, 0xF0, 0x01, 0xFC, 0xF8, 0x00,
  0x3E, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC7,
  0xC0, 0x01, 0xF3, 0xF8, 0x00, 0xF9, 0xFF, 0x00, 0x3C, 0xFF, 0xE0, 0x1F,
  0x3E, 0xF8, 0x0F, 0x8F, 0x1E, 0x03, 0xC3, 0xC7, 0x81, 0xF0, 0xF1, 0xE0,
  0xF8, 0x3C, 0x78, 0x3C, 0x0F, 0x1E, 0x1F, 0x03, 0xC7, 0x8F, 0x80, 0xF9,
  0xE3, 0xC0, 0x3F, 0xF9, 0xF0, 0x07, 0xFC, 0xF8, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0x8F, 0xC0, 0x3F, 0x07, 0xC0, 0x3F,
  0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x1F, 0x0F, 0xC0, 0x1F,
  0x9F, 0x80, 0x1F, 0xBF, 0x80, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xF8, 0x3C, 0x0F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x3F, 0xFC, 0x7E, 0x7E,
  0x7E, 0x7C, 0x7E, 0x7F, 0x7C, 0xFC, 0x3F, 0xFC, 0xFC, 0x1F, 0xFC, 0xFC,
  0x0F, 0xF8, 0xFC, 0x07, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF8, 0x7E,
  0x0F, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0x7E, 0x0F,
  0xFE, 0x7F, 0x03, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7D, 0xE7, 0x9E, 0x00, 0x04, 0x00, 0x0F, 0x00, 0x0F, 0xC0,
  0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x20, 0x10, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x0F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0,
  0x1F, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x00, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x30, 0x7C, 0x10, 0xF1,
  0xE3, 0xC7, 0xE7, 0x9F, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0xFC, 0xFC, 0x07, 0xF3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3E, 0x1F, 0x00, 0x78,
  0x38, 0x00, 0x40, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x83, 0xF8, 0xFF,
  0x1F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF8, 0xFF, 0x0F, 0xE0, 0x7C, 0x1F, 0x03,
  0xE0, 0xF8, 0xFF, 0x3F, 0xC7, 0xF0, 0xF8, 0x1C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x1F, 0xE7, 0xFB,
  0xFF, 0xFF, 0xFF, 0xF7, 0xF9, 0xFE, 0x1E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0xFE, 0x1F, 0xC7, 0xF0, 0x3F, 0x9F, 0x80, 0x7E, 0x7E, 0x01,
  0xF9, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF1, 0xE3, 0xFF, 0xC7, 0x8F, 0xFF, 0x3F, 0x3F, 0xFC, 0xFC, 0xFF, 0xF3,
  0xF3, 0xFF, 0xC7, 0x8F, 0xFF, 0x1E, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x7C, 0x00, 0xF9, 0xF8, 0x07, 0xE7,
  0xE0, 0x1F, 0x9F, 0xC0, 0xFE, 0x3F, 0x87, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00,
  0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFD,
  0xF8, 0x03, 0xC7, 0xE0, 0x0C, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE1, 0xF8, 0x3F, 0xC3, 0x80, 0x7F, 0x04, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0x03, 0xFC, 0x00,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x1E, 0x07,
  0xF8, 0x40, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x80, 0x07, 0xF7, 0x80,
  0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0x80,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xF0, 0x01, 0xFB, 0xF0, 0x01, 0xFB, 0xF0, 0x03, 0xF3, 0xF0,
  0x07, 0xE3, 0xF0, 0x07, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x1F, 0x83, 0xF0,
  0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0xE0, 0x1F, 0xE7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x1F, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xC0,
  0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFF,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xF8, 0x1F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80,
  0x7E, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xF7, 0xE0, 0x1F, 0xDF, 0x80, 0x7F,
  0x7E, 0x01, 0xF9, 0xFC, 0x07, 0xE7, 0xF0, 0x3F, 0x8F, 0xE1, 0xFC, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0xFE, 0x1F, 0xE7, 0xF0, 0x3F, 0x9F, 0x80, 0x7E, 0x7E,
  0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0xC0, 0x7E, 0x7F, 0x83,
  0xF0, 0xFF, 0x1F, 0xC3, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xCF, 0xFC, 0x7F, 0x0F, 0xF9, 0xF8,
  0x0F, 0xEF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0x7F, 0x83, 0xF9, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0xFE, 0x1F, 0xC7, 0xF0, 0x3F, 0x9F, 0x80, 0xFE, 0x7E, 0x01, 0xFB,
  0xF8, 0x07, 0xEF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFD, 0xF8,
  0x03, 0xF7, 0xF0, 0x1F, 0xDF, 0xE0, 0x7F, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x07,
  0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x1E, 0x1F, 0xE7, 0xFB, 0xFF, 0xFF,
  0xFF, 0xF7, 0xF9, 0xFE, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x1F, 0xE7, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xF9, 0xFE,
  0x1E, 0x00, 0x07, 0x81, 0xFE, 0x1F, 0xE3, 0xFF, 0x3F, 0xF3, 0xFF, 0x1F,
  0xE1, 0xFE, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x81, 0xFC, 0x1F, 0xE3, 0xFE, 0x3F, 0xF3, 0xFF, 0x1F,
  0xF1, 0xFF, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0xC3, 0xF8, 0xFF,
  0x0F, 0xE0, 0x7C, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x01, 0xE0, 0x00,
  0x3F, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x20, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F,
  0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00,
  0x01, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x0F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0xF0, 0x7F, 0x90, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0xFC, 0x1F, 0xC3, 0xF0, 0x0F, 0x87, 0xC0, 0x1F,
  0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0xF8, 0x0F, 0xFD, 0xF0, 0x7F, 0xFB,
  0xE1, 0xFF, 0xF7, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0x9F, 0xFC,
  0x7E, 0x1F, 0xF8, 0xFC, 0x3F, 0xF1, 0xF0, 0x7F, 0xE3, 0xE0, 0xFF, 0xC7,
  0xC1, 0xFF, 0x8F, 0x83, 0xFF, 0x1F, 0x07, 0xFE, 0x3E, 0x0F, 0xFC, 0x7E,
  0x1F, 0xF8, 0xFC, 0x3F, 0xF1, 0xFC, 0x7F, 0xE1, 0xFF, 0xFB, 0xC3, 0xFF,
  0xF7, 0xC3, 0xFF, 0xEF, 0x83, 0xFF, 0xDF, 0x01, 0xFF, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x80, 0x60,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F,
  0xCF, 0xC0, 0x03, 0xE1, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80,
  0x1F, 0x87, 0xE0, 0x07, 0xC1, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F,
  0xC0, 0x3F, 0x03, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xC0, 0x1F, 0xC3,
  0xF0, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x0F,
  0xE7, 0xE0, 0x03, 0xF9, 0xF8, 0x00, 0x7E, 0x3F, 0xF8, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7E, 0x07, 0xF3, 0xF0,
  0x1F, 0xDF, 0x80, 0xFE, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFD,
  0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x0F, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xF8, 0x1F, 0xEF,
  0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0x81, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE1, 0xFE, 0x07, 0x87, 0xF0, 0x01, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x21, 0xFF, 0x01,
  0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xF0, 0x7F, 0x8F, 0xC0, 0xFF, 0x3F, 0x01,
  0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xEF, 0xC0, 0x3F, 0xBF, 0x00, 0x7E,
  0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7E, 0xFC, 0x01,
  0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0xBF, 0x00, 0xFE, 0xFC, 0x03, 0xF3,
  0xF0, 0x1F, 0xCF, 0xC0, 0xFE, 0x3F, 0x0F, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xE3, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFE, 0x07, 0x87,
  0xF8, 0x01, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F,
  0xBF, 0x80, 0x3F, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFE, 0x01, 0xF8,
  0xFE, 0x03, 0xF1, 0xFE, 0x07, 0xE1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0x8C, 0x01, 0xFC, 0x78, 0x3F, 0xE7, 0xFF, 0xFE,
  0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0xFE,
  0x01, 0xFD, 0xFC, 0x07, 0xFB, 0xF8, 0x0F, 0xE7, 0xF0, 0x3F, 0x8F, 0xE0,
  0x7F, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x0F, 0xE0, 0xFE, 0x3F,
  0x81, 0xFC, 0x7F, 0x03, 0xF9, 0xFC, 0x07, 0xF7, 0xF0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xFC, 0x03, 0xFB, 0xFC, 0x07, 0xF3, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F,
  0xC7, 0xF8, 0x3F, 0x87, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xF1, 0xFC,
  0x0F, 0xF3, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0,
  0x3F, 0xBF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC,
  0x3F, 0x01, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x7F, 0x83, 0xFC,
  0x7F, 0xC3, 0xFC, 0x7F, 0xC3, 0xFE, 0x7F, 0xC7, 0xFE, 0x7D, 0xE7, 0xBE,
  0x7D, 0xE7, 0xBE, 0x7D, 0xEF, 0xBE, 0x7C, 0xFF, 0x3E, 0x7C, 0xFF, 0x3E,
  0x7C, 0xFF, 0x3E, 0x7C, 0xFF, 0x3E, 0x7C, 0x7E, 0x3E, 0x7C, 0x7E, 0x3E,
  0x7C, 0x7E, 0x3E, 0x7C, 0x7C, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0x7C, 0x3F,
  0xFD, 0xF0, 0xFF, 0xF3, 0xE3, 0xFF, 0xCF, 0x8F, 0xFF, 0x1F, 0x3F, 0xFC,
  0x7C, 0xFF, 0xF0, 0xFB, 0xFF, 0xC3, 0xEF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xC3,
  0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x00, 0xFC, 0x7F, 0x00, 0xFE, 0x7F, 0x00,
  0xFE, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x7F, 0x00,
  0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x7E,
  0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF3, 0xF0, 0x3F, 0xCF, 0xC0, 0x3F, 0xBF, 0x00, 0xFE, 0xFC,
  0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01,
  0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0xBF, 0x00, 0xFE, 0xFF, 0x0F, 0xF3,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF,
  0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F,
  0xC3, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x00, 0xFC, 0x7F, 0x00, 0xFE, 0x7F,
  0x00, 0xFE, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x7F,
  0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1C, 0x3F, 0xF0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE3, 0xF0, 0x7F, 0x8F, 0xC0, 0xFF, 0x3F, 0x01, 0xFC,
  0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC,
  0x03, 0xF3, 0xF0, 0x1F, 0xCF, 0xC0, 0xFF, 0x3F, 0x07, 0xF8, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03,
  0xF0, 0xFE, 0x0F, 0xC3, 0xF8, 0x3F, 0x07, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0,
  0x3F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F,
  0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7F, 0xFC, 0x00, 0xFC, 0x01, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFE,
  0x07, 0x87, 0xF0, 0x02, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC8,
  0x00, 0x7F, 0x7C, 0x07, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0xE1, 0xFE,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x01,
  0xFE, 0x00, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x7F,
  0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F,
  0x81, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x0F,
  0x81, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x07,
  0xC3, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xE7, 0xE0, 0x03,
  0xE7, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C,
  0x3C, 0x3E, 0x7C, 0x7E, 0x3E, 0x7C, 0x7E, 0x3E, 0x7C, 0x7E, 0x3E, 0x7C,
  0xFF, 0x3E, 0x7C, 0xFF, 0x3E, 0x7C, 0xFF, 0x3E, 0x7C, 0xFF, 0x3E, 0x7D,
  0xF7, 0xBE, 0x7D, 0xE7, 0xBE, 0x7D, 0xE7, 0xBE, 0x7F, 0xE3, 0xFE, 0x7F,
  0xC3, 0xFE, 0x7F, 0xC3, 0xFE, 0x7F, 0xC1, 0xFE, 0x3F, 0x81, 0xFC, 0x3F,
  0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F,
  0x00, 0xFC, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x3F,
  0x80, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0xC1, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F,
  0xE3, 0xF0, 0x07, 0xE7, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xE7, 0xE0, 0x0F, 0xE7, 0xF0, 0x0F,
  0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F,
  0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0x7F,
  0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x81, 0xFC, 0x1F,
  0x81, 0xF8, 0x1F, 0xC1, 0xF8, 0x0F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F,
  0xE3, 0xF0, 0x07, 0xE7, 0xE0, 0x07, 0xF7, 0xE0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xBF, 0x00, 0x1F, 0x9F, 0xC0, 0x1F, 0xC7, 0xE0, 0x1F, 0xC3, 0xF8, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x1F, 0xC7, 0xF0, 0x07, 0xF7,
  0xF0, 0x03, 0xF8, 0xF8, 0x00, 0xF0, 0x18, 0x00, 0x60, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x10, 0x07, 0x01, 0xF8, 0x3F, 0x8F, 0xFC, 0xFF, 0xC3, 0xF8,
  0x1E, 0x00, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x0C, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xF3, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xF7, 0xF0, 0x1F, 0xBF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x1F, 0xFC, 0x00,
  0x1E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF7, 0xF8, 0x7F, 0xBF,
  0x81, 0xFD, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFE,
  0xFE, 0x0F, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0x80, 0x63, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xE0, 0x08, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x1F, 0xDF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF9, 0xFC, 0x1F, 0xDF, 0xC0, 0x7E, 0xFE, 0x03, 0xF7, 0xE0, 0x1F, 0xBF,
  0x00, 0xFD, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x80, 0xFD, 0xFC,
  0x07, 0xE7, 0xF0, 0x3F, 0x3F, 0xC1, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFE, 0x1F,
  0xE7, 0xF0, 0x1F, 0x9F, 0x80, 0x7E, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x30, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03,
  0xFC, 0x0E, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF,
  0xBF, 0xC1, 0xFD, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xDF, 0xE1,
  0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0,
  0x7F, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xE4, 0x00, 0x7F, 0x3C, 0x07, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF,
  0xFF, 0x87, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x1E, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xEF, 0xE0, 0xFE, 0xFE, 0x07, 0xEF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03,
  0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0,
  0x3F, 0xFE, 0x03, 0xF0, 0x01, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x83, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x1E,
  0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x03, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFD, 0x80, 0x7E, 0x78, 0x3F, 0x9F, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF,
  0xF8, 0x7F, 0xFC, 0x03, 0xFC, 0x00, 0x1E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xEF, 0xE0, 0x7F, 0x3F,
  0x83, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE3, 0xF8, 0x3F, 0x9F,
  0xC0, 0xFE, 0xFE, 0x03, 0xFB, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0xC0, 0xFE,
  0x7F, 0x03, 0xF8, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF8, 0xFE, 0x0F,
  0xE3, 0xF8, 0x1F, 0xCF, 0xE0, 0x7F, 0xBF, 0x80, 0xFE, 0xFE, 0x01, 0xFC,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x83, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xC7, 0xE3, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xE3, 0xFF, 0x8F,
  0x87, 0xFE, 0x3E, 0x1F, 0xF8, 0xFC, 0x7F, 0xE3, 0xF1, 0xFF, 0x8F, 0xC7,
  0xFE, 0x3F, 0x1F, 0xF8, 0xFC, 0x7F, 0xE3, 0xF1, 0xFF, 0x8F, 0xC7, 0xFE,
  0x3F, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7C, 0x0F, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xEF, 0xE0, 0xFE, 0xFE, 0x07, 0xEF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF,
  0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03,
  0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F,
  0xC0, 0xFE, 0x7F, 0x00, 0xFE, 0xFE, 0x01, 0xFD, 0xF8, 0x01, 0xFB, 0xF0,
  0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x07,
  0xF3, 0xF8, 0x1F, 0xC7, 0xF8, 0x7F, 0x87, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0x07,
  0xFB, 0xF8, 0x1F, 0xDF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x0F, 0xEF, 0xF0, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8,
  0xFF, 0xFF, 0x87, 0xF3, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0xC1, 0xFD, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFE, 0xFE, 0x07, 0xF7, 0xF8, 0x7F, 0xBF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x1F, 0xDF, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFD, 0xFC, 0x01, 0xBF,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xF0, 0x1C,
  0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF4, 0x00, 0x3F, 0x78,
  0x07, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0x7F, 0xFF, 0x00,
  0xFF, 0xC0, 0x00, 0x70, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x30, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xF8, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x7E, 0x07, 0xF7, 0xF0, 0x7F,
  0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF,
  0x00, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x81,
  0xFC, 0x3F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xC3,
  0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xEF,
  0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E,
  0x1F, 0xF8, 0x7E, 0x1F, 0x7C, 0x7E, 0x1E, 0x7C, 0xFF, 0x3E, 0x7C, 0xFF,
  0x3E, 0x7C, 0xFF, 0x3E, 0x7C, 0xFF, 0xBE, 0x7D, 0xEF, 0xBE, 0x7D, 0xE7,
  0xBC, 0x3D, 0xE7, 0xBC, 0x3F, 0xC7, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3,
  0xFC, 0x3F, 0x83, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x00,
  0xF8, 0xFE, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0xFC, 0x1F, 0x81,
  0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xE3, 0xF0, 0x07, 0xE7, 0xE0, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x07, 0xE7, 0xF0, 0x0F, 0xC7, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0x81,
  0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0xFE, 0x00,
  0x7F, 0x7F, 0x00, 0x7E, 0x7F, 0x00, 0x7E, 0x3F, 0x00, 0xFE, 0x3F, 0x00,
  0xFE, 0x3F, 0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0xC1,
  0xF8, 0x1F, 0xC1, 0xF8, 0x0F, 0xC1, 0xF8, 0x0F, 0xE1, 0xF8, 0x0F, 0xE3,
  0xF0, 0x07, 0xE3, 0xF0, 0x07, 0xF3, 0xF0, 0x07, 0xF7, 0xE0, 0x03, 0xF7,
  0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x41, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFF,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x3F,
  0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFE, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x18, 0x1F, 0xF0, 0x1F, 0x3F, 0xF8, 0x1F,
  0x3F, 0xFE, 0x3F, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFC, 0x7F, 0xFE,
  0xF8, 0x1F, 0xFC, 0x18, 0x07, 0xF8, 0x00, 0x01, 0xE0,
};

const GFXglyph UbuntuMono_Bold52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 8, 33, 26, 9, -32 },
  { 34, 17, 15, 26, 5, -35 },
  { 66, 24, 32, 26, 1, -32 },
  { 162, 22, 41, 26, 2, -36 },
  { 275, 26, 34, 26, 0, -33 },
  { 386, 24, 33, 26, 1, -33 },
  { 485, 6, 16, 26, 10, -35 },
  { 497, 17, 46, 26, 5, -37 },
  { 595, 17, 46, 26, 4, -37 },
  { 693, 22, 20, 26, 2, -32 },
  { 748, 22, 23, 26, 2, -24 },
  { 812, 11, 18, 26, 7, -8 },
  { 837, 14, 6, 26, 6, -16 },
  { 848, 10, 9, 26, 8, -8 },
  { 860, 22, 45, 26, 2, -36 },
  { 984, 22, 34, 26, 2, -33 },
  { 1078, 22, 32, 26, 2, -32 },
  { 1166, 22, 33, 26, 2, -33 },
  { 1257, 21, 34, 26, 2, -33 },
  { 1347, 24, 32, 26, 1, -32 },
  { 1443, 21, 33, 26, 2, -32 },
  { 1530, 22, 33, 26, 2, -32 },
  { 1621, 21, 32, 26, 3, -32 },
  { 1705, 22, 34, 26, 2, -33 },
  { 1799, 22, 33, 26, 2, -33 },
  { 1890, 10, 25, 26, 8, -24 },
  { 1922, 12, 34, 26, 6, -24 },
  { 1973, 22, 23, 26, 2, -25 },
  { 2037, 22, 15, 26, 2, -21 },
  { 2079, 22, 23, 26, 2, -25 },
  { 2143, 19, 34, 26, 4, -33 },
  { 2224, 23, 40, 26, 1, -33 },
  { 2339, 26, 32, 26, 0, -32 },
  { 2443, 21, 34, 26, 3, -33 },
  { 2533, 23, 34, 26, 1, -33 },
  { 2631, 22, 33, 26, 3, -32 },
  { 2722, 21, 32, 26, 3, -32 },
  { 2806, 20, 32, 26, 3, -32 },
  { 2886, 23, 34, 26, 1, -33 },
  { 2984, 22, 32, 26, 2, -32 },
  { 3072, 20, 32, 26, 3, -32 },
  { 3152, 21, 33, 26, 2, -32 },
  { 3239, 23, 32, 26, 2, -32 },
  { 3331, 20, 32, 26, 4, -32 },
  { 3411, 24, 32, 26, 1, -32 },
  { 3507, 22, 32, 26, 2, -32 },
  { 3595, 24, 34, 26, 1, -33 },
  { 3697, 22, 33, 26, 3, -33 },
  { 3788, 24, 42, 26, 1, -33 },
  { 3914, 22, 33, 26, 3, -33 },
  { 4005, 22, 34, 26, 2, -33 },
  { 4099, 24, 32, 26, 1, -32 },
  { 4195, 22, 33, 26, 2, -32 },
  { 4286, 24, 32, 26, 1, -32 },
  { 4382, 24, 32, 26, 1, -32 },
  { 4478, 24, 32, 26, 1, -32 },
  { 4574, 24, 32, 26, 1, -32 },
  { 4670, 22, 32, 26, 2, -32 },
  { 4758, 14, 45, 26, 6, -36 },
  { 4837, 21, 45, 26, 3, -36 },
  { 4956, 14, 45, 26, 6, -36 },
  { 5035, 25, 16, 26, 1, -32 },
  { 5085, 26, 5, 26, 0, 4 },
  { 5102, 11, 9, 26, 8, -36 },
  { 5115, 21, 26, 26, 2, -25 },
  { 5184, 21, 38, 26, 3, -37 },
  { 5284, 22, 26, 26, 2, -25 },
  { 5356, 21, 38, 26, 1, -37 },
  { 5456, 22, 26, 26, 2, -25 },
  { 5528, 24, 37, 26, 2, -37 },
  { 5639, 21, 35, 26, 2, -25 },
  { 5731, 20, 37, 26, 3, -37 },
  { 5824, 22, 37, 26, 2, -36 },
  { 5926, 18, 46, 26, 3, -36 },
  { 6030, 22, 37, 26, 3, -37 },
  { 6132, 22, 37, 26, 2, -36 },
  { 6234, 22, 25, 26, 2, -25 },
  { 6303, 20, 25, 26, 3, -25 },
  { 6366, 23, 26, 26, 2, -25 },
  { 6441, 21, 34, 26, 3, -25 },
  { 6531, 21, 34, 26, 2, -25 },
  { 6621, 19, 25, 26, 5, -25 },
  { 6681, 20, 26, 26, 3, -25 },
  { 6746, 23, 32, 26, 2, -31 },
  { 6838, 20, 25, 26, 3, -24 },
  { 6901, 24, 24, 26, 1, -24 },
  { 6973, 24, 24, 26, 1, -24 },
  { 7045, 24, 24, 26, 1, -24 },
  { 7117, 24, 34, 26, 1, -24 },
  { 7219, 20, 24, 26, 3, -24 },
  { 7279, 20, 45, 26, 3, -36 },
  { 7392, 6, 45, 26, 10, -36 },
  { 7426, 20, 45, 26, 3, -36 },
  { 7539, 24, 10, 26, 1, -19 },
};

const GFXfont UbuntuMono_Bold52pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Bold52pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Bold52pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _UBUNTUMONO_BOLD52PT7B_H_
