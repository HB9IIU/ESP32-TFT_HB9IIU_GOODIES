#ifndef _UBUNTUMONO_BOLD16PT7B_H_
#define _UBUNTUMONO_BOLD16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Bold.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Bold16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFC, 0xF0, 0xCF, 0x34, 0xD2, 0x48, 0x16, 0x36, 0xFF, 0xFF,
  0x24, 0x24, 0xFF, 0xFF, 0x6C, 0x68, 0x30, 0xC7, 0xFF, 0xC3, 0xC7, 0xC7,
  0x0F, 0xFF, 0xCC, 0x30, 0x63, 0xB2, 0xB4, 0x6C, 0x08, 0x10, 0x36, 0x2D,
  0x4F, 0xC6, 0x38, 0x7C, 0x6C, 0x68, 0x32, 0x5A, 0xCE, 0xCE, 0x7E, 0x7B,
  0xFF, 0xC0, 0x08, 0x63, 0x18, 0x61, 0x04, 0x10, 0x41, 0x86, 0x0C, 0x18,
  0x20, 0x41, 0x83, 0x06, 0x18, 0x20, 0xC3, 0x08, 0x61, 0x8C, 0x61, 0x00,
  0x30, 0xCF, 0xFF, 0x31, 0xE4, 0x80, 0x30, 0xC3, 0x3F, 0xFC, 0xC3, 0x0C,
  0x67, 0x72, 0x6C, 0xFF, 0xFC, 0x0C, 0x31, 0x86, 0x18, 0xE3, 0x0C, 0x31,
  0x86, 0x18, 0xC3, 0x00, 0x7B, 0xFC, 0xE1, 0xB6, 0xD8, 0x73, 0xFD, 0xE0,
  0x31, 0xCF, 0x2C, 0x30, 0xC3, 0x0C, 0xFF, 0xF0, 0x7B, 0xF8, 0xC3, 0x18,
  0xC6, 0x30, 0xFF, 0xF0, 0x7B, 0xF8, 0xC3, 0x79, 0xE0, 0xC3, 0xFF, 0xE0,
  0x0E, 0x1E, 0x1E, 0x36, 0x66, 0x66, 0xFF, 0xFF, 0x06, 0x06, 0x7D, 0xF4,
  0x3C, 0xFC, 0x30, 0xC3, 0xFF, 0xE0, 0x1D, 0xF6, 0x30, 0xFF, 0xFC, 0xF3,
  0xFD, 0xE0, 0xFF, 0xF0, 0xC6, 0x18, 0xC3, 0x0C, 0x61, 0x80, 0x7B, 0xFC,
  0xF3, 0x7B, 0x38, 0x73, 0xFD, 0xE0, 0x7B, 0xFC, 0xF3, 0xFF, 0xF0, 0xC6,
  0xFB, 0x80, 0xFC, 0x3F, 0x6D, 0x80, 0xDB, 0x2F, 0x00, 0x04, 0x73, 0xFE,
  0xE3, 0x8F, 0x8F, 0x1C, 0x10, 0xFF, 0xF0, 0x3F, 0xFC, 0x83, 0x8F, 0x1F,
  0x1C, 0x77, 0xFC, 0xE2, 0x00, 0x7B, 0xF0, 0xC3, 0x18, 0xC3, 0x00, 0x30,
  0xC0, 0x3C, 0xCD, 0x0A, 0x7D, 0xFB, 0x74, 0xED, 0x5E, 0x9D, 0x80, 0xF0,
  0x18, 0x3C, 0x3C, 0x3C, 0x24, 0x66, 0x7E, 0x7E, 0x67, 0xC3, 0xF9, 0xFB,
  0x36, 0x6F, 0x9F, 0xB3, 0x66, 0xFD, 0xF0, 0x1E, 0x3E, 0x62, 0x60, 0xC0,
  0xC0, 0x60, 0x62, 0x7E, 0x1E, 0xF9, 0xFB, 0x36, 0x6C, 0x78, 0xF3, 0x66,
  0xFD, 0xE0, 0xFF, 0xFC, 0x30, 0xFB, 0xEC, 0x30, 0xFF, 0xF0, 0xFF, 0xFC,
  0x30, 0xFF, 0xFC, 0x30, 0xC3, 0x00, 0x1E, 0xFD, 0x8B, 0x0C, 0x18, 0xD9,
  0xB3, 0x7E, 0x7C, 0xCF, 0x3C, 0xF3, 0xFF, 0xFC, 0xF3, 0xCF, 0x30, 0xFF,
  0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0xFF, 0xF0, 0x7D, 0xF0, 0xC3, 0x0C, 0x30,
  0xE3, 0xFF, 0xE0, 0xCD, 0xBB, 0x67, 0x8F, 0x1E, 0x36, 0x6E, 0xCD, 0x9C,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFF, 0xF0, 0x66, 0x66, 0x66, 0x5A,
  0x5A, 0x5A, 0x43, 0xC3, 0xC3, 0xC3, 0xCF, 0x3E, 0xFB, 0xFF, 0x7D, 0xF3,
  0xCF, 0x30, 0x3C, 0x7E, 0x66, 0x66, 0xC3, 0xC3, 0x66, 0x66, 0x7E, 0x3C,
  0xF9, 0xFB, 0x36, 0x3C, 0xDF, 0xBE, 0x60, 0xC1, 0x80, 0x3C, 0x7E, 0x66,
  0x66, 0xC3, 0xC3, 0x66, 0x66, 0x7E, 0x3C, 0x18, 0x0E, 0x06, 0xF9, 0xFB,
  0x36, 0x6C, 0xDF, 0xBE, 0x6C, 0xCD, 0x8C, 0x7B, 0xFC, 0x70, 0xF8, 0xF0,
  0xE3, 0xFF, 0xE0, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xFD, 0xE0, 0xC3, 0x66, 0x66,
  0x66, 0x66, 0x24, 0x3C, 0x3C, 0x3C, 0x18, 0xC3, 0xC3, 0xC3, 0xC2, 0x5A,
  0x5A, 0x7E, 0x66, 0x66, 0x66, 0x66, 0x66, 0x3C, 0x3C, 0x18, 0x3C, 0x3C,
  0x66, 0x66, 0xE3, 0xC3, 0x66, 0x66, 0x34, 0x3C, 0x18, 0x18, 0x18, 0x18,
  0x18, 0xFF, 0xF1, 0x86, 0x30, 0x86, 0x30, 0xFF, 0xF0, 0xFF, 0xCC, 0xCC,
  0xCC, 0xCC, 0xCC, 0xFF, 0xC3, 0x06, 0x18, 0x60, 0xC3, 0x0C, 0x38, 0x61,
  0x86, 0x0C, 0x30, 0xFF, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFF, 0x18, 0x3C,
  0x7E, 0x66, 0x42, 0xFF, 0xFF, 0x4E, 0x30, 0xF9, 0xF0, 0xDF, 0xFF, 0x3F,
  0xDF, 0xC1, 0x83, 0x07, 0xCF, 0xD9, 0xB3, 0xE6, 0xCD, 0xFB, 0xE0, 0x3F,
  0xFC, 0x30, 0xC3, 0x0F, 0xCF, 0x06, 0x0C, 0x19, 0xF7, 0xEC, 0xF1, 0xE3,
  0x66, 0xFC, 0xF8, 0x3C, 0xFD, 0x9B, 0xF7, 0xEC, 0x1F, 0x9F, 0x3E, 0xFD,
  0x87, 0xEF, 0xCC, 0x18, 0x30, 0x60, 0xC1, 0x80, 0x7F, 0xFC, 0xF3, 0xCF,
  0x3F, 0xDF, 0x0F, 0xFF, 0x80, 0xC3, 0x0C, 0x3E, 0xFF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xC0, 0x61, 0x80, 0x3C, 0xF0, 0xC3, 0x0C, 0x30, 0xF1, 0xC0, 0x18,
  0xC1, 0xFF, 0x8C, 0x63, 0x18, 0xC7, 0x3F, 0xF8, 0xC1, 0x83, 0x06, 0x6D,
  0x9A, 0x3C, 0x78, 0xD9, 0x9B, 0x38, 0xF3, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xF1, 0xC0, 0xFE, 0xFE, 0xDB, 0xDB, 0xDB, 0xC3, 0xC3, 0xC3, 0xFB,
  0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0x3C, 0x7E, 0x66, 0xE3, 0xE7, 0x66, 0x7E,
  0x3C, 0xF9, 0xFB, 0x36, 0x6C, 0xD9, 0xBF, 0x7C, 0xC1, 0x83, 0x00, 0x3E,
  0xFD, 0x9B, 0x36, 0x6C, 0xDF, 0x9F, 0x06, 0x0C, 0x18, 0x7F, 0xFC, 0x30,
  0xC3, 0x0C, 0x30, 0x7F, 0xFC, 0x3C, 0x3C, 0x3F, 0xFE, 0x60, 0xC3, 0xF7,
  0xE6, 0x0C, 0x18, 0x30, 0x7C, 0x7C, 0xCF, 0x3C, 0xF3, 0xCF, 0x3F, 0xDF,
  0xC3, 0x66, 0x66, 0x66, 0x3C, 0x3C, 0x38, 0x18, 0xC3, 0xC3, 0xDB, 0x5A,
  0x5A, 0x7E, 0x66, 0x66, 0x66, 0x66, 0x3C, 0x18, 0x1C, 0x3C, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x36, 0x3C, 0x3C, 0x1C, 0x18, 0x18, 0x70, 0xF0, 0xFF,
  0xE1, 0x8C, 0x21, 0x8F, 0xFF, 0x3C, 0xF3, 0x0C, 0x30, 0xCE, 0x38, 0x30,
  0xC3, 0x0C, 0x3C, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xF3, 0xC3, 0x0C, 0x30,
  0xC1, 0xC7, 0x30, 0xC3, 0x0C, 0xF3, 0xC0, 0x73, 0x7E, 0xCE,
};

const GFXglyph UbuntuMono_Bold16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 10, 8, 3, -10 },
  { 4, 6, 5, 8, 1, -11 },
  { 8, 8, 10, 8, 0, -10 },
  { 18, 6, 13, 8, 1, -11 },
  { 28, 8, 10, 8, 0, -10 },
  { 38, 8, 10, 8, 0, -10 },
  { 48, 2, 5, 8, 3, -11 },
  { 50, 6, 14, 8, 1, -11 },
  { 61, 6, 14, 8, 1, -11 },
  { 72, 6, 7, 8, 1, -10 },
  { 78, 6, 8, 8, 1, -8 },
  { 84, 4, 6, 8, 2, -3 },
  { 87, 4, 2, 8, 2, -5 },
  { 88, 2, 3, 8, 3, -3 },
  { 89, 6, 14, 8, 1, -11 },
  { 100, 6, 10, 8, 1, -10 },
  { 108, 6, 10, 8, 1, -10 },
  { 116, 6, 10, 8, 1, -10 },
  { 124, 6, 10, 8, 1, -10 },
  { 132, 8, 10, 8, 0, -10 },
  { 142, 6, 10, 8, 1, -10 },
  { 150, 6, 10, 8, 1, -10 },
  { 158, 6, 10, 8, 1, -10 },
  { 166, 6, 10, 8, 1, -10 },
  { 174, 6, 10, 8, 1, -10 },
  { 182, 2, 8, 8, 3, -8 },
  { 184, 3, 11, 8, 2, -8 },
  { 189, 6, 10, 8, 1, -11 },
  { 197, 6, 5, 8, 1, -6 },
  { 201, 6, 10, 8, 1, -11 },
  { 209, 6, 10, 8, 1, -10 },
  { 217, 7, 12, 8, 0, -10 },
  { 228, 8, 10, 8, 0, -10 },
  { 238, 7, 10, 8, 1, -10 },
  { 247, 8, 10, 8, 0, -10 },
  { 257, 7, 10, 8, 1, -10 },
  { 266, 6, 10, 8, 1, -10 },
  { 274, 6, 10, 8, 1, -10 },
  { 282, 7, 10, 8, 0, -10 },
  { 291, 6, 10, 8, 1, -10 },
  { 299, 6, 10, 8, 1, -10 },
  { 307, 6, 10, 8, 1, -10 },
  { 315, 7, 10, 8, 1, -10 },
  { 324, 6, 10, 8, 1, -10 },
  { 332, 8, 10, 8, 0, -10 },
  { 342, 6, 10, 8, 1, -10 },
  { 350, 8, 10, 8, 0, -10 },
  { 360, 7, 10, 8, 1, -10 },
  { 369, 8, 13, 8, 0, -10 },
  { 382, 7, 10, 8, 1, -10 },
  { 391, 6, 10, 8, 1, -10 },
  { 399, 8, 10, 8, 0, -10 },
  { 409, 6, 10, 8, 1, -10 },
  { 417, 8, 10, 8, 0, -10 },
  { 427, 8, 10, 8, 0, -10 },
  { 437, 8, 10, 8, 0, -10 },
  { 447, 8, 10, 8, 0, -10 },
  { 457, 6, 10, 8, 1, -10 },
  { 465, 4, 14, 8, 2, -11 },
  { 472, 6, 14, 8, 1, -11 },
  { 483, 4, 14, 8, 2, -11 },
  { 490, 8, 5, 8, 0, -10 },
  { 495, 8, 2, 8, 0, 1 },
  { 497, 4, 3, 8, 2, -11 },
  { 499, 6, 8, 8, 1, -8 },
  { 505, 7, 11, 8, 1, -11 },
  { 515, 6, 8, 8, 1, -8 },
  { 521, 7, 11, 8, 0, -11 },
  { 531, 7, 8, 8, 0, -8 },
  { 538, 7, 11, 8, 1, -11 },
  { 548, 6, 11, 8, 1, -8 },
  { 557, 6, 11, 8, 1, -11 },
  { 566, 6, 11, 8, 1, -11 },
  { 575, 5, 14, 8, 1, -11 },
  { 584, 7, 11, 8, 1, -11 },
  { 594, 6, 11, 8, 1, -11 },
  { 603, 8, 8, 8, 0, -8 },
  { 611, 6, 8, 8, 1, -8 },
  { 617, 8, 8, 8, 0, -8 },
  { 625, 7, 11, 8, 1, -8 },
  { 635, 7, 11, 8, 0, -8 },
  { 645, 6, 8, 8, 1, -8 },
  { 651, 6, 8, 8, 1, -8 },
  { 657, 7, 10, 8, 1, -10 },
  { 666, 6, 8, 8, 1, -8 },
  { 672, 8, 8, 8, 0, -8 },
  { 680, 8, 8, 8, 0, -8 },
  { 688, 8, 8, 8, 0, -8 },
  { 696, 8, 11, 8, 0, -8 },
  { 707, 6, 8, 8, 1, -8 },
  { 713, 6, 14, 8, 1, -11 },
  { 724, 2, 14, 8, 3, -11 },
  { 728, 6, 14, 8, 1, -11 },
  { 739, 8, 3, 8, 0, -6 },
};

const GFXfont UbuntuMono_Bold16pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Bold16pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Bold16pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _UBUNTUMONO_BOLD16PT7B_H_
