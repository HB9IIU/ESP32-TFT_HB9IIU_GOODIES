#ifndef _UBUNTUMONO_BOLD9PT7B_H_
#define _UBUNTUMONO_BOLD9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Bold.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Bold9pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x30, 0xB6, 0x80, 0x5F, 0x55, 0xF6, 0x27, 0xC7, 0x1F, 0x20,
  0xDD, 0xE5, 0x79, 0x66, 0x5B, 0x97, 0xE0, 0x5A, 0x49, 0x18, 0x89, 0x92,
  0xA0, 0x77, 0x66, 0x22, 0xF2, 0x20, 0x58, 0xC0, 0x50, 0x13, 0x22, 0x44,
  0x40, 0x7D, 0xB9, 0xD7, 0x26, 0x22, 0x27, 0x61, 0x36, 0x47, 0xE1, 0x61,
  0x1E, 0x33, 0x55, 0xF1, 0x74, 0x61, 0x1E, 0x34, 0x6D, 0x57, 0xF1, 0x22,
  0x64, 0x7D, 0x65, 0x97, 0x6D, 0xD7, 0x36, 0x51, 0x40, 0x51, 0x60, 0x13,
  0xCC, 0x31, 0xF0, 0xF0, 0x4E, 0x33, 0xE8, 0xE5, 0xA1, 0x80, 0x79, 0xBD,
  0xBF, 0x70, 0x26, 0x55, 0xF9, 0xFD, 0xED, 0xDF, 0x74, 0x88, 0xC7, 0xED,
  0xDD, 0xDE, 0xF3, 0xC9, 0xC0, 0xF3, 0xC9, 0x00, 0x74, 0x89, 0xD7, 0xDD,
  0xFD, 0xDD, 0xF2, 0x22, 0x2F, 0x71, 0x11, 0x1E, 0xDE, 0xEE, 0xFD, 0x92,
  0x49, 0xC0, 0xDD, 0xFB, 0x99, 0xDD, 0xBB, 0x99, 0x7D, 0x99, 0xD7, 0xFD,
  0xDF, 0xCC, 0x7D, 0x99, 0xD7, 0x30, 0xED, 0xDF, 0xFD, 0x7C, 0x63, 0x1F,
  0xF2, 0x22, 0x22, 0x99, 0x99, 0xD7, 0x9D, 0x57, 0x62, 0x99, 0xBF, 0xDD,
  0xD7, 0x66, 0x59, 0x95, 0x62, 0x22, 0x73, 0x24, 0x4F, 0xF2, 0x49, 0x38,
  0x44, 0x42, 0x23, 0x10, 0xD5, 0x5C, 0x65, 0x90, 0xF0, 0x50, 0x77, 0x97,
  0x93, 0xDB, 0xC0, 0x7C, 0xC7, 0x11, 0x79, 0x97, 0x7F, 0xC7, 0x34, 0xF4,
  0x44, 0x79, 0x71, 0xF0, 0x93, 0xDB, 0x40, 0x60, 0xE6, 0x23, 0x20, 0x73,
  0x33, 0x60, 0x92, 0xED, 0x40, 0xE6, 0x66, 0x23, 0xFB, 0x99, 0xF6, 0xD0,
  0x79, 0x97, 0xF6, 0xF8, 0x7D, 0x97, 0x10, 0xF2, 0x40, 0x74, 0x37, 0x4F,
  0x44, 0x70, 0xB6, 0xF0, 0x95, 0x66, 0x9B, 0xF5, 0x56, 0x65, 0xD5, 0x62,
  0xC0, 0xEA, 0x70, 0x69, 0x44, 0x98, 0xFE, 0xC9, 0x14, 0xB0, 0x5B,
};

const GFXglyph UbuntuMono_Bold9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 6, 5, 1, -6 },
  { 3, 3, 3, 5, 1, -6 },
  { 5, 4, 6, 5, 0, -6 },
  { 8, 4, 7, 5, 0, -6 },
  { 12, 4, 6, 5, 0, -6 },
  { 15, 4, 6, 5, 0, -6 },
  { 18, 1, 3, 5, 2, -6 },
  { 19, 3, 7, 5, 1, -6 },
  { 22, 3, 7, 5, 1, -6 },
  { 25, 4, 4, 5, 0, -6 },
  { 27, 4, 5, 5, 0, -4 },
  { 30, 2, 3, 5, 1, -2 },
  { 31, 2, 1, 5, 1, -3 },
  { 32, 2, 2, 5, 1, -2 },
  { 33, 4, 7, 5, 0, -6 },
  { 37, 4, 6, 5, 0, -6 },
  { 40, 4, 6, 5, 0, -6 },
  { 43, 4, 6, 5, 0, -6 },
  { 46, 4, 6, 5, 0, -6 },
  { 49, 4, 6, 5, 0, -6 },
  { 52, 4, 6, 5, 0, -6 },
  { 55, 4, 6, 5, 0, -6 },
  { 58, 4, 6, 5, 0, -6 },
  { 61, 4, 6, 5, 0, -6 },
  { 64, 4, 6, 5, 0, -6 },
  { 67, 2, 5, 5, 1, -5 },
  { 69, 2, 6, 5, 1, -5 },
  { 71, 4, 6, 5, 0, -6 },
  { 74, 4, 3, 5, 0, -4 },
  { 76, 4, 6, 5, 0, -6 },
  { 79, 3, 6, 5, 1, -6 },
  { 82, 4, 7, 5, 0, -6 },
  { 86, 4, 6, 5, 0, -6 },
  { 89, 4, 6, 5, 0, -6 },
  { 92, 4, 6, 5, 0, -6 },
  { 95, 4, 6, 5, 0, -6 },
  { 98, 3, 6, 5, 1, -6 },
  { 101, 3, 6, 5, 1, -6 },
  { 104, 4, 6, 5, 0, -6 },
  { 107, 4, 6, 5, 0, -6 },
  { 110, 4, 6, 5, 0, -6 },
  { 113, 4, 6, 5, 0, -6 },
  { 116, 4, 6, 5, 0, -6 },
  { 119, 3, 6, 5, 1, -6 },
  { 122, 4, 6, 5, 0, -6 },
  { 125, 4, 6, 5, 0, -6 },
  { 128, 4, 6, 5, 0, -6 },
  { 131, 4, 6, 5, 0, -6 },
  { 134, 4, 7, 5, 0, -6 },
  { 138, 4, 6, 5, 0, -6 },
  { 141, 4, 6, 5, 0, -6 },
  { 144, 4, 6, 5, 0, -6 },
  { 147, 4, 6, 5, 0, -6 },
  { 150, 4, 6, 5, 0, -6 },
  { 153, 4, 6, 5, 0, -6 },
  { 156, 4, 6, 5, 0, -6 },
  { 159, 4, 6, 5, 0, -6 },
  { 162, 4, 6, 5, 0, -6 },
  { 165, 3, 7, 5, 1, -6 },
  { 168, 4, 7, 5, 0, -6 },
  { 172, 2, 7, 5, 1, -6 },
  { 174, 4, 3, 5, 0, -6 },
  { 176, 4, 1, 5, 0, 0 },
  { 177, 2, 2, 5, 1, -6 },
  { 178, 4, 4, 5, 0, -4 },
  { 180, 3, 6, 5, 1, -6 },
  { 183, 4, 4, 5, 0, -4 },
  { 185, 4, 6, 5, 0, -6 },
  { 188, 4, 4, 5, 0, -4 },
  { 190, 4, 6, 5, 0, -6 },
  { 193, 4, 5, 5, 0, -4 },
  { 196, 3, 6, 5, 1, -6 },
  { 199, 4, 6, 5, 0, -6 },
  { 202, 4, 7, 5, 0, -6 },
  { 206, 3, 6, 5, 1, -6 },
  { 209, 4, 6, 5, 0, -6 },
  { 212, 4, 4, 5, 0, -4 },
  { 214, 3, 4, 5, 1, -4 },
  { 216, 4, 4, 5, 0, -4 },
  { 218, 3, 5, 5, 1, -4 },
  { 220, 4, 5, 5, 0, -4 },
  { 223, 3, 4, 5, 1, -4 },
  { 225, 4, 4, 5, 0, -4 },
  { 227, 4, 5, 5, 0, -5 },
  { 230, 3, 4, 5, 1, -4 },
  { 232, 4, 4, 5, 0, -4 },
  { 234, 4, 4, 5, 0, -4 },
  { 236, 4, 4, 5, 0, -4 },
  { 238, 4, 5, 5, 0, -4 },
  { 241, 3, 4, 5, 1, -4 },
  { 243, 3, 7, 5, 1, -6 },
  { 246, 1, 7, 5, 2, -6 },
  { 247, 3, 7, 5, 1, -6 },
  { 250, 4, 2, 5, 0, -3 },
};

const GFXfont UbuntuMono_Bold9pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Bold9pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Bold9pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _UBUNTUMONO_BOLD9PT7B_H_
