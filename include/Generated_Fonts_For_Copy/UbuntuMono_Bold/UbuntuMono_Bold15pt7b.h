#ifndef _UBUNTUMONO_BOLD15PT7B_H_
#define _UBUNTUMONO_BOLD15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Bold.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Bold15pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xC3, 0x60, 0xDE, 0xF6, 0x90, 0x36, 0x6B, 0xFF, 0xF2,
  0xDF, 0xFF, 0xB4, 0x48, 0x31, 0xCF, 0xF0, 0xF9, 0xF0, 0xFF, 0xF8, 0xC3,
  0x00, 0x63, 0x4A, 0xB3, 0x41, 0x07, 0xCA, 0xA5, 0xCE, 0x38, 0xF9, 0xA3,
  0xC7, 0x7B, 0xF3, 0x3F, 0x7E, 0xFE, 0x09, 0xC8, 0xC4, 0x63, 0x18, 0x43,
  0x0C, 0x70, 0x80, 0x43, 0x0C, 0x21, 0x8C, 0x63, 0x18, 0xCC, 0xC4, 0x00,
  0x33, 0xAF, 0xDC, 0x79, 0x40, 0x30, 0xC3, 0x3F, 0xFC, 0xC3, 0x0C, 0x6D,
  0xBC, 0xFF, 0x7D, 0x80, 0x0C, 0x61, 0x86, 0x30, 0xC3, 0x18, 0x61, 0x0C,
  0x30, 0x7B, 0xEC, 0xEB, 0xAE, 0x3C, 0xFE, 0x78, 0x33, 0xCF, 0x0C, 0x30,
  0xC3, 0x3F, 0xFC, 0x73, 0xE9, 0xC2, 0x11, 0x84, 0x3F, 0xFC, 0x73, 0xE8,
  0x9E, 0x78, 0x30, 0xFE, 0xF0, 0x0C, 0x38, 0xF3, 0x64, 0xDF, 0xFF, 0x86,
  0x0C, 0x79, 0xEC, 0x3C, 0xF8, 0x30, 0xFE, 0xF0, 0x19, 0xEE, 0x3C, 0xFB,
  0x3C, 0xFE, 0x78, 0xFF, 0xF1, 0x86, 0x30, 0xC6, 0x18, 0x60, 0x7B, 0xFC,
  0xF2, 0x73, 0x38, 0xFF, 0x78, 0x73, 0xEC, 0xF3, 0xFD, 0xF1, 0xBE, 0xE0,
  0x7D, 0x80, 0xFB, 0x7D, 0x80, 0xFB, 0x78, 0x04, 0x77, 0xBC, 0xC3, 0xC7,
  0x87, 0x04, 0xFF, 0xF0, 0x3F, 0xFC, 0x83, 0x8F, 0x0F, 0x0C, 0xFF, 0x38,
  0x80, 0x7B, 0xE0, 0xC6, 0x31, 0x80, 0x1C, 0x70, 0x3C, 0xCD, 0x7E, 0xFD,
  0x7E, 0xF5, 0xEF, 0x4E, 0xC0, 0xF8, 0x18, 0x70, 0xB1, 0x66, 0x4F, 0x9F,
  0xA3, 0xC6, 0xFB, 0xEC, 0xFE, 0xFB, 0x3C, 0xFF, 0xF8, 0x3C, 0xFD, 0x8E,
  0x0C, 0x18, 0x18, 0xBF, 0x3C, 0xF3, 0xEC, 0xF3, 0xCF, 0x3C, 0xFE, 0xF0,
  0xFF, 0xFC, 0x3E, 0xFB, 0x0C, 0x3F, 0xFC, 0xFF, 0xFC, 0x30, 0xFB, 0xEC,
  0x30, 0xC0, 0x3E, 0xFD, 0x8E, 0x0C, 0x78, 0xD9, 0xBF, 0x3E, 0xCF, 0x3C,
  0xFF, 0xFF, 0x3C, 0xF3, 0xCC, 0xFF, 0xF3, 0x0C, 0x30, 0xC3, 0x3F, 0xFC,
  0x7D, 0xF0, 0xC3, 0x0C, 0x39, 0xFE, 0xF0, 0xCF, 0x6F, 0x3C, 0xF3, 0xCD,
  0xB3, 0xCC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x3F, 0xFC, 0x66, 0xCD, 0xAB,
  0xD5, 0xAB, 0x71, 0xE3, 0xC6, 0x8F, 0x3E, 0xEB, 0xBE, 0x79, 0xE3, 0x8C,
  0x3C, 0xF9, 0x9E, 0x3C, 0x78, 0xD9, 0xBE, 0x3C, 0xFB, 0xFC, 0xF3, 0xFF,
  0xEC, 0x30, 0xC0, 0x3C, 0xF9, 0x9E, 0x3C, 0x78, 0xD9, 0xBF, 0x3C, 0x3C,
  0x38, 0xF3, 0xEC, 0xF3, 0xFB, 0xCD, 0xB3, 0xCC, 0x7B, 0xEC, 0xBC, 0x78,
  0x78, 0xFF, 0xF8, 0xFF, 0xFC, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x8E,
  0x38, 0xE3, 0x8E, 0x3C, 0xFF, 0x78, 0xC6, 0x8D, 0x9B, 0x26, 0xC5, 0x8F,
  0x1C, 0x18, 0xC7, 0x8F, 0x1E, 0xF5, 0xEF, 0x5A, 0xB3, 0x66, 0x66, 0xC8,
  0xF1, 0xC1, 0x87, 0x9B, 0x33, 0xC6, 0xC6, 0xCD, 0x91, 0xE3, 0x83, 0x06,
  0x0C, 0x18, 0xFF, 0xE1, 0x8C, 0x21, 0x84, 0x3F, 0xFC, 0xFF, 0x88, 0x88,
  0x88, 0x88, 0xFF, 0xC3, 0x06, 0x18, 0x60, 0xC3, 0x0C, 0x18, 0x61, 0x83,
  0xFF, 0x33, 0x33, 0x33, 0x33, 0xFF, 0x18, 0x79, 0xB3, 0x34, 0x60, 0xFF,
  0xFC, 0x4E, 0x20, 0xFB, 0xE0, 0xFF, 0x8F, 0xFF, 0xC0, 0xC3, 0x0C, 0x3E,
  0xFF, 0x3C, 0xF3, 0xFF, 0xE0, 0x7F, 0xFC, 0x30, 0xC3, 0xF7, 0xC0, 0x04,
  0x10, 0x4F, 0x7D, 0x9C, 0x59, 0x7C, 0xF0, 0x3C, 0xFD, 0x9F, 0xF6, 0x0F,
  0x8F, 0x80, 0x3D, 0xF6, 0x3F, 0xFD, 0x86, 0x18, 0x61, 0x80, 0x3E, 0xFD,
  0x9A, 0x37, 0xE7, 0xC1, 0xBE, 0x78, 0xC3, 0x0C, 0x3E, 0xFB, 0x3C, 0xF3,
  0xCF, 0x30, 0x61, 0x80, 0x38, 0xE1, 0x86, 0x18, 0x3C, 0xF0, 0x18, 0xC1,
  0xFF, 0x8C, 0x63, 0x1C, 0xFF, 0xE0, 0xC3, 0x0C, 0x33, 0xDB, 0xCF, 0x36,
  0xDB, 0x30, 0xE3, 0x86, 0x18, 0x61, 0x86, 0x18, 0x3C, 0xF0, 0xFF, 0xFF,
  0x5E, 0xDC, 0x38, 0x70, 0x80, 0xFB, 0xEC, 0xF3, 0xCF, 0x3C, 0xC0, 0x3C,
  0xFD, 0x9E, 0x36, 0x6F, 0xCF, 0x00, 0xFB, 0xFC, 0xF3, 0xCF, 0xFF, 0xB0,
  0xC0, 0x3E, 0xFD, 0x9E, 0x36, 0x6F, 0xCF, 0x83, 0x06, 0x7F, 0xFC, 0x30,
  0xC3, 0x0C, 0x00, 0x7B, 0xEC, 0x1E, 0x0F, 0xFF, 0x80, 0x61, 0x8F, 0xFF,
  0x61, 0x86, 0x1F, 0x3C, 0xCF, 0x3C, 0xF3, 0xCF, 0xF7, 0xC0, 0xC6, 0xCD,
  0x93, 0x63, 0xC7, 0x06, 0x00, 0xC3, 0xB7, 0x6A, 0xD6, 0xED, 0xD9, 0x00,
  0x66, 0xD8, 0xE0, 0xC3, 0xCD, 0x91, 0x80, 0x66, 0xCD, 0x91, 0x63, 0xC3,
  0x06, 0x38, 0xE0, 0xFB, 0xE1, 0x08, 0x63, 0xFF, 0xC0, 0x3C, 0xF2, 0x08,
  0x23, 0x8E, 0x08, 0x20, 0x83, 0xCF, 0xFF, 0xFF, 0xFF, 0xE3, 0xC3, 0x0C,
  0x30, 0x71, 0xCC, 0x30, 0xCF, 0x38, 0x72, 0xFF, 0x30,
};

const GFXglyph UbuntuMono_Bold15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 3, 9, 8, 2, -9 },
  { 5, 5, 4, 8, 1, -10 },
  { 8, 7, 9, 8, 0, -9 },
  { 16, 6, 11, 8, 1, -10 },
  { 25, 7, 9, 8, 0, -9 },
  { 33, 7, 9, 8, 0, -9 },
  { 41, 2, 4, 8, 3, -10 },
  { 42, 5, 13, 8, 1, -11 },
  { 51, 5, 13, 8, 1, -11 },
  { 60, 6, 6, 8, 1, -9 },
  { 65, 6, 8, 8, 1, -7 },
  { 71, 3, 5, 8, 2, -3 },
  { 73, 4, 2, 8, 2, -5 },
  { 74, 3, 3, 8, 2, -3 },
  { 76, 6, 12, 8, 1, -10 },
  { 85, 6, 9, 8, 1, -9 },
  { 92, 6, 9, 8, 1, -9 },
  { 99, 6, 9, 8, 1, -9 },
  { 106, 6, 9, 8, 1, -9 },
  { 113, 7, 9, 8, 0, -9 },
  { 121, 6, 9, 8, 1, -9 },
  { 128, 6, 9, 8, 1, -9 },
  { 135, 6, 9, 8, 1, -9 },
  { 142, 6, 9, 8, 1, -9 },
  { 149, 6, 9, 8, 1, -9 },
  { 156, 3, 8, 8, 2, -8 },
  { 159, 3, 10, 8, 2, -8 },
  { 163, 6, 9, 8, 1, -10 },
  { 170, 6, 5, 8, 1, -6 },
  { 174, 6, 9, 8, 1, -10 },
  { 181, 6, 9, 8, 1, -9 },
  { 188, 7, 11, 8, 0, -9 },
  { 198, 7, 9, 8, 0, -9 },
  { 206, 6, 9, 8, 1, -9 },
  { 213, 7, 9, 8, 0, -9 },
  { 221, 6, 9, 8, 1, -9 },
  { 228, 6, 9, 8, 1, -9 },
  { 235, 6, 9, 8, 1, -9 },
  { 242, 7, 9, 8, 0, -9 },
  { 250, 6, 9, 8, 1, -9 },
  { 257, 6, 9, 8, 1, -9 },
  { 264, 6, 9, 8, 1, -9 },
  { 271, 6, 9, 8, 1, -9 },
  { 278, 6, 9, 8, 1, -9 },
  { 285, 7, 9, 8, 0, -9 },
  { 293, 6, 9, 8, 1, -9 },
  { 300, 7, 9, 8, 0, -9 },
  { 308, 6, 9, 8, 1, -9 },
  { 315, 7, 11, 8, 0, -9 },
  { 325, 6, 9, 8, 1, -9 },
  { 332, 6, 9, 8, 1, -9 },
  { 339, 7, 9, 8, 0, -9 },
  { 347, 6, 9, 8, 1, -9 },
  { 354, 7, 9, 8, 0, -9 },
  { 362, 7, 9, 8, 0, -9 },
  { 370, 7, 9, 8, 0, -9 },
  { 378, 7, 9, 8, 0, -9 },
  { 386, 6, 9, 8, 1, -9 },
  { 393, 4, 12, 8, 2, -10 },
  { 399, 6, 12, 8, 1, -10 },
  { 408, 4, 12, 8, 2, -10 },
  { 414, 7, 5, 8, 0, -9 },
  { 419, 7, 2, 8, 0, 0 },
  { 421, 4, 3, 8, 2, -10 },
  { 423, 6, 7, 8, 1, -7 },
  { 429, 6, 10, 8, 1, -10 },
  { 437, 6, 7, 8, 1, -7 },
  { 443, 6, 10, 8, 0, -10 },
  { 451, 7, 7, 8, 0, -7 },
  { 458, 6, 10, 8, 1, -10 },
  { 466, 7, 9, 8, 0, -7 },
  { 474, 6, 10, 8, 1, -10 },
  { 482, 6, 10, 8, 1, -10 },
  { 490, 5, 12, 8, 1, -10 },
  { 498, 6, 10, 8, 1, -10 },
  { 506, 6, 10, 8, 1, -10 },
  { 514, 7, 7, 8, 0, -7 },
  { 521, 6, 7, 8, 1, -7 },
  { 527, 7, 7, 8, 0, -7 },
  { 534, 6, 9, 8, 1, -7 },
  { 541, 7, 9, 8, 0, -7 },
  { 549, 6, 7, 8, 1, -7 },
  { 555, 6, 7, 8, 1, -7 },
  { 561, 6, 9, 8, 1, -9 },
  { 568, 6, 7, 8, 1, -7 },
  { 574, 7, 7, 8, 0, -7 },
  { 581, 7, 7, 8, 0, -7 },
  { 588, 7, 7, 8, 0, -7 },
  { 595, 7, 9, 8, 0, -7 },
  { 603, 6, 7, 8, 1, -7 },
  { 609, 6, 12, 8, 1, -10 },
  { 618, 2, 12, 8, 3, -10 },
  { 621, 6, 12, 8, 1, -10 },
  { 630, 7, 3, 8, 0, -5 },
};

const GFXfont UbuntuMono_Bold15pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Bold15pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Bold15pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _UBUNTUMONO_BOLD15PT7B_H_
