#ifndef _UBUNTUMONO_BOLD33PT7B_H_
#define _UBUNTUMONO_BOLD33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Bold.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Bold33pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xBD, 0xE7, 0x00, 0x0E, 0xFF,
  0xFE, 0xE0, 0x33, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x1D, 0xE3, 0xBC, 0x73,
  0x8E, 0x61, 0xC0, 0x0F, 0x3C, 0x1E, 0x78, 0x38, 0xE0, 0x71, 0xC0, 0xE3,
  0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x70, 0x38, 0xE0, 0xF3, 0xC1,
  0xE7, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBC, 0xF0, 0x79, 0xE0, 0xE3,
  0x81, 0xC7, 0x03, 0x8E, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xFE,
  0x3F, 0xFC, 0xFF, 0xE7, 0xC1, 0x9E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xF0,
  0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x0F, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF7, 0x07, 0xDF, 0xFF, 0xFF, 0xF8, 0xFF, 0xC0, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x3C, 0x07, 0x7E, 0x0E, 0x7E, 0x0E, 0xE7, 0x1C, 0xE7,
  0x38, 0xE7, 0x38, 0xE7, 0x70, 0x7E, 0xE0, 0x7E, 0xE0, 0x3D, 0xC0, 0x03,
  0x9C, 0x03, 0xBE, 0x07, 0x7F, 0x0E, 0x77, 0x0E, 0x67, 0x1C, 0x67, 0x38,
  0x77, 0x38, 0x7F, 0x70, 0x3E, 0xE0, 0x1C, 0x0F, 0x80, 0x3F, 0x80, 0xFF,
  0x83, 0xC7, 0x07, 0x8E, 0x0F, 0x1C, 0x1E, 0x78, 0x1D, 0xE0, 0x3F, 0xC0,
  0x3E, 0x20, 0xFC, 0x73, 0xFC, 0xEF, 0x7F, 0xDC, 0x7F, 0xB8, 0x7E, 0x70,
  0x7C, 0xF0, 0xF9, 0xFF, 0xF9, 0xFF, 0xF0, 0xF8, 0xF0, 0xFF, 0xFF, 0xFF,
  0x77, 0x77, 0x00, 0x80, 0x78, 0x1F, 0x07, 0xE1, 0xF8, 0x3C, 0x0F, 0x83,
  0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x00, 0x40, 0x60, 0x1C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x0F, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x78, 0x3E,
  0x3E, 0x07, 0x01, 0x80, 0x0F, 0x00, 0x78, 0x11, 0xC5, 0xEE, 0xEF, 0xEF,
  0xFF, 0xFD, 0xFF, 0x81, 0xF0, 0x1F, 0xC1, 0xEF, 0x1F, 0x7C, 0x71, 0xC1,
  0x08, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x00, 0x1C, 0x7C, 0xF9, 0xF3, 0xE3, 0xC3, 0x8E,
  0xFD, 0xF1, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x39, 0xFF, 0xFF, 0x7C,
  0xE0, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07,
  0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0,
  0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E,
  0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0x1E, 0x78, 0x3D, 0xC0, 0xFF, 0x03, 0xFC,
  0x07, 0xF3, 0x1F, 0xDE, 0x7F, 0x79, 0xFC, 0xE7, 0xF0, 0x1F, 0xC0, 0xF7,
  0x03, 0xDE, 0x0F, 0x7C, 0x78, 0xFF, 0xE1, 0xFF, 0x01, 0xF0, 0x03, 0x80,
  0x3C, 0x07, 0xE0, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xDE, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x83, 0xFF, 0xDF, 0xFE, 0xFF, 0xF0, 0x0F, 0xC0, 0xFF, 0x8F, 0xFF,
  0x1C, 0x3E, 0x20, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x07,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x7C,
  0x01, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0x1F, 0xC1, 0xFF, 0x87, 0xFF, 0x0C,
  0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x0F, 0xE0, 0x3F, 0xC0,
  0xFF, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x60, 0xF9,
  0xFF, 0xEF, 0xFF, 0x0F, 0xF0, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x80, 0x7F, 0x01, 0xFE, 0x07, 0xBC, 0x0E, 0x78, 0x3C, 0xF0, 0xF1, 0xE1,
  0xE3, 0xC7, 0x87, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0xF8, 0xFF, 0xE3, 0xFF,
  0x8F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF,
  0xC0, 0x1F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x40,
  0xF9, 0xFF, 0xCF, 0xFE, 0x0F, 0xE0, 0x00, 0xF0, 0x3F, 0x87, 0xFC, 0x7F,
  0x03, 0xE0, 0x3C, 0x03, 0xE0, 0x1E, 0xF0, 0xFF, 0xE7, 0xFF, 0xBC, 0x3D,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF8, 0xF3, 0xFF, 0x8F,
  0xF8, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x1F, 0x00,
  0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x00,
  0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0x1F, 0x78, 0x3D, 0xE0, 0xF7, 0x83,
  0x9F, 0x1E, 0x3F, 0xF0, 0x7F, 0x83, 0xFF, 0x1E, 0x7E, 0x78, 0x7F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0x78, 0x7D, 0xFF, 0xE3, 0xFF, 0x03, 0xF0, 0x0F,
  0xC0, 0x7F, 0xC3, 0xFF, 0x1F, 0x1E, 0x78, 0x7D, 0xE0, 0xFF, 0x03, 0xDE,
  0x0F, 0x78, 0x3D, 0xF1, 0xF3, 0xFF, 0xC7, 0xFF, 0x0F, 0xF8, 0x01, 0xE0,
  0x0F, 0x80, 0x7C, 0x07, 0xE0, 0xFF, 0x03, 0xF8, 0x0F, 0x00, 0x39, 0xFF,
  0xFF, 0x7C, 0xE0, 0x00, 0x00, 0x03, 0x9F, 0xFF, 0xF7, 0xCE, 0x1C, 0x7D,
  0xFB, 0xF3, 0xE3, 0x80, 0x00, 0x00, 0x00, 0x71, 0xF7, 0xEF, 0xCF, 0x8F,
  0x0E, 0x7B, 0xE7, 0x8C, 0x00, 0x00, 0x08, 0x00, 0xF0, 0x1F, 0xC1, 0xFF,
  0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0x3E, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFC, 0x00, 0xF0, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x60, 0x01, 0xE0, 0x07, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xC0, 0x0F, 0x01, 0xFC, 0x1F, 0xF3, 0xFF, 0x3F, 0xE0, 0x7E, 0x01, 0xE0,
  0x06, 0x00, 0x00, 0x3F, 0x8F, 0xFE, 0x7F, 0xF6, 0x1F, 0x00, 0xF0, 0x0F,
  0x01, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x0F, 0x80, 0xF0, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xE0, 0x07, 0xE0, 0x7F,
  0xC3, 0xFF, 0x9F, 0x0F, 0x70, 0x1D, 0xC0, 0x7E, 0x1F, 0xF8, 0xFF, 0xE7,
  0xFF, 0x9E, 0x7E, 0x71, 0xFB, 0xC7, 0xEF, 0x1F, 0x9C, 0x7E, 0x71, 0xF9,
  0xE7, 0xE7, 0xFF, 0x8F, 0xF7, 0x0F, 0xDE, 0x00, 0x3E, 0x00, 0x7F, 0xF0,
  0xFF, 0xC0, 0xFF, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07,
  0xF0, 0x0F, 0x70, 0x0E, 0x78, 0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x38, 0x1E,
  0x3C, 0x1C, 0x3C, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFE, 0x78, 0x1E, 0x78,
  0x1E, 0x78, 0x1F, 0x78, 0x0F, 0xF8, 0x0F, 0xFF, 0x87, 0xFF, 0x3F, 0xFD,
  0xE1, 0xEF, 0x0F, 0x78, 0x3B, 0xC3, 0xDE, 0x3E, 0xFF, 0xE7, 0xFF, 0x3F,
  0xFD, 0xE1, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0xFF,
  0xBF, 0xF9, 0xFF, 0x00, 0x03, 0xF8, 0x3F, 0xF1, 0xFF, 0xCF, 0x83, 0x7C,
  0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x7E, 0x0C, 0xFF, 0xF1,
  0xFF, 0xC1, 0xFE, 0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x3C, 0x7C, 0xF0, 0xFB,
  0xC1, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0xBC, 0x3E, 0xF1, 0xF3, 0xFF, 0x8F, 0xFC,
  0x3F, 0xC0, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xFF, 0xE7, 0xFF, 0x3F, 0xF9, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x00, 0x03, 0xFC, 0x3F, 0xF1,
  0xFF, 0xCF, 0x82, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF7, 0x83, 0xDE, 0x0F,
  0x7C, 0x3C, 0xFF, 0xF1, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xE0, 0xFF, 0x83,
  0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE4, 0x0F, 0x70, 0xFB, 0xFF, 0x9F, 0xF8, 0x3F, 0x00,
  0xF8, 0x3D, 0xF0, 0xFB, 0xE1, 0xE7, 0xC7, 0x8F, 0x9F, 0x1F, 0x3C, 0x3E,
  0xF0, 0x7F, 0xE0, 0xFF, 0x81, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xBE,
  0x1F, 0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0xF8, 0x7D, 0xF0, 0xFB, 0xE0, 0xFF,
  0xC1, 0xF0, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x70,
  0x3C, 0xF0, 0x79, 0xE1, 0xF3, 0xC3, 0xE7, 0xC7, 0xDD, 0x9F, 0xBB, 0x3F,
  0x77, 0x6E, 0xEF, 0xDD, 0xCF, 0xBB, 0x9E, 0x77, 0x3C, 0xEE, 0x39, 0xDC,
  0x03, 0xB8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xF0, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xFE, 0x3F, 0xF1,
  0xFD, 0xCF, 0xEE, 0x7F, 0x3B, 0xF9, 0xDF, 0xC7, 0xFE, 0x3F, 0xF0, 0xFF,
  0x87, 0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xF0, 0x0F, 0xC0,
  0x3F, 0xE0, 0xFF, 0xE3, 0xE3, 0xC7, 0x83, 0xDF, 0x07, 0xBC, 0x0F, 0x78,
  0x1E, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xDE, 0x07,
  0xBE, 0x0F, 0x3C, 0x1E, 0x7C, 0x78, 0x7F, 0xF0, 0x7F, 0xC0, 0x3E, 0x00,
  0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x3C, 0x3E, 0xF0, 0x7B, 0xC1, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0x7B, 0xC3, 0xEF, 0xFF, 0x3F, 0xF8, 0xFF, 0x83, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x0F,
  0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xE3, 0xC7, 0x83, 0xDF, 0x07, 0xBC, 0x0F,
  0x78, 0x1E, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xDE,
  0x07, 0xBC, 0x0F, 0x3C, 0x1E, 0x7C, 0x78, 0x7F, 0xF0, 0x7F, 0xC0, 0x7E,
  0x00, 0x38, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x1C, 0xFF, 0x83,
  0xFF, 0x8F, 0xFF, 0x3C, 0x7C, 0xF0, 0xFB, 0xC1, 0xEF, 0x07, 0xBC, 0x3E,
  0xF1, 0xF3, 0xFF, 0xCF, 0xFE, 0x3F, 0xF0, 0xF3, 0xE3, 0xC7, 0x8F, 0x1F,
  0x3C, 0x3C, 0xF0, 0xFB, 0xC1, 0xEF, 0x07, 0xFC, 0x0F, 0x0F, 0xE0, 0xFF,
  0xE3, 0xFF, 0x9F, 0x04, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7F,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0x7E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x60, 0x7D, 0xFF, 0xEF, 0xFF, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xDE, 0x0F, 0x78, 0x7D, 0xFF, 0xE3, 0xFF, 0x03, 0xF8, 0x78, 0x0F, 0x78,
  0x0F, 0x78, 0x1F, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C,
  0x3C, 0x1C, 0x3C, 0x1E, 0x3C, 0x1E, 0x38, 0x1E, 0x78, 0x0E, 0x78, 0x0F,
  0x78, 0x0F, 0x70, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0x71, 0xCE, 0xE7, 0x9D, 0xCF, 0x3B, 0x9F, 0x77, 0x7E, 0xEE,
  0xED, 0xDD, 0xDF, 0xBB, 0x3F, 0x3E, 0x3E, 0x78, 0x7C, 0xF0, 0xF9, 0xE0,
  0xF3, 0xC1, 0xE0, 0x78, 0x1F, 0x3C, 0x1E, 0x3C, 0x3C, 0x1E, 0x3C, 0x1E,
  0x78, 0x0F, 0x78, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x1E, 0x7C, 0x1E, 0x3C, 0x3C,
  0x3E, 0x3C, 0x1E, 0x78, 0x1F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x7C,
  0x1E, 0x3C, 0x1E, 0x3C, 0x3C, 0x1E, 0x3C, 0x1E, 0x38, 0x0F, 0x78, 0x0F,
  0x70, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF8,
  0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F,
  0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x7F, 0xFF, 0xFF, 0xF0, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80,
  0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00,
  0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07,
  0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3E,
  0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80,
  0x0F, 0x80, 0x3F, 0x80, 0xF7, 0x83, 0xCF, 0x07, 0x8F, 0x1E, 0x1F, 0x7C,
  0x1E, 0xF0, 0x1E, 0x60, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x20,
  0xE3, 0xF3, 0xF1, 0xE0, 0x80, 0x3F, 0xC0, 0xFF, 0xC3, 0xFF, 0x88, 0x1E,
  0x00, 0x78, 0x00, 0xF0, 0xFF, 0xCF, 0xFF, 0x7F, 0xFD, 0xE0, 0xFF, 0x03,
  0xFC, 0x0F, 0x78, 0x3D, 0xFF, 0xF3, 0xFF, 0xC3, 0xFC, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3D, 0xF0, 0xFF,
  0xE3, 0xFF, 0xCF, 0x8F, 0xBC, 0x1E, 0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0xBC,
  0x1F, 0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0xBC, 0x3C, 0xFF, 0xF3, 0xFF, 0x87,
  0xF8, 0x00, 0x03, 0xF8, 0x3F, 0xF3, 0xFF, 0xCF, 0x80, 0x7C, 0x01, 0xE0,
  0x07, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E,
  0x04, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE1, 0xEF, 0x3F, 0xFB, 0xFF, 0xDE, 0x3F,
  0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFE,
  0x1E, 0xF8, 0xF7, 0xFF, 0x9F, 0xFC, 0x3F, 0xC0, 0x07, 0xC0, 0x7F, 0xC3,
  0xFF, 0x9F, 0x1E, 0x78, 0x3F, 0xE0, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x7C, 0x08, 0xFF, 0xE1, 0xFF, 0x81, 0xFC,
  0x01, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x7C, 0x30, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x07, 0xF0, 0xFF, 0xCF,
  0xFE, 0xF8, 0xF7, 0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFE, 0x1E, 0xF0, 0xF7, 0xFF, 0x9F, 0xFC, 0x3F, 0xE0, 0x0F, 0x00, 0x7B,
  0x07, 0xDF, 0xFC, 0xFF, 0xC3, 0xF8, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0xF0, 0xFF, 0xE7, 0xFF, 0xBC,
  0x3D, 0xE1, 0xEF, 0x0F, 0x78, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87,
  0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xE0, 0x0E, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0xFF,
  0x83, 0xFE, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE1, 0x07, 0xFC, 0x0F, 0xF0,
  0x1F, 0x80, 0x01, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x1C, 0x00, 0x00, 0x03,
  0xFF, 0x7F, 0xEF, 0xFC, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x43,
  0xFF, 0xFB, 0xFF, 0x1F, 0x80, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x3E, 0xF0, 0xF3, 0xC7, 0x8F, 0x3E,
  0x3C, 0xF0, 0xF7, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0xF7, 0xC3, 0xCF,
  0x8F, 0x1E, 0x3C, 0x7C, 0xF0, 0xFB, 0xC1, 0xEF, 0x07, 0xC0, 0xFF, 0x83,
  0xFE, 0x0F, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE1, 0x07, 0xFC, 0x0F,
  0xF0, 0x1F, 0x80, 0x7E, 0xF9, 0xFF, 0xFB, 0xFF, 0xF7, 0x3C, 0xEE, 0x79,
  0xDC, 0x73, 0xF8, 0xE7, 0xF1, 0xCF, 0xE3, 0x9F, 0xC7, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0x3F, 0x87, 0xFF,
  0x3F, 0xFD, 0xE1, 0xEF, 0x0F, 0x78, 0x7B, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF,
  0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0x07,
  0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xE3, 0xE7, 0x83, 0xDE, 0x07, 0xBC, 0x0F,
  0x78, 0x1F, 0xF0, 0x3F, 0xE0, 0x7B, 0xC0, 0xF3, 0xC1, 0xE7, 0xC7, 0x87,
  0xFF, 0x07, 0xFC, 0x03, 0xE0, 0x7F, 0x87, 0xFF, 0x3F, 0xFD, 0xE1, 0xEF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x0F, 0xFF, 0xFB, 0xFF, 0x9E, 0xF8, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0x07, 0xF0, 0xFF, 0xCF, 0xFE, 0xF8, 0xF7, 0x87,
  0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xF0, 0xF7,
  0xC7, 0xBF, 0xFC, 0xFF, 0xE1, 0xEF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0x1F, 0xE1, 0xFF, 0x9F, 0xFD, 0xF0, 0x4F, 0x00, 0x7C,
  0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0x80, 0x3E, 0x00, 0xFE, 0x0F,
  0x7F, 0xFB, 0xFF, 0x87, 0xF0, 0x03, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x1F, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x08, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF8, 0xF7, 0xFF, 0x3F, 0xF1, 0xFE, 0x78, 0x0F, 0x78,
  0x1F, 0x78, 0x1E, 0x3C, 0x1E, 0x3C, 0x3E, 0x3C, 0x3C, 0x1E, 0x3C, 0x1E,
  0x7C, 0x1E, 0x78, 0x0F, 0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0xF0, 0x07, 0xF0, 0x07, 0x70, 0x07, 0x71,
  0xC7, 0x73, 0xCF, 0x73, 0xCF, 0x73, 0xEE, 0x73, 0xEE, 0x73, 0xEE, 0x77,
  0xEE, 0x3F, 0x7E, 0x3E, 0x7E, 0x3E, 0x7C, 0x3E, 0x3C, 0x3C, 0x3C, 0x1C,
  0x3C, 0xF0, 0x3C, 0xF0, 0x79, 0xF1, 0xE1, 0xE7, 0x81, 0xEF, 0x01, 0xFC,
  0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0xC0, 0x7F, 0xC1, 0xF7, 0x83,
  0xC7, 0x8F, 0x0F, 0xBE, 0x0F, 0x78, 0x1F, 0xF8, 0x3C, 0xF0, 0x79, 0xE0,
  0xF3, 0xC1, 0xE7, 0xC7, 0x87, 0x8F, 0x0F, 0x1E, 0x1F, 0x38, 0x1E, 0xF0,
  0x3D, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xF8, 0x01, 0xF0, 0x01,
  0xC0, 0x07, 0x81, 0x1F, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x7F,
  0xF7, 0xFF, 0x7F, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF8, 0x1F,
  0x01, 0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xF0, 0x7F, 0x0F, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x0F, 0xC0, 0xF0, 0x0F, 0xC0, 0x1E,
  0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xFF, 0x07, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0xFF, 0x00,
  0xF8, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x3F, 0x00, 0xF0, 0x3F, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x8F, 0xF0, 0xFF, 0x0F,
  0xC0, 0x3C, 0x0C, 0xFF, 0x3D, 0xFF, 0xFF, 0xFF, 0xEE, 0x3F, 0xCC, 0x1E,
  0x00,
};

const GFXglyph UbuntuMono_Bold33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 5, 20, 17, 6, -20 },
  { 14, 11, 9, 17, 3, -23 },
  { 27, 15, 20, 17, 1, -20 },
  { 65, 14, 26, 17, 1, -23 },
  { 111, 16, 20, 17, 0, -20 },
  { 151, 15, 20, 17, 1, -20 },
  { 189, 4, 10, 17, 6, -23 },
  { 194, 11, 28, 17, 3, -23 },
  { 233, 10, 28, 17, 3, -23 },
  { 268, 13, 13, 17, 2, -20 },
  { 290, 14, 15, 17, 1, -16 },
  { 317, 7, 11, 17, 4, -6 },
  { 327, 9, 4, 17, 4, -10 },
  { 332, 6, 6, 17, 5, -6 },
  { 337, 13, 28, 17, 2, -23 },
  { 383, 14, 20, 17, 1, -20 },
  { 418, 13, 20, 17, 2, -20 },
  { 451, 14, 20, 17, 1, -20 },
  { 486, 14, 20, 17, 1, -20 },
  { 521, 15, 20, 17, 1, -20 },
  { 559, 14, 20, 17, 1, -20 },
  { 594, 13, 20, 17, 2, -20 },
  { 627, 13, 20, 17, 2, -20 },
  { 660, 14, 20, 17, 1, -20 },
  { 695, 14, 20, 17, 1, -20 },
  { 730, 6, 16, 17, 5, -16 },
  { 742, 7, 21, 17, 4, -16 },
  { 761, 14, 15, 17, 1, -16 },
  { 788, 14, 9, 17, 1, -13 },
  { 804, 14, 15, 17, 1, -16 },
  { 831, 12, 20, 17, 2, -20 },
  { 861, 14, 24, 17, 1, -20 },
  { 903, 16, 20, 17, 0, -20 },
  { 943, 13, 20, 17, 2, -20 },
  { 976, 14, 20, 17, 1, -20 },
  { 1011, 14, 20, 17, 2, -20 },
  { 1046, 13, 20, 17, 2, -20 },
  { 1079, 13, 20, 17, 2, -20 },
  { 1112, 14, 20, 17, 1, -20 },
  { 1147, 14, 20, 17, 1, -20 },
  { 1182, 13, 20, 17, 2, -20 },
  { 1215, 13, 20, 17, 1, -20 },
  { 1248, 15, 20, 17, 1, -20 },
  { 1286, 13, 20, 17, 2, -20 },
  { 1319, 15, 20, 17, 1, -20 },
  { 1357, 13, 20, 17, 2, -20 },
  { 1390, 15, 20, 17, 1, -20 },
  { 1428, 14, 20, 17, 2, -20 },
  { 1463, 15, 25, 17, 1, -20 },
  { 1510, 14, 20, 17, 2, -20 },
  { 1545, 14, 20, 17, 1, -20 },
  { 1580, 15, 20, 17, 1, -20 },
  { 1618, 14, 20, 17, 1, -20 },
  { 1653, 16, 20, 17, 0, -20 },
  { 1693, 15, 20, 17, 1, -20 },
  { 1731, 16, 20, 17, 0, -20 },
  { 1771, 16, 20, 17, 0, -20 },
  { 1811, 13, 20, 17, 2, -20 },
  { 1844, 9, 28, 17, 4, -23 },
  { 1876, 13, 28, 17, 2, -23 },
  { 1922, 9, 28, 17, 4, -23 },
  { 1954, 15, 10, 17, 1, -20 },
  { 1973, 16, 3, 17, 0, 2 },
  { 1979, 7, 6, 17, 5, -23 },
  { 1985, 14, 16, 17, 1, -16 },
  { 2013, 14, 23, 17, 2, -23 },
  { 2054, 14, 16, 17, 1, -16 },
  { 2082, 13, 23, 17, 1, -23 },
  { 2120, 14, 16, 17, 1, -16 },
  { 2148, 15, 23, 17, 1, -23 },
  { 2192, 13, 21, 17, 1, -16 },
  { 2227, 13, 23, 17, 2, -23 },
  { 2265, 14, 23, 17, 1, -23 },
  { 2306, 11, 28, 17, 2, -23 },
  { 2345, 14, 23, 17, 2, -23 },
  { 2386, 14, 23, 17, 1, -23 },
  { 2427, 15, 16, 17, 1, -16 },
  { 2457, 13, 16, 17, 2, -16 },
  { 2483, 15, 16, 17, 1, -16 },
  { 2513, 13, 21, 17, 2, -16 },
  { 2548, 13, 21, 17, 1, -16 },
  { 2583, 12, 16, 17, 3, -16 },
  { 2607, 13, 16, 17, 2, -16 },
  { 2633, 15, 21, 17, 1, -21 },
  { 2673, 12, 16, 17, 2, -16 },
  { 2697, 16, 16, 17, 0, -16 },
  { 2729, 16, 16, 17, 0, -16 },
  { 2761, 15, 16, 17, 1, -16 },
  { 2791, 15, 21, 17, 1, -16 },
  { 2831, 12, 16, 17, 2, -16 },
  { 2855, 12, 28, 17, 2, -23 },
  { 2897, 4, 28, 17, 6, -23 },
  { 2911, 12, 28, 17, 2, -23 },
  { 2953, 15, 6, 17, 1, -12 },
};

const GFXfont UbuntuMono_Bold33pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Bold33pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Bold33pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _UBUNTUMONO_BOLD33PT7B_H_
