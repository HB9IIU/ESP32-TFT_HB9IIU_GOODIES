#ifndef _UBUNTUMONO_BOLD6PT7B_H_
#define _UBUNTUMONO_BOLD6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Bold.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Bold6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0x80, 0x7F, 0xE0, 0x51, 0xF4, 0xB9, 0xD0, 0x5B, 0xF0, 0xC0,
  0xAA, 0x80, 0xF8, 0x4C, 0x00, 0x5D, 0x00, 0xC0, 0x80, 0x80, 0x29, 0x28,
  0x56, 0xF0, 0x59, 0x70, 0xC5, 0x70, 0xC5, 0xF0, 0x0B, 0x90, 0x71, 0xF0,
  0x7A, 0xF0, 0xE9, 0x20, 0x57, 0xF0, 0x55, 0xA0, 0xA0, 0xB0, 0x38, 0x80,
  0x40, 0x8E, 0x00, 0xC5, 0x20, 0x5F, 0xF6, 0x4B, 0xD0, 0xD7, 0xF0, 0x72,
  0x30, 0xD6, 0xE0, 0xF3, 0x70, 0xF3, 0x40, 0x72, 0xB0, 0xB7, 0xD0, 0xE9,
  0x70, 0x64, 0xE0, 0xBB, 0x50, 0x92, 0x70, 0xB7, 0xD0, 0xBF, 0xD0, 0x56,
  0xF0, 0xD7, 0x40, 0x56, 0xF6, 0xD7, 0x50, 0x71, 0xF0, 0xE9, 0x20, 0xB6,
  0xF0, 0xB6, 0xA0, 0xB7, 0xD0, 0xA9, 0x50, 0xB5, 0x20, 0xE9, 0x70, 0xF8,
  0x89, 0x22, 0xF8, 0x54, 0xE0, 0x80, 0x4F, 0x80, 0x9E, 0xF0, 0x71, 0x80,
  0x3E, 0xF0, 0x5F, 0x80, 0x7D, 0x20, 0x75, 0xE0, 0x9A, 0xD0, 0x59, 0x30,
  0x55, 0xC0, 0x97, 0x50, 0x49, 0x30, 0xFE, 0x80, 0xD6, 0x80, 0x57, 0x80,
  0xD7, 0xC0, 0x77, 0x90, 0xE8, 0x4B, 0x80, 0x5D, 0x30, 0xB7, 0x80, 0xB5,
  0x00, 0xBE, 0x80, 0xAA, 0x80, 0xB5, 0x60, 0xEB, 0x80, 0x4A, 0x26, 0xF8,
  0x48, 0xAC, 0xE0,
};

const GFXglyph UbuntuMono_Bold6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 4, 3, 1, -4 },
  { 2, 1, 2, 3, 1, -4 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 3, 5, 3, 0, -4 },
  { 7, 3, 4, 3, 0, -4 },
  { 9, 3, 4, 3, 0, -4 },
  { 11, 1, 2, 3, 1, -4 },
  { 12, 2, 5, 3, 1, -4 },
  { 14, 1, 5, 3, 1, -4 },
  { 15, 3, 3, 3, 0, -4 },
  { 17, 3, 3, 3, 0, -3 },
  { 19, 1, 2, 3, 1, -1 },
  { 20, 1, 1, 3, 1, -2 },
  { 21, 1, 1, 3, 1, -1 },
  { 22, 3, 5, 3, 0, -4 },
  { 24, 3, 4, 3, 0, -4 },
  { 26, 3, 4, 3, 0, -4 },
  { 28, 3, 4, 3, 0, -4 },
  { 30, 3, 4, 3, 0, -4 },
  { 32, 3, 4, 3, 0, -4 },
  { 34, 3, 4, 3, 0, -4 },
  { 36, 3, 4, 3, 0, -4 },
  { 38, 3, 4, 3, 0, -4 },
  { 40, 3, 4, 3, 0, -4 },
  { 42, 3, 4, 3, 0, -4 },
  { 44, 1, 3, 3, 1, -3 },
  { 45, 1, 4, 3, 1, -3 },
  { 46, 3, 3, 3, 0, -3 },
  { 48, 3, 1, 3, 0, -2 },
  { 49, 3, 3, 3, 0, -3 },
  { 51, 3, 4, 3, 0, -4 },
  { 53, 3, 5, 3, 0, -4 },
  { 55, 3, 4, 3, 0, -4 },
  { 57, 3, 4, 3, 0, -4 },
  { 59, 3, 4, 3, 0, -4 },
  { 61, 3, 4, 3, 0, -4 },
  { 63, 3, 4, 3, 0, -4 },
  { 65, 3, 4, 3, 0, -4 },
  { 67, 3, 4, 3, 0, -4 },
  { 69, 3, 4, 3, 0, -4 },
  { 71, 3, 4, 3, 0, -4 },
  { 73, 3, 4, 3, 0, -4 },
  { 75, 3, 4, 3, 0, -4 },
  { 77, 3, 4, 3, 0, -4 },
  { 79, 3, 4, 3, 0, -4 },
  { 81, 3, 4, 3, 0, -4 },
  { 83, 3, 4, 3, 0, -4 },
  { 85, 3, 4, 3, 0, -4 },
  { 87, 3, 5, 3, 0, -4 },
  { 89, 3, 4, 3, 0, -4 },
  { 91, 3, 4, 3, 0, -4 },
  { 93, 3, 4, 3, 0, -4 },
  { 95, 3, 4, 3, 0, -4 },
  { 97, 3, 4, 3, 0, -4 },
  { 99, 3, 4, 3, 0, -4 },
  { 101, 3, 4, 3, 0, -4 },
  { 103, 3, 4, 3, 0, -4 },
  { 105, 3, 4, 3, 0, -4 },
  { 107, 1, 5, 3, 1, -4 },
  { 108, 3, 5, 3, 0, -4 },
  { 110, 1, 5, 3, 1, -4 },
  { 111, 3, 2, 3, 0, -4 },
  { 112, 3, 1, 3, 0, 0 },
  { 113, 1, 1, 3, 1, -4 },
  { 114, 3, 3, 3, 0, -3 },
  { 116, 3, 4, 3, 0, -4 },
  { 118, 3, 3, 3, 0, -3 },
  { 120, 3, 4, 3, 0, -4 },
  { 122, 3, 3, 3, 0, -3 },
  { 124, 3, 4, 3, 0, -4 },
  { 126, 3, 4, 3, 0, -3 },
  { 128, 3, 4, 3, 0, -4 },
  { 130, 3, 4, 3, 0, -4 },
  { 132, 2, 5, 3, 0, -4 },
  { 134, 3, 4, 3, 0, -4 },
  { 136, 3, 4, 3, 0, -4 },
  { 138, 3, 3, 3, 0, -3 },
  { 140, 3, 3, 3, 0, -3 },
  { 142, 3, 3, 3, 0, -3 },
  { 144, 3, 4, 3, 0, -3 },
  { 146, 3, 4, 3, 0, -3 },
  { 148, 2, 3, 3, 1, -3 },
  { 149, 3, 3, 3, 0, -3 },
  { 151, 3, 4, 3, 0, -4 },
  { 153, 3, 3, 3, 0, -3 },
  { 155, 3, 3, 3, 0, -3 },
  { 157, 3, 3, 3, 0, -3 },
  { 159, 3, 3, 3, 0, -3 },
  { 161, 3, 4, 3, 0, -3 },
  { 163, 3, 3, 3, 0, -3 },
  { 165, 3, 5, 3, 0, -4 },
  { 167, 1, 5, 3, 1, -4 },
  { 168, 3, 5, 3, 0, -4 },
  { 170, 3, 1, 3, 0, -2 },
};

const GFXfont UbuntuMono_Bold6pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Bold6pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Bold6pt7bGlyphs,
  0x20, 0x7E, 6
};

#endif // _UBUNTUMONO_BOLD6PT7B_H_
