#ifndef _UBUNTUMONO_BOLD11PT7B_H_
#define _UBUNTUMONO_BOLD11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Bold.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Bold11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x3C, 0x7A, 0xA0, 0x29, 0x7E, 0xAF, 0xA9, 0x40, 0x23, 0xD0,
  0x87, 0x0C, 0x3E, 0x20, 0xCD, 0x74, 0x43, 0xAE, 0x60, 0x72, 0x94, 0xDB,
  0xCD, 0xE0, 0xE0, 0x26, 0x4C, 0x88, 0x84, 0x62, 0x88, 0x92, 0x49, 0x50,
  0x23, 0x5C, 0x65, 0x00, 0x21, 0x3E, 0x42, 0x00, 0x6D, 0xE0, 0xE0, 0xF0,
  0x33, 0x22, 0x64, 0x4C, 0x88, 0x72, 0x73, 0xDC, 0xA5, 0xC0, 0x6E, 0x66,
  0x66, 0xF0, 0x70, 0xC6, 0x66, 0x21, 0xE0, 0x70, 0xC6, 0x61, 0x8F, 0xC0,
  0x11, 0x94, 0xAF, 0x88, 0x40, 0x7A, 0x1C, 0x30, 0x8F, 0xC0, 0x3B, 0x10,
  0xF4, 0xA5, 0xC0, 0xF3, 0x26, 0x44, 0xC0, 0x72, 0x56, 0xE5, 0xE5, 0xC0,
  0x72, 0xD2, 0xF1, 0x89, 0x80, 0xF3, 0xC0, 0x6C, 0x36, 0xB0, 0x08, 0xDD,
  0xCE, 0x38, 0x61, 0xF8, 0x3E, 0x43, 0x1C, 0x31, 0xB9, 0x88, 0xE3, 0x24,
  0x04, 0x40, 0x72, 0x6F, 0x5A, 0xDD, 0x07, 0x31, 0x94, 0xB7, 0xE7, 0x20,
  0xEB, 0xBE, 0x99, 0xE0, 0x3A, 0x71, 0x8C, 0x21, 0xE0, 0xEB, 0x99, 0x9B,
  0xE0, 0xF8, 0x8E, 0x88, 0xF0, 0xF8, 0x8F, 0x88, 0x80, 0x3A, 0x31, 0x9C,
  0xA5, 0xE0, 0xCE, 0x73, 0xFC, 0xE7, 0x20, 0xF4, 0x44, 0x44, 0xF0, 0x78,
  0xC6, 0x31, 0xAD, 0xC0, 0xDE, 0xBD, 0xCF, 0x6F, 0x20, 0x88, 0x88, 0x88,
  0xF0, 0x4A, 0xEF, 0x7A, 0xC6, 0x20, 0xCE, 0x7B, 0xDD, 0xEF, 0x20, 0x72,
  0x73, 0x9C, 0xA5, 0xC0, 0xE9, 0x99, 0xE8, 0x80, 0x72, 0x73, 0x9C, 0xA5,
  0xC6, 0x18, 0xEB, 0xBE, 0xAB, 0x90, 0x7A, 0x10, 0xE1, 0x85, 0xC0, 0xF9,
  0x08, 0x42, 0x10, 0x80, 0xCE, 0x73, 0x9C, 0xA5, 0xC0, 0xCE, 0x56, 0xB7,
  0x18, 0xC0, 0x8C, 0x6B, 0x7B, 0xAD, 0x20, 0x4A, 0x8C, 0x67, 0x2F, 0x20,
  0xCA, 0xD4, 0x62, 0x10, 0x80, 0x78, 0xCC, 0x46, 0x23, 0xE0, 0xFB, 0x6D,
  0xB6, 0xDC, 0x88, 0xC4, 0x46, 0x22, 0x33, 0xE4, 0x92, 0x49, 0x3C, 0x32,
  0xF2, 0xF8, 0x90, 0x70, 0xDF, 0x97, 0x80, 0x88, 0x8E, 0x99, 0x9E, 0x7A,
  0x30, 0x87, 0x80, 0x18, 0xC6, 0xFD, 0xEF, 0x6F, 0x72, 0x7F, 0x87, 0x80,
  0x39, 0x09, 0xF2, 0x10, 0x84, 0x7A, 0xF7, 0xB7, 0x8D, 0xC0, 0x88, 0x8E,
  0xBB, 0xBB, 0x21, 0x01, 0xC2, 0x10, 0x87, 0x24, 0x72, 0x49, 0x3C, 0x88,
  0x8B, 0xEC, 0xAB, 0xE1, 0x08, 0x42, 0x10, 0x87, 0xFD, 0x6B, 0x18, 0x80,
  0xEB, 0xBB, 0xB0, 0x76, 0x73, 0x97, 0x00, 0xE9, 0x99, 0xE8, 0x80, 0x7E,
  0xF7, 0xB7, 0x8C, 0x60, 0xF8, 0x88, 0x80, 0xF8, 0xE3, 0xE0, 0x21, 0x3E,
  0x42, 0x10, 0xE0, 0xBB, 0xBB, 0xF0, 0xCA, 0xD4, 0xE3, 0x00, 0x8D, 0x6E,
  0xB5, 0x80, 0x4B, 0x8C, 0xE4, 0x80, 0x4A, 0xDC, 0x63, 0x13, 0x80, 0xF2,
  0x4C, 0xF0, 0x74, 0x44, 0x48, 0x44, 0x47, 0xFF, 0xC0, 0xC6, 0x66, 0x63,
  0x66, 0x6C, 0x6C, 0xC0,
};

const GFXglyph UbuntuMono_Bold11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 7, 6, 2, -7 },
  { 3, 4, 3, 6, 1, -8 },
  { 5, 5, 7, 6, 0, -7 },
  { 10, 5, 9, 6, 0, -8 },
  { 16, 5, 7, 6, 0, -7 },
  { 21, 5, 7, 6, 0, -7 },
  { 26, 1, 3, 6, 2, -8 },
  { 27, 4, 10, 6, 1, -8 },
  { 32, 3, 10, 6, 1, -8 },
  { 36, 5, 5, 6, 0, -7 },
  { 40, 5, 5, 6, 0, -5 },
  { 44, 3, 4, 6, 1, -2 },
  { 46, 3, 1, 6, 1, -3 },
  { 47, 2, 2, 6, 2, -2 },
  { 48, 4, 10, 6, 1, -8 },
  { 53, 5, 7, 6, 0, -7 },
  { 58, 4, 7, 6, 1, -7 },
  { 62, 5, 7, 6, 0, -7 },
  { 67, 5, 7, 6, 0, -7 },
  { 72, 5, 7, 6, 0, -7 },
  { 77, 5, 7, 6, 0, -7 },
  { 82, 5, 7, 6, 0, -7 },
  { 87, 4, 7, 6, 1, -7 },
  { 91, 5, 7, 6, 0, -7 },
  { 96, 5, 7, 6, 0, -7 },
  { 101, 2, 5, 6, 2, -5 },
  { 103, 3, 7, 6, 1, -5 },
  { 106, 5, 8, 6, 0, -8 },
  { 111, 5, 3, 6, 0, -4 },
  { 113, 5, 8, 6, 0, -8 },
  { 118, 4, 7, 6, 1, -7 },
  { 122, 5, 8, 6, 0, -7 },
  { 127, 5, 7, 6, 0, -7 },
  { 132, 4, 7, 6, 1, -7 },
  { 136, 5, 7, 6, 0, -7 },
  { 141, 4, 7, 6, 1, -7 },
  { 145, 4, 7, 6, 1, -7 },
  { 149, 4, 7, 6, 1, -7 },
  { 153, 5, 7, 6, 0, -7 },
  { 158, 5, 7, 6, 0, -7 },
  { 163, 4, 7, 6, 1, -7 },
  { 167, 5, 7, 6, 0, -7 },
  { 172, 5, 7, 6, 0, -7 },
  { 177, 4, 7, 6, 1, -7 },
  { 181, 5, 7, 6, 0, -7 },
  { 186, 5, 7, 6, 0, -7 },
  { 191, 5, 7, 6, 0, -7 },
  { 196, 4, 7, 6, 1, -7 },
  { 200, 5, 9, 6, 0, -7 },
  { 206, 4, 7, 6, 1, -7 },
  { 210, 5, 7, 6, 0, -7 },
  { 215, 5, 7, 6, 0, -7 },
  { 220, 5, 7, 6, 0, -7 },
  { 225, 5, 7, 6, 0, -7 },
  { 230, 5, 7, 6, 0, -7 },
  { 235, 5, 7, 6, 0, -7 },
  { 240, 5, 7, 6, 0, -7 },
  { 245, 5, 7, 6, 0, -7 },
  { 250, 3, 10, 6, 1, -8 },
  { 254, 4, 10, 6, 1, -8 },
  { 259, 3, 10, 6, 1, -8 },
  { 263, 5, 3, 6, 0, -7 },
  { 265, 5, 1, 6, 0, 1 },
  { 266, 2, 2, 6, 2, -8 },
  { 267, 5, 5, 6, 0, -5 },
  { 271, 4, 8, 6, 1, -8 },
  { 275, 5, 5, 6, 0, -5 },
  { 279, 5, 8, 6, 0, -8 },
  { 284, 5, 5, 6, 0, -5 },
  { 288, 5, 8, 6, 0, -8 },
  { 293, 5, 7, 6, 0, -5 },
  { 298, 4, 8, 6, 1, -8 },
  { 302, 5, 8, 6, 0, -8 },
  { 307, 3, 10, 6, 1, -8 },
  { 311, 4, 8, 6, 1, -8 },
  { 315, 5, 8, 6, 0, -8 },
  { 320, 5, 5, 6, 0, -5 },
  { 324, 4, 5, 6, 1, -5 },
  { 327, 5, 5, 6, 0, -5 },
  { 331, 4, 7, 6, 1, -5 },
  { 335, 5, 7, 6, 0, -5 },
  { 340, 4, 5, 6, 1, -5 },
  { 343, 4, 5, 6, 1, -5 },
  { 346, 5, 7, 6, 0, -7 },
  { 351, 4, 5, 6, 1, -5 },
  { 354, 5, 5, 6, 0, -5 },
  { 358, 5, 5, 6, 0, -5 },
  { 362, 5, 5, 6, 0, -5 },
  { 366, 5, 7, 6, 0, -5 },
  { 371, 4, 5, 6, 1, -5 },
  { 374, 4, 10, 6, 1, -8 },
  { 379, 1, 10, 6, 2, -8 },
  { 381, 4, 10, 6, 1, -8 },
  { 386, 5, 2, 6, 0, -4 },
};

const GFXfont UbuntuMono_Bold11pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Bold11pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Bold11pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _UBUNTUMONO_BOLD11PT7B_H_
