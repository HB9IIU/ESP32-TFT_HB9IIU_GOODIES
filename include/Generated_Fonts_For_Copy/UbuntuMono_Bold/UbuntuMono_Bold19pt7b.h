#ifndef _UBUNTUMONO_BOLD19PT7B_H_
#define _UBUNTUMONO_BOLD19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Bold.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Bold19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xDB, 0x63, 0xF0, 0xDF, 0x7C, 0xF3, 0xC8, 0x19, 0x0D,
  0x86, 0xDF, 0xFF, 0xF9, 0x98, 0xD9, 0xFF, 0xFF, 0xB3, 0x19, 0x8D, 0x80,
  0x18, 0x18, 0x7E, 0xFE, 0xE0, 0xE0, 0xF8, 0x7E, 0x0F, 0x07, 0x87, 0xFE,
  0xFC, 0x18, 0x18, 0x71, 0xF8, 0xFC, 0xDA, 0x4F, 0x63, 0xE0, 0x2E, 0x3F,
  0x36, 0x93, 0xD9, 0xF8, 0x70, 0x3C, 0x1F, 0x19, 0x8C, 0xC3, 0xC1, 0xCD,
  0xF6, 0xDA, 0xC7, 0x33, 0x9F, 0xE7, 0xB0, 0xFF, 0xF0, 0x08, 0x63, 0x18,
  0xE3, 0x0C, 0x30, 0xC3, 0x0C, 0x38, 0x60, 0xC1, 0xC2, 0xC3, 0x83, 0x0E,
  0x18, 0x61, 0xC3, 0x0C, 0x71, 0x86, 0x39, 0xCE, 0x30, 0x18, 0x18, 0xD6,
  0xFF, 0x38, 0x6E, 0x24, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18,
  0x33, 0xCE, 0x6F, 0x20, 0xFF, 0xC0, 0xFF, 0x80, 0x06, 0x06, 0x0E, 0x0C,
  0x0C, 0x1C, 0x18, 0x18, 0x38, 0x30, 0x30, 0x70, 0x60, 0x60, 0xE0, 0xC0,
  0x3C, 0x7E, 0xE6, 0xC7, 0xC3, 0xDB, 0xDB, 0xC3, 0xC7, 0xE6, 0x7E, 0x3C,
  0x18, 0x38, 0xF8, 0xF8, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x7F, 0x7F,
  0x7C, 0xFE, 0xC6, 0x06, 0x06, 0x0C, 0x1C, 0x38, 0x70, 0xE0, 0xFF, 0xFF,
  0x78, 0xFE, 0x0E, 0x06, 0x0E, 0x3C, 0x3E, 0x06, 0x07, 0x86, 0xFE, 0xFC,
  0x0E, 0x1E, 0x1E, 0x3E, 0x6E, 0xEE, 0xCE, 0xFF, 0xFF, 0x0E, 0x0E, 0x0E,
  0x7E, 0x7E, 0x60, 0x60, 0x78, 0x7E, 0x0E, 0x06, 0x06, 0x06, 0xFE, 0xF8,
  0x0E, 0x3E, 0x70, 0x60, 0xF8, 0xFE, 0xC6, 0xC7, 0xC7, 0xE6, 0x7E, 0x3C,
  0xFF, 0xFF, 0x06, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x38, 0x30, 0x30, 0x30,
  0x3C, 0x7E, 0xE6, 0xC6, 0xE6, 0x7E, 0x7C, 0xCE, 0xC3, 0xC7, 0xFE, 0x7C,
  0x3C, 0x7E, 0xE6, 0xC7, 0xC7, 0xE7, 0x7F, 0x3E, 0x0E, 0x1C, 0x78, 0x70,
  0xFF, 0x80, 0x3F, 0xE0, 0x77, 0x70, 0x00, 0x77, 0x73, 0xFC, 0x02, 0x1F,
  0x7C, 0xF0, 0xF0, 0x7C, 0x1F, 0x02, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0xF0, 0x7E, 0x0F, 0x0F, 0x7E, 0xF0, 0xC0, 0x7C, 0xFC, 0x18, 0x30,
  0xE3, 0xC7, 0x1C, 0x30, 0x00, 0xE1, 0xC0, 0x1E, 0x1F, 0x9C, 0xEC, 0x34,
  0xFE, 0x7F, 0x67, 0xB3, 0xD9, 0xEC, 0xD3, 0xEC, 0xF7, 0x01, 0xF8, 0x3E,
  0x1C, 0x0F, 0x07, 0x86, 0xC3, 0x61, 0x98, 0xCC, 0xFE, 0x7F, 0x31, 0xD8,
  0x7C, 0x30, 0xFC, 0xFE, 0xC6, 0xC6, 0xC6, 0xFC, 0xFE, 0xC7, 0xC3, 0xC7,
  0xFE, 0xFC, 0x3E, 0x7F, 0xE1, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE1,
  0x7F, 0x3E, 0xF8, 0xFE, 0xC6, 0xC7, 0xC7, 0xC3, 0xC3, 0xC7, 0xC7, 0xCE,
  0xFE, 0xF8, 0xFE, 0xFE, 0xE0, 0xE0, 0xE0, 0xFE, 0xFE, 0xE0, 0xE0, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x0E, 0x1F, 0xFF, 0xF0, 0xE1, 0xC3, 0x87,
  0x00, 0x3F, 0x7F, 0xE2, 0xC0, 0xC0, 0xC0, 0xC7, 0xC7, 0xC7, 0xE7, 0x7F,
  0x3F, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xFF, 0xFF, 0xC7, 0xC7, 0xC7, 0xC7,
  0xC7, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF,
  0xFF, 0x7E, 0xFC, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x07, 0x1F, 0xFB, 0xC0,
  0xC7, 0xCE, 0xCC, 0xDC, 0xD8, 0xF0, 0xF8, 0xDC, 0xCE, 0xCE, 0xC7, 0xC7,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF,
  0x63, 0x39, 0x9C, 0xEA, 0xF7, 0x7B, 0xED, 0xF6, 0xDB, 0x61, 0xB0, 0xF8,
  0x7C, 0x30, 0xC3, 0xE3, 0xE3, 0xF3, 0xF3, 0xDB, 0xDB, 0xCF, 0xCF, 0xC7,
  0xC7, 0xC3, 0x3C, 0x7E, 0xE6, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0xE6,
  0x7E, 0x3C, 0xFC, 0xFE, 0xC7, 0xC3, 0xC3, 0xC7, 0xFE, 0xFC, 0xC0, 0xC0,
  0xC0, 0xC0, 0x3C, 0x7E, 0xE6, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0xE6,
  0x7E, 0x3C, 0x18, 0x1F, 0x07, 0xFC, 0xFE, 0xC6, 0xC6, 0xC7, 0xC6, 0xFE,
  0xFC, 0xCC, 0xC6, 0xC7, 0xC3, 0x3C, 0xFE, 0xE2, 0xC0, 0xE0, 0x7C, 0x3E,
  0x07, 0x07, 0x87, 0xFE, 0x7C, 0xFF, 0xFF, 0xC3, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7,
  0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xFE, 0x7C, 0xE1, 0xB0, 0xD8, 0xEC, 0x67,
  0x31, 0x98, 0xCC, 0x6C, 0x36, 0x0F, 0x07, 0x03, 0x80, 0xE1, 0xF0, 0xD8,
  0x6C, 0x36, 0xDB, 0x6D, 0xF6, 0xBF, 0x57, 0xB9, 0xDC, 0xEC, 0x60, 0x63,
  0xB9, 0x8D, 0xC7, 0xC1, 0xE0, 0xE0, 0x78, 0x7C, 0x37, 0x39, 0x98, 0xFC,
  0x30, 0xE1, 0xB1, 0xDC, 0xC6, 0x63, 0x60, 0xF0, 0x70, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xFE, 0xFE, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x70, 0x60,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0xFF, 0xC0, 0xE0, 0x60, 0x60, 0x70, 0x30, 0x30, 0x38, 0x18, 0x18, 0x1C,
  0x0C, 0x0C, 0x0E, 0x06, 0x06, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8F, 0xFF, 0x1C, 0x0F, 0x0F, 0xCE, 0x66, 0x3B, 0x08, 0xFF, 0xFF,
  0xC0, 0x4E, 0x30, 0x7C, 0xFC, 0x1B, 0xFF, 0xF8, 0xF1, 0xFF, 0x7E, 0xE0,
  0xE0, 0xE0, 0xE0, 0xFC, 0xFE, 0xE7, 0xE7, 0xE3, 0xE7, 0xE7, 0xFE, 0xFC,
  0x3F, 0x7E, 0xE0, 0xC0, 0xC0, 0xC0, 0xE0, 0x7F, 0x3F, 0x06, 0x0C, 0x18,
  0x37, 0xFF, 0xF1, 0xE3, 0xC7, 0x8F, 0x9F, 0xF7, 0xE0, 0x3C, 0x7E, 0xE6,
  0xC3, 0xFF, 0xFF, 0xC0, 0x7E, 0x3E, 0x1F, 0x3F, 0x30, 0x30, 0xFF, 0xFF,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x3F, 0xFF, 0x9E, 0x3C, 0x78,
  0xFF, 0xBF, 0x07, 0x1F, 0xFF, 0xE0, 0xE1, 0xC3, 0x87, 0x0F, 0xDF, 0xF9,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x60, 0x30, 0x30, 0x00, 0xF0, 0xF0, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x38, 0x1F, 0x1F, 0x0C, 0x18, 0x03, 0xF7, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xF1, 0xBF, 0x3C, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE7, 0xEE, 0xFC, 0xF8, 0xF8, 0xFC, 0xEE, 0xE6, 0xE7, 0xF0, 0xF0,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x38, 0x1F, 0x1F, 0xFE,
  0xFF, 0x9B, 0x9B, 0x9B, 0x9B, 0x83, 0x83, 0x83, 0xFD, 0xFF, 0x9F, 0x3E,
  0x7C, 0xF9, 0xF3, 0xE6, 0x3C, 0xFE, 0xE7, 0xC7, 0xC3, 0xC7, 0xC7, 0x7E,
  0x3C, 0xFC, 0xFE, 0xE7, 0xE7, 0xE3, 0xE7, 0xE7, 0xFE, 0xFC, 0xE0, 0xE0,
  0xE0, 0x3F, 0xFF, 0x9E, 0x3C, 0x78, 0xF1, 0xFF, 0x7E, 0x0C, 0x18, 0x30,
  0xFF, 0xFB, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0x3E, 0xFF, 0x87, 0x87,
  0xC1, 0xE1, 0xFF, 0x7C, 0x30, 0x30, 0x30, 0xFF, 0xFF, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x3F, 0x1F, 0xC7, 0x8F, 0x1E, 0x3C, 0x7C, 0xF9, 0xBF, 0x3E,
  0xE1, 0xB1, 0xD8, 0xCE, 0x63, 0x71, 0xB0, 0x78, 0x38, 0x1C, 0x00, 0xC1,
  0xE0, 0xF3, 0x69, 0xB5, 0xDB, 0xFD, 0xDC, 0xE6, 0x73, 0x00, 0x63, 0xB9,
  0x8F, 0x83, 0xC1, 0xC0, 0xF0, 0xDC, 0xE6, 0x63, 0x80, 0x63, 0xB9, 0xDC,
  0xC6, 0x63, 0x30, 0xF0, 0x78, 0x3C, 0x0C, 0x0E, 0x1E, 0x1E, 0x00, 0xFF,
  0xFC, 0x38, 0xE3, 0x86, 0x18, 0x7F, 0xFE, 0x1E, 0x3C, 0xE1, 0x83, 0x06,
  0x0C, 0x78, 0xF0, 0x60, 0xC1, 0x83, 0x07, 0x07, 0x8F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF1, 0xF0, 0x60, 0xC1, 0x83, 0x06, 0x07, 0x0E, 0x30, 0x60, 0xC1,
  0x83, 0x3E, 0x78, 0x39, 0xBF, 0xF1, 0xC0,
};

const GFXglyph UbuntuMono_Bold19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 12, 10, 3, -12 },
  { 6, 6, 5, 10, 2, -13 },
  { 10, 9, 12, 10, 0, -12 },
  { 24, 8, 15, 10, 1, -13 },
  { 39, 9, 12, 10, 0, -12 },
  { 53, 9, 12, 10, 0, -12 },
  { 67, 2, 6, 10, 4, -13 },
  { 69, 6, 16, 10, 2, -13 },
  { 81, 6, 16, 10, 2, -13 },
  { 93, 8, 7, 10, 1, -12 },
  { 100, 8, 8, 10, 1, -9 },
  { 108, 5, 6, 10, 2, -3 },
  { 112, 5, 2, 10, 2, -6 },
  { 114, 3, 3, 10, 3, -3 },
  { 116, 8, 16, 10, 1, -13 },
  { 132, 8, 12, 10, 1, -12 },
  { 144, 8, 12, 10, 1, -12 },
  { 156, 8, 12, 10, 1, -12 },
  { 168, 8, 12, 10, 1, -12 },
  { 180, 8, 12, 10, 1, -12 },
  { 192, 8, 12, 10, 1, -12 },
  { 204, 8, 12, 10, 1, -12 },
  { 216, 8, 12, 10, 1, -12 },
  { 228, 8, 12, 10, 1, -12 },
  { 240, 8, 12, 10, 1, -12 },
  { 252, 3, 9, 10, 3, -9 },
  { 256, 4, 12, 10, 2, -9 },
  { 262, 8, 8, 10, 1, -9 },
  { 270, 8, 6, 10, 1, -8 },
  { 276, 8, 8, 10, 1, -9 },
  { 284, 7, 12, 10, 1, -12 },
  { 295, 9, 15, 10, 0, -12 },
  { 312, 9, 12, 10, 0, -12 },
  { 326, 8, 12, 10, 1, -12 },
  { 338, 8, 12, 10, 1, -12 },
  { 350, 8, 12, 10, 1, -12 },
  { 362, 8, 12, 10, 1, -12 },
  { 374, 7, 12, 10, 1, -12 },
  { 385, 8, 12, 10, 1, -12 },
  { 397, 8, 12, 10, 1, -12 },
  { 409, 8, 12, 10, 1, -12 },
  { 421, 7, 12, 10, 1, -12 },
  { 432, 8, 12, 10, 1, -12 },
  { 444, 8, 12, 10, 1, -12 },
  { 456, 9, 12, 10, 0, -12 },
  { 470, 8, 12, 10, 1, -12 },
  { 482, 8, 12, 10, 1, -12 },
  { 494, 8, 12, 10, 1, -12 },
  { 506, 8, 15, 10, 1, -12 },
  { 521, 8, 12, 10, 1, -12 },
  { 533, 8, 12, 10, 1, -12 },
  { 545, 9, 12, 10, 0, -12 },
  { 559, 8, 12, 10, 1, -12 },
  { 571, 9, 12, 10, 0, -12 },
  { 585, 9, 12, 10, 0, -12 },
  { 599, 9, 12, 10, 0, -12 },
  { 613, 9, 12, 10, 0, -12 },
  { 627, 8, 12, 10, 1, -12 },
  { 639, 5, 16, 10, 2, -13 },
  { 649, 8, 16, 10, 1, -13 },
  { 665, 5, 16, 10, 2, -13 },
  { 675, 9, 6, 10, 0, -12 },
  { 682, 9, 2, 10, 0, 1 },
  { 685, 4, 3, 10, 3, -13 },
  { 687, 7, 9, 10, 1, -9 },
  { 695, 8, 13, 10, 1, -13 },
  { 708, 8, 9, 10, 1, -9 },
  { 717, 7, 13, 10, 1, -13 },
  { 729, 8, 9, 10, 1, -9 },
  { 738, 8, 13, 10, 1, -13 },
  { 751, 7, 12, 10, 1, -9 },
  { 762, 7, 13, 10, 1, -13 },
  { 774, 8, 13, 10, 1, -13 },
  { 787, 7, 16, 10, 1, -13 },
  { 801, 8, 13, 10, 1, -13 },
  { 814, 8, 13, 10, 1, -13 },
  { 827, 8, 9, 10, 1, -9 },
  { 836, 7, 9, 10, 1, -9 },
  { 844, 8, 9, 10, 1, -9 },
  { 853, 8, 12, 10, 1, -9 },
  { 865, 7, 12, 10, 1, -9 },
  { 876, 7, 9, 10, 2, -9 },
  { 884, 7, 9, 10, 1, -9 },
  { 892, 8, 12, 10, 1, -12 },
  { 904, 7, 9, 10, 1, -9 },
  { 912, 9, 9, 10, 0, -9 },
  { 923, 9, 9, 10, 0, -9 },
  { 934, 9, 9, 10, 0, -9 },
  { 945, 9, 12, 10, 0, -9 },
  { 959, 7, 9, 10, 1, -9 },
  { 967, 7, 16, 10, 1, -13 },
  { 981, 2, 16, 10, 4, -13 },
  { 985, 7, 16, 10, 1, -13 },
  { 999, 9, 3, 10, 0, -7 },
};

const GFXfont UbuntuMono_Bold19pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Bold19pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Bold19pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _UBUNTUMONO_BOLD19PT7B_H_
