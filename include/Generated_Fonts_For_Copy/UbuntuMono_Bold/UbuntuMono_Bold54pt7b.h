#ifndef _UBUNTUMONO_BOLD54PT7B_H_
#define _UBUNTUMONO_BOLD54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Bold.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Bold54pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE3,
  0xE1, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x8F, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0x1F, 0x00, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7,
  0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE,
  0x0F, 0xDF, 0x07, 0xEF, 0x83, 0xE7, 0xC1, 0xF3, 0xC0, 0x79, 0xE0, 0x3C,
  0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0x3E, 0x1F, 0x80, 0x3F, 0x0F,
  0xC0, 0x1F, 0x87, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xF0, 0x03, 0xE1,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0x87, 0xE0, 0x0F,
  0xC3, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xC3, 0xE0, 0x07, 0xC1, 0xF0,
  0x03, 0xE1, 0xF8, 0x01, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3E,
  0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE3, 0xFC, 0x03, 0xC7, 0xF0, 0x00, 0x8F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE4, 0x00, 0x1F, 0xDF, 0x80,
  0x7F, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x7C, 0xFF, 0x80, 0x1F, 0x3F, 0xF8,
  0x07, 0xC7, 0xDF, 0x00, 0xF8, 0xF1, 0xE0, 0x3E, 0x1E, 0x3E, 0x0F, 0x83,
  0xC7, 0xC1, 0xF0, 0x78, 0xF8, 0x7C, 0x0F, 0x1F, 0x1F, 0x01, 0xE3, 0xE3,
  0xE0, 0x3C, 0x78, 0xF8, 0x07, 0xDF, 0x3E, 0x00, 0xFF, 0xE7, 0xC0, 0x0F,
  0xF9, 0xF0, 0x00, 0xFE, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x3F, 0x80, 0x07, 0xCF, 0xF8, 0x01,
  0xF3, 0xFF, 0x80, 0x3E, 0x79, 0xF0, 0x0F, 0x8F, 0x1E, 0x03, 0xE3, 0xE3,
  0xC0, 0x7C, 0x7C, 0x78, 0x1F, 0x0F, 0x8F, 0x07, 0xC1, 0xF1, 0xE0, 0xF8,
  0x3E, 0x3C, 0x3E, 0x03, 0xC7, 0x8F, 0x80, 0x79, 0xF1, 0xF0, 0x0F, 0xFE,
  0x7C, 0x00, 0xFF, 0x9F, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7E, 0x1F, 0x80, 0x7E, 0x0F, 0xC0,
  0x3F, 0x03, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xF8, 0x03, 0xF1, 0xF8,
  0x01, 0xFD, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8,
  0x7C, 0x0F, 0xF8, 0x3F, 0x0F, 0xFE, 0x1F, 0x8F, 0xFF, 0x8F, 0xC7, 0xEF,
  0xE7, 0xC7, 0xE3, 0xF3, 0xE3, 0xE0, 0xFF, 0xF3, 0xF0, 0x3F, 0xF9, 0xF8,
  0x0F, 0xF8, 0xFC, 0x03, 0xFC, 0x7E, 0x01, 0xFE, 0x3F, 0x80, 0xFE, 0x1F,
  0xE1, 0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0x7E, 0x0F, 0xFF, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFD, 0xF3, 0xE7, 0xCF, 0x9F, 0x1E,
  0x00, 0x02, 0x00, 0x03, 0xC0, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x80,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x03, 0x80, 0x00, 0x60, 0x30, 0x00,
  0x1C, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0xE0, 0x01, 0xC0, 0x00,
  0x40, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x06, 0x0F, 0x83, 0x0F, 0x1F, 0x1E, 0x1F, 0x9E,
  0xFE, 0x7F, 0xBB, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0x80, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xF7, 0xE0,
  0x0F, 0xEF, 0xE0, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7E, 0x1F, 0x00,
  0x38, 0x38, 0x00, 0x20, 0x20, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x07, 0x81, 0xFC, 0x1F, 0xE3, 0xFE, 0x3F, 0xF3, 0xFF,
  0x3F, 0xF1, 0xFF, 0x1F, 0xF0, 0x7E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0xFC,
  0x3F, 0x8F, 0xF0, 0xFE, 0x0F, 0x80, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0x3F,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x1F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F,
  0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xF1, 0xFE, 0x3F, 0x80,
  0xFE, 0x7F, 0x01, 0xFC, 0xFC, 0x01, 0xFB, 0xF8, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x87, 0x0F, 0xFF, 0x1F, 0x1F, 0xFE, 0x3E, 0x3F,
  0xFC, 0x7E, 0x7F, 0xF8, 0xF8, 0xFF, 0xF1, 0xF1, 0xFF, 0xE1, 0xC3, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0xFE, 0xFC, 0x01, 0xF9, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE3, 0xFC,
  0x3F, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xCF,
  0xE0, 0x08, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x03, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xC3, 0xFE, 0x1E, 0x01,
  0xFC, 0x10, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xE0, 0xFF, 0x84,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xD0, 0x00, 0xFF, 0x78, 0x07, 0xFD,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFD, 0xFC,
  0x00, 0xFC, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x7E, 0x3F, 0x80, 0x7E, 0x1F,
  0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x81,
  0xFC, 0x1F, 0x80, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xDC, 0x03, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF3, 0xE0,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFB, 0xFC, 0x1F, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x0F, 0xCF,
  0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0xBF, 0x00, 0x7F, 0x7E, 0x00, 0xFC, 0xFE,
  0x01, 0xF9, 0xFC, 0x07, 0xF1, 0xFE, 0x1F, 0xE3, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x9F, 0xE0, 0xFF,
  0x3F, 0x80, 0xFE, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3,
  0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0x87, 0xF8, 0x7F, 0x0F, 0xFD, 0xFC, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0xC1, 0xFC,
  0xFF, 0xC7, 0xF0, 0x7F, 0xCF, 0xC0, 0x3F, 0x9F, 0x80, 0x3F, 0x7E, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x3F, 0xEF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0x80, 0xFE, 0x7E, 0x01, 0xFC, 0xFC,
  0x01, 0xFB, 0xF8, 0x03, 0xF7, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xEF, 0xC0,
  0x1F, 0xDF, 0xC0, 0x3F, 0xBF, 0xE0, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x1F, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0x1F, 0x00, 0x07, 0xC0, 0xFE, 0x1F, 0xF1, 0xFF, 0x1F,
  0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0xFE, 0x1F, 0xF1, 0xFF, 0x1F,
  0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0x7F, 0x01, 0xF0, 0x3E, 0x03,
  0xE0, 0x7C, 0x3F, 0xCF, 0xF8, 0x7F, 0x07, 0xC0, 0x70, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x78, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x81,
  0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x20, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xFE,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xDE, 0x07, 0xFA, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x7F, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00,
  0xFE, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xE0, 0xFC, 0x1F, 0x80, 0x7E, 0x1F,
  0x00, 0x3E, 0x3E, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C,
  0x07, 0xFF, 0x7C, 0x1F, 0xFF, 0x7C, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFE, 0x1F, 0xF8, 0xFC, 0x1F, 0xF8,
  0xFC, 0x1F, 0xF8, 0xFC, 0x1F, 0xF8, 0xFC, 0x1F, 0xF8, 0xFC, 0x1F, 0xF8,
  0xFC, 0x1F, 0xF8, 0xFC, 0x1F, 0xF8, 0xFC, 0x1F, 0xF8, 0xFE, 0x1F, 0xF8,
  0x7F, 0xFF, 0x78, 0x7F, 0xFF, 0x7C, 0x3F, 0xFF, 0x7C, 0x1F, 0xFF, 0x7C,
  0x0F, 0xFF, 0x3E, 0x03, 0xF8, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x06, 0x03, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x80, 0x01,
  0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF8, 0xFC,
  0x00, 0x3F, 0x1F, 0x80, 0x07, 0xC3, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x3F,
  0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xF8, 0x1F, 0xC0, 0x3F, 0x01, 0xF8,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xF0, 0x07, 0xF0,
  0xFE, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0xC3, 0xF0, 0x01, 0xF8, 0xFE, 0x00,
  0x3F, 0x9F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xE0, 0xFF, 0x3F, 0x80, 0xFE, 0xFE, 0x03,
  0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0xFC, 0xFE, 0x07, 0xF3,
  0xF8, 0x3F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0xFE, 0x07, 0xFB, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFE, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xF8, 0x1E, 0x1F, 0xE0,
  0x02, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0,
  0x02, 0x1F, 0xF0, 0x1E, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xF0,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x3F, 0x87, 0xFC, 0x7F, 0x03, 0xFC, 0xFE, 0x03, 0xF9,
  0xFC, 0x07, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0xDF,
  0xC0, 0x1F, 0xBF, 0x80, 0x3F, 0x7F, 0x00, 0x7E, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xEF, 0xE0, 0x0F, 0xDF, 0xC0,
  0x3F, 0xBF, 0x80, 0x7F, 0x7F, 0x00, 0xFE, 0xFE, 0x03, 0xF9, 0xFC, 0x07,
  0xF3, 0xF8, 0x1F, 0xE7, 0xF0, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x8F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xF8, 0x1E, 0x1F, 0xE0, 0x04, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7E, 0x00,
  0x7F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00,
  0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0xC0, 0x7F, 0x1F, 0xF0,
  0x7F, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xF8, 0xFE, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE1, 0x00, 0x3F, 0x8F,
  0x03, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0xFE, 0xFE, 0x01,
  0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x07,
  0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0xFE, 0x3F,
  0x80, 0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0xFE, 0xFF, 0x00, 0xFE, 0x7F, 0x80, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F,
  0xC0, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07,
  0xF8, 0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x01,
  0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x3F, 0x87, 0xF0,
  0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F,
  0x83, 0xFC, 0x7F, 0xC3, 0xFE, 0x3E, 0xF1, 0xEF, 0x9F, 0x78, 0xF7, 0xCF,
  0xBC, 0xFB, 0xE7, 0xCF, 0x79, 0xF3, 0xE7, 0xBC, 0xF9, 0xF3, 0xFE, 0x7C,
  0xF9, 0xFF, 0x3E, 0x7C, 0x7F, 0x1F, 0x3E, 0x3F, 0x8F, 0x9F, 0x1F, 0xC7,
  0xCF, 0x87, 0xC3, 0xE7, 0xC3, 0xE1, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00,
  0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC1, 0xFF, 0xEF, 0x83, 0xFF, 0xDF, 0x87, 0xFF, 0x9F,
  0x0F, 0xFF, 0x3F, 0x1F, 0xFE, 0x3E, 0x3F, 0xFC, 0x7E, 0x7F, 0xF8, 0x7C,
  0xFF, 0xF0, 0xFD, 0xFF, 0xE0, 0xFB, 0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0xFF, 0x07, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE,
  0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xE0, 0x03,
  0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFD, 0xFC, 0x00, 0x7E, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xE7, 0xE0,
  0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0xFE, 0x7F,
  0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3,
  0xFC, 0x1F, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFC,
  0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xEF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF,
  0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0xFF, 0x07, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE,
  0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xE0, 0x03,
  0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFD, 0xFC, 0x00, 0x7E, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xF7, 0xE0,
  0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0xFE, 0x7F,
  0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3,
  0xFC, 0x1F, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0x87, 0xFC, 0x7F, 0x03,
  0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F,
  0xCF, 0xE0, 0x3F, 0x9F, 0xC0, 0x7F, 0x3F, 0x81, 0xFE, 0x7F, 0x0F, 0xFC,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0,
  0x3F, 0x9F, 0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x7F, 0x00, 0xFE, 0xFE, 0x00,
  0xFF, 0xFC, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xE0, 0x3C,
  0x3F, 0x80, 0x18, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF9, 0x00, 0x0F,
  0xF3, 0xC0, 0x3F, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFD, 0xFC, 0x07, 0xF3, 0xFC,
  0x1F, 0xE7, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xF7, 0xE0, 0x03, 0xF3, 0xF8,
  0x03, 0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x3F, 0x00, 0x7E, 0x1F,
  0x80, 0x3F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC1, 0xF8, 0x0F, 0xC0,
  0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x83, 0xF8, 0x0F, 0xC1, 0xF8,
  0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F,
  0x00, 0x3F, 0x1F, 0x80, 0x0F, 0x8F, 0xC0, 0x07, 0xEF, 0xC0, 0x03, 0xF7,
  0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x00,
  0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC3, 0xE1, 0xF3, 0xE1, 0xF0, 0xF9, 0xF1,
  0xFC, 0x7C, 0xF8, 0xFE, 0x3E, 0x7C, 0x7F, 0x1F, 0x3E, 0x7F, 0xCF, 0x9F,
  0x3F, 0xE7, 0xCF, 0x9E, 0xF3, 0xE7, 0xCF, 0x79, 0xF3, 0xEF, 0x9E, 0xF9,
  0xF7, 0x8F, 0x7C, 0xFB, 0xC7, 0xBE, 0x7F, 0xE1, 0xFF, 0x3F, 0xE0, 0xFF,
  0x8F, 0xF0, 0x7F, 0x87, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07,
  0xF0, 0xFE, 0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x00, 0xFF,
  0x00, 0x3F, 0xBF, 0x80, 0x3F, 0x8F, 0xE0, 0x1F, 0x87, 0xF0, 0x1F, 0xC1,
  0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x87, 0xE0, 0x1F, 0xC7, 0xF0,
  0x07, 0xF3, 0xF0, 0x03, 0xFB, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xCF, 0xC0, 0x1F,
  0xC7, 0xF0, 0x0F, 0xE1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x87,
  0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE3, 0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xFD,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xDF, 0xC0, 0x0F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF1, 0xFC,
  0x03, 0xF0, 0xFE, 0x03, 0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0xC1, 0xFC, 0x07,
  0xE0, 0xFE, 0x03, 0xF8, 0x7E, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x3F, 0x00,
  0x3F, 0xBF, 0x80, 0x0F, 0xDF, 0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x1F, 0xCF, 0xC0,
  0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0xFF, 0x03,
  0xF8, 0x3F, 0x80, 0xFF, 0x1F, 0xC0, 0x1F, 0xCF, 0xF0, 0x03, 0xFB, 0xF8,
  0x00, 0xFE, 0x1E, 0x00, 0x1E, 0x01, 0x00, 0x06, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x10, 0x01, 0xC0, 0x3E, 0x07, 0xF0,
  0x7F, 0xC7, 0xFE, 0x1F, 0xF0, 0x7E, 0x01, 0xE0, 0x04, 0x03, 0xFE, 0x00,
  0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xE0, 0x80, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0x7F, 0x01, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x3F, 0xFC, 0x00,
  0x0E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0xFF, 0x03,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xEF, 0xF0, 0x7F, 0xBF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0xFE, 0xFE, 0x07, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xFC, 0x02, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x47, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x3F, 0x9F, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xE1, 0xFF, 0xFE, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0x7F, 0x81, 0xFB, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x07, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F, 0x80, 0xFE,
  0xFE, 0x00, 0xFD, 0xFC, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFC,
  0x01, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x0F, 0xF0, 0x3C, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x07,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFC,
  0x1F, 0xDF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xF7, 0xF8, 0x3F, 0xDF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x03, 0xF9, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x60,
  0x03, 0xF9, 0xE0, 0x3F, 0xE7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x0E, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF, 0x83, 0xFD, 0xFC,
  0x0F, 0xEF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01,
  0xFC, 0x01, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x02, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF,
  0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF1,
  0x00, 0xFE, 0x7C, 0x3F, 0xCF, 0xFF, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF,
  0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFC, 0x00, 0x0E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0xBF,
  0x81, 0xFE, 0x7F, 0x03, 0xF8, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0xC3, 0xF8,
  0x7F, 0x07, 0xF1, 0xFC, 0x0F, 0xE7, 0xF0, 0x1F, 0xDF, 0xC0, 0x3F, 0xFF,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8,
  0x07, 0xF7, 0xF8, 0x0F, 0xE7, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x87, 0xF0,
  0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x0F, 0xE7,
  0xF0, 0x1F, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0xC0, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x02, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xC3, 0xF1, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0x1F, 0xFC, 0x7E, 0x1F, 0xF8, 0x7C,
  0x3F, 0xF0, 0xF8, 0x7F, 0xE1, 0xF0, 0xFF, 0xC3, 0xE1, 0xFF, 0x87, 0xC3,
  0xFF, 0x0F, 0x87, 0xFE, 0x1F, 0x0F, 0xFC, 0x3E, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7C, 0x0F, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xF8, 0x3F, 0xDF, 0xC0, 0xFE, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F, 0x80, 0xFE, 0xFE, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFB, 0xF8, 0x0F, 0xE7, 0xF8, 0x3F, 0xC7,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xE0, 0xFF,
  0xBF, 0x80, 0xFE, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFF, 0x07, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFE, 0x0F, 0xE7, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF7, 0xFC,
  0x1F, 0xDF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x7F, 0x7F, 0x83, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x3F, 0x9F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFE, 0x00,
  0x6F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF1, 0xFC, 0x07, 0x8F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x80, 0x07, 0xF7, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE1, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x00,
  0x70, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x38, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xF0, 0xFE, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xDF, 0xC0, 0xFE,
  0xFF, 0x07, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0x1F, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xDF, 0x80, 0x0F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8,
  0x03, 0xF8, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFC, 0x0F,
  0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x3F, 0x80,
  0x7F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xEF, 0xE0, 0x03, 0xF7, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE1, 0xF0, 0xFF, 0xF0, 0xF8, 0x7F,
  0xF8, 0x7E, 0x3F, 0xFC, 0x7F, 0x1F, 0xBE, 0x3F, 0x8F, 0x9F, 0x1F, 0xC7,
  0xCF, 0x8F, 0xF3, 0xE7, 0xCF, 0xF9, 0xF3, 0xE7, 0xFC, 0xF9, 0xF3, 0xDE,
  0x7C, 0xFB, 0xEF, 0xBC, 0x3D, 0xE7, 0xDE, 0x1F, 0xF1, 0xFF, 0x0F, 0xF8,
  0xFF, 0x87, 0xF8, 0x7F, 0xC3, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7E,
  0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x3F, 0x83, 0xF8, 0x1F, 0x81, 0xFC, 0x1F,
  0xC0, 0x7F, 0x1F, 0xC0, 0x1F, 0xCF, 0xC0, 0x07, 0xEF, 0xE0, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03,
  0xF7, 0xF0, 0x03, 0xF3, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xF8, 0x3F, 0x81,
  0xF8, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x7F, 0x00, 0x7F, 0x3F, 0x80,
  0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7E, 0x1F, 0x80, 0xFE, 0x1F, 0xC0,
  0xFE, 0x1F, 0xC0, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xE1,
  0xFC, 0x0F, 0xE1, 0xF8, 0x07, 0xF1, 0xF8, 0x07, 0xF3, 0xF8, 0x03, 0xF3,
  0xF0, 0x03, 0xFB, 0xF0, 0x03, 0xFB, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x41, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xFE, 0x00, 0x7F,
  0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x0C, 0x07, 0xF8, 0x07,
  0xC7, 0xFF, 0x03, 0xE7, 0xFF, 0xC3, 0xF7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xF9, 0xF8, 0xFF, 0xF9, 0xF8, 0x1F, 0xFC, 0xF8, 0x07, 0xFC, 0x0C, 0x00,
  0xF8, 0x00,
};

const GFXglyph UbuntuMono_Bold54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 9, 34, 27, 9, -33 },
  { 40, 17, 15, 27, 5, -37 },
  { 72, 25, 33, 27, 1, -33 },
  { 176, 23, 43, 27, 2, -38 },
  { 300, 27, 35, 27, 0, -34 },
  { 419, 25, 34, 27, 1, -34 },
  { 526, 7, 16, 27, 10, -37 },
  { 540, 18, 47, 27, 5, -38 },
  { 646, 17, 47, 27, 5, -38 },
  { 746, 23, 22, 27, 2, -33 },
  { 810, 23, 24, 27, 2, -25 },
  { 879, 12, 19, 27, 7, -9 },
  { 908, 15, 7, 27, 6, -17 },
  { 922, 9, 10, 27, 9, -9 },
  { 934, 21, 47, 27, 3, -38 },
  { 1058, 23, 35, 27, 2, -34 },
  { 1159, 22, 33, 27, 3, -33 },
  { 1250, 23, 34, 27, 2, -34 },
  { 1348, 22, 35, 27, 2, -34 },
  { 1445, 25, 33, 27, 1, -33 },
  { 1549, 22, 34, 27, 2, -33 },
  { 1643, 23, 34, 27, 2, -33 },
  { 1741, 21, 33, 27, 3, -33 },
  { 1828, 23, 35, 27, 2, -34 },
  { 1929, 23, 34, 27, 2, -34 },
  { 2027, 9, 26, 27, 9, -25 },
  { 2057, 12, 35, 27, 6, -25 },
  { 2110, 23, 24, 27, 2, -26 },
  { 2179, 23, 17, 27, 2, -22 },
  { 2228, 23, 24, 27, 2, -26 },
  { 2297, 19, 35, 27, 4, -34 },
  { 2381, 24, 41, 27, 1, -34 },
  { 2504, 27, 33, 27, 0, -33 },
  { 2616, 22, 35, 27, 3, -34 },
  { 2713, 24, 35, 27, 1, -34 },
  { 2818, 23, 34, 27, 3, -33 },
  { 2916, 22, 33, 27, 3, -33 },
  { 3007, 21, 33, 27, 3, -33 },
  { 3094, 24, 35, 27, 1, -34 },
  { 3199, 23, 33, 27, 2, -33 },
  { 3294, 21, 33, 27, 3, -33 },
  { 3381, 22, 34, 27, 2, -33 },
  { 3475, 24, 33, 27, 2, -33 },
  { 3574, 21, 33, 27, 4, -33 },
  { 3661, 25, 33, 27, 1, -33 },
  { 3765, 23, 33, 27, 2, -33 },
  { 3860, 25, 35, 27, 1, -34 },
  { 3970, 22, 34, 27, 3, -34 },
  { 4064, 25, 44, 27, 1, -34 },
  { 4202, 23, 34, 27, 3, -34 },
  { 4300, 23, 35, 27, 2, -34 },
  { 4401, 25, 33, 27, 1, -33 },
  { 4505, 23, 34, 27, 2, -33 },
  { 4603, 25, 33, 27, 1, -33 },
  { 4707, 25, 33, 27, 1, -33 },
  { 4811, 25, 33, 27, 1, -33 },
  { 4915, 25, 33, 27, 1, -33 },
  { 5019, 23, 33, 27, 2, -33 },
  { 5114, 15, 47, 27, 6, -38 },
  { 5203, 22, 47, 27, 3, -38 },
  { 5333, 15, 47, 27, 6, -38 },
  { 5422, 26, 18, 27, 1, -33 },
  { 5481, 27, 6, 27, 0, 3 },
  { 5502, 12, 10, 27, 8, -37 },
  { 5517, 22, 27, 27, 2, -26 },
  { 5592, 22, 39, 27, 3, -38 },
  { 5700, 23, 27, 27, 2, -26 },
  { 5778, 21, 39, 27, 2, -38 },
  { 5881, 23, 27, 27, 2, -26 },
  { 5959, 25, 38, 27, 2, -38 },
  { 6078, 22, 36, 27, 2, -26 },
  { 6177, 21, 38, 27, 3, -38 },
  { 6277, 23, 38, 27, 2, -37 },
  { 6387, 19, 47, 27, 3, -37 },
  { 6499, 23, 38, 27, 3, -38 },
  { 6609, 23, 38, 27, 2, -37 },
  { 6719, 23, 26, 27, 2, -26 },
  { 6794, 21, 26, 27, 3, -26 },
  { 6863, 23, 27, 27, 2, -26 },
  { 6941, 22, 35, 27, 3, -26 },
  { 7038, 22, 35, 27, 2, -26 },
  { 7135, 20, 26, 27, 5, -26 },
  { 7200, 21, 27, 27, 3, -26 },
  { 7271, 23, 33, 27, 2, -32 },
  { 7366, 21, 26, 27, 3, -25 },
  { 7435, 25, 25, 27, 1, -25 },
  { 7514, 25, 25, 27, 1, -25 },
  { 7593, 25, 25, 27, 1, -25 },
  { 7672, 24, 35, 27, 1, -25 },
  { 7777, 20, 25, 27, 4, -25 },
  { 7840, 21, 47, 27, 3, -38 },
  { 7964, 7, 47, 27, 10, -38 },
  { 8006, 21, 47, 27, 3, -38 },
  { 8130, 25, 10, 27, 1, -19 },
};

const GFXfont UbuntuMono_Bold54pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Bold54pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Bold54pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _UBUNTUMONO_BOLD54PT7B_H_
