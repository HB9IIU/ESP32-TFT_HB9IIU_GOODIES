#ifndef _UBUNTUMONO_BOLD62PT7B_H_
#define _UBUNTUMONO_BOLD62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Bold.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Bold62pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE,
  0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFF, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC1, 0xFC, 0x7F, 0xDF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFC, 0x7F, 0x07, 0xC0, 0xFF, 0x87, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFD, 0xFC,
  0x1F, 0xEF, 0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0x9F, 0xC1, 0xFC,
  0xFE, 0x0F, 0xE7, 0xF0, 0x3F, 0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0x87, 0xC0,
  0x7C, 0x3E, 0x03, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF0, 0x7F, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x7F,
  0x0F, 0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F,
  0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0x0F, 0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F,
  0x80, 0x07, 0xE0, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x03, 0xF8, 0x3F, 0x00,
  0x1F, 0x83, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x87, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF8, 0x3F, 0x00,
  0x1F, 0x83, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F,
  0x07, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xC3, 0xFE, 0x01, 0xF0, 0x7F, 0x80, 0x02, 0x1F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0xE0, 0x00, 0xFF, 0x9F, 0x80, 0x3F, 0xE7,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0xFC, 0xFF, 0xE0, 0x03, 0xF1, 0xFF, 0xC0, 0x07, 0xC7,
  0xFF, 0xC0, 0x1F, 0x8F, 0x9F, 0x80, 0x7E, 0x1F, 0x1F, 0x00, 0xF8, 0x3E,
  0x3E, 0x03, 0xF0, 0x7C, 0x3E, 0x0F, 0xC0, 0xF8, 0x7C, 0x1F, 0x01, 0xF1,
  0xF8, 0x7E, 0x03, 0xE3, 0xE1, 0xF8, 0x07, 0xC7, 0xC3, 0xE0, 0x0F, 0x8F,
  0x8F, 0xC0, 0x1F, 0xFF, 0x3F, 0x00, 0x1F, 0xFC, 0x7C, 0x00, 0x3F, 0xF9,
  0xF8, 0x00, 0x3F, 0xE7, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x01, 0xF3, 0xFE, 0x00, 0x07, 0xEF,
  0xFC, 0x00, 0x1F, 0x9F, 0xFC, 0x00, 0x3E, 0x7F, 0xFC, 0x00, 0xFC, 0xF9,
  0xF8, 0x03, 0xF1, 0xF1, 0xF0, 0x07, 0xC3, 0xE3, 0xE0, 0x1F, 0x8F, 0x87,
  0xC0, 0x7E, 0x1F, 0x0F, 0x80, 0xF8, 0x3E, 0x1F, 0x03, 0xF0, 0x7C, 0x3E,
  0x0F, 0xC0, 0x7C, 0x7C, 0x1F, 0x00, 0xF8, 0xF8, 0x7E, 0x01, 0xF3, 0xF1,
  0xF8, 0x03, 0xFF, 0xE3, 0xE0, 0x03, 0xFF, 0x8F, 0xC0, 0x07, 0xFE, 0x3F,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0x87, 0xF0, 0x03, 0xF8, 0x3F, 0x80,
  0x1F, 0xC0, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F,
  0x83, 0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0xBF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xC1, 0xF8, 0x0F, 0xFC, 0x0F, 0xC0, 0xFF, 0xF0, 0x7E, 0x0F,
  0xFF, 0xC3, 0xF0, 0xFF, 0xFF, 0x1F, 0x87, 0xF7, 0xFC, 0xFC, 0x7F, 0x1F,
  0xEF, 0xE3, 0xF8, 0x7F, 0xFE, 0x1F, 0x81, 0xFF, 0xF1, 0xFC, 0x07, 0xFF,
  0x8F, 0xE0, 0x1F, 0xF8, 0x7F, 0x00, 0x7F, 0xC3, 0xF8, 0x03, 0xFC, 0x1F,
  0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0xC3, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFE, 0x7F, 0x07, 0xFF, 0xE3,
  0xF8, 0x1F, 0xFC, 0x1F, 0xE0, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x7E, 0x7C,
  0x7C, 0x7C, 0x7C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0x01,
  0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xE0, 0x00,
  0xFC, 0x00, 0x07, 0x80, 0x00, 0x10, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x3F,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F,
  0x80, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x01, 0x81, 0xF8, 0x10, 0xF0, 0xF8, 0x3C, 0xFC, 0x7C, 0x7E, 0x7F, 0xBE,
  0xFF, 0x3F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x07,
  0xF7, 0xF0, 0x07, 0xFB, 0xFC, 0x03, 0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0xC1,
  0xFE, 0x1F, 0xC0, 0x3E, 0x0F, 0x80, 0x0F, 0x03, 0x80, 0x01, 0x00, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xC0, 0x3F, 0xC1, 0xFF, 0x07, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0xC7,
  0xFF, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0,
  0x7E, 0x0F, 0xF8, 0xFF, 0xC3, 0xFE, 0x0F, 0xF0, 0x1F, 0x00, 0x60, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x07, 0xF1, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xC7, 0xF0, 0x7C, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x3F, 0x80,
  0x3F, 0x8F, 0xF0, 0x07, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE7,
  0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFE, 0x0E, 0x0F, 0xFF, 0xC3, 0xE1, 0xFF, 0xF8, 0xFE, 0x3F, 0xFF,
  0x1F, 0xC7, 0xFF, 0xE3, 0xF8, 0xFF, 0xFC, 0x7F, 0x1F, 0xFF, 0x87, 0xC3,
  0xFF, 0xF0, 0x70, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFD, 0xFC,
  0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x3F,
  0x9F, 0xE0, 0x0F, 0xF1, 0xFC, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xF7, 0xF8, 0x03,
  0xE3, 0xFC, 0x01, 0x81, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xF0, 0x7F, 0xE0, 0xF0, 0x07, 0xF8, 0x38,
  0x00, 0xFF, 0x04, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xF8,
  0x1F, 0xF8, 0x70, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x40, 0x01, 0xFF, 0x3C,
  0x01, 0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0xFE,
  0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x3F, 0x80,
  0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x03,
  0xF8, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x3F,
  0x80, 0x3F, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFE, 0x78, 0x03, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xEF, 0xF0, 0x1F, 0xF7, 0xF0, 0x07, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xFB, 0xF8, 0x03, 0xFD, 0xFE,
  0x01, 0xFE, 0xFF, 0x01, 0xFE, 0x3F, 0xE1, 0xFF, 0x1F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0xF8,
  0x3F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0x3F, 0xCF, 0xF0, 0x07, 0xF9,
  0xFC, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xE7, 0xF8, 0x03, 0xF8, 0x7F, 0x00,
  0x7F, 0x0F, 0xF0, 0x1F, 0xE1, 0xFF, 0x87, 0xF8, 0x1F, 0xFD, 0xFE, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xFB, 0xFF, 0xC1, 0xFE, 0x1F, 0xFC, 0x7F,
  0x80, 0xFF, 0xCF, 0xE0, 0x07, 0xF9, 0xFC, 0x00, 0x7F, 0x7F, 0x80, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8,
  0x00, 0xFE, 0x7F, 0x80, 0x3F, 0xCF, 0xFC, 0x1F, 0xF8, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF1,
  0xFF, 0x0F, 0xF8, 0xFF, 0x01, 0xFE, 0x7F, 0x00, 0xFF, 0x7F, 0x80, 0x3F,
  0xBF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x1F, 0xDF, 0xF0, 0x1F, 0xEF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x00, 0xFE, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x07, 0xF1, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xC7, 0xF0, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x83, 0xF8,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xE3, 0xF8, 0x3E,
  0x00, 0x03, 0xE0, 0x1F, 0xC0, 0xFF, 0x87, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1,
  0xFF, 0xC7, 0xFF, 0x0F, 0xF8, 0x1F, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0x87, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF,
  0xC3, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF8, 0x1F,
  0xC3, 0xFE, 0x3F, 0xF0, 0x7F, 0x81, 0xFC, 0x07, 0xE0, 0x1C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x30, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x3F,
  0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x8F, 0x81, 0xFF, 0x18, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0x83, 0xFC,
  0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE3, 0xF0,
  0x00, 0x7F, 0x3F, 0x00, 0x07, 0xF3, 0xE0, 0x1F, 0xFF, 0x7E, 0x07, 0xFF,
  0xF7, 0xE0, 0xFF, 0xFF, 0x7E, 0x1F, 0xFF, 0xF7, 0xC1, 0xFF, 0xFF, 0x7C,
  0x3F, 0xFF, 0xFF, 0xC3, 0xFC, 0x7F, 0xFC, 0x3F, 0x87, 0xFF, 0xC3, 0xF0,
  0x7F, 0xFC, 0x7F, 0x07, 0xFF, 0xC7, 0xF0, 0x7F, 0xFC, 0x7F, 0x07, 0xFF,
  0xC7, 0xF0, 0x7F, 0xFC, 0x7F, 0x07, 0xFF, 0xC7, 0xF0, 0x7F, 0xFC, 0x7F,
  0x07, 0xFF, 0xC3, 0xF0, 0x7F, 0xFC, 0x3F, 0x87, 0xFF, 0xC3, 0xFC, 0x7F,
  0x7C, 0x1F, 0xFF, 0xF7, 0xC1, 0xFF, 0xFF, 0x7E, 0x0F, 0xFF, 0xF7, 0xE0,
  0x7F, 0xFF, 0x7E, 0x03, 0xFF, 0xF3, 0xF0, 0x07, 0xFE, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x0C, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x7F, 0x7F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x01,
  0xFC, 0x7F, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xF0,
  0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0, 0xFF,
  0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xC0, 0x07,
  0xF1, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF3,
  0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFC, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x8F, 0xF0, 0x1F, 0xF3, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x3F,
  0xC0, 0x1F, 0xCF, 0xF0, 0x07, 0xF3, 0xFC, 0x01, 0xFC, 0xFF, 0x00, 0x7F,
  0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x1F, 0xE3, 0xFC, 0x0F, 0xF8, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xF0, 0x1F, 0xFB, 0xFC, 0x01, 0xFE,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x7F, 0xEF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0x01, 0xF0, 0xFF, 0x80, 0x0E, 0x3F, 0xE0, 0x00, 0x87, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x04, 0x3F, 0xF0, 0x01, 0xC3, 0xFF, 0x80, 0xF8, 0x3F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x00, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x8F, 0xF0, 0x7F, 0xE3, 0xFC, 0x07, 0xFC, 0xFF, 0x00, 0xFF,
  0x3F, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC, 0x01, 0xFE, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x3F, 0xEF, 0xF0, 0x0F, 0xF3,
  0xFC, 0x0F, 0xFC, 0xFF, 0x0F, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x9F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x87,
  0xFF, 0x01, 0xE0, 0xFF, 0x80, 0x04, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xF7, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xDF, 0xF0, 0x07, 0xF9,
  0xFE, 0x00, 0xFF, 0x3F, 0xE0, 0x1F, 0xE3, 0xFF, 0x03, 0xFC, 0x3F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x20, 0x01,
  0xFE, 0x38, 0x03, 0xFE, 0x7E, 0x07, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0xFE, 0x00, 0x7F, 0xDF, 0xC0, 0x0F, 0xF3, 0xF8, 0x03, 0xFE, 0x7F,
  0x00, 0x7F, 0x8F, 0xE0, 0x1F, 0xF1, 0xFC, 0x07, 0xFC, 0x3F, 0x80, 0xFF,
  0x07, 0xF0, 0x3F, 0xE0, 0xFE, 0x07, 0xF8, 0x1F, 0xC1, 0xFE, 0x03, 0xF8,
  0x7F, 0xC0, 0x7F, 0x0F, 0xF0, 0x0F, 0xE3, 0xFC, 0x01, 0xFC, 0xFF, 0x00,
  0x3F, 0xBF, 0xE0, 0x07, 0xF7, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x01,
  0xFD, 0xFF, 0x80, 0x3F, 0x9F, 0xF8, 0x07, 0xF1, 0xFF, 0x00, 0xFE, 0x1F,
  0xF0, 0x1F, 0xC1, 0xFF, 0x03, 0xF8, 0x1F, 0xF0, 0x7F, 0x03, 0xFE, 0x0F,
  0xE0, 0x3F, 0xE1, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x7F, 0xC7, 0xF0, 0x07,
  0xFC, 0xFE, 0x00, 0xFF, 0x9F, 0xC0, 0x0F, 0xFB, 0xF8, 0x01, 0xFF, 0x7F,
  0x00, 0x1F, 0xEF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0x80, 0x0F,
  0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0xC3,
  0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x87, 0xFC,
  0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0x83, 0xFF, 0x0F, 0xBC, 0x3E,
  0xF8, 0x7D, 0xF1, 0xF7, 0xC3, 0xEF, 0x8F, 0xBE, 0x1F, 0x7C, 0xFD, 0xF1,
  0xF9, 0xF7, 0xCF, 0x8F, 0xCF, 0xBE, 0x7E, 0x7E, 0x7D, 0xF3, 0xF3, 0xF1,
  0xFF, 0x1F, 0x9F, 0x8F, 0xF8, 0xFC, 0xFC, 0x7F, 0xC7, 0xE7, 0xE3, 0xFE,
  0x3F, 0x3F, 0x0F, 0xE1, 0xF9, 0xF8, 0x7F, 0x0F, 0xCF, 0xC3, 0xF8, 0x7E,
  0x7E, 0x1F, 0x83, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xFC,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFC, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0xFB,
  0xF0, 0xFF, 0xFD, 0xFC, 0x7F, 0xFE, 0x7E, 0x3F, 0xFF, 0x3F, 0x9F, 0xFF,
  0x8F, 0xCF, 0xFF, 0xC7, 0xE7, 0xFF, 0xE1, 0xFB, 0xFF, 0xF0, 0xFD, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xF8,
  0x3F, 0xE1, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xCF, 0xF0, 0x07, 0xF9,
  0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xEF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xF7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x9F, 0xE0, 0x0F, 0xF3, 0xFC,
  0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x87, 0xFC, 0x1F, 0xF0, 0x7F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xCF, 0xF0, 0x1F, 0xFB, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFB, 0xFF, 0x07, 0xFE, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xF8, 0x3F, 0xE1,
  0xFE, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xCF, 0xF0, 0x07, 0xF9, 0xFC, 0x00,
  0x7F, 0x3F, 0x80, 0x0F, 0xEF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x01, 0xFE, 0xFE, 0x00, 0x3F, 0x9F, 0xE0, 0x0F, 0xF3, 0xFC, 0x01, 0xFE,
  0x3F, 0xC0, 0x7F, 0x87, 0xFC, 0x1F, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x78, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x3F, 0xC1, 0xFF,
  0xC7, 0xF8, 0x0F, 0xF8, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xF3, 0xFC,
  0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xCF, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0xFF,
  0x3F, 0xC0, 0x1F, 0xE7, 0xF8, 0x07, 0xF8, 0xFF, 0x01, 0xFF, 0x1F, 0xE0,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0x0F,
  0xF0, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x0F,
  0xF0, 0x3F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x07,
  0xF8, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x0F, 0xF3, 0xFC, 0x01, 0xFE, 0x7F,
  0x80, 0x1F, 0xEF, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xF8, 0x07,
  0x81, 0xFE, 0x00, 0x30, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x80, 0x01,
  0xFE, 0x38, 0x00, 0x7F, 0xC7, 0xE0, 0x1F, 0xF9, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xBF, 0x80, 0x0F, 0xE7,
  0xF0, 0x01, 0xFC, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x0F, 0xF3, 0xFC, 0x01,
  0xFE, 0x3F, 0xE0, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFE,
  0xFE, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xF9, 0xFE,
  0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFE, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00,
  0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC1, 0xFC, 0x01, 0xFC,
  0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0,
  0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xC1, 0xFC,
  0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x7E, 0x3F, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7E,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x3F, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E,
  0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xFC,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x3F, 0x07, 0xC1, 0xF9, 0xF8, 0x7F,
  0x0F, 0xCF, 0xC3, 0xF8, 0x7E, 0x7E, 0x1F, 0xC3, 0xF3, 0xF0, 0xFE, 0x1F,
  0x9F, 0x8F, 0xF8, 0xFC, 0xFC, 0x7F, 0xC7, 0xE7, 0xE3, 0xFE, 0x3F, 0x3F,
  0x3F, 0xF9, 0xF9, 0xF9, 0xF7, 0xCF, 0xCF, 0xCF, 0xBE, 0x7E, 0x3E, 0x78,
  0xF3, 0xE1, 0xF7, 0xC7, 0xDF, 0x0F, 0xBE, 0x3E, 0xF8, 0x7D, 0xE0, 0xF7,
  0xC3, 0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0x80, 0xFF, 0x87,
  0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x0F, 0xF0,
  0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x07,
  0xE0, 0x7F, 0x80, 0x07, 0xF3, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xF8,
  0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x01, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFD, 0xFE, 0x00, 0x1F, 0xE7, 0xF0, 0x00,
  0xFE, 0x3F, 0xC0, 0x0F, 0xF0, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x1F,
  0xE1, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xEF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xDF, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0xFF, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x03, 0xF8,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x0F,
  0xE0, 0xFF, 0x00, 0x7F, 0x87, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xE3,
  0xF8, 0x00, 0x7F, 0x9F, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xEF, 0xF8, 0x01, 0xFF, 0x3F, 0xC0,
  0x0F, 0xF1, 0xFF, 0x00, 0xFF, 0x87, 0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF3, 0xFE, 0x00,
  0xFF, 0x9F, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xF3, 0xF0, 0x00, 0x7F,
  0x07, 0x80, 0x01, 0xE0, 0x08, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x08, 0x00, 0x70, 0x01,
  0xF0, 0x0F, 0xE0, 0x7F, 0xE1, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0x03, 0xF8,
  0x03, 0xC0, 0x03, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1C, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x01, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xE0, 0x0E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF9, 0xFE, 0x01,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xCF, 0xF8, 0x3F, 0xE7, 0xF0, 0x0F, 0xFB, 0xF8, 0x03,
  0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xEF, 0xE0, 0x0F, 0xF7, 0xF0, 0x0F, 0xFB,
  0xF8, 0x0F, 0xF9, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0x80, 0x30, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x01, 0x87, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x03,
  0xF9, 0xFE, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF7, 0xFE, 0x0F, 0xFB, 0xFC, 0x03, 0xFD,
  0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xF7, 0xF8, 0x07, 0xFB, 0xFE,
  0x03, 0xFC, 0xFF, 0x81, 0xFE, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xF8, 0x3F, 0xE1,
  0xFE, 0x01, 0xFC, 0x7F, 0x80, 0x3F, 0xCF, 0xF0, 0x03, 0xF9, 0xFC, 0x00,
  0x7F, 0x7F, 0x80, 0x0F, 0xEF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x03,
  0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFE, 0x07, 0x80, 0x3F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xC1, 0xFE, 0xFF,
  0x80, 0xFF, 0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F,
  0xEF, 0xF0, 0x0F, 0xF7, 0xF8, 0x07, 0xFB, 0xFF, 0x07, 0xFC, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xE0, 0x1F, 0xCF, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x10, 0x00, 0x7F, 0x8F,
  0x00, 0xFF, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xDF, 0xC0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xEF, 0xF0, 0x7F, 0xDF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x81, 0x80, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xE3, 0x00, 0x7F, 0x8F, 0x83, 0xFE, 0x7F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x03, 0xFE, 0xFF, 0x01, 0xFF, 0x3F, 0xC0,
  0xFF, 0x8F, 0xF0, 0x3F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x3F,
  0xC3, 0xFC, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x7F, 0x80,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0xFF,
  0x3F, 0xC0, 0x3F, 0xCF, 0xF8, 0x0F, 0xF1, 0xFF, 0x03, 0xFC, 0x3F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFF, 0x0F, 0xF0, 0x3F, 0xE3, 0xFC, 0x07,
  0xF8, 0xFF, 0x01, 0xFF, 0x3F, 0xC0, 0x3F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x81, 0x80, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0xFE, 0x1F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xC3, 0xFF, 0xE1, 0xF8, 0x7F, 0xFC, 0x3F,
  0x07, 0xFF, 0x87, 0xE0, 0xFF, 0xF0, 0xFE, 0x1F, 0xFE, 0x1F, 0xC3, 0xFF,
  0xC3, 0xF8, 0x7F, 0xF8, 0x7F, 0x0F, 0xFF, 0x0F, 0xE1, 0xFF, 0xE1, 0xFC,
  0x3F, 0xFC, 0x3F, 0x87, 0xFF, 0x87, 0xF0, 0xFF, 0xF0, 0xFE, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xC0, 0x07, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0xC1, 0xFF, 0x7F, 0x80, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x0F, 0xF8, 0x3F, 0xE3, 0xFE, 0x03, 0xFE, 0x7F, 0x80, 0x3F, 0xCF, 0xF0,
  0x07, 0xFB, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x0F, 0xF3, 0xFE, 0x03,
  0xFE, 0x3F, 0xE0, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFC, 0x1F, 0xF9, 0xFE,
  0x03, 0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFB, 0xFC, 0x03,
  0xFD, 0xFE, 0x03, 0xFE, 0xFF, 0x83, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x03, 0xFC,
  0xFE, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0xFF, 0xC0, 0xFE, 0xFF, 0x80, 0x7F, 0x7F, 0x80, 0x3F, 0xBF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFB,
  0xFC, 0x01, 0xFD, 0xFE, 0x00, 0xFE, 0xFF, 0x80, 0x7F, 0x3F, 0xE0, 0xFF,
  0x9F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x01,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xF0, 0x01, 0xBF, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xC0, 0x3C, 0x7F, 0x80, 0x04, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x70, 0x00, 0x7F, 0x7E, 0x00,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x01, 0xC0, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0xFE, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x7F, 0xBF, 0xE0, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xDF, 0xC0, 0x01, 0xFC, 0xFF, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0xFF, 0x1F, 0xC0, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x87,
  0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F,
  0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0xFE, 0x00,
  0x1F, 0xCF, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x3F, 0x07, 0xFF, 0xC1, 0xF8,
  0x7F, 0x7E, 0x1F, 0xC3, 0xF3, 0xF0, 0xFE, 0x1F, 0x9F, 0x87, 0xF0, 0xFC,
  0xFC, 0x3F, 0xC7, 0xE7, 0xE3, 0xFE, 0x3F, 0x3F, 0x1F, 0xF1, 0xF9, 0xF8,
  0xFF, 0x8F, 0xCF, 0xCF, 0xFE, 0x7C, 0x3E, 0x7D, 0xF3, 0xE1, 0xF3, 0xEF,
  0x9F, 0x0F, 0x9F, 0x7E, 0xF8, 0x7F, 0xF1, 0xFF, 0xC3, 0xFF, 0x8F, 0xFE,
  0x1F, 0xFC, 0x7F, 0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F,
  0xF0, 0x7F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0x80,
  0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF3, 0xFC, 0x00,
  0x7F, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xF8,
  0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x9F, 0xC0, 0x03,
  0xFD, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0x8F, 0xF0, 0x03, 0xFC,
  0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F,
  0xC1, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x0F, 0xF3, 0xFC, 0x00, 0xFF, 0x3F,
  0xC0, 0x0F, 0xF3, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xE1, 0xFE, 0x01,
  0xFE, 0x1F, 0xE0, 0x1F, 0xC1, 0xFE, 0x01, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x07, 0xF8,
  0x3F, 0x80, 0x7F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0xC7, 0xF0,
  0x01, 0xFC, 0xFF, 0x00, 0x1F, 0xEF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x20, 0xFF, 0x80, 0x07,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x01, 0x80, 0x3F, 0xE0, 0x0F,
  0xC7, 0xFF, 0xC0, 0x7E, 0x3F, 0xFF, 0x87, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x8F, 0xE3, 0xFF, 0xFC, 0xFE, 0x07,
  0xFF, 0xC7, 0xE0, 0x0F, 0xFC, 0x03, 0x00, 0x1F, 0x80,
};

const GFXglyph UbuntuMono_Bold62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 11, 39, 31, 10, -38 },
  { 55, 21, 17, 31, 5, -42 },
  { 100, 29, 38, 31, 1, -38 },
  { 238, 27, 49, 31, 2, -43 },
  { 404, 31, 40, 31, 0, -39 },
  { 559, 29, 40, 31, 1, -39 },
  { 704, 8, 19, 31, 12, -42 },
  { 723, 20, 54, 31, 6, -44 },
  { 858, 20, 54, 31, 5, -44 },
  { 993, 25, 24, 31, 3, -38 },
  { 1068, 27, 28, 31, 2, -29 },
  { 1163, 14, 21, 31, 8, -10 },
  { 1200, 17, 8, 31, 7, -19 },
  { 1217, 11, 11, 31, 10, -10 },
  { 1233, 25, 53, 31, 3, -43 },
  { 1399, 27, 40, 31, 2, -39 },
  { 1534, 25, 38, 31, 3, -38 },
  { 1653, 26, 39, 31, 3, -39 },
  { 1780, 25, 40, 31, 3, -39 },
  { 1905, 27, 38, 31, 2, -38 },
  { 2034, 26, 39, 31, 2, -38 },
  { 2161, 25, 39, 31, 3, -38 },
  { 2283, 25, 38, 31, 3, -38 },
  { 2402, 27, 40, 31, 2, -39 },
  { 2537, 25, 39, 31, 3, -39 },
  { 2659, 11, 30, 31, 10, -29 },
  { 2701, 14, 40, 31, 7, -29 },
  { 2771, 26, 27, 31, 3, -29 },
  { 2859, 27, 18, 31, 2, -25 },
  { 2920, 26, 27, 31, 2, -29 },
  { 3008, 23, 40, 31, 4, -39 },
  { 3123, 28, 47, 31, 1, -39 },
  { 3288, 29, 38, 31, 1, -38 },
  { 3426, 26, 40, 31, 3, -39 },
  { 3556, 27, 40, 31, 2, -39 },
  { 3691, 26, 39, 31, 3, -38 },
  { 3818, 25, 38, 31, 4, -38 },
  { 3937, 23, 38, 31, 4, -38 },
  { 4047, 27, 40, 31, 2, -39 },
  { 4182, 25, 38, 31, 3, -38 },
  { 4301, 25, 38, 31, 3, -38 },
  { 4420, 24, 39, 31, 3, -38 },
  { 4537, 27, 38, 31, 3, -38 },
  { 4666, 25, 38, 31, 4, -38 },
  { 4785, 29, 38, 31, 1, -38 },
  { 4923, 25, 38, 31, 3, -38 },
  { 5042, 27, 40, 31, 2, -39 },
  { 5177, 26, 39, 31, 3, -39 },
  { 5304, 27, 50, 31, 2, -39 },
  { 5473, 27, 39, 31, 3, -39 },
  { 5605, 27, 40, 31, 2, -39 },
  { 5740, 27, 38, 31, 2, -38 },
  { 5869, 27, 39, 31, 2, -38 },
  { 6001, 29, 38, 31, 1, -38 },
  { 6139, 29, 38, 31, 1, -38 },
  { 6277, 29, 38, 31, 1, -38 },
  { 6415, 29, 38, 31, 1, -38 },
  { 6553, 25, 38, 31, 3, -38 },
  { 6672, 17, 53, 31, 7, -43 },
  { 6785, 25, 53, 31, 3, -43 },
  { 6951, 17, 53, 31, 7, -43 },
  { 7064, 29, 23, 31, 1, -38 },
  { 7148, 31, 6, 31, 0, 4 },
  { 7172, 14, 11, 31, 9, -43 },
  { 7192, 24, 31, 31, 3, -30 },
  { 7285, 25, 45, 31, 4, -44 },
  { 7426, 26, 31, 31, 3, -30 },
  { 7527, 25, 45, 31, 2, -44 },
  { 7668, 27, 31, 31, 2, -30 },
  { 7773, 29, 44, 31, 2, -44 },
  { 7933, 25, 41, 31, 2, -30 },
  { 8062, 23, 44, 31, 4, -44 },
  { 8189, 27, 44, 31, 2, -43 },
  { 8338, 22, 54, 31, 3, -43 },
  { 8487, 26, 44, 31, 4, -44 },
  { 8630, 27, 44, 31, 2, -43 },
  { 8779, 27, 30, 31, 2, -30 },
  { 8881, 23, 30, 31, 4, -30 },
  { 8968, 27, 31, 31, 2, -30 },
  { 9073, 25, 40, 31, 4, -30 },
  { 9198, 25, 40, 31, 2, -30 },
  { 9323, 22, 30, 31, 6, -30 },
  { 9406, 24, 31, 31, 3, -30 },
  { 9499, 27, 39, 31, 2, -38 },
  { 9631, 23, 30, 31, 4, -29 },
  { 9718, 29, 29, 31, 1, -29 },
  { 9824, 29, 29, 31, 1, -29 },
  { 9930, 29, 29, 31, 1, -29 },
  { 10036, 28, 40, 31, 1, -29 },
  { 10176, 23, 29, 31, 4, -29 },
  { 10260, 23, 53, 31, 4, -43 },
  { 10413, 7, 53, 31, 12, -43 },
  { 10460, 23, 53, 31, 4, -43 },
  { 10613, 29, 11, 31, 1, -22 },
};

const GFXfont UbuntuMono_Bold62pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Bold62pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Bold62pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _UBUNTUMONO_BOLD62PT7B_H_
