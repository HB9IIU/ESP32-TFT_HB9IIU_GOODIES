#ifndef _UBUNTUMONO_BOLD47PT7B_H_
#define _UBUNTUMONO_BOLD47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Bold.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Bold47pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x00, 0x00, 0x00,
  0x3C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x3C, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC,
  0x7F, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0x3E, 0xFC, 0x3E, 0x7C, 0x3E, 0x7C,
  0x3E, 0x7C, 0x3E, 0x78, 0x3E, 0x78, 0x3C, 0x78, 0x1C, 0x01, 0xF1, 0xF0,
  0x07, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x78, 0x03, 0xE3, 0xE0, 0x0F,
  0x8F, 0x80, 0x3C, 0x3E, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00,
  0xF8, 0x78, 0x03, 0xE3, 0xE0, 0x0F, 0x0F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xE1, 0xF0,
  0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F,
  0x0F, 0x80, 0x7C, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xE1, 0xFF,
  0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0x01, 0xC7, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x40, 0x03,
  0xF7, 0x80, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xC7, 0xFF,
  0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x3D, 0xFF, 0x00,
  0xF3, 0xFE, 0x01, 0xE7, 0x9E, 0x07, 0x8F, 0x3C, 0x1E, 0x3C, 0x78, 0x3C,
  0x78, 0xF0, 0xF0, 0xF1, 0xE3, 0xC0, 0xE3, 0xC7, 0x81, 0xE7, 0x9E, 0x03,
  0xFE, 0x78, 0x07, 0xFC, 0xF0, 0x07, 0xF3, 0xC0, 0x07, 0xCF, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x79, 0xF0, 0x01, 0xF7, 0xF0, 0x03, 0xDF, 0xF0, 0x0F,
  0x3F, 0xE0, 0x3E, 0x79, 0xE0, 0x78, 0xE3, 0xC1, 0xE3, 0xC7, 0x87, 0xC7,
  0x8F, 0x0F, 0x0F, 0x1E, 0x3C, 0x0E, 0x3C, 0xF8, 0x1E, 0x79, 0xE0, 0x3F,
  0xE7, 0x80, 0x7F, 0xDF, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0xFC, 0x7E, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x1F, 0x00, 0xFC,
  0x7C, 0x01, 0xF7, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0xC3,
  0x80, 0xFE, 0x0F, 0x8F, 0xFC, 0x3C, 0x3F, 0xF8, 0xF1, 0xFB, 0xF7, 0xC7,
  0xC7, 0xFF, 0x3E, 0x0F, 0xFC, 0xF8, 0x3F, 0xE3, 0xE0, 0x7F, 0x8F, 0x80,
  0xFE, 0x3F, 0x03, 0xF8, 0xFC, 0x1F, 0xE1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFC, 0xF8, 0x1F, 0xC3, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xE7, 0x9E, 0x79, 0xE0, 0x00, 0x08, 0x00, 0x3C,
  0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x3C, 0x00, 0x08, 0x30, 0x00, 0x70, 0x01, 0xF0, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x1F, 0x80, 0x1C, 0x00, 0x30, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x02, 0x1F, 0x04, 0x78, 0xF1, 0xC7,
  0xEF, 0x7E, 0x7F, 0xEF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF1, 0xFF, 0xF8,
  0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xBE, 0x01, 0xF9, 0xF0, 0x1F, 0x9F,
  0x81, 0xF1, 0xF8, 0x0F, 0x0E, 0x00, 0x20, 0x40, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x07, 0xE3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF1, 0xFC, 0x3F, 0x07,
  0xC1, 0xF0, 0xF8, 0xFC, 0xFF, 0x3F, 0x8F, 0x81, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3C, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xFF,
  0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xF0, 0xFC, 0x7E, 0x07, 0xE7, 0xC0,
  0x7E, 0xFC, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0xE3, 0xFF, 0x9F, 0x1F, 0xF9, 0xF1, 0xFF, 0x9F, 0x1F, 0xF9, 0xF1, 0xFF,
  0x8E, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3E,
  0xFC, 0x03, 0xE7, 0xC0, 0x7E, 0x7E, 0x07, 0xE7, 0xF0, 0xFC, 0x3F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x07,
  0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0xFC, 0x03, 0x8F, 0xC0,
  0x20, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x3F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF0,
  0x03, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xC7, 0xC1, 0xFC, 0x30, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x07, 0xF0, 0x07, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC7, 0xFF, 0xF8, 0x70, 0x3F, 0x88, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xEE, 0x03, 0xF9, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1,
  0xFF, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x03, 0xEF, 0xC0, 0x3F, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x1F,
  0x81, 0xF0, 0xFC, 0x0F, 0x87, 0xE0, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7C,
  0x0F, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x80,
  0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x60, 0x1F, 0xDF, 0xFF, 0xFB,
  0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x07, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xF8,
  0x07, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x3F, 0xFE, 0x07, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x7F, 0x0F, 0xC7, 0xFF, 0xF8,
  0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xF0, 0xFE, 0x7C, 0x07,
  0xE7, 0xC0, 0x7E, 0xFC, 0x07, 0xE7, 0xC0, 0x7E, 0x7E, 0x07, 0xC7, 0xF0,
  0xFC, 0x7F, 0x8F, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F,
  0xFF, 0x87, 0xE7, 0xFC, 0x7E, 0x1F, 0xEF, 0xC0, 0x7E, 0xF8, 0x03, 0xEF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0xFE,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF,
  0xFC, 0xFE, 0x3F, 0x9F, 0x83, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3E, 0xFC, 0x07, 0xDF, 0xFF,
  0xFB, 0xFF, 0xFF, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFF,
  0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3C, 0x0F,
  0x0F, 0xE3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xF8, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0xFE, 0x3F, 0x8F, 0xF3, 0xFC, 0xFF,
  0x3F, 0xC3, 0xF0, 0x78, 0x1E, 0x0F, 0x9F, 0xCF, 0xE3, 0xF0, 0xF8, 0x38,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x1E, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x01,
  0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x01,
  0xE0, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x60, 0x00, 0x07, 0x80, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xF0, 0xFF,
  0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x78,
  0x00, 0x06, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF,
  0xE7, 0xFF, 0xFB, 0xC1, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x07, 0xF0, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x00, 0xFE,
  0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xF8, 0x3F, 0x1F,
  0x80, 0xF8, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xC0, 0xFF,
  0xDE, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7,
  0xE3, 0xFE, 0x3E, 0x1F, 0xF1, 0xF0, 0xFF, 0x8F, 0x87, 0xFC, 0x7C, 0x3F,
  0xE3, 0xE1, 0xFF, 0x1F, 0x0F, 0xF8, 0xF8, 0x7F, 0xC7, 0xE3, 0xFE, 0x1F,
  0xFF, 0xF8, 0xFF, 0xFB, 0xC3, 0xFF, 0xDE, 0x0F, 0xFE, 0xF8, 0x1F, 0xC3,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFC, 0x06, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x7B, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xE7, 0xC0, 0x07,
  0xCF, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x7C, 0x3E, 0x00, 0xF8,
  0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF8, 0x0F, 0x83, 0xF0, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x0F, 0xC0, 0x3F, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0xFC, 0xFC, 0x01, 0xF9,
  0xF8, 0x03, 0xF3, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xE0, 0x7F, 0xF0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xF0, 0x3F, 0x3E,
  0x03, 0xF7, 0xC0, 0x7E, 0xF8, 0x0F, 0xDF, 0x01, 0xF3, 0xE0, 0x7E, 0x7C,
  0x1F, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xFC, 0xFF,
  0xFF, 0xDF, 0x03, 0xFB, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFB, 0xFF,
  0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xF0, 0x38, 0xFE, 0x00, 0x47, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x11, 0xFF, 0x03, 0x87, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x1F,
  0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF9, 0xF0, 0x7F, 0x3E,
  0x07, 0xF7, 0xC0, 0x7E, 0xF8, 0x0F, 0xDF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x1F, 0xBE, 0x03, 0xF7, 0xC0, 0xFE, 0xF8, 0x7F, 0x9F, 0xFF, 0xE3, 0xFF,
  0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F,
  0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0x3F,
  0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x0F, 0xF0, 0x78, 0xFE, 0x00, 0x87, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7E, 0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x07,
  0xE7, 0xE0, 0x3F, 0x3F, 0x81, 0xF9, 0xFE, 0x0F, 0xC7, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF,
  0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF1, 0x00, 0x7E, 0x78, 0x3F,
  0xCF, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0xE0,
  0x00, 0xFC, 0x07, 0xF7, 0xE0, 0x3F, 0x3F, 0x03, 0xF9, 0xF8, 0x1F, 0x8F,
  0xC1, 0xF8, 0x7E, 0x1F, 0xC3, 0xF0, 0xFC, 0x1F, 0x8F, 0xC0, 0xFC, 0xFE,
  0x07, 0xE7, 0xE0, 0x3F, 0x7E, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFD, 0xFC, 0x07, 0xE7, 0xF0,
  0x3F, 0x3F, 0x81, 0xF8, 0xFE, 0x0F, 0xC3, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0,
  0x7F, 0x1F, 0x81, 0xFC, 0xFC, 0x0F, 0xE7, 0xE0, 0x3F, 0xBF, 0x01, 0xFD,
  0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xFE,
  0x07, 0xE7, 0xF0, 0x7F, 0x3F, 0x83, 0xF9, 0xFE, 0x1F, 0xCF, 0xF1, 0xFE,
  0x7B, 0x8F, 0xF3, 0xDE, 0x7F, 0x9E, 0xF7, 0xBE, 0xF3, 0xBD, 0xF7, 0x9F,
  0xEF, 0xBC, 0xFE, 0x7D, 0xE7, 0xF3, 0xEF, 0x1F, 0x9F, 0x78, 0xFC, 0xFB,
  0xC7, 0xC7, 0xFE, 0x3E, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x80, 0xF8, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xEF, 0x8F, 0xFD, 0xF1,
  0xFF, 0x9F, 0x3F, 0xF3, 0xE7, 0xFE, 0x3E, 0xFF, 0xC7, 0xDF, 0xF8, 0x7F,
  0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3E, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0xC3, 0xF0, 0xFC, 0x0F, 0xCF,
  0xC0, 0x7E, 0x7E, 0x01, 0xF3, 0xF0, 0x0F, 0xDF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xF7, 0xC0, 0x1F,
  0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xCF, 0xC0, 0x7E, 0x3F, 0x03, 0xF1, 0xFC,
  0x3F, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x80,
  0x07, 0xF0, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF,
  0xCF, 0xFF, 0xFD, 0xF0, 0x3F, 0xBE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x1F,
  0xFE, 0x07, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xF8,
  0x7F, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F,
  0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0xC3, 0xF0, 0xFC, 0x0F, 0xCF, 0xC0, 0x7E,
  0x7E, 0x01, 0xF3, 0xF0, 0x0F, 0xDF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0xBF, 0x00,
  0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x7E, 0x3F, 0x03, 0xF1, 0xFC, 0x3F, 0x8F,
  0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xF8,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xC0, 0x3F, 0xE0,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0x83,
  0xF8, 0xF8, 0x1F, 0xCF, 0x80, 0xFC, 0xF8, 0x0F, 0xCF, 0x80, 0xFC, 0xF8,
  0x0F, 0xCF, 0x80, 0xFC, 0xF8, 0x1F, 0xCF, 0x83, 0xF8, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0x87, 0xE0,
  0xF8, 0x7E, 0x0F, 0x83, 0xF0, 0xF8, 0x3F, 0x0F, 0x81, 0xF8, 0xF8, 0x1F,
  0x8F, 0x80, 0xFC, 0xF8, 0x0F, 0xCF, 0x80, 0x7E, 0xF8, 0x07, 0xEF, 0x80,
  0x3F, 0x03, 0xFC, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F,
  0xFF, 0x87, 0xF0, 0x38, 0x7E, 0x00, 0x8F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x60, 0x07, 0xE7, 0x80, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF,
  0xFF, 0x87, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xEF, 0xC0, 0x7E,
  0x7E, 0x0F, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0x3F, 0xC0, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xBF,
  0x00, 0x7E, 0x7C, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80,
  0xFC, 0x3E, 0x03, 0xF0, 0xF8, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xF8,
  0x1F, 0x07, 0xE0, 0x7C, 0x1F, 0x81, 0xF8, 0x7C, 0x07, 0xE1, 0xF0, 0x0F,
  0x87, 0xC0, 0x3E, 0x3F, 0x00, 0xF8, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF,
  0x80, 0x1F, 0x7C, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x1E, 0x3F, 0xF1, 0xF1, 0xF7, 0x8F, 0x8F, 0xBC, 0x7E, 0x7D,
  0xE7, 0xF3, 0xEF, 0x3F, 0x9F, 0x79, 0xFE, 0xFB, 0xCE, 0xF7, 0xDE, 0xF3,
  0xBE, 0xF7, 0x9D, 0xF7, 0xB8, 0xFF, 0x3F, 0xC3, 0xF9, 0xFE, 0x1F, 0xCF,
  0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x1F, 0x8F, 0x80, 0xFC, 0x7C, 0x07,
  0xE3, 0xE0, 0x1F, 0x00, 0xFC, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x3F,
  0x0F, 0xC0, 0xFC, 0x3F, 0x07, 0xE0, 0x7E, 0x1F, 0x80, 0xF8, 0xFC, 0x03,
  0xF3, 0xE0, 0x07, 0xDF, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xF3, 0xF0, 0x0F,
  0xCF, 0xC0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x0F, 0xC1, 0xFC, 0x3F, 0x03,
  0xF1, 0xF8, 0x0F, 0xE7, 0xE0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x00, 0xFC,
  0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E,
  0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x1F, 0x87,
  0xE0, 0x3E, 0x1F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xE0, 0x07, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0xFC, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x87, 0xE0, 0xFC, 0x0F,
  0xC7, 0xF0, 0x3F, 0x9F, 0x80, 0x7E, 0xFE, 0x01, 0xFD, 0xF0, 0x03, 0xC0,
  0x80, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x10, 0x0E, 0x07, 0xE1, 0xFC, 0x7F,
  0xC7, 0xF0, 0x78, 0x06, 0x0F, 0xF8, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x20, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF8,
  0x1F, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x3F,
  0xF8, 0x1C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF7, 0xE0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF7, 0xF0, 0xFE, 0xFC, 0x0F, 0xDF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xEF, 0xC1, 0xFD, 0xFF, 0xFF,
  0x3F, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x3F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFC,
  0x04, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x23, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x00,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xDF,
  0x87, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xFB, 0xF8, 0x7F,
  0x7E, 0x07, 0xEF, 0xC0, 0xFD, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xEF, 0xC0, 0xFD,
  0xF8, 0x1F, 0xBF, 0x83, 0xF7, 0xF8, 0x7E, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8,
  0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xC3, 0xF9, 0xFC,
  0x0F, 0xCF, 0xC0, 0x3E, 0x7E, 0x01, 0xFB, 0xE0, 0x0F, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x18, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x83,
  0xF8, 0x18, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x01, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFC, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xFF, 0x01, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xFF, 0xF7, 0xFF,
  0xFE, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x9F, 0xFF,
  0xF1, 0xFF, 0xFE, 0x0F, 0xCF, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF9, 0x80, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFE,
  0x3F, 0xFF, 0x00, 0xFF, 0x80, 0x1C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x83, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0xFF,
  0xCF, 0xFF, 0xFB, 0xF0, 0xFE, 0xFC, 0x1F, 0xBF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xC0, 0x03, 0xC0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x82, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x3C, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF,
  0xFC, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC8, 0x07, 0xE7, 0x07, 0xE7,
  0xFF, 0xF3, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xF8, 0x0F, 0xF0, 0x00, 0x1C,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0xFE, 0xFC, 0x1F, 0xCF, 0xC3, 0xF8, 0xFC, 0x3F,
  0x0F, 0xC7, 0xE0, 0xFC, 0xFC, 0x0F, 0xCF, 0x80, 0xFD, 0xF8, 0x0F, 0xFF,
  0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xDF, 0x80, 0xFC,
  0xFC, 0x0F, 0xCF, 0xE0, 0xFC, 0x7F, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x8F,
  0xC1, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFE, 0xFC, 0x07, 0xF0, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x82, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xC7, 0xC7,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7C,
  0x7F, 0xE3, 0xE3, 0xFF, 0x1F, 0x1F, 0xF8, 0xF8, 0xFF, 0xC7, 0xC7, 0xFE,
  0x3E, 0x3F, 0xF1, 0xF1, 0xFF, 0x8F, 0x8F, 0xFC, 0x7C, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xE0, 0x1F, 0xF0,
  0x3F, 0xFF, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0x0F, 0xEF,
  0xC1, 0xFB, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0x83, 0xFF, 0xFE, 0x1F, 0xC3, 0xF9, 0xFC, 0x0F, 0xCF, 0xC0, 0x7F, 0x7E,
  0x01, 0xFB, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFD, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x03, 0xFB, 0xF8,
  0x1F, 0x8F, 0xE1, 0xFC, 0x7F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xF8, 0x7F, 0xBF, 0x03, 0xF7, 0xE0, 0x7E,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xFB,
  0xF8, 0x7F, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x87,
  0xEF, 0xC0, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xFF,
  0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xF8, 0x3F, 0x7F, 0x03,
  0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x7C, 0x03, 0xF7, 0xE0, 0x3F, 0x7E,
  0x03, 0xF7, 0xF0, 0x3F, 0x7F, 0x87, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x07, 0xFF, 0x1F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF,
  0xBF, 0x80, 0x6F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFC, 0x07, 0xFF, 0xE3, 0xFF, 0xF9,
  0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0x81, 0xCF, 0xC0, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF,
  0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0x01, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE0, 0x7F, 0xC0, 0x00,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x03, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xC0,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x83, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7,
  0xFF, 0xF0, 0x7F, 0xC0, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xEF, 0xC0, 0x1F,
  0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xF1, 0xF8, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F,
  0xC0, 0xF8, 0x3F, 0x07, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0xFC, 0x03, 0xE3,
  0xF0, 0x0F, 0xCF, 0x80, 0x3F, 0x7E, 0x00, 0x7D, 0xF8, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x78, 0x7F, 0xE3, 0xE1, 0xEF, 0x8F, 0x87,
  0xBE, 0x3F, 0x1E, 0xF8, 0xFC, 0x79, 0xE7, 0xF1, 0xE7, 0x9F, 0xCF, 0x9E,
  0x7F, 0xBE, 0x79, 0xDE, 0xF1, 0xEF, 0x7B, 0xC7, 0xBC, 0xFF, 0x1F, 0xF3,
  0xFC, 0x3F, 0x8F, 0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x03, 0xE0, 0x78, 0x0F, 0x80, 0xFC, 0x01, 0xF9, 0xF8, 0x0F, 0xC3,
  0xF0, 0x3F, 0x07, 0xE1, 0xF8, 0x1F, 0x8F, 0xC0, 0x3F, 0x3F, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03,
  0xF7, 0xF0, 0x1F, 0x8F, 0xC0, 0x7C, 0x1F, 0x83, 0xF0, 0x3F, 0x1F, 0x80,
  0xFC, 0x7E, 0x01, 0xFB, 0xF0, 0x07, 0xE0, 0x7E, 0x01, 0xFB, 0xF0, 0x0F,
  0xDF, 0x80, 0x7E, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0x7C,
  0x0F, 0x83, 0xF0, 0x7C, 0x1F, 0x87, 0xE0, 0x7C, 0x3F, 0x03, 0xF1, 0xF0,
  0x1F, 0x8F, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xC0, 0x1F, 0xBE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x02, 0x1F, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F,
  0xE0, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF,
  0xFF, 0xF7, 0xFF, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x07, 0xFF, 0xC1, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x0F, 0xF8, 0x03, 0xFC,
  0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x7F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x3F, 0xF0,
  0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03,
  0xFF, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x60, 0x7F, 0x81, 0xF3, 0xFF,
  0x8F, 0xDF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0x87, 0xFF,
  0x3E, 0x07, 0xF8, 0x30, 0x07, 0xC0,
};

const GFXglyph UbuntuMono_Bold47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 8, 30, 24, 8, -29 },
  { 31, 16, 13, 24, 4, -32 },
  { 57, 22, 29, 24, 1, -29 },
  { 137, 20, 38, 24, 2, -33 },
  { 232, 23, 31, 24, 0, -30 },
  { 322, 22, 30, 24, 1, -30 },
  { 405, 6, 14, 24, 9, -32 },
  { 416, 16, 41, 24, 4, -33 },
  { 498, 15, 41, 24, 4, -33 },
  { 575, 20, 18, 24, 2, -29 },
  { 620, 20, 21, 24, 2, -22 },
  { 673, 10, 16, 24, 6, -7 },
  { 693, 13, 6, 24, 5, -15 },
  { 703, 8, 8, 24, 8, -7 },
  { 711, 19, 41, 24, 2, -33 },
  { 809, 20, 31, 24, 2, -30 },
  { 887, 20, 29, 24, 2, -29 },
  { 960, 20, 30, 24, 2, -30 },
  { 1035, 19, 31, 24, 2, -30 },
  { 1109, 21, 29, 24, 1, -29 },
  { 1186, 19, 30, 24, 2, -29 },
  { 1258, 19, 30, 24, 2, -29 },
  { 1330, 19, 29, 24, 2, -29 },
  { 1399, 20, 31, 24, 2, -30 },
  { 1477, 19, 30, 24, 2, -30 },
  { 1549, 8, 22, 24, 8, -21 },
  { 1571, 10, 30, 24, 6, -21 },
  { 1609, 20, 20, 24, 2, -22 },
  { 1659, 20, 14, 24, 2, -19 },
  { 1694, 20, 20, 24, 2, -22 },
  { 1744, 17, 31, 24, 3, -30 },
  { 1810, 21, 36, 24, 1, -30 },
  { 1905, 23, 29, 24, 0, -29 },
  { 1989, 19, 31, 24, 3, -30 },
  { 2063, 21, 31, 24, 1, -30 },
  { 2145, 19, 30, 24, 3, -29 },
  { 2217, 19, 29, 24, 3, -29 },
  { 2286, 18, 29, 24, 3, -29 },
  { 2352, 21, 31, 24, 1, -30 },
  { 2434, 19, 29, 24, 2, -29 },
  { 2503, 18, 29, 24, 3, -29 },
  { 2569, 19, 30, 24, 2, -29 },
  { 2641, 21, 29, 24, 2, -29 },
  { 2718, 19, 29, 24, 3, -29 },
  { 2787, 21, 29, 24, 1, -29 },
  { 2864, 19, 29, 24, 2, -29 },
  { 2933, 21, 31, 24, 1, -30 },
  { 3015, 19, 30, 24, 3, -30 },
  { 3087, 21, 39, 24, 1, -30 },
  { 3190, 20, 30, 24, 3, -30 },
  { 3265, 20, 31, 24, 2, -30 },
  { 3343, 21, 29, 24, 1, -29 },
  { 3420, 20, 30, 24, 2, -29 },
  { 3495, 22, 29, 24, 1, -29 },
  { 3575, 21, 29, 24, 1, -29 },
  { 3652, 22, 29, 24, 1, -29 },
  { 3732, 22, 29, 24, 1, -29 },
  { 3812, 19, 29, 24, 2, -29 },
  { 3881, 13, 41, 24, 5, -33 },
  { 3948, 19, 41, 24, 2, -33 },
  { 4046, 13, 41, 24, 5, -33 },
  { 4113, 22, 15, 24, 1, -29 },
  { 4155, 23, 5, 24, 0, 3 },
  { 4170, 10, 8, 24, 7, -32 },
  { 4180, 19, 24, 24, 2, -23 },
  { 4237, 19, 34, 24, 3, -33 },
  { 4318, 20, 24, 24, 2, -23 },
  { 4378, 19, 34, 24, 1, -33 },
  { 4459, 21, 24, 24, 1, -23 },
  { 4522, 21, 33, 24, 2, -33 },
  { 4609, 19, 32, 24, 2, -23 },
  { 4685, 18, 33, 24, 3, -33 },
  { 4760, 20, 33, 24, 2, -32 },
  { 4843, 17, 41, 24, 2, -32 },
  { 4931, 20, 33, 24, 3, -33 },
  { 5014, 20, 33, 24, 2, -32 },
  { 5097, 21, 23, 24, 1, -23 },
  { 5158, 18, 23, 24, 3, -23 },
  { 5210, 21, 24, 24, 1, -23 },
  { 5273, 19, 31, 24, 3, -23 },
  { 5347, 20, 31, 24, 1, -23 },
  { 5425, 18, 23, 24, 4, -23 },
  { 5477, 18, 24, 24, 3, -23 },
  { 5531, 20, 29, 24, 2, -28 },
  { 5604, 18, 23, 24, 3, -22 },
  { 5656, 22, 22, 24, 1, -22 },
  { 5717, 22, 22, 24, 1, -22 },
  { 5778, 22, 22, 24, 1, -22 },
  { 5839, 21, 31, 24, 1, -22 },
  { 5921, 17, 22, 24, 3, -22 },
  { 5968, 18, 41, 24, 3, -33 },
  { 6061, 6, 41, 24, 9, -33 },
  { 6092, 18, 41, 24, 3, -33 },
  { 6185, 22, 9, 24, 1, -17 },
};

const GFXfont UbuntuMono_Bold47pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Bold47pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Bold47pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _UBUNTUMONO_BOLD47PT7B_H_
