#ifndef _UBUNTUMONO_BOLD32PT7B_H_
#define _UBUNTUMONO_BOLD32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Bold.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Bold32pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x78, 0x00,
  0x1E, 0x7B, 0xF7, 0x9E, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFE,
  0x1F, 0x87, 0x61, 0x80, 0x0F, 0x38, 0x38, 0xE0, 0xE3, 0x83, 0x9E, 0x0E,
  0x7B, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0xF0, 0x73, 0xC3, 0xCE, 0x0E,
  0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDE, 0x70, 0x71, 0xC1, 0xC7, 0x07,
  0x1C, 0x1C, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xFC, 0x3F, 0xF9,
  0xFF, 0xE7, 0xC1, 0x9E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xF0, 0x0F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF6, 0x07,
  0xDF, 0xFE, 0xFF, 0xF0, 0xFF, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C,
  0x07, 0x7E, 0x0E, 0x7E, 0x1C, 0xE6, 0x1C, 0xE7, 0x38, 0xE7, 0x70, 0xE6,
  0x70, 0x7E, 0xE0, 0x7E, 0xC0, 0x3D, 0xC0, 0x03, 0xBC, 0x03, 0x7E, 0x07,
  0x7E, 0x0E, 0x67, 0x0E, 0xE7, 0x1C, 0xE7, 0x38, 0x67, 0x38, 0x7E, 0x70,
  0x7E, 0xE0, 0x3C, 0x0F, 0x00, 0xFF, 0x03, 0xFE, 0x1E, 0x78, 0x70, 0xE1,
  0xC3, 0x87, 0x9E, 0x1E, 0xF0, 0x3F, 0x80, 0x7C, 0xC3, 0xF3, 0xDF, 0xCF,
  0xF7, 0xBB, 0x8F, 0xEE, 0x1F, 0xB8, 0x3C, 0xF1, 0xFB, 0xFF, 0xE7, 0xFF,
  0xC7, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x66, 0x00, 0x80, 0xF0, 0x7C, 0x3C,
  0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x02, 0x40, 0x3C, 0x0F, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x83, 0xC1, 0xF0, 0x78,
  0x7C, 0x3E, 0x07, 0x01, 0x80, 0x07, 0x80, 0x1E, 0x06, 0x79, 0x9C, 0xCE,
  0x7F, 0x79, 0xFF, 0xF3, 0xFF, 0x01, 0xE0, 0x0F, 0xC0, 0x7F, 0x83, 0xCF,
  0x07, 0x38, 0x08, 0x40, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0x1C, 0x7D, 0xFB, 0xF3, 0xE3,
  0xC3, 0x9E, 0xF9, 0xE3, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xFF, 0xFF,
  0xFD, 0xE0, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x00, 0x0F, 0xC0, 0x7F, 0x83, 0xFF, 0x1F, 0x3E, 0x78, 0x79, 0xC0,
  0xEF, 0x03, 0xFC, 0x0F, 0xF3, 0x3F, 0xDE, 0xFF, 0x7B, 0xFC, 0xCF, 0xF0,
  0x3F, 0xC0, 0xF7, 0x03, 0x9E, 0x1E, 0x7C, 0xF8, 0xFF, 0xC1, 0xFE, 0x03,
  0xF0, 0x03, 0x80, 0x7C, 0x07, 0xE0, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0x9E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x83, 0xFF, 0xDF, 0xFE, 0xFF, 0xF0, 0x0F, 0x80,
  0xFF, 0x8F, 0xFF, 0x1C, 0x3E, 0x20, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0x78, 0x01, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0x1F, 0x83, 0xFF,
  0x1F, 0xFC, 0x61, 0xE0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x3E, 0x0F, 0xE0,
  0x7F, 0x03, 0xFC, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x60,
  0xFB, 0xFF, 0xBF, 0xF8, 0x7F, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x3F, 0x00,
  0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xEF, 0x07, 0x3C, 0x3C, 0xF1, 0xE3, 0xC7,
  0x0F, 0x3C, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0x80, 0xFE, 0x01,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x40, 0xFB, 0xFF, 0xBF, 0xF8,
  0x7F, 0x00, 0x00, 0xF0, 0x0F, 0xE0, 0xFF, 0x87, 0xE0, 0x3E, 0x00, 0xF0,
  0x07, 0x80, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xEF, 0x8F, 0xBC, 0x1E, 0xF0,
  0x3D, 0xC0, 0xF7, 0x83, 0x9E, 0x1E, 0x7C, 0x78, 0xFF, 0xC1, 0xFE, 0x03,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F,
  0x00, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0xC0,
  0xFF, 0xC3, 0xFF, 0x9E, 0x1E, 0x78, 0x79, 0xC0, 0xE7, 0x87, 0x9F, 0x1E,
  0x3F, 0xF0, 0x7F, 0x83, 0xFF, 0x1E, 0x7E, 0x70, 0x7B, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF8, 0x79, 0xFF, 0xE3, 0xFF, 0x03, 0xF0, 0x0F, 0xC0, 0x7F,
  0x83, 0xFF, 0x1E, 0x3E, 0x78, 0x79, 0xC1, 0xEF, 0x03, 0xFC, 0x0F, 0x78,
  0x3D, 0xF1, 0xF7, 0xFF, 0x8F, 0xFE, 0x07, 0xF8, 0x01, 0xE0, 0x0F, 0x00,
  0x7C, 0x07, 0xE0, 0xFF, 0x03, 0xF0, 0x0F, 0x00, 0x7B, 0xFF, 0xFF, 0xFD,
  0xE0, 0x00, 0x00, 0x07, 0xBF, 0xFF, 0xFF, 0xDE, 0x3C, 0xFD, 0xFB, 0xF7,
  0xE7, 0x80, 0x00, 0x00, 0x00, 0xF3, 0xE7, 0xEF, 0xDF, 0x9F, 0x1C, 0x7B,
  0xE7, 0x8C, 0x00, 0x00, 0x08, 0x01, 0xE0, 0x1F, 0xC3, 0xFF, 0x3F, 0xE3,
  0xFE, 0x0F, 0xC0, 0x3F, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0x00, 0x78, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x60, 0x01, 0xE0, 0x07,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xC0, 0x3F, 0x07, 0xFC,
  0x7F, 0xCF, 0xFC, 0x1F, 0x80, 0x78, 0x01, 0x80, 0x00, 0x3F, 0x8F, 0xFC,
  0x7F, 0xE6, 0x1F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x0F, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x1F, 0x01, 0xF0,
  0x1F, 0x00, 0xE0, 0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x9E, 0x1E, 0x70, 0x3F,
  0xC0, 0x7E, 0x1F, 0xF8, 0xFF, 0xE7, 0xFF, 0x9C, 0x7E, 0xF1, 0xF3, 0xC7,
  0xCF, 0x1F, 0xBC, 0x7E, 0xF1, 0xF9, 0xC7, 0xE7, 0xFF, 0x8F, 0xF7, 0x1F,
  0xDE, 0x00, 0x3C, 0x00, 0xFF, 0xE0, 0xFF, 0x80, 0xFE, 0x03, 0xC0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0E, 0x70, 0x0E,
  0x70, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x38, 0x3C, 0x3C, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0xF0,
  0x1F, 0xFF, 0x87, 0xFF, 0x3F, 0xF9, 0xE3, 0xEF, 0x0F, 0x78, 0x7B, 0xC3,
  0xDE, 0x3C, 0xFF, 0xC7, 0xFF, 0x3F, 0xFD, 0xE1, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0xF7, 0xFF, 0xBF, 0xF9, 0xFF, 0x00, 0x03, 0xF8,
  0x3F, 0xF1, 0xFF, 0x8F, 0x82, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x7E, 0x08, 0xFF, 0xF1, 0xFF, 0xC1, 0xFC, 0xFF, 0x07, 0xFE,
  0x3F, 0xF9, 0xE3, 0xEF, 0x0F, 0x78, 0x7F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC3, 0xDE, 0x1E, 0xF1,
  0xF7, 0xFF, 0x3F, 0xF1, 0xFE, 0x00, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFF, 0xE7, 0xFF, 0x3F, 0xF9,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0xFC, 0x7F,
  0xE3, 0xFF, 0x8F, 0x82, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x83, 0xDE,
  0x0F, 0x7C, 0x3C, 0xFF, 0xF1, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x20, 0xF3, 0xFF, 0xBF, 0xF8, 0x7F, 0x00, 0xF0, 0x7D,
  0xE0, 0xF3, 0xC3, 0xE7, 0x87, 0x8F, 0x1E, 0x1E, 0x7C, 0x3C, 0xF0, 0x7B,
  0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xBE, 0x0F, 0x3E, 0x1E, 0x3C,
  0x3C, 0x7C, 0x78, 0x7C, 0xF0, 0x79, 0xE0, 0xFB, 0xC0, 0xF7, 0x81, 0xE0,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x70, 0x39, 0xE1,
  0xE7, 0x87, 0x9E, 0x1E, 0xFC, 0xFB, 0xF3, 0xFE, 0xCD, 0xFB, 0xF7, 0xEF,
  0xDF, 0x9E, 0x7E, 0x79, 0xF9, 0xE7, 0xE7, 0x9F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0xE0, 0xFF,
  0x83, 0xFF, 0x0F, 0xFC, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0xCF, 0xF7, 0x3F,
  0xCE, 0xFF, 0x3B, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x0F, 0xFC, 0x3F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x03, 0xFC, 0x0F, 0x0F, 0xC0, 0x7F, 0x83, 0xFF,
  0x1E, 0x1E, 0x78, 0x7B, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xDE, 0x1E, 0x78,
  0x78, 0xFF, 0xC1, 0xFE, 0x03, 0xF0, 0xFF, 0x87, 0xFF, 0x3F, 0xFD, 0xE1,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xFF, 0xFD,
  0xFF, 0xCF, 0xF8, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x7F, 0x83, 0xFF, 0x1E, 0x1E, 0x78, 0x7B,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xDE, 0x1E, 0x78, 0x78, 0xFF, 0xC3, 0xFF,
  0x03, 0xF0, 0x07, 0x80, 0x0F, 0x80, 0x3F, 0xC0, 0x3F, 0x00, 0x38, 0xFF,
  0x03, 0xFF, 0x0F, 0xFE, 0x3C, 0x7C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C,
  0x3C, 0xF1, 0xF3, 0xFF, 0x8F, 0xFC, 0x3F, 0xF0, 0xF3, 0xC3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x3C, 0xF0, 0xF3, 0xC1, 0xEF, 0x07, 0xBC, 0x1E, 0x0F, 0xE0,
  0xFF, 0xE7, 0xFF, 0x1E, 0x0C, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00,
  0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0x7E, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x60, 0x79, 0xFF, 0xEF, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC1, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xDE, 0x1E,
  0x78, 0x79, 0xFF, 0xE3, 0xFF, 0x03, 0xF0, 0x78, 0x1F, 0x78, 0x1E, 0x78,
  0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x1C, 0x38, 0x1E, 0x78, 0x1E, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x0F,
  0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF9,
  0xE7, 0xE7, 0x9F, 0x9E, 0x7E, 0x79, 0xFB, 0xF7, 0xEF, 0xDF, 0xB3, 0x7F,
  0xCF, 0xFF, 0x3F, 0x78, 0x79, 0xE1, 0xE7, 0x87, 0x9C, 0x0E, 0x78, 0x1E,
  0x7C, 0x1E, 0x3C, 0x3C, 0x1E, 0x38, 0x1E, 0x78, 0x0F, 0x70, 0x0F, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xF0,
  0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x7C, 0x3C, 0x3C, 0x7C, 0x3E, 0x78, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C,
  0x1E, 0x38, 0x1E, 0x78, 0x0E, 0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x80,
  0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x3C,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0x80, 0x1F, 0x80, 0x3F, 0x80, 0xFF, 0x03, 0xCF, 0x07, 0x8F, 0x1E, 0x1E,
  0x7C, 0x1E, 0xF0, 0x3E, 0x40, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x60, 0xE3, 0xE3, 0xF3, 0xC1, 0x80, 0x3F, 0xC1, 0xFF, 0x8F, 0xFC, 0x41,
  0xF0, 0x07, 0x80, 0x3C, 0x7F, 0xE7, 0xFF, 0x7F, 0xFF, 0xC3, 0xFC, 0x1E,
  0xF0, 0xF7, 0xFF, 0x9F, 0xFC, 0x7F, 0xC0, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0xF8, 0xFF, 0xE7, 0xFF, 0xBE,
  0x3D, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x87,
  0xFC, 0x3D, 0xFF, 0xEF, 0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0xE3, 0xFF,
  0x9F, 0x82, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0x80, 0x1F, 0x80, 0x3F, 0xFC, 0x7F, 0xF0, 0x7F, 0x80, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE3, 0xEF, 0x3F,
  0xFB, 0xFF, 0xDE, 0x3F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0xC3, 0xDE, 0x1E, 0xFF, 0xF3, 0xFF, 0x87, 0xF8, 0x0F, 0xC0,
  0x7F, 0xC3, 0xFF, 0x9E, 0x1E, 0x78, 0x3B, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x1F, 0x06, 0x3F, 0xF8, 0x7F, 0xE0, 0x7F,
  0x00, 0x01, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x78, 0x20, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x0F, 0xF1, 0xFF, 0xDF, 0xFE,
  0xF8, 0xFF, 0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xDE,
  0x1E, 0xFF, 0xF3, 0xFF, 0x8F, 0xFC, 0x01, 0xE0, 0x0F, 0x40, 0xF3, 0xFF,
  0xBF, 0xF8, 0x7F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0xF8, 0xFF, 0xEF, 0xFE, 0xF1, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0x0E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x41, 0xFF,
  0x03, 0xFC, 0x07, 0xE0, 0x03, 0x80, 0x78, 0x1F, 0x01, 0xE0, 0x38, 0x00,
  0x00, 0x03, 0xFF, 0x7F, 0xEF, 0xFC, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7A,
  0x1E, 0xFF, 0xDF, 0xF1, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x3E, 0xF1, 0xF3, 0xC7, 0x8F,
  0x3C, 0x3D, 0xE0, 0xFF, 0x03, 0xF8, 0x0F, 0xF0, 0x3D, 0xE0, 0xF7, 0xC3,
  0xCF, 0x8F, 0x1E, 0x3C, 0x3C, 0xF0, 0xFB, 0xC1, 0xE0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0xC1, 0xFF, 0x03, 0xFC, 0x07, 0xE0,
  0x7E, 0xF3, 0xFF, 0xEF, 0xFF, 0xF9, 0xCF, 0xE7, 0x9F, 0x9E, 0x7E, 0x79,
  0xF9, 0xE7, 0xE7, 0x9F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xC0, 0x7F, 0x8F, 0xFE, 0xFF, 0xEF, 0x1F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xF0, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9E, 0x1E, 0xF8, 0x7F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xDE, 0x1E, 0x3F,
  0xF8, 0x7F, 0xC0, 0xFC, 0x00, 0x7F, 0x87, 0xFF, 0x3F, 0xFD, 0xE3, 0xEF,
  0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xE1,
  0xEF, 0xFF, 0x7F, 0xF3, 0xFF, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x00, 0x0F, 0xF1, 0xFF, 0xDF, 0xFE, 0xF8, 0xFF, 0x87, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1E, 0xF1, 0xF7, 0xFF, 0x9F,
  0xFC, 0x7D, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x3F,
  0xFF, 0xFE, 0xFF, 0xEF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x1F, 0xE7,
  0xFE, 0x7F, 0xEF, 0x02, 0xF0, 0x0F, 0x80, 0x7F, 0x03, 0xFC, 0x0F, 0xE0,
  0x1F, 0x00, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x3F, 0x80, 0x03, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC1, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0x80, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x8F, 0x7F, 0xF7, 0xFF, 0x1F, 0xE0, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x78, 0x1E, 0x78, 0x1E, 0x78,
  0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xC0,
  0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0E, 0x71, 0xCE, 0x73, 0xCE, 0x73, 0xCE,
  0x73, 0xCE, 0x73, 0xEE, 0x77, 0xEE, 0x77, 0xEC, 0x36, 0x6C, 0x3E, 0x7C,
  0x3E, 0x7C, 0x3C, 0x3C, 0x3C, 0x38, 0xF0, 0x3D, 0xE1, 0xE7, 0xC7, 0x8F,
  0x3C, 0x1F, 0xE0, 0x3F, 0x80, 0xFC, 0x01, 0xF0, 0x0F, 0xC0, 0x7F, 0x81,
  0xDF, 0x0F, 0x3C, 0x78, 0x79, 0xC1, 0xFF, 0x03, 0xC0, 0xF0, 0x3D, 0xE0,
  0xF7, 0x83, 0x9E, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x07, 0x3C, 0x1E,
  0xF0, 0x7B, 0x80, 0xFE, 0x03, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x38, 0x01,
  0xE0, 0x8F, 0x03, 0xFC, 0x0F, 0xE0, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3E, 0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xE0, 0x7C,
  0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0xFF, 0x0F, 0xF0,
  0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01,
  0xE0, 0xFC, 0x0F, 0x00, 0xFC, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0xF0, 0xFF, 0x03, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFC, 0x0F, 0xF0, 0xFF, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x80, 0x78, 0x03, 0xF0, 0x0F, 0x03,
  0xF0, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0xF0, 0xFF, 0x0F, 0xF0, 0xFC, 0x00, 0x3C, 0x1C, 0xFE, 0x39, 0xFF,
  0xF7, 0xFF, 0xEE, 0x3F, 0x8C, 0x1E, 0x00,
};

const GFXglyph UbuntuMono_Bold32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 6, 20, 16, 5, -20 },
  { 16, 10, 9, 16, 3, -22 },
  { 28, 14, 20, 16, 1, -20 },
  { 63, 14, 25, 16, 1, -22 },
  { 107, 16, 20, 16, 0, -20 },
  { 147, 14, 20, 16, 1, -20 },
  { 182, 4, 10, 16, 6, -22 },
  { 187, 10, 28, 16, 3, -23 },
  { 222, 10, 28, 16, 3, -23 },
  { 257, 14, 13, 16, 1, -20 },
  { 280, 14, 15, 16, 1, -15 },
  { 307, 7, 11, 16, 4, -6 },
  { 317, 8, 4, 16, 4, -10 },
  { 321, 6, 6, 16, 5, -6 },
  { 326, 14, 27, 16, 1, -22 },
  { 374, 14, 20, 16, 1, -20 },
  { 409, 13, 20, 16, 2, -20 },
  { 442, 14, 20, 16, 1, -20 },
  { 477, 13, 20, 16, 1, -20 },
  { 510, 14, 20, 16, 1, -20 },
  { 545, 13, 20, 16, 1, -20 },
  { 578, 14, 20, 16, 1, -20 },
  { 613, 13, 20, 16, 2, -20 },
  { 646, 14, 20, 16, 1, -20 },
  { 681, 14, 20, 16, 1, -20 },
  { 716, 6, 16, 16, 5, -16 },
  { 728, 7, 21, 16, 4, -16 },
  { 747, 14, 14, 16, 1, -15 },
  { 772, 14, 9, 16, 1, -13 },
  { 788, 14, 14, 16, 1, -15 },
  { 813, 12, 20, 16, 2, -20 },
  { 843, 14, 24, 16, 1, -20 },
  { 885, 16, 20, 16, 0, -20 },
  { 925, 13, 20, 16, 2, -20 },
  { 958, 14, 20, 16, 1, -20 },
  { 993, 13, 20, 16, 2, -20 },
  { 1026, 13, 20, 16, 2, -20 },
  { 1059, 12, 20, 16, 2, -20 },
  { 1089, 14, 20, 16, 1, -20 },
  { 1124, 14, 20, 16, 1, -20 },
  { 1159, 12, 20, 16, 2, -20 },
  { 1189, 13, 20, 16, 1, -20 },
  { 1222, 15, 20, 16, 1, -20 },
  { 1260, 13, 20, 16, 2, -20 },
  { 1293, 14, 20, 16, 1, -20 },
  { 1328, 14, 20, 16, 1, -20 },
  { 1363, 14, 20, 16, 1, -20 },
  { 1398, 13, 20, 16, 2, -20 },
  { 1431, 14, 25, 16, 1, -20 },
  { 1475, 14, 20, 16, 2, -20 },
  { 1510, 14, 20, 16, 1, -20 },
  { 1545, 14, 20, 16, 1, -20 },
  { 1580, 14, 20, 16, 1, -20 },
  { 1615, 16, 20, 16, 0, -20 },
  { 1655, 14, 20, 16, 1, -20 },
  { 1690, 16, 20, 16, 0, -20 },
  { 1730, 16, 20, 16, 0, -20 },
  { 1770, 14, 20, 16, 1, -20 },
  { 1805, 8, 27, 16, 4, -22 },
  { 1832, 13, 27, 16, 2, -22 },
  { 1876, 9, 27, 16, 3, -22 },
  { 1907, 15, 10, 16, 1, -20 },
  { 1926, 16, 3, 16, 0, 2 },
  { 1932, 7, 6, 16, 5, -22 },
  { 1938, 13, 15, 16, 1, -15 },
  { 1963, 13, 22, 16, 2, -22 },
  { 1999, 14, 15, 16, 1, -15 },
  { 2026, 13, 22, 16, 1, -22 },
  { 2062, 14, 15, 16, 1, -15 },
  { 2089, 15, 22, 16, 1, -22 },
  { 2131, 13, 20, 16, 1, -15 },
  { 2164, 12, 22, 16, 2, -22 },
  { 2197, 14, 22, 16, 1, -22 },
  { 2236, 11, 27, 16, 2, -22 },
  { 2274, 14, 22, 16, 2, -22 },
  { 2313, 14, 22, 16, 1, -22 },
  { 2352, 14, 15, 16, 1, -15 },
  { 2379, 12, 15, 16, 2, -15 },
  { 2402, 14, 15, 16, 1, -15 },
  { 2429, 13, 20, 16, 2, -15 },
  { 2462, 13, 20, 16, 1, -15 },
  { 2495, 12, 15, 16, 3, -15 },
  { 2518, 12, 15, 16, 2, -15 },
  { 2541, 14, 19, 16, 1, -19 },
  { 2575, 12, 15, 16, 2, -15 },
  { 2598, 16, 15, 16, 0, -15 },
  { 2628, 16, 15, 16, 0, -15 },
  { 2658, 14, 15, 16, 1, -15 },
  { 2685, 14, 20, 16, 1, -15 },
  { 2720, 12, 15, 16, 2, -15 },
  { 2743, 12, 27, 16, 2, -22 },
  { 2784, 4, 27, 16, 6, -22 },
  { 2798, 12, 27, 16, 2, -22 },
  { 2839, 15, 6, 16, 1, -11 },
};

const GFXfont UbuntuMono_Bold32pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Bold32pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Bold32pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _UBUNTUMONO_BOLD32PT7B_H_
