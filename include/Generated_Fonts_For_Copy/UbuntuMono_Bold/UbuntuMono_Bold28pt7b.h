#ifndef _UBUNTUMONO_BOLD28PT7B_H_
#define _UBUNTUMONO_BOLD28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Bold.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Bold28pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x70, 0x0F, 0xFF, 0xF0, 0xF3, 0xFC,
  0xFF, 0x3D, 0xCF, 0x73, 0x9C, 0xE7, 0x19, 0x86, 0x06, 0x30, 0x39, 0xC0,
  0xE7, 0x03, 0x9C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0x38, 0x1C, 0xE0,
  0x73, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE7, 0x03, 0x9C, 0x0E, 0x70,
  0x71, 0x80, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xFE, 0x3F, 0xE7, 0xFE, 0x78,
  0x27, 0x00, 0x70, 0x07, 0xC0, 0x7F, 0x83, 0xFC, 0x0F, 0xE0, 0x1F, 0x00,
  0xF0, 0x0F, 0x60, 0xFF, 0xFF, 0xFF, 0xE3, 0xF8, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0x38, 0x1D, 0xF0, 0xEE, 0xC3, 0x3B, 0x9C, 0xCE, 0xE3, 0xB3, 0x07,
  0xDC, 0x0E, 0xE0, 0x03, 0x00, 0x1D, 0xC0, 0xEF, 0x83, 0x37, 0x1D, 0xDC,
  0xE7, 0x73, 0x0D, 0xDC, 0x3E, 0xE0, 0x70, 0x1F, 0x01, 0xFC, 0x1F, 0xE0,
  0xE7, 0x07, 0x38, 0x39, 0xC1, 0xFC, 0x07, 0xC0, 0x7E, 0x77, 0xF3, 0xBB,
  0xDD, 0xC7, 0xCE, 0x1E, 0x70, 0xF3, 0xFF, 0x8F, 0xFE, 0x3E, 0x70, 0xFF,
  0xFF, 0xF7, 0x66, 0x02, 0x03, 0x83, 0xC3, 0xC3, 0xC3, 0xC1, 0xC1, 0xE0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x78, 0x1C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x02, 0x00, 0x20, 0x38, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x83, 0xC1, 0xC1, 0xE1, 0xE1, 0xE1, 0xF0, 0xE0, 0x20,
  0x00, 0x0F, 0x00, 0x70, 0x66, 0x67, 0xEE, 0xFF, 0xF3, 0xFC, 0x0F, 0x01,
  0xF8, 0x3D, 0xC3, 0x9C, 0x18, 0x80, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x39, 0xE7, 0xDF, 0x3C, 0x63, 0x9C, 0xE3, 0x00, 0xFF, 0xFF,
  0xFF, 0x77, 0xBF, 0xEF, 0x00, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01,
  0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0F,
  0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38,
  0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x00, 0x0F, 0x83, 0xFC, 0x7F, 0xE7,
  0x9E, 0xF0, 0xFE, 0x07, 0xE6, 0x7E, 0xF7, 0xEF, 0x7E, 0x67, 0xE0, 0x7E,
  0x07, 0xF0, 0xF7, 0x9E, 0x7F, 0xE3, 0xFC, 0x1F, 0x00, 0x03, 0x00, 0xF0,
  0x1F, 0x0F, 0xF0, 0x7F, 0x06, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x7F, 0xF7, 0xFF, 0x7F, 0xF0, 0x1F,
  0x07, 0xFC, 0xFF, 0xE6, 0x1E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x7F, 0xF7, 0xFF, 0x7F,
  0xF0, 0x1F, 0x07, 0xFC, 0x7F, 0xC6, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC1,
  0xFC, 0x1F, 0xC1, 0xFE, 0x01, 0xE0, 0x0F, 0x00, 0xF4, 0x1E, 0xFF, 0xEF,
  0xFC, 0x7F, 0x00, 0x01, 0xC0, 0x3C, 0x07, 0xC0, 0xFC, 0x1F, 0xC1, 0xDC,
  0x39, 0xC7, 0x9C, 0x71, 0xCE, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0x80, 0x38,
  0x03, 0x80, 0x3F, 0x07, 0xFC, 0x7F, 0xE0, 0x3E, 0x00, 0xE0, 0x0F, 0x00,
  0xE0, 0x1E, 0xFF, 0xEF, 0xFC, 0x7F, 0x00, 0x01, 0xE0, 0x7E, 0x1F, 0xE3,
  0xF0, 0x3C, 0x07, 0x80, 0x7F, 0x8F, 0xFC, 0xFF, 0xEF, 0x1E, 0xF0, 0xFF,
  0x0F, 0x70, 0xF7, 0x8E, 0x7F, 0xE3, 0xFC, 0x1F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0,
  0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x00, 0x1F,
  0x83, 0xFC, 0x7F, 0xE7, 0x0E, 0xF0, 0xE7, 0x0E, 0x79, 0xE3, 0xFC, 0x3F,
  0xC7, 0x3E, 0xF0, 0xFE, 0x07, 0xE0, 0x7F, 0x0F, 0x7F, 0xE7, 0xFE, 0x1F,
  0x80, 0x1F, 0x03, 0xFC, 0x7F, 0xE7, 0x1E, 0xF0, 0xFF, 0x0F, 0xF0, 0xF7,
  0x8F, 0x7F, 0xF3, 0xFF, 0x1F, 0xE0, 0x1E, 0x03, 0xE0, 0xFC, 0x7F, 0x87,
  0xF0, 0x78, 0x00, 0x77, 0xBF, 0xEF, 0x00, 0x00, 0x77, 0xBF, 0xEF, 0x00,
  0x1C, 0x78, 0xF9, 0xE1, 0xC0, 0x00, 0x00, 0x38, 0x79, 0xF1, 0xF3, 0xC1,
  0x87, 0x1C, 0xF0, 0xC0, 0x00, 0x20, 0x1E, 0x07, 0xF1, 0xFE, 0xFF, 0x0F,
  0x80, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x01, 0xF0, 0x02, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x40, 0x07, 0x80, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0x01, 0xF0, 0xFF,
  0x7F, 0xCF, 0xE0, 0x78, 0x04, 0x00, 0x3F, 0x3F, 0xEF, 0xFD, 0x0F, 0x01,
  0xC0, 0xF0, 0x78, 0x3C, 0x1E, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x03,
  0xE0, 0xF8, 0x1C, 0x00, 0x07, 0xC0, 0xFF, 0x8F, 0x1C, 0x70, 0x77, 0x03,
  0xB8, 0xFD, 0x8F, 0xEC, 0xFF, 0x67, 0x3F, 0x39, 0xF9, 0xCE, 0xCE, 0x76,
  0x73, 0xB3, 0xFD, 0x8F, 0xEE, 0x3F, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1F,
  0xE0, 0x3F, 0x80, 0x07, 0x80, 0x1E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x73, 0x81, 0xCE, 0x07, 0x38, 0x1C, 0xF0, 0xE1, 0xC3, 0xFF, 0x0F, 0xFC,
  0x7F, 0xF9, 0xE1, 0xE7, 0x03, 0x9C, 0x0E, 0xF0, 0x3C, 0xFE, 0x1F, 0xF3,
  0xFF, 0x71, 0xEE, 0x1D, 0xC3, 0xB8, 0xF7, 0xFC, 0xFF, 0x9F, 0xFB, 0x87,
  0xF0, 0x7E, 0x0F, 0xC3, 0xFF, 0xF7, 0xFE, 0xFF, 0x00, 0x07, 0xE1, 0xFF,
  0x3F, 0xF7, 0x82, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x82, 0x7F, 0xF3, 0xFF, 0x0F, 0xE0, 0xFE,
  0x1F, 0xF3, 0xFF, 0x71, 0xEE, 0x1F, 0xC3, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0xFE, 0x1F, 0xC7, 0xBF, 0xE7, 0xF8, 0xFE, 0x00, 0xFF,
  0xDF, 0xFB, 0xFF, 0x70, 0x0E, 0x01, 0xC0, 0x3F, 0xE7, 0xFC, 0xFF, 0x9C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFE, 0xFF, 0xBF, 0xEE,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x0F, 0xF1, 0xFF,
  0x3F, 0xE7, 0xC2, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFF, 0x0F, 0xF0, 0xF7, 0x8F, 0x7F, 0xF3, 0xFF, 0x0F, 0xF0, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xE7, 0xFC, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0xC3, 0xDF, 0xF7, 0xFE, 0x3F,
  0x00, 0xF0, 0xF7, 0x8F, 0x3C, 0x79, 0xE7, 0x8F, 0x38, 0x7B, 0xC3, 0xFC,
  0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0x3D, 0xE1, 0xE7, 0x8F, 0x3E, 0x78, 0xF3,
  0xC3, 0xDE, 0x1E, 0xF0, 0x78, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0xEF, 0x0E, 0xF0, 0xFF, 0x9F, 0xF9,
  0xFF, 0x9F, 0xFF, 0xFE, 0xF7, 0xEF, 0x7E, 0xF7, 0xE6, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x70, 0xE0, 0x7F, 0x07, 0xF8, 0x7F,
  0x87, 0xFC, 0x7F, 0xC7, 0xEE, 0x7E, 0xE7, 0xE7, 0x7E, 0x77, 0xE3, 0xFE,
  0x3F, 0xE1, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0x70, 0x1F, 0x83, 0xFC,
  0x7F, 0xE7, 0x9E, 0xF0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x0F, 0xF0, 0xF7, 0x9E, 0x7F, 0xE3, 0xFC, 0x1F, 0x80, 0xFF,
  0x1F, 0xFB, 0xFF, 0xF0, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xFF, 0xDF,
  0xFB, 0xFC, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x00, 0x1F,
  0x83, 0xFC, 0x7F, 0xE7, 0x9E, 0xF0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xF0, 0xF7, 0x9E, 0x7F, 0xE3, 0xFC, 0x1F,
  0x80, 0x70, 0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x07, 0xFE, 0x0F, 0xF8, 0xFF,
  0xCE, 0x3C, 0xE1, 0xCE, 0x1E, 0xE1, 0xCE, 0x3C, 0xFF, 0xCF, 0xF8, 0xFF,
  0x0E, 0x78, 0xE3, 0x8E, 0x3C, 0xE1, 0xEE, 0x1E, 0xE0, 0xE0, 0x1F, 0x83,
  0xFE, 0x7F, 0xE7, 0x04, 0xF0, 0x0F, 0x00, 0x7C, 0x07, 0xF8, 0x3F, 0xC0,
  0xFE, 0x01, 0xF0, 0x0F, 0x00, 0xF4, 0x0F, 0x7F, 0xEF, 0xFE, 0x3F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0x7F,
  0xE3, 0xFC, 0x1F, 0x80, 0xF0, 0x3D, 0xC0, 0xE7, 0x03, 0x9E, 0x1E, 0x78,
  0x78, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3C, 0xF0, 0x73, 0x81, 0xCE, 0x07,
  0x38, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xE0, 0x07, 0x80, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE6, 0x7E, 0xF7, 0xEF, 0x7E,
  0xF7, 0xFF, 0xFF, 0x9F, 0xF9, 0xFF, 0x9F, 0xF0, 0xF7, 0x0F, 0x70, 0xE0,
  0x78, 0x39, 0xE1, 0xE3, 0xC7, 0x07, 0x38, 0x1E, 0xE0, 0x3F, 0x00, 0xFC,
  0x01, 0xE0, 0x07, 0x80, 0x3F, 0x00, 0xFE, 0x07, 0xB8, 0x1C, 0xF0, 0xF3,
  0xC7, 0x87, 0x9E, 0x1E, 0x70, 0x38, 0x70, 0x39, 0xE0, 0xE7, 0x87, 0x8E,
  0x1C, 0x3C, 0xF0, 0x73, 0x81, 0xEE, 0x03, 0xF0, 0x0F, 0xC0, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x7F, 0xE7, 0xFE, 0x7F, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x70,
  0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xFF, 0xFF, 0xFF, 0x70, 0x07, 0x00, 0x78, 0x07, 0x80, 0x38, 0x03, 0xC0,
  0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x70,
  0x07, 0x00, 0x78, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1E,
  0x01, 0xE0, 0x0E, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x1F, 0x00, 0xFC, 0x07,
  0xF8, 0x1C, 0xF0, 0xF1, 0xC7, 0x87, 0x9C, 0x0F, 0x30, 0x30, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x21, 0xCF, 0xCF, 0x08, 0x3F, 0x87, 0xF8, 0xFF,
  0x80, 0xF0, 0x0E, 0x3F, 0xDF, 0xFF, 0xFF, 0xF0, 0xFE, 0x1F, 0xFF, 0xBF,
  0xF3, 0xFE, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3B, 0xC7,
  0xFE, 0xFF, 0xDE, 0x3F, 0x87, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7F, 0x0F,
  0xFF, 0xDF, 0xF1, 0xFC, 0x00, 0x0F, 0xE1, 0xFF, 0x3F, 0xE7, 0x80, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x7F, 0xF3, 0xFF, 0x0F,
  0xF0, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC7, 0xBB, 0xFF,
  0x7F, 0xFE, 0x3F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC1, 0xFC, 0x3F, 0x87, 0x7F,
  0xE7, 0xFC, 0x7F, 0x00, 0x0F, 0x83, 0xFC, 0x7F, 0xEF, 0x0F, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x82, 0x7F, 0xE3, 0xFE, 0x0F, 0xC0,
  0x03, 0xF0, 0x7F, 0xC7, 0xFC, 0x3C, 0x21, 0xC0, 0x0E, 0x03, 0xFF, 0xDF,
  0xFE, 0xFF, 0xF0, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1F, 0xE7, 0xFD, 0xFF, 0xFC,
  0x7F, 0x0F, 0xC1, 0xF8, 0x3F, 0x87, 0xF0, 0xEF, 0xFD, 0xFF, 0x8F, 0xF0,
  0x0E, 0x01, 0xD0, 0x7F, 0xFE, 0xFF, 0xCF, 0xE0, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0F, 0xF3, 0xFE, 0xFF, 0xF8, 0xFE, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1C, 0x1C, 0x01, 0xE0, 0x1E,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF1, 0x0F, 0xF0, 0x7F, 0x03,
  0xE0, 0x03, 0x81, 0xF0, 0x7C, 0x0E, 0x00, 0x00, 0x07, 0xFD, 0xFF, 0x7F,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x63, 0xDF, 0xFF, 0xF8, 0xFC, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE1, 0xEE, 0x3C, 0xE7, 0x8E, 0x70, 0xEE, 0x0F,
  0xC0, 0xFE, 0x0E, 0xF0, 0xE7, 0x8E, 0x78, 0xE3, 0xCE, 0x1E, 0xE1, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF1,
  0x0F, 0xF0, 0x7F, 0x03, 0xE0, 0xFD, 0xEF, 0xFF, 0xFF, 0xFE, 0xE7, 0xE6,
  0x7E, 0x67, 0xE6, 0x7E, 0x67, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x70, 0x7F, 0x3F, 0xEF, 0xFF, 0x8F, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xC0, 0x1F, 0x83, 0xFC, 0x7F, 0xEF, 0x0F,
  0xF0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0xFF, 0x0F, 0x7F, 0xE3, 0xFC,
  0x1F, 0x80, 0x7F, 0x1F, 0xF3, 0xFF, 0x71, 0xFE, 0x1F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE1, 0xFC, 0x3F, 0xFF, 0x7F, 0xEF, 0xF1, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x00, 0x1F, 0xC7, 0xFD, 0xFF, 0xFC, 0x7F, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xF0, 0xFE, 0x3D, 0xFF, 0xBF, 0xF1, 0xEE, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x3F, 0xFF, 0xFF, 0xFF, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0x3F, 0x9F,
  0xFF, 0xFB, 0x82, 0xF0, 0x3F, 0x07, 0xF8, 0x3F, 0x01, 0xF0, 0x7F, 0xFF,
  0xFF, 0x7F, 0x00, 0x04, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF1, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xE1,
  0x1F, 0xF0, 0xFF, 0x07, 0xF0, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xFC, 0x7F, 0xFD, 0xFF, 0x3F, 0x80, 0x70, 0x39,
  0xC0, 0xE7, 0x87, 0x9E, 0x1C, 0x38, 0x70, 0xF3, 0xC1, 0xCE, 0x07, 0x38,
  0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xE0, 0x07, 0x80, 0xE0, 0x1F, 0x80,
  0x76, 0x01, 0x98, 0xC6, 0x67, 0x99, 0xDE, 0xE7, 0x7B, 0x9D, 0xEE, 0x7F,
  0xF8, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x38, 0x70, 0xF0, 0xF7, 0x0E, 0x79,
  0xE3, 0xDC, 0x1F, 0x80, 0xF8, 0x0F, 0x01, 0xF8, 0x1F, 0xC3, 0x9C, 0x79,
  0xEF, 0x0F, 0xE0, 0x70, 0xF0, 0x7F, 0x0F, 0x70, 0xF7, 0x8E, 0x78, 0xE3,
  0x9E, 0x3D, 0xC3, 0xDC, 0x1D, 0xC1, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0x00,
  0xF0, 0x0E, 0x0F, 0xE0, 0xFC, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E,
  0x0F, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x1C, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xC3, 0xF1, 0xFC, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x03, 0xC3, 0xE0, 0xE0, 0x3E, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xFC, 0x3F, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x3F, 0x0F,
  0xE0, 0x78, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF0, 0x1F,
  0x01, 0xC1, 0xF0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x8F, 0xE3, 0xF0, 0xF8, 0x00, 0x38, 0x33, 0xF3, 0xBF, 0xFD, 0xCF, 0xEC,
  0x1C, 0x00,
};

const GFXglyph UbuntuMono_Bold28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 17, 14, 5, -17 },
  { 10, 10, 8, 14, 2, -19 },
  { 20, 14, 17, 14, 0, -17 },
  { 50, 12, 23, 14, 1, -20 },
  { 85, 14, 17, 14, 0, -17 },
  { 115, 13, 17, 14, 1, -17 },
  { 143, 4, 8, 14, 5, -19 },
  { 147, 9, 25, 14, 3, -20 },
  { 176, 9, 25, 14, 2, -20 },
  { 205, 12, 11, 14, 1, -17 },
  { 222, 12, 13, 14, 1, -13 },
  { 242, 6, 10, 14, 4, -5 },
  { 250, 8, 3, 14, 3, -9 },
  { 253, 5, 5, 14, 5, -5 },
  { 257, 12, 25, 14, 1, -20 },
  { 295, 12, 17, 14, 1, -17 },
  { 321, 12, 17, 14, 1, -17 },
  { 347, 12, 17, 14, 1, -17 },
  { 373, 12, 17, 14, 1, -17 },
  { 399, 12, 17, 14, 1, -17 },
  { 425, 12, 17, 14, 1, -17 },
  { 451, 12, 17, 14, 1, -17 },
  { 477, 12, 17, 14, 1, -17 },
  { 503, 12, 17, 14, 1, -17 },
  { 529, 12, 17, 14, 1, -17 },
  { 555, 5, 13, 14, 5, -13 },
  { 564, 7, 18, 14, 3, -13 },
  { 580, 12, 12, 14, 1, -13 },
  { 598, 12, 9, 14, 1, -11 },
  { 612, 12, 12, 14, 1, -13 },
  { 630, 10, 17, 14, 2, -17 },
  { 652, 13, 21, 14, 0, -17 },
  { 687, 14, 17, 14, 0, -17 },
  { 717, 11, 17, 14, 2, -17 },
  { 741, 12, 17, 14, 1, -17 },
  { 767, 11, 17, 14, 2, -17 },
  { 791, 11, 17, 14, 2, -17 },
  { 815, 10, 17, 14, 2, -17 },
  { 837, 12, 17, 14, 1, -17 },
  { 863, 12, 17, 14, 1, -17 },
  { 889, 11, 17, 14, 2, -17 },
  { 913, 11, 17, 14, 1, -17 },
  { 937, 13, 17, 14, 1, -17 },
  { 965, 11, 17, 14, 2, -17 },
  { 989, 12, 17, 14, 1, -17 },
  { 1015, 12, 17, 14, 1, -17 },
  { 1041, 12, 17, 14, 1, -17 },
  { 1067, 11, 17, 14, 2, -17 },
  { 1091, 12, 22, 14, 1, -17 },
  { 1124, 12, 17, 14, 2, -17 },
  { 1150, 12, 17, 14, 1, -17 },
  { 1176, 12, 17, 14, 1, -17 },
  { 1202, 12, 17, 14, 1, -17 },
  { 1228, 14, 17, 14, 0, -17 },
  { 1258, 12, 17, 14, 1, -17 },
  { 1284, 14, 17, 14, 0, -17 },
  { 1314, 14, 17, 14, 0, -17 },
  { 1344, 12, 17, 14, 1, -17 },
  { 1370, 8, 25, 14, 3, -20 },
  { 1395, 12, 25, 14, 1, -20 },
  { 1433, 8, 25, 14, 3, -20 },
  { 1458, 14, 9, 14, 0, -17 },
  { 1474, 14, 3, 14, 0, 2 },
  { 1480, 6, 5, 14, 4, -19 },
  { 1484, 11, 13, 14, 1, -13 },
  { 1502, 11, 19, 14, 2, -19 },
  { 1529, 12, 13, 14, 1, -13 },
  { 1549, 11, 19, 14, 1, -19 },
  { 1576, 12, 13, 14, 1, -13 },
  { 1596, 13, 19, 14, 1, -19 },
  { 1627, 11, 18, 14, 1, -13 },
  { 1652, 10, 19, 14, 2, -19 },
  { 1676, 12, 19, 14, 1, -19 },
  { 1705, 10, 24, 14, 1, -19 },
  { 1735, 12, 19, 14, 2, -19 },
  { 1764, 12, 19, 14, 1, -19 },
  { 1793, 12, 13, 14, 1, -13 },
  { 1813, 10, 13, 14, 2, -13 },
  { 1830, 12, 13, 14, 1, -13 },
  { 1850, 11, 18, 14, 2, -13 },
  { 1875, 11, 18, 14, 1, -13 },
  { 1900, 11, 13, 14, 2, -13 },
  { 1918, 10, 13, 14, 2, -13 },
  { 1935, 12, 17, 14, 1, -17 },
  { 1961, 10, 13, 14, 2, -13 },
  { 1978, 14, 13, 14, 0, -13 },
  { 2001, 14, 13, 14, 0, -13 },
  { 2024, 12, 13, 14, 1, -13 },
  { 2044, 12, 18, 14, 1, -13 },
  { 2071, 10, 13, 14, 2, -13 },
  { 2088, 10, 25, 14, 2, -20 },
  { 2120, 4, 25, 14, 5, -20 },
  { 2133, 10, 25, 14, 2, -20 },
  { 2165, 13, 5, 14, 1, -10 },
};

const GFXfont UbuntuMono_Bold28pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Bold28pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Bold28pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _UBUNTUMONO_BOLD28PT7B_H_
