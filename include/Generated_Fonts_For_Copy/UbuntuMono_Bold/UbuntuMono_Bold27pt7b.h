#ifndef _UBUNTUMONO_BOLD27PT7B_H_
#define _UBUNTUMONO_BOLD27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Bold.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Bold27pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEE, 0xE0, 0x0E, 0xFF, 0xE0, 0xF3, 0xF9,
  0xFC, 0xFE, 0x77, 0x3B, 0x9D, 0x8E, 0xC7, 0x0E, 0x70, 0x73, 0x83, 0x9C,
  0x1C, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0x9C, 0x1C, 0xE0, 0xC6, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x9C, 0xE0, 0xE6, 0x06, 0x70, 0x73, 0x80, 0x0E,
  0x00, 0xE0, 0x0E, 0x01, 0xFC, 0x3F, 0xE7, 0xFE, 0x70, 0x4F, 0x00, 0x78,
  0x07, 0xE0, 0x3F, 0x81, 0xFE, 0x07, 0xE0, 0x0F, 0x00, 0xF4, 0x0F, 0xFF,
  0xEF, 0xFE, 0x3F, 0x80, 0xE0, 0x0E, 0x00, 0xE0, 0x38, 0x1B, 0xE1, 0xBB,
  0x1D, 0x98, 0xCC, 0xCE, 0x76, 0xE1, 0xF6, 0x07, 0x70, 0x03, 0x00, 0x33,
  0x83, 0xBE, 0x1B, 0xB1, 0x99, 0x9C, 0xCC, 0xC7, 0x6C, 0x1F, 0xE0, 0xF0,
  0x1E, 0x03, 0xF0, 0x7F, 0x87, 0x38, 0x73, 0x87, 0x78, 0x7F, 0x03, 0xE0,
  0x7C, 0x6F, 0xEE, 0xEF, 0xEC, 0x7E, 0xC3, 0xCE, 0x3C, 0xFF, 0xE7, 0xFE,
  0x3E, 0x70, 0xFF, 0xFE, 0xEE, 0x66, 0x02, 0x0F, 0x1E, 0x3C, 0x38, 0x70,
  0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0x70,
  0x78, 0x3C, 0x1E, 0x0F, 0x02, 0x60, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1C, 0x0E, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x07,
  0x07, 0x87, 0x83, 0x87, 0x83, 0x80, 0x80, 0x0E, 0x01, 0xC1, 0x99, 0xBB,
  0xFF, 0xFE, 0x1E, 0x07, 0xE1, 0xDE, 0x39, 0xC2, 0x20, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x38, 0xF3, 0xCF, 0x3C, 0x73, 0x9C, 0x60, 0xFF, 0xFF,
  0xF8, 0x73, 0xFE, 0xF7, 0x00, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C,
  0x07, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C,
  0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C,
  0x00, 0x1F, 0x03, 0xFC, 0x7F, 0xC7, 0x1E, 0xF0, 0xEE, 0x0E, 0xE6, 0xEE,
  0xE7, 0xEE, 0x7E, 0x67, 0xE0, 0xEE, 0x0E, 0xF0, 0xE7, 0x1E, 0x7F, 0xC3,
  0xFC, 0x1F, 0x00, 0x07, 0x01, 0xE0, 0xFC, 0x7F, 0x87, 0xF0, 0xCE, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x1F, 0xFB,
  0xFF, 0x7F, 0xE0, 0x1F, 0x0F, 0xFB, 0xFF, 0x30, 0xF0, 0x1E, 0x03, 0xC0,
  0x70, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0xE0, 0x1F, 0xFB,
  0xFF, 0xFF, 0xE0, 0x3F, 0x1F, 0xF1, 0xFF, 0x30, 0xE0, 0x1E, 0x03, 0x80,
  0xF0, 0xFC, 0x1F, 0x83, 0xF8, 0x07, 0x80, 0x70, 0x0E, 0x83, 0xFF, 0xFF,
  0xFE, 0x7F, 0x00, 0x01, 0xC0, 0x3C, 0x07, 0xC0, 0xFC, 0x1D, 0xC1, 0xDC,
  0x39, 0xC7, 0x1C, 0x71, 0xCE, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3F, 0xC7, 0xF8, 0xFF, 0x1C, 0x03, 0x80,
  0x60, 0x1F, 0x83, 0xFC, 0x7F, 0xC0, 0x7C, 0x07, 0x80, 0x70, 0x0E, 0x03,
  0xFF, 0xF7, 0xFC, 0x7F, 0x00, 0x01, 0xC1, 0xF8, 0x7F, 0x1F, 0x07, 0x80,
  0xF0, 0x1F, 0xC7, 0xFE, 0xFF, 0xFE, 0x3F, 0xC3, 0xF8, 0x7F, 0x0E, 0xF3,
  0xDF, 0xF1, 0xFE, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x3C,
  0x07, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x00, 0x1F, 0x83, 0xFC, 0x7F, 0xE7, 0x1E, 0xF0,
  0xE7, 0x0E, 0x79, 0xC3, 0xF8, 0x3F, 0x87, 0x3E, 0xE0, 0xEE, 0x0E, 0xE0,
  0xEF, 0x1E, 0x7F, 0xE7, 0xFC, 0x1F, 0x80, 0x1F, 0x07, 0xF9, 0xFF, 0x38,
  0xFF, 0x0F, 0xC1, 0xFC, 0x3F, 0x87, 0x7F, 0xE7, 0xFC, 0x7F, 0x80, 0xF0,
  0x3C, 0x1F, 0x1F, 0xE3, 0xF0, 0x78, 0x00, 0x73, 0xFE, 0xF7, 0x00, 0x00,
  0x73, 0xFE, 0xF7, 0x00, 0x38, 0xF7, 0xCF, 0x38, 0x00, 0x00, 0x39, 0xF7,
  0xDF, 0x3C, 0x73, 0xBC, 0x60, 0x00, 0x60, 0x1E, 0x07, 0xE3, 0xFC, 0xFF,
  0x0F, 0x80, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7E, 0x01, 0xE0, 0x06, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x40, 0x0F, 0x03, 0xF8, 0x3F, 0xC0, 0xFE, 0x07, 0xC0, 0xF8, 0x7F, 0x7F,
  0x9F, 0xC1, 0xC0, 0x20, 0x00, 0x3E, 0x3F, 0xEF, 0xF9, 0x0F, 0x03, 0xC0,
  0xE0, 0x78, 0x3C, 0x1E, 0x07, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x03, 0xC0,
  0xF0, 0x1C, 0x00, 0x07, 0xC0, 0xFF, 0x0E, 0x1C, 0x60, 0x67, 0x03, 0xB8,
  0xFD, 0x9F, 0xEC, 0xFF, 0x67, 0x3F, 0x71, 0xFB, 0x8F, 0xCC, 0x76, 0x73,
  0xB3, 0xFD, 0x8F, 0xEE, 0x3E, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1F, 0xE0,
  0x3F, 0x00, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x80, 0xDC, 0x0E, 0xE0,
  0x73, 0x83, 0x9C, 0x38, 0xE1, 0xC7, 0x0F, 0xFC, 0x7F, 0xE7, 0xFF, 0x38,
  0x39, 0xC1, 0xEE, 0x0F, 0xF0, 0x38, 0xFF, 0x0F, 0xFC, 0xFF, 0xCF, 0x1E,
  0xF0, 0xEF, 0x0E, 0xF1, 0xCF, 0xF8, 0xFF, 0xCF, 0xFE, 0xF0, 0xEF, 0x0F,
  0xF0, 0xFF, 0x0E, 0xFF, 0xEF, 0xFC, 0xFF, 0x00, 0x0F, 0xC1, 0xFF, 0x3F,
  0xE7, 0x82, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0F, 0x00, 0xF0, 0x07, 0x82, 0x7F, 0xE3, 0xFF, 0x0F, 0xC0, 0xFF, 0x0F,
  0xF8, 0xFF, 0xCF, 0x1E, 0xF0, 0xEF, 0x0E, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0E, 0xF1, 0xEF, 0x3E, 0xFF, 0xCF, 0xF8, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0F, 0xFB, 0xFE, 0xFF, 0xB8,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFE, 0xFF, 0xBF, 0xEE, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x0F, 0xE1, 0xFE, 0x3F,
  0xE7, 0x82, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xEE, 0x0E, 0xE0,
  0xEE, 0x0E, 0xF0, 0xE7, 0x8E, 0x7F, 0xE3, 0xFE, 0x0F, 0xE0, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x87, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xE7,
  0xFC, 0xFF, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0xC7, 0x9F, 0xF7, 0xFC, 0x3F, 0x00, 0xF0, 0xEF,
  0x1E, 0xF1, 0xCF, 0x3C, 0xF7, 0x8F, 0x70, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F,
  0xF0, 0xF7, 0x8F, 0x78, 0xF3, 0xCF, 0x1E, 0xF1, 0xEF, 0x0F, 0xF0, 0xF0,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x60, 0xEF,
  0x0E, 0xF1, 0xEF, 0x1E, 0xF9, 0xEF, 0xBE, 0xFB, 0x6E, 0xF6, 0xEF, 0x7E,
  0xE7, 0xEE, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x70,
  0xE0, 0xFE, 0x1F, 0xC3, 0xFC, 0x7F, 0x8F, 0xF9, 0xFB, 0x3F, 0x77, 0xE6,
  0xFC, 0xFF, 0x8F, 0xF1, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x07, 0xE0, 0xE0,
  0x1F, 0x03, 0xFC, 0x7F, 0xC7, 0x1E, 0xF0, 0xEE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xE7, 0x1E, 0x7F, 0xC3, 0xFC,
  0x1F, 0x00, 0xFF, 0x0F, 0xFC, 0xFF, 0xEF, 0x1E, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x1E, 0xFF, 0xEF, 0xFC, 0xFF, 0x8F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x00, 0x1F, 0x03, 0xFC, 0x7F, 0xC7, 0x1E, 0xF0, 0xEE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xEF,
  0x1E, 0x7F, 0xE3, 0xFC, 0x1F, 0x80, 0xF0, 0x07, 0xF0, 0x3E, 0x00, 0xE0,
  0xFF, 0x0F, 0xFC, 0xFF, 0xCF, 0x1E, 0xF0, 0xEF, 0x0E, 0xF0, 0xEF, 0x1E,
  0xFF, 0xCF, 0xFC, 0xFF, 0x8F, 0x38, 0xF3, 0xCF, 0x1E, 0xF0, 0xEF, 0x0F,
  0xF0, 0xF0, 0x1F, 0x87, 0xFD, 0xFF, 0x78, 0x2F, 0x01, 0xE0, 0x1F, 0x03,
  0xF8, 0x3F, 0xC1, 0xFC, 0x07, 0x80, 0x70, 0x0E, 0x83, 0xFF, 0xFF, 0xFE,
  0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0x0F, 0xE3, 0xDF,
  0xFB, 0xFE, 0x1F, 0x80, 0xF0, 0x3B, 0x83, 0xDC, 0x1E, 0xE0, 0xE7, 0x87,
  0x1C, 0x38, 0xE3, 0xC7, 0x1C, 0x38, 0xE0, 0xE7, 0x07, 0x38, 0x3B, 0x80,
  0xDC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xEE, 0x7E, 0xE7, 0xEF, 0x7E, 0xF6, 0xFB,
  0x6F, 0xB6, 0xF9, 0xEF, 0x1E, 0xF1, 0xEF, 0x0E, 0x70, 0xE0, 0x70, 0x7B,
  0xC3, 0x8E, 0x3C, 0x79, 0xC1, 0xDE, 0x07, 0xE0, 0x3E, 0x00, 0xF0, 0x07,
  0x80, 0x7E, 0x03, 0xF0, 0x3B, 0xC3, 0xCE, 0x1C, 0x79, 0xE1, 0xCF, 0x0F,
  0xF0, 0x78, 0x70, 0x3B, 0x83, 0xDE, 0x1C, 0x70, 0xE3, 0x8E, 0x0E, 0x70,
  0x77, 0x83, 0xF8, 0x0F, 0xC0, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x7F, 0xEF, 0xFD, 0xFF, 0x80, 0xE0,
  0x38, 0x07, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x03, 0x80,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x03, 0x80,
  0x78, 0x0F, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x0E,
  0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0xC0,
  0x38, 0xFF, 0xFF, 0xF8, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0x80,
  0x7C, 0x03, 0xF0, 0x3F, 0xC3, 0xCE, 0x1C, 0x79, 0xE1, 0xCE, 0x0F, 0x30,
  0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x41, 0xCF, 0x8F, 0x08, 0x3F, 0x07,
  0xF8, 0xFF, 0x00, 0xF0, 0x0E, 0x7F, 0xDF, 0xFF, 0xFF, 0xF0, 0xFE, 0x1F,
  0xFF, 0xBF, 0xF3, 0xFC, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x3B, 0xC7, 0xFC, 0xFF, 0xDE, 0x7B, 0x87, 0x70, 0xFE, 0x1F, 0xC3, 0xF8,
  0x77, 0x1E, 0xFF, 0xDF, 0xF1, 0xF8, 0x00, 0x0F, 0xE3, 0xFE, 0x7F, 0xE7,
  0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x7F, 0xE3,
  0xFE, 0x0F, 0xE0, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC7,
  0xFB, 0xFF, 0x7F, 0xFE, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x8F, 0x7F, 0xEF, 0xFC, 0x7F, 0x00, 0x1F, 0x03, 0xFC, 0x7F, 0xEF, 0x0E,
  0xE0, 0xEF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x04, 0x7F, 0xE3, 0xFE,
  0x0F, 0xC0, 0x07, 0xE0, 0xFF, 0x1F, 0xF1, 0xE1, 0x1C, 0x01, 0xC0, 0xFF,
  0xEF, 0xFE, 0xFF, 0xE1, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x1F, 0xC7, 0xFD, 0xFF, 0xF8,
  0xFF, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xF1, 0xEF, 0xFD, 0xFF, 0x8F, 0xF0,
  0x1E, 0x83, 0xFF, 0xF7, 0xFC, 0x7F, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0F, 0xE3, 0xFE, 0xFF, 0xB8, 0xFE, 0x3F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1C, 0x1C, 0x01, 0xE0, 0x1E, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0xFE, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xE2, 0x0F, 0xE0, 0xFF, 0x03, 0xE0,
  0x03, 0x81, 0xE0, 0x78, 0x0E, 0x00, 0x00, 0x07, 0xFD, 0xFF, 0x7F, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3D,
  0x0F, 0x7F, 0xBF, 0xE3, 0xE0, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0xF7, 0x1C, 0xE7, 0x9D, 0xE3, 0xB8, 0x7E, 0x0F, 0xC1, 0xDC,
  0x3B, 0xC7, 0x3C, 0xE3, 0xDC, 0x3B, 0x87, 0x80, 0xFE, 0x0F, 0xE0, 0xFE,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xE2, 0x0F, 0xE0, 0xFF, 0x03,
  0xE0, 0xFF, 0xCF, 0xFE, 0xFF, 0xEC, 0xE7, 0xCE, 0x7C, 0xE7, 0xCE, 0x7C,
  0xE7, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x70, 0xFE, 0x3F, 0xEF,
  0xFB, 0x8F, 0xE3, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xC0, 0x1F, 0x03, 0xFC, 0x7F, 0xEF, 0x1E, 0xF0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFF, 0x1E, 0x7F, 0xE3, 0xFC, 0x1F, 0x00, 0xFE, 0x1F,
  0xF3, 0xFF, 0x71, 0xEE, 0x1D, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xDC, 0x7B,
  0xFF, 0x7F, 0xCF, 0xF1, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x00, 0x1F, 0xC7,
  0xFD, 0xFF, 0xF8, 0xFF, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFE, 0x3D,
  0xFF, 0xBF, 0xF1, 0xFE, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x00, 0x1F, 0xC7, 0xF9, 0xFF, 0x38, 0x27, 0x00, 0xFC, 0x0F,
  0xE0, 0x3E, 0x01, 0xE8, 0x1D, 0xFF, 0xBF, 0xE3, 0xF0, 0x04, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x1F, 0xE0, 0xFF, 0x07, 0xE0, 0xE3,
  0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xFC, 0xFF,
  0xFD, 0xFF, 0x3F, 0x80, 0x70, 0x3B, 0x83, 0xDE, 0x1C, 0xF0, 0xE3, 0x8F,
  0x1C, 0x70, 0xF3, 0x83, 0xBC, 0x1F, 0xC0, 0x7E, 0x03, 0xE0, 0x0F, 0x00,
  0x70, 0x00, 0xE0, 0x3F, 0x01, 0xD8, 0x0E, 0xCE, 0x76, 0x73, 0xB3, 0xDD,
  0x9E, 0xCF, 0xF6, 0x7D, 0xB3, 0xEF, 0x8F, 0x3C, 0x71, 0xE3, 0x8E, 0x00,
  0xE0, 0xF7, 0x1E, 0x79, 0xC3, 0xFC, 0x1F, 0x81, 0xF0, 0x0F, 0x01, 0xF8,
  0x3F, 0x83, 0xBC, 0x71, 0xEF, 0x0E, 0xE0, 0xF0, 0xF0, 0xFF, 0x0E, 0x70,
  0xE7, 0x0E, 0x79, 0xC3, 0x9C, 0x39, 0xC1, 0xDC, 0x1F, 0x81, 0xF8, 0x0F,
  0x00, 0xF0, 0x0F, 0x01, 0xE0, 0xFE, 0x0F, 0xC0, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1C, 0x0F, 0x07, 0x81, 0xC0, 0xE0, 0x78, 0x1C, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xC7, 0xF1, 0xFC, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x0F, 0x0F, 0x83, 0x80, 0xF8, 0x0F, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1F, 0xC7, 0xF0, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x3F, 0x0F, 0xE0, 0x78, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFC, 0x0F, 0x0F, 0xC3, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0xFE, 0x3F, 0x0F, 0x80, 0x38, 0x27,
  0xE7, 0xFF, 0xFE, 0x7E, 0xC1, 0xC0,
};

const GFXglyph UbuntuMono_Bold27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 17, 14, 5, -17 },
  { 10, 9, 8, 14, 2, -18 },
  { 19, 13, 17, 14, 0, -17 },
  { 47, 12, 22, 14, 1, -19 },
  { 80, 13, 17, 14, 0, -17 },
  { 108, 12, 17, 14, 1, -17 },
  { 134, 4, 8, 14, 5, -18 },
  { 138, 8, 23, 14, 3, -19 },
  { 161, 9, 23, 14, 2, -19 },
  { 187, 11, 10, 14, 1, -17 },
  { 201, 11, 13, 14, 1, -13 },
  { 219, 6, 9, 14, 3, -5 },
  { 226, 7, 3, 14, 3, -8 },
  { 229, 5, 5, 14, 4, -5 },
  { 233, 11, 23, 14, 1, -19 },
  { 265, 12, 17, 14, 1, -17 },
  { 291, 11, 17, 14, 1, -17 },
  { 315, 11, 17, 14, 1, -17 },
  { 339, 11, 17, 14, 1, -17 },
  { 363, 12, 17, 14, 1, -17 },
  { 389, 11, 17, 14, 1, -17 },
  { 413, 11, 17, 14, 1, -17 },
  { 437, 11, 17, 14, 1, -17 },
  { 461, 12, 17, 14, 1, -17 },
  { 487, 11, 17, 14, 1, -17 },
  { 511, 5, 13, 14, 4, -13 },
  { 520, 6, 17, 14, 3, -13 },
  { 533, 12, 12, 14, 1, -13 },
  { 551, 11, 9, 14, 1, -11 },
  { 564, 11, 12, 14, 1, -13 },
  { 581, 10, 17, 14, 2, -17 },
  { 603, 13, 21, 14, 0, -17 },
  { 638, 13, 17, 14, 0, -17 },
  { 666, 12, 17, 14, 1, -17 },
  { 692, 12, 17, 14, 1, -17 },
  { 718, 12, 17, 14, 1, -17 },
  { 744, 10, 17, 14, 2, -17 },
  { 766, 10, 17, 14, 2, -17 },
  { 788, 12, 17, 14, 1, -17 },
  { 814, 11, 17, 14, 1, -17 },
  { 838, 11, 17, 14, 1, -17 },
  { 862, 11, 17, 14, 1, -17 },
  { 886, 12, 17, 14, 1, -17 },
  { 912, 10, 17, 14, 2, -17 },
  { 934, 12, 17, 14, 1, -17 },
  { 960, 11, 17, 14, 1, -17 },
  { 984, 12, 17, 14, 1, -17 },
  { 1010, 12, 17, 14, 1, -17 },
  { 1036, 12, 21, 14, 1, -17 },
  { 1068, 12, 17, 14, 1, -17 },
  { 1094, 11, 17, 14, 1, -17 },
  { 1118, 12, 17, 14, 1, -17 },
  { 1144, 11, 17, 14, 1, -17 },
  { 1168, 13, 17, 14, 0, -17 },
  { 1196, 12, 17, 14, 1, -17 },
  { 1222, 13, 17, 14, 0, -17 },
  { 1250, 13, 17, 14, 0, -17 },
  { 1278, 11, 17, 14, 1, -17 },
  { 1302, 8, 23, 14, 3, -19 },
  { 1325, 11, 23, 14, 1, -19 },
  { 1357, 7, 23, 14, 3, -19 },
  { 1378, 13, 9, 14, 0, -17 },
  { 1393, 13, 3, 14, 0, 1 },
  { 1398, 6, 5, 14, 4, -19 },
  { 1402, 11, 13, 14, 1, -13 },
  { 1420, 11, 19, 14, 2, -19 },
  { 1447, 12, 13, 14, 1, -13 },
  { 1467, 11, 19, 14, 1, -19 },
  { 1494, 12, 13, 14, 1, -13 },
  { 1514, 12, 19, 14, 1, -19 },
  { 1543, 11, 17, 14, 1, -13 },
  { 1567, 10, 19, 14, 2, -19 },
  { 1591, 12, 19, 14, 1, -19 },
  { 1620, 10, 23, 14, 1, -19 },
  { 1649, 11, 19, 14, 2, -19 },
  { 1676, 12, 19, 14, 1, -19 },
  { 1705, 12, 13, 14, 1, -13 },
  { 1725, 10, 13, 14, 2, -13 },
  { 1742, 12, 13, 14, 1, -13 },
  { 1762, 11, 17, 14, 2, -13 },
  { 1786, 11, 17, 14, 1, -13 },
  { 1810, 10, 13, 14, 2, -13 },
  { 1827, 11, 13, 14, 1, -13 },
  { 1845, 12, 17, 14, 1, -17 },
  { 1871, 10, 13, 14, 2, -13 },
  { 1888, 13, 13, 14, 0, -13 },
  { 1910, 13, 13, 14, 0, -13 },
  { 1932, 12, 13, 14, 1, -13 },
  { 1952, 12, 17, 14, 1, -13 },
  { 1978, 10, 13, 14, 2, -13 },
  { 1995, 10, 23, 14, 2, -19 },
  { 2024, 3, 23, 14, 5, -19 },
  { 2033, 10, 23, 14, 2, -19 },
  { 2062, 12, 5, 14, 1, -10 },
};

const GFXfont UbuntuMono_Bold27pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Bold27pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Bold27pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _UBUNTUMONO_BOLD27PT7B_H_
