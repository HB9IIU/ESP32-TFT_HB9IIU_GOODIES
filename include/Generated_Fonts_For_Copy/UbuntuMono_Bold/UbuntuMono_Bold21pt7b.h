#ifndef _UBUNTUMONO_BOLD21PT7B_H_
#define _UBUNTUMONO_BOLD21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Bold.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Bold21pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x76, 0x00, 0x77, 0x70, 0xEF, 0xDF, 0x3E, 0x7C,
  0xD8, 0x80, 0x1D, 0x86, 0x61, 0x9B, 0xFF, 0xFF, 0xCE, 0xC3, 0x30, 0xCC,
  0xFF, 0xFF, 0xF3, 0x61, 0x98, 0x66, 0x00, 0x18, 0x0C, 0x0F, 0xCF, 0xEE,
  0x17, 0x03, 0x80, 0xF8, 0x3E, 0x07, 0x80, 0xE0, 0x78, 0x3F, 0xF9, 0xF0,
  0x30, 0x18, 0x00, 0x70, 0xFE, 0x2F, 0x9B, 0x6C, 0xFA, 0x1D, 0x80, 0xC0,
  0x3E, 0x1B, 0xCC, 0x93, 0x3D, 0x8F, 0xC3, 0x80, 0x1E, 0x0F, 0xC7, 0x31,
  0xCC, 0x36, 0x0F, 0x83, 0x9D, 0xF7, 0x6F, 0xB9, 0xE6, 0x39, 0xFE, 0x3D,
  0xC0, 0xFF, 0xED, 0x80, 0x04, 0x38, 0xF1, 0xC7, 0x0C, 0x38, 0x70, 0xC1,
  0x83, 0x07, 0x06, 0x0C, 0x1C, 0x1C, 0x1E, 0x08, 0x41, 0xC1, 0xC1, 0xC1,
  0xC3, 0x83, 0x06, 0x0E, 0x1C, 0x30, 0x60, 0xC3, 0x8E, 0x38, 0xE0, 0x80,
  0x1C, 0x2C, 0xBB, 0xDF, 0xF1, 0xC1, 0xF1, 0xDC, 0x48, 0x18, 0x0C, 0x06,
  0x1F, 0x0F, 0xFF, 0xFC, 0x60, 0x30, 0x18, 0x00, 0x77, 0x77, 0x3E, 0xC0,
  0xFF, 0xFF, 0xC0, 0x7F, 0xF7, 0x03, 0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x70,
  0x30, 0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x03, 0x03, 0x81, 0xC0, 0xC0, 0xE0,
  0x70, 0x00, 0x3C, 0x3F, 0xB9, 0xD8, 0x6C, 0x3E, 0xDF, 0x6F, 0xB7, 0xC3,
  0xE1, 0xB9, 0xCF, 0xE3, 0xC0, 0x0C, 0x1E, 0x1F, 0x1F, 0x85, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x0F, 0xF7, 0xF8, 0x3C, 0x7F, 0x11, 0xC0,
  0xE0, 0x70, 0x78, 0x78, 0x78, 0x38, 0x38, 0x38, 0x1F, 0xFF, 0xF8, 0x7C,
  0xFE, 0x47, 0x07, 0x07, 0x3E, 0x3E, 0x07, 0x03, 0x03, 0x87, 0xFF, 0xFC,
  0x07, 0x07, 0x87, 0xC7, 0xE3, 0x73, 0x3B, 0x9D, 0x8E, 0xFF, 0xFF, 0xC1,
  0xC0, 0xE0, 0x70, 0x7F, 0x7F, 0x60, 0x60, 0x60, 0x7C, 0x7E, 0x07, 0x03,
  0x03, 0x07, 0xFF, 0xFC, 0x07, 0x0F, 0x8E, 0x0E, 0x0E, 0x07, 0xF3, 0xFD,
  0xC6, 0xE3, 0xF1, 0xB9, 0xCF, 0xE3, 0xC0, 0xFF, 0xFF, 0xC1, 0xC0, 0xC0,
  0xE0, 0x60, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x00, 0x3E, 0x3F,
  0xB8, 0xDC, 0x6E, 0x33, 0xF1, 0xF9, 0xCE, 0xC3, 0xE1, 0xF8, 0xFF, 0xE3,
  0xE0, 0x3C, 0x3F, 0x39, 0xDC, 0x6C, 0x3F, 0x1F, 0xFE, 0xFE, 0x07, 0x03,
  0x87, 0x8F, 0x87, 0x00, 0x7F, 0xF7, 0x00, 0x7F, 0xF7, 0x3B, 0xDE, 0x70,
  0x00, 0xEF, 0x79, 0xC6, 0xE6, 0x00, 0x01, 0x07, 0x8F, 0xDF, 0x0E, 0x07,
  0xC0, 0xFC, 0x1E, 0x01, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC,
  0xC0, 0x78, 0x1F, 0x83, 0xF0, 0x38, 0xFD, 0xF9, 0xE0, 0xC0, 0x00, 0x7E,
  0x7F, 0x47, 0x07, 0x07, 0x1E, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x3C, 0x38,
  0x1F, 0x0F, 0xE7, 0x19, 0x83, 0x67, 0xD3, 0xFC, 0xCF, 0x73, 0xCC, 0xF3,
  0x34, 0xFD, 0x9F, 0x60, 0x0C, 0x03, 0xF8, 0x3E, 0x0E, 0x07, 0x81, 0xE0,
  0x7C, 0x1B, 0x0C, 0xC3, 0x38, 0xCE, 0x7F, 0x9F, 0xE6, 0x1D, 0x87, 0xE1,
  0xC0, 0xFC, 0x7F, 0xB9, 0xDC, 0x6E, 0x77, 0xF3, 0xFD, 0xC6, 0xE3, 0xF1,
  0xF8, 0xFF, 0xEF, 0xE0, 0x1F, 0x3F, 0xDC, 0x5C, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x70, 0x3C, 0x4F, 0xF1, 0xF0, 0xFC, 0x7F, 0x39, 0xDC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xB9, 0xDF, 0xCF, 0xC0, 0xFF, 0x7F,
  0xB8, 0x1C, 0x0E, 0x07, 0xFB, 0xFD, 0xC0, 0xE0, 0x70, 0x38, 0x1F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0x1F, 0xBF, 0x9C, 0x5C, 0x0C, 0x06, 0x03, 0x0F, 0x87, 0xC3,
  0xF1, 0xF8, 0xEF, 0xF3, 0xF8, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0xFF,
  0xFF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x38, 0xFF, 0xFF, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0xFF, 0xFF, 0x7F, 0x7F, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x07, 0x47, 0xFE, 0x7C, 0xE3, 0xF3,
  0xB9, 0x9D, 0xCF, 0xC7, 0xC3, 0xE1, 0xF8, 0xEE, 0x73, 0xB9, 0xDC, 0x7E,
  0x38, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1F, 0xFF, 0xF8, 0x71, 0x9C, 0x67, 0x39, 0xCF, 0x7A, 0xDB, 0xB6,
  0xED, 0xB3, 0x60, 0xD8, 0x36, 0x0D, 0x83, 0x60, 0xC0, 0xC3, 0xF1, 0xF8,
  0xFE, 0x7F, 0xBE, 0xDF, 0x7F, 0x9F, 0xCF, 0xE3, 0xF1, 0xF8, 0x7C, 0x38,
  0x3C, 0x3F, 0xB9, 0xD8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF9,
  0xCF, 0xE3, 0xC0, 0xFE, 0x7F, 0xB8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xFE,
  0xFE, 0x70, 0x38, 0x1C, 0x0E, 0x00, 0x3C, 0x3F, 0xB9, 0xD8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF9, 0xCF, 0xE3, 0xE0, 0xE0, 0x3E, 0x06,
  0xFC, 0x7F, 0xB9, 0xDC, 0x6E, 0x37, 0x3B, 0xFD, 0xF8, 0xEE, 0x73, 0xB9,
  0xDC, 0x7E, 0x38, 0x3E, 0x3F, 0xB8, 0x5C, 0x0E, 0x03, 0xC0, 0xF8, 0x1E,
  0x03, 0x81, 0xF0, 0xFF, 0xE7, 0xE0, 0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xF1, 0xF8, 0xCF, 0xE3, 0xE0,
  0xE1, 0xD8, 0x76, 0x1D, 0xC6, 0x71, 0x8C, 0xE3, 0x38, 0xCC, 0x3B, 0x06,
  0xC1, 0xE0, 0x78, 0x0E, 0x00, 0xE0, 0xD8, 0x36, 0x0D, 0x83, 0x60, 0xDB,
  0x36, 0xED, 0xFB, 0x7A, 0xDE, 0xF7, 0x39, 0xC6, 0x71, 0x80, 0x61, 0xDC,
  0x63, 0x38, 0xEC, 0x1F, 0x07, 0x80, 0xE0, 0x7C, 0x1B, 0x0E, 0xE7, 0x39,
  0xC7, 0xE1, 0xC0, 0xE1, 0xDC, 0x77, 0x18, 0xCE, 0x3B, 0x06, 0xC1, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0xFF, 0x7F, 0x81, 0xC1,
  0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x30, 0x38, 0x38, 0x1F, 0xFF, 0xF8, 0xFF,
  0xFE, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xFF,
  0xF0, 0xE0, 0x30, 0x18, 0x0E, 0x07, 0x01, 0x80, 0xE0, 0x70, 0x18, 0x0E,
  0x07, 0x01, 0x80, 0xE0, 0x70, 0x18, 0x0E, 0x07, 0x01, 0x80, 0xFF, 0xF0,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xFF, 0xF0,
  0x0E, 0x07, 0x81, 0xB0, 0xEE, 0x71, 0x98, 0x72, 0x08, 0xFF, 0xFF, 0xF0,
  0x43, 0x1E, 0x20, 0x7E, 0x7F, 0x07, 0x03, 0x7F, 0xFF, 0xE3, 0xE3, 0xFF,
  0x7F, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0xE7, 0xFB, 0x8D, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x6F, 0xF7, 0xE0, 0x1F, 0xBF, 0x9C, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xE0, 0x7F, 0x8F, 0xC0, 0x07, 0x07, 0x07, 0x07, 0x3F, 0xFF, 0xE7,
  0xC7, 0xC7, 0xC7, 0xC7, 0xE7, 0x7F, 0x3F, 0x3E, 0x3F, 0xB8, 0xD8, 0x7F,
  0xFF, 0xFF, 0x01, 0xC2, 0x7F, 0x1F, 0x80, 0x0F, 0x9F, 0xCE, 0x07, 0x0F,
  0xFF, 0xFC, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x3F,
  0x7F, 0xE3, 0xC3, 0xC3, 0xC3, 0xE3, 0xFF, 0x7F, 0x03, 0x87, 0xFE, 0xFC,
  0xE0, 0xE0, 0xE0, 0xE0, 0xFE, 0xFF, 0xE7, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3,
  0xE3, 0xE3, 0x38, 0x1C, 0x0E, 0x00, 0x0F, 0x87, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x06, 0x03, 0x01, 0xF8, 0x7C, 0x0E, 0x1C, 0x38, 0x07, 0xEF, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xD1, 0xFF, 0x7C, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x77, 0x3B, 0xB9, 0xF8, 0xF8, 0x7E, 0x3B, 0x9C, 0xEE, 0x77,
  0x1C, 0xF8, 0x7C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x03, 0x01, 0xF8, 0x7C, 0xFF, 0x7F, 0xF6, 0x7B, 0x3D, 0x9E, 0xCF,
  0x07, 0x83, 0xC1, 0xE0, 0xC0, 0xFE, 0xFF, 0xE7, 0xE3, 0xE3, 0xE3, 0xE3,
  0xE3, 0xE3, 0xE3, 0x3C, 0x3F, 0xB8, 0xD8, 0x7C, 0x3E, 0x1F, 0x0F, 0xCE,
  0x7F, 0x1E, 0x00, 0xFE, 0x7F, 0xB9, 0xDC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC6,
  0xFF, 0x7F, 0x38, 0x1C, 0x0E, 0x00, 0x3F, 0x7F, 0xE3, 0xE3, 0xC3, 0xC3,
  0xC3, 0xE3, 0x7F, 0x3F, 0x03, 0x03, 0x03, 0x7F, 0xFE, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x3F, 0x7F, 0xE0, 0xF0, 0x7C, 0x3F, 0x07,
  0x83, 0xFF, 0x7E, 0x38, 0x1C, 0x0E, 0x1F, 0xFF, 0xF9, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x27, 0xF1, 0xF8, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3,
  0xE3, 0xE3, 0x7F, 0x3F, 0xE1, 0xD8, 0x77, 0x19, 0xCE, 0x33, 0x8E, 0xC1,
  0xF0, 0x78, 0x1E, 0x03, 0x00, 0xC0, 0xF8, 0x3E, 0xCD, 0xBB, 0x6E, 0xDB,
  0xB7, 0xA9, 0xEE, 0x73, 0x8C, 0x60, 0x71, 0xCC, 0xE3, 0xB0, 0x7C, 0x0E,
  0x07, 0x81, 0xF0, 0xEE, 0x71, 0x98, 0x70, 0x71, 0xDC, 0x63, 0x18, 0xCE,
  0x3B, 0x86, 0xC1, 0xF0, 0x7C, 0x0E, 0x03, 0x80, 0xC1, 0xF0, 0xF8, 0x00,
  0x7F, 0x7F, 0x0F, 0x0E, 0x1C, 0x38, 0x38, 0x70, 0xFF, 0xFF, 0x0F, 0x1F,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x38, 0xF0, 0xF0, 0x38, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x1F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8,
  0xFC, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x0C, 0x0F, 0x0F, 0x0C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0xFC, 0xF8, 0x38, 0xDF, 0xFE, 0x78,
};

const GFXglyph UbuntuMono_Bold21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 4, 13, 11, 3, -13 },
  { 8, 7, 6, 11, 2, -14 },
  { 14, 10, 13, 11, 0, -13 },
  { 31, 9, 17, 11, 1, -15 },
  { 51, 10, 13, 11, 0, -13 },
  { 68, 10, 13, 11, 0, -13 },
  { 85, 3, 6, 11, 4, -14 },
  { 88, 7, 18, 11, 2, -15 },
  { 104, 7, 18, 11, 2, -15 },
  { 120, 9, 8, 11, 1, -13 },
  { 129, 9, 9, 11, 1, -10 },
  { 140, 4, 7, 11, 3, -4 },
  { 144, 6, 3, 11, 2, -7 },
  { 147, 4, 4, 11, 3, -4 },
  { 149, 9, 18, 11, 1, -15 },
  { 170, 9, 13, 11, 1, -13 },
  { 185, 9, 13, 11, 1, -13 },
  { 200, 9, 13, 11, 1, -13 },
  { 215, 8, 13, 11, 1, -13 },
  { 228, 9, 13, 11, 1, -13 },
  { 243, 8, 13, 11, 1, -13 },
  { 256, 9, 13, 11, 1, -13 },
  { 271, 9, 13, 11, 1, -13 },
  { 286, 9, 13, 11, 1, -13 },
  { 301, 9, 13, 11, 1, -13 },
  { 316, 4, 10, 11, 3, -10 },
  { 321, 5, 13, 11, 2, -10 },
  { 330, 9, 9, 11, 1, -10 },
  { 341, 9, 6, 11, 1, -9 },
  { 348, 9, 9, 11, 1, -10 },
  { 359, 8, 13, 11, 1, -13 },
  { 372, 10, 16, 11, 0, -13 },
  { 392, 10, 13, 11, 0, -13 },
  { 409, 9, 13, 11, 1, -13 },
  { 424, 9, 13, 11, 1, -13 },
  { 439, 9, 13, 11, 1, -13 },
  { 454, 9, 13, 11, 1, -13 },
  { 469, 8, 13, 11, 1, -13 },
  { 482, 9, 13, 11, 1, -13 },
  { 497, 9, 13, 11, 1, -13 },
  { 512, 8, 13, 11, 1, -13 },
  { 525, 8, 13, 11, 1, -13 },
  { 538, 9, 13, 11, 1, -13 },
  { 553, 9, 13, 11, 1, -13 },
  { 568, 10, 13, 11, 0, -13 },
  { 585, 9, 13, 11, 1, -13 },
  { 600, 9, 13, 11, 1, -13 },
  { 615, 9, 13, 11, 1, -13 },
  { 630, 9, 16, 11, 1, -13 },
  { 648, 9, 13, 11, 1, -13 },
  { 663, 9, 13, 11, 1, -13 },
  { 678, 9, 13, 11, 1, -13 },
  { 693, 9, 13, 11, 1, -13 },
  { 708, 10, 13, 11, 0, -13 },
  { 725, 10, 13, 11, 0, -13 },
  { 742, 10, 13, 11, 0, -13 },
  { 759, 10, 13, 11, 0, -13 },
  { 776, 9, 13, 11, 1, -13 },
  { 791, 6, 18, 11, 2, -15 },
  { 805, 9, 18, 11, 1, -15 },
  { 826, 6, 18, 11, 2, -15 },
  { 840, 10, 7, 11, 0, -13 },
  { 849, 10, 2, 11, 0, 1 },
  { 852, 5, 4, 11, 3, -15 },
  { 855, 8, 10, 11, 1, -10 },
  { 865, 9, 14, 11, 1, -14 },
  { 881, 9, 10, 11, 1, -10 },
  { 893, 8, 14, 11, 1, -14 },
  { 907, 9, 10, 11, 1, -10 },
  { 919, 9, 14, 11, 1, -14 },
  { 935, 8, 13, 11, 1, -10 },
  { 948, 8, 14, 11, 1, -14 },
  { 962, 9, 14, 11, 1, -14 },
  { 978, 7, 17, 11, 1, -14 },
  { 993, 9, 14, 11, 1, -14 },
  { 1009, 9, 14, 11, 1, -14 },
  { 1025, 9, 10, 11, 1, -10 },
  { 1037, 8, 10, 11, 1, -10 },
  { 1047, 9, 10, 11, 1, -10 },
  { 1059, 9, 13, 11, 1, -10 },
  { 1074, 8, 13, 11, 1, -10 },
  { 1087, 8, 10, 11, 2, -10 },
  { 1097, 8, 10, 11, 1, -10 },
  { 1107, 9, 13, 11, 1, -13 },
  { 1122, 8, 10, 11, 1, -10 },
  { 1132, 10, 10, 11, 0, -10 },
  { 1145, 10, 10, 11, 0, -10 },
  { 1158, 10, 10, 11, 0, -10 },
  { 1171, 10, 13, 11, 0, -10 },
  { 1188, 8, 10, 11, 1, -10 },
  { 1198, 8, 18, 11, 1, -15 },
  { 1216, 3, 18, 11, 4, -15 },
  { 1223, 8, 18, 11, 1, -15 },
  { 1241, 10, 3, 11, 0, -7 },
};

const GFXfont UbuntuMono_Bold21pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Bold21pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Bold21pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _UBUNTUMONO_BOLD21PT7B_H_
