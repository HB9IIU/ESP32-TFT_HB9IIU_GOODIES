#ifndef _UBUNTUMONO_BOLD18PT7B_H_
#define _UBUNTUMONO_BOLD18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Bold.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Bold18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFA, 0x1F, 0x80, 0xDE, 0xF7, 0xB8, 0x80, 0x1B, 0x0D,
  0x84, 0xDF, 0xFF, 0xF9, 0xB3, 0xFF, 0xFF, 0x64, 0x36, 0x1B, 0x00, 0x18,
  0x31, 0xFF, 0xFC, 0x38, 0x3E, 0x3E, 0x1E, 0x0E, 0x1F, 0xFF, 0xC7, 0x0E,
  0x00, 0x71, 0xE9, 0xB4, 0x9A, 0xC7, 0xC0, 0x40, 0x7C, 0x6B, 0x25, 0xB2,
  0xF1, 0xC0, 0x3C, 0x3F, 0x19, 0x8D, 0x83, 0x83, 0xD9, 0xBD, 0x8E, 0xE6,
  0x3F, 0x8F, 0xE0, 0xFF, 0xA4, 0x08, 0xE7, 0x18, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x38, 0x61, 0xC3, 0x82, 0x87, 0x1C, 0x61, 0x8C, 0x63, 0x18, 0xC6,
  0x33, 0x3B, 0x90, 0x38, 0x23, 0x5F, 0xF3, 0x8D, 0x8B, 0x00, 0x10, 0x20,
  0x47, 0xFF, 0xE2, 0x04, 0x08, 0x77, 0x73, 0x2C, 0xFF, 0xC0, 0xFF, 0x80,
  0x06, 0x1C, 0x30, 0x61, 0xC3, 0x06, 0x0C, 0x38, 0x60, 0xC3, 0x86, 0x0C,
  0x38, 0x60, 0x38, 0xFB, 0x1E, 0x3D, 0x7A, 0xF1, 0xE3, 0xC6, 0xF8, 0xE0,
  0x18, 0xF3, 0xE6, 0xC1, 0x83, 0x06, 0x0C, 0x19, 0xFF, 0xF8, 0x79, 0xFB,
  0x38, 0x30, 0xC3, 0x8E, 0x38, 0xE1, 0xFF, 0xF8, 0x79, 0xF8, 0x38, 0x73,
  0xC7, 0x83, 0x83, 0x0F, 0xFF, 0xE0, 0x06, 0x07, 0x07, 0x86, 0xC3, 0x63,
  0x33, 0xFF, 0xFF, 0x06, 0x03, 0x01, 0x80, 0x7E, 0xFD, 0x83, 0x07, 0x8F,
  0x83, 0x83, 0x0F, 0xFB, 0xE0, 0x0E, 0x7D, 0xC7, 0x0F, 0xDF, 0xF1, 0xE3,
  0xC6, 0xFC, 0xF0, 0xFF, 0xFC, 0x38, 0x61, 0xC3, 0x0E, 0x18, 0x30, 0x61,
  0xC0, 0x7D, 0xFF, 0x1E, 0x3E, 0xCF, 0xB3, 0xE3, 0xC7, 0xFD, 0xF0, 0x39,
  0xFB, 0x1E, 0x3C, 0x7F, 0xDF, 0x87, 0x1C, 0xF1, 0xC0, 0xFF, 0x81, 0xFF,
  0x77, 0x70, 0x07, 0x77, 0x36, 0xC0, 0x02, 0x3D, 0xF7, 0x8F, 0x0F, 0x87,
  0x81, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0xC1, 0xE1, 0xF0, 0x70, 0xEF,
  0xBC, 0x60, 0x79, 0xF8, 0x38, 0x70, 0xC3, 0x8E, 0x18, 0x00, 0x60, 0xC0,
  0x1E, 0x23, 0x61, 0x4F, 0xDF, 0xD9, 0xD9, 0xD9, 0xDF, 0x4F, 0x60, 0x30,
  0x1F, 0x1C, 0x0E, 0x05, 0x86, 0xC3, 0x61, 0xB1, 0xFC, 0xFE, 0x63, 0x31,
  0xB8, 0xE0, 0xFD, 0xFF, 0x1E, 0x3F, 0xDF, 0xB1, 0xE3, 0xC7, 0xFF, 0xF0,
  0x1F, 0x3F, 0x71, 0x60, 0x60, 0xE0, 0x60, 0x60, 0x71, 0x3F, 0x1F, 0xF8,
  0xFC, 0xCE, 0xC6, 0xC6, 0xC7, 0xC6, 0xC6, 0xCE, 0xFC, 0xF8, 0xFF, 0xFF,
  0x06, 0x0F, 0xDF, 0xB0, 0x60, 0xC1, 0xFF, 0xF8, 0xFF, 0xFF, 0x06, 0x0F,
  0xDF, 0xB0, 0x60, 0xC1, 0x83, 0x00, 0x1F, 0x3F, 0x71, 0x60, 0x60, 0xE3,
  0x63, 0x63, 0x73, 0x3F, 0x1F, 0xC7, 0x8F, 0x1E, 0x3F, 0xFF, 0xF1, 0xE3,
  0xC7, 0x8F, 0x18, 0xFF, 0xFC, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x39, 0xFF,
  0xF8, 0x7E, 0xFC, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x8F, 0xF9, 0xE0, 0xC6,
  0xCE, 0xCC, 0xD8, 0xF0, 0xF0, 0xD8, 0xDC, 0xCE, 0xC6, 0xC7, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xFF, 0xF8, 0x63, 0x31, 0x9D, 0xCA,
  0xA5, 0x52, 0xE9, 0x24, 0x82, 0x41, 0xE0, 0xF0, 0x60, 0xC7, 0xCF, 0x9F,
  0xBF, 0x7B, 0xF7, 0xE7, 0xCF, 0x8F, 0x18, 0x1E, 0x3F, 0x98, 0xCC, 0x66,
  0x37, 0x1D, 0x8C, 0xC6, 0x63, 0x3F, 0x87, 0x00, 0xFC, 0xFE, 0xC6, 0xC6,
  0xC6, 0xFE, 0xFC, 0xC0, 0xC0, 0xC0, 0xC0, 0x1E, 0x3F, 0x98, 0xCC, 0x66,
  0x37, 0x1D, 0x8C, 0xC6, 0x63, 0x3F, 0x8F, 0x81, 0x80, 0xF0, 0x18, 0xF8,
  0xFE, 0xCE, 0xC6, 0xCE, 0xFE, 0xF8, 0xCC, 0xCE, 0xC6, 0xC7, 0x7D, 0xFF,
  0x16, 0x0F, 0x0F, 0x87, 0x83, 0x87, 0xFD, 0xF0, 0xFF, 0xFF, 0xC7, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0xFD, 0xF0, 0xE3, 0xB1, 0x98, 0xCC, 0x66,
  0x31, 0xB0, 0xD8, 0x6C, 0x16, 0x0E, 0x07, 0x00, 0xC1, 0xE0, 0xF0, 0x48,
  0x24, 0x92, 0xE9, 0x54, 0xAA, 0x77, 0x31, 0x98, 0xC0, 0x63, 0x39, 0x8D,
  0x87, 0xC1, 0xC0, 0xE0, 0x78, 0x6C, 0x77, 0x31, 0xB8, 0xE0, 0xE3, 0xB1,
  0x98, 0xC6, 0xC3, 0x60, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0xFF,
  0xFC, 0x38, 0xE1, 0x87, 0x0C, 0x30, 0x61, 0xFF, 0xF8, 0xFF, 0xF1, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0xFF, 0xC1, 0xC1, 0x83, 0x07, 0x06,
  0x0C, 0x1C, 0x18, 0x30, 0x60, 0xE0, 0xC1, 0x83, 0x83, 0xFF, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8F, 0xFF, 0x1C, 0x0E, 0x0D, 0x8E, 0xE6,
  0x33, 0x08, 0xFF, 0xFF, 0xC0, 0xCE, 0x20, 0x7C, 0xFC, 0x1B, 0xFF, 0xF8,
  0xFF, 0xBF, 0xC1, 0x83, 0x06, 0x0F, 0xDF, 0xF1, 0xE3, 0xC7, 0x8F, 0xFF,
  0xE0, 0x3E, 0xFF, 0x86, 0x0C, 0x1C, 0x1F, 0x9F, 0x03, 0x03, 0x03, 0x03,
  0x3F, 0x7F, 0x63, 0x63, 0x63, 0x63, 0x7F, 0x3F, 0x3D, 0xFF, 0x1F, 0xFF,
  0xF8, 0x3F, 0x9F, 0x1F, 0x3F, 0x30, 0x70, 0xFE, 0xFE, 0x70, 0x70, 0x70,
  0x70, 0x70, 0x70, 0x3F, 0xFF, 0x1E, 0x3C, 0x78, 0xFF, 0xBF, 0x8F, 0xFB,
  0xE0, 0xC1, 0x83, 0x06, 0x0F, 0xDF, 0xF3, 0xE3, 0xC7, 0x8F, 0x1E, 0x30,
  0x70, 0xE0, 0x07, 0x8F, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xF8, 0xF0, 0x1C,
  0x70, 0x1F, 0x7C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x8F, 0xF7, 0x80, 0xC0,
  0xC0, 0xC0, 0xC0, 0xCE, 0xCC, 0xD8, 0xF0, 0xD8, 0xDC, 0xCE, 0xC6, 0xF1,
  0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xF8, 0xF0, 0xFF, 0xFE,
  0x4C, 0x99, 0x30, 0x60, 0xC1, 0xFD, 0xFF, 0x3E, 0x3C, 0x78, 0xF1, 0xE3,
  0x7C, 0xFE, 0xC6, 0xC6, 0xC6, 0xC6, 0xFE, 0x7C, 0xFD, 0xFF, 0x1E, 0x3C,
  0x78, 0xFF, 0xFE, 0xC1, 0x83, 0x00, 0x7F, 0xFF, 0x1E, 0x3C, 0x78, 0xFF,
  0xBF, 0x06, 0x0C, 0x18, 0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0x7F, 0xFB,
  0x03, 0xC3, 0xD0, 0xFF, 0xBE, 0x30, 0x30, 0xFE, 0xFE, 0x30, 0x30, 0x30,
  0x30, 0x3E, 0x3E, 0xC7, 0x8F, 0x1E, 0x3C, 0x7C, 0xFF, 0xBF, 0xE3, 0xB1,
  0x98, 0xCE, 0xC3, 0x61, 0xB0, 0x70, 0x38, 0xC1, 0xE0, 0xF2, 0x6B, 0xA5,
  0xD2, 0xA9, 0xDC, 0xC6, 0x63, 0x1B, 0x0D, 0x83, 0x81, 0xC1, 0xB1, 0x9C,
  0xC6, 0x63, 0x31, 0x9C, 0xC6, 0xC3, 0x60, 0xF0, 0x70, 0x18, 0x1C, 0x3C,
  0x3C, 0x00, 0xFF, 0xFC, 0x70, 0xC3, 0x0C, 0x3F, 0xFF, 0x1E, 0x7C, 0xC1,
  0x83, 0x06, 0x0C, 0x70, 0xF0, 0x60, 0xC1, 0x83, 0x06, 0x0F, 0x8F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xF0, 0x60, 0xC1, 0x83, 0x06, 0x0F,
  0x0E, 0x30, 0x60, 0xC1, 0x83, 0x3E, 0x78, 0x79, 0xBF, 0xB3, 0xC0,
};

const GFXglyph UbuntuMono_Bold18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 11, 9, 3, -11 },
  { 6, 5, 5, 9, 2, -12 },
  { 10, 9, 11, 9, 0, -11 },
  { 23, 7, 15, 9, 1, -13 },
  { 37, 9, 11, 9, 0, -11 },
  { 50, 9, 11, 9, 0, -11 },
  { 63, 3, 5, 9, 3, -12 },
  { 65, 6, 16, 9, 2, -13 },
  { 77, 5, 16, 9, 2, -13 },
  { 87, 7, 7, 9, 1, -11 },
  { 94, 7, 8, 9, 1, -8 },
  { 101, 4, 6, 9, 2, -3 },
  { 104, 5, 2, 9, 2, -6 },
  { 106, 3, 3, 9, 3, -3 },
  { 108, 7, 16, 9, 1, -13 },
  { 122, 7, 11, 9, 1, -11 },
  { 132, 7, 11, 9, 1, -11 },
  { 142, 7, 11, 9, 1, -11 },
  { 152, 7, 11, 9, 1, -11 },
  { 162, 9, 11, 9, 0, -11 },
  { 175, 7, 11, 9, 1, -11 },
  { 185, 7, 11, 9, 1, -11 },
  { 195, 7, 11, 9, 1, -11 },
  { 205, 7, 11, 9, 1, -11 },
  { 215, 7, 11, 9, 1, -11 },
  { 225, 3, 8, 9, 3, -8 },
  { 228, 4, 11, 9, 2, -8 },
  { 234, 7, 8, 9, 1, -9 },
  { 241, 7, 6, 9, 1, -7 },
  { 247, 7, 8, 9, 1, -9 },
  { 254, 7, 11, 9, 1, -11 },
  { 264, 8, 13, 9, 0, -11 },
  { 277, 9, 11, 9, 0, -11 },
  { 290, 7, 11, 9, 1, -11 },
  { 300, 8, 11, 9, 0, -11 },
  { 311, 8, 11, 9, 1, -11 },
  { 322, 7, 11, 9, 1, -11 },
  { 332, 7, 11, 9, 1, -11 },
  { 342, 8, 11, 9, 0, -11 },
  { 353, 7, 11, 9, 1, -11 },
  { 363, 7, 11, 9, 1, -11 },
  { 373, 7, 11, 9, 1, -11 },
  { 383, 8, 11, 9, 1, -11 },
  { 394, 7, 11, 9, 1, -11 },
  { 404, 9, 11, 9, 0, -11 },
  { 417, 7, 11, 9, 1, -11 },
  { 427, 9, 11, 9, 0, -11 },
  { 440, 8, 11, 9, 1, -11 },
  { 451, 9, 14, 9, 0, -11 },
  { 467, 8, 11, 9, 1, -11 },
  { 478, 7, 11, 9, 1, -11 },
  { 488, 9, 11, 9, 0, -11 },
  { 501, 7, 11, 9, 1, -11 },
  { 511, 9, 11, 9, 0, -11 },
  { 524, 9, 11, 9, 0, -11 },
  { 537, 9, 11, 9, 0, -11 },
  { 550, 9, 11, 9, 0, -11 },
  { 563, 7, 11, 9, 1, -11 },
  { 573, 5, 16, 9, 2, -13 },
  { 583, 7, 16, 9, 1, -13 },
  { 597, 5, 16, 9, 2, -13 },
  { 607, 9, 6, 9, 0, -11 },
  { 614, 9, 2, 9, 0, 1 },
  { 617, 4, 3, 9, 3, -12 },
  { 619, 7, 8, 9, 1, -8 },
  { 626, 7, 12, 9, 1, -12 },
  { 637, 7, 8, 9, 1, -8 },
  { 644, 8, 12, 9, 0, -12 },
  { 656, 7, 8, 9, 1, -8 },
  { 663, 8, 12, 9, 1, -12 },
  { 675, 7, 11, 9, 1, -8 },
  { 685, 7, 12, 9, 1, -12 },
  { 696, 7, 12, 9, 1, -12 },
  { 707, 6, 15, 9, 1, -12 },
  { 719, 8, 12, 9, 1, -12 },
  { 731, 7, 12, 9, 1, -12 },
  { 742, 7, 8, 9, 1, -8 },
  { 749, 7, 8, 9, 1, -8 },
  { 756, 8, 8, 9, 1, -8 },
  { 764, 7, 11, 9, 1, -8 },
  { 774, 7, 11, 9, 1, -8 },
  { 784, 6, 8, 9, 2, -8 },
  { 790, 7, 8, 9, 1, -8 },
  { 797, 8, 10, 9, 1, -10 },
  { 807, 7, 8, 9, 1, -8 },
  { 814, 9, 8, 9, 0, -8 },
  { 823, 9, 8, 9, 0, -8 },
  { 832, 9, 8, 9, 0, -8 },
  { 841, 9, 11, 9, 0, -8 },
  { 854, 7, 8, 9, 1, -8 },
  { 861, 7, 16, 9, 1, -13 },
  { 875, 3, 16, 9, 3, -13 },
  { 881, 7, 16, 9, 1, -13 },
  { 895, 9, 3, 9, 0, -6 },
};

const GFXfont UbuntuMono_Bold18pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Bold18pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Bold18pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _UBUNTUMONO_BOLD18PT7B_H_
