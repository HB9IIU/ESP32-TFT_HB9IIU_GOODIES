#ifndef _UBUNTUMONO_BOLD38PT7B_H_
#define _UBUNTUMONO_BOLD38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Bold.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Bold38pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x1E, 0x00, 0x00, 0x01, 0xC7, 0xDF, 0xDF, 0x1C, 0xF8, 0xFF,
  0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xBC, 0x7D, 0xE3, 0xCF, 0x1E, 0x78,
  0xF3, 0x83, 0x9C, 0x1C, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF1,
  0xC0, 0x71, 0xE0, 0x78, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC7, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0x1E, 0x07, 0x8E, 0x07, 0x8F,
  0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xFC,
  0x7E, 0x06, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x01, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7D, 0xE0, 0x7C, 0xFF, 0xFE, 0x7F, 0xFE,
  0x3F, 0xFE, 0x07, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x1E, 0x01, 0xEF, 0xE0, 0x39, 0xFC, 0x0E, 0x3B, 0xC3, 0xCE, 0x38,
  0x71, 0xC7, 0x1C, 0x38, 0xE7, 0x83, 0xBC, 0xE0, 0x7F, 0x38, 0x0F, 0xEF,
  0x00, 0x79, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0xF0, 0x03, 0xBF, 0x00, 0xF7,
  0xF0, 0x1D, 0xEE, 0x07, 0x39, 0xE1, 0xE7, 0x1C, 0x38, 0xE7, 0x8E, 0x1C,
  0xF3, 0xC3, 0xDC, 0x70, 0x3F, 0x9C, 0x07, 0xE7, 0x80, 0x78, 0x07, 0xC0,
  0x0F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xC7, 0x83, 0xE3, 0xC1, 0xE1,
  0xE0, 0x78, 0xF0, 0x3C, 0xF0, 0x1F, 0xF8, 0x07, 0xF0, 0x03, 0xF0, 0xE3,
  0xF8, 0xF3, 0xFE, 0x7B, 0xEF, 0xBD, 0xE3, 0xFE, 0xF0, 0xFF, 0x78, 0x3F,
  0x3C, 0x0F, 0x9F, 0x0F, 0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xBE, 0x1F,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x73, 0x9C, 0x00, 0x40, 0x1E, 0x03,
  0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x78,
  0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xE0, 0x1E, 0x00, 0x40, 0x20, 0x03,
  0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0,
  0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x01, 0xF0,
  0x0F, 0x00, 0x20, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x03, 0x1C, 0x27,
  0x39, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x1F, 0xC0, 0x7B,
  0xC1, 0xF7, 0xC3, 0xE7, 0xC3, 0x8E, 0x02, 0x08, 0x00, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x3F, 0x7F, 0x7F, 0x7F,
  0x3F, 0x1F, 0x0F, 0x0E, 0x3E, 0xFC, 0xF0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x38, 0xFB, 0xFF, 0xFF, 0xEF, 0x8E, 0x00, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC3, 0xE3, 0xE3, 0xE0,
  0xF9, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x7C, 0xE7, 0xFE, 0x73, 0xFF,
  0x7D, 0xFF, 0x9C, 0xFF, 0xCE, 0x7F, 0xE0, 0x3E, 0xF0, 0x1E, 0x78, 0x0F,
  0x3C, 0x07, 0x9F, 0x07, 0xC7, 0xC7, 0xC3, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F,
  0xE0, 0x0F, 0xE0, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0xFF, 0x07, 0xFE,
  0x1F, 0xFC, 0x3F, 0xF8, 0x3D, 0xF0, 0x43, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x07, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF,
  0x0F, 0xC0, 0x3F, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0x70, 0xFC, 0x60, 0x7C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xC0, 0xFF, 0xE3, 0xFF, 0xE3, 0xFF, 0xE7, 0x0F, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x1F, 0xF0, 0x3F, 0x80, 0x7F, 0xC0, 0xFF,
  0xC0, 0x1F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFF,
  0x03, 0xFF, 0xFF, 0xDF, 0xFF, 0x3F, 0xFC, 0x1F, 0xE0, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1E, 0xF8,
  0x1F, 0x7C, 0x0F, 0x3E, 0x0F, 0x1F, 0x0F, 0x8F, 0x87, 0x87, 0xC7, 0x83,
  0xE7, 0xC1, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1F, 0xC0, 0x3F, 0xF0, 0x3F, 0xFC, 0x3F, 0xFE,
  0x01, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x60, 0x7E, 0x7F, 0xFE, 0x7F, 0xFC, 0xFF, 0xF8, 0x1F, 0xC0,
  0x00, 0x3C, 0x03, 0xF8, 0x1F, 0xF0, 0x7F, 0xE1, 0xFC, 0x07, 0xE0, 0x1F,
  0x80, 0x3E, 0x00, 0x78, 0x01, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0xFF,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0xFB,
  0xE3, 0xF7, 0xFF, 0xC7, 0xFF, 0x07, 0xFC, 0x03, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7C,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF,
  0x87, 0xFF, 0xC7, 0xE3, 0xF3, 0xE0, 0xF9, 0xE0, 0x3C, 0xF8, 0x3E, 0x7C,
  0x1E, 0x1F, 0x9F, 0x07, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xE7, 0xF1,
  0xF0, 0xFC, 0xF0, 0x1E, 0x78, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xEF, 0x83,
  0xE7, 0xFF, 0xF1, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F,
  0xE0, 0xFF, 0xE3, 0xFF, 0xEF, 0xC7, 0xDF, 0x07, 0xFC, 0x0F, 0xF8, 0x0F,
  0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xFF, 0xF7, 0xFF, 0xE7, 0xFF, 0xC7,
  0xFF, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x87, 0xFE,
  0x0F, 0xF8, 0x1F, 0xE0, 0x3E, 0x00, 0x38, 0xFB, 0xFF, 0xFF, 0xEF, 0x8E,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x8F, 0xBF, 0xFF, 0xFE, 0xF8, 0xE0, 0x0E,
  0x0F, 0x8F, 0xE7, 0xF3, 0xF8, 0xF8, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0xF8, 0xFE, 0x7F, 0x3F, 0x8F, 0xC3, 0xE0, 0xE0, 0xF1, 0xF1,
  0xF0, 0xF0, 0x60, 0x00, 0x00, 0x04, 0x00, 0x1E, 0x00, 0xFE, 0x03, 0xFE,
  0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0x80, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0x80,
  0x7F, 0xF0, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x1E, 0x00, 0x04,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x40,
  0x01, 0xE0, 0x03, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF,
  0x80, 0x7F, 0x00, 0x3E, 0x01, 0xFC, 0x1F, 0xF8, 0xFF, 0xEF, 0xFE, 0x1F,
  0xF0, 0x3F, 0x80, 0x78, 0x00, 0x40, 0x00, 0x1F, 0x87, 0xFF, 0x3F, 0xFD,
  0xFF, 0xF6, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x81,
  0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xE0, 0x03, 0xF0,
  0x07, 0xFE, 0x07, 0xFF, 0x87, 0xC3, 0xE3, 0xC0, 0xF3, 0xC0, 0x39, 0xC0,
  0x1E, 0xE0, 0xFF, 0xF1, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xFC, 0x78, 0xFE,
  0x7C, 0x7F, 0x3C, 0x3F, 0x9E, 0x1F, 0xCF, 0x0F, 0xE7, 0x87, 0xF1, 0xE3,
  0xF8, 0xF1, 0xFE, 0x7F, 0xFF, 0x1F, 0xFB, 0x87, 0xFD, 0xE1, 0xFC, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x0F, 0x78, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0,
  0x3C, 0x78, 0x07, 0x8F, 0x81, 0xE1, 0xF0, 0x3C, 0x1E, 0x07, 0xFF, 0xC1,
  0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xF0, 0x1E, 0x3E, 0x03, 0xE7,
  0xC0, 0x7C, 0xF8, 0x0F, 0x9E, 0x01, 0xF7, 0xC0, 0x1F, 0xFF, 0xC0, 0xFF,
  0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF8, 0x7C, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8,
  0x3E, 0xF8, 0x3C, 0xF8, 0x7C, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF,
  0xFE, 0xF8, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0, 0x01, 0xFC, 0x03,
  0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xE3, 0xF0, 0x73, 0xF0, 0x09, 0xF0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x47, 0xE0, 0xE3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFC, 0x03, 0xF8,
  0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF8, 0xFC, 0xF8, 0x3E,
  0xF8, 0x3E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x3E,
  0xF8, 0x7E, 0xF8, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF,
  0x9F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBE,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0x83, 0xFF,
  0xC3, 0xFF, 0xE3, 0xF0, 0x33, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0x78, 0x0F, 0xBE, 0x07, 0xDF, 0x03, 0xE7, 0xE1,
  0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFE, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7D, 0x01, 0xF3, 0x87, 0xEF, 0xFF, 0xDF, 0xFF, 0x3F, 0xFC, 0x0F, 0xE0,
  0xF0, 0x3F, 0x78, 0x1F, 0x3C, 0x1F, 0x1E, 0x0F, 0x8F, 0x0F, 0x87, 0x8F,
  0xC3, 0xC7, 0xC1, 0xE7, 0xC0, 0xF7, 0xE0, 0x7B, 0xE0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xFC, 0x07, 0xBF, 0x03, 0xCF, 0xC1, 0xE3, 0xE0, 0xF1, 0xF8,
  0x78, 0x7E, 0x3C, 0x1F, 0x1E, 0x0F, 0xCF, 0x03, 0xE7, 0x81, 0xFB, 0xC0,
  0x7D, 0xE0, 0x3E, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x78, 0x0F, 0x3E,
  0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0xE3, 0xF3, 0xF1, 0xF9, 0xF8, 0xFC,
  0xEC, 0xFE, 0x77, 0x77, 0x7B, 0xBB, 0xBD, 0xFD, 0xFE, 0x7C, 0xFF, 0x3E,
  0x7F, 0x9F, 0x3F, 0xCF, 0x9F, 0xE3, 0x8F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF,
  0x87, 0xFF, 0x8F, 0xFF, 0x1F, 0xEF, 0x3F, 0xDE, 0x7F, 0x9E, 0xFF, 0x3D,
  0xFE, 0x3B, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0x03, 0xF0, 0x07,
  0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xE3, 0xF3, 0xE0, 0xF9, 0xE0, 0x3D,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xBC, 0x07, 0x9F,
  0x07, 0xCF, 0xC7, 0xE3, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xE0, 0x07, 0xE0,
  0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF8, 0x7E, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x7E,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xC0, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xE3, 0xF3, 0xE0,
  0xF9, 0xE0, 0x3D, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xBC, 0x07, 0x9F, 0x07, 0xCF, 0xC7, 0xE3, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F,
  0xF0, 0x0F, 0xE0, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xE0,
  0x03, 0xF0, 0x00, 0x38, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF,
  0x8F, 0x8F, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C,
  0x1F, 0x3E, 0x1F, 0x9F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC1,
  0xF3, 0xE0, 0xF8, 0xF8, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x07, 0xCF, 0x83,
  0xE7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0x0F, 0xF0, 0x7F, 0xF9, 0xFF,
  0xF3, 0xFF, 0xEF, 0xC0, 0x9F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x01,
  0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0x80,
  0x1F, 0x00, 0x1E, 0x00, 0x3D, 0x00, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFE, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0x78, 0x0F, 0x3C, 0x07, 0x9F, 0x07, 0xCF,
  0x83, 0xE7, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xE0, 0x78, 0x03,
  0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0x78, 0x0F,
  0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x83, 0xC1, 0xE0, 0x78, 0x3C,
  0x0F, 0x8F, 0x80, 0xF1, 0xF0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x7C, 0xF0,
  0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF1, 0xC7, 0xF8, 0xE3, 0xFC, 0xF9, 0xFE, 0x7C, 0xFF, 0x3E, 0x7F, 0xBF,
  0xBF, 0xDD, 0xDE, 0xEE, 0xEE, 0x77, 0x37, 0x3F, 0x1F, 0x9F, 0x8F, 0xCF,
  0xC7, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF0, 0x1E, 0x7C, 0x07,
  0xC7, 0xC0, 0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0x81, 0xF1, 0xF0, 0x1F, 0x3C,
  0x03, 0xEF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3D, 0xF0,
  0x0F, 0xBE, 0x01, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x07, 0xC3, 0xE0, 0xF8,
  0x78, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x03, 0xCF, 0x80, 0xF9,
  0xF0, 0x1F, 0x1F, 0x03, 0xC3, 0xE0, 0xF8, 0x3C, 0x1E, 0x07, 0xC7, 0xC0,
  0xF8, 0xF8, 0x0F, 0x9E, 0x01, 0xF7, 0xC0, 0x1E, 0xF0, 0x03, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F,
  0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8,
  0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80,
  0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x0F, 0x7C, 0x07, 0xCF,
  0x03, 0xE3, 0xE1, 0xF8, 0x7C, 0x7C, 0x1F, 0x3E, 0x03, 0xEF, 0x80, 0x78,
  0x40, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x20, 0x70, 0x7C, 0xFE, 0x7F, 0x1E, 0x06, 0x3F, 0xE0, 0xFF, 0xF0, 0xFF,
  0xF1, 0xFF, 0xE2, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x8F, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFE, 0x3F, 0xF0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFB, 0xF0, 0xFF,
  0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFC, 0x7E, 0xF8, 0x3E, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3E, 0xF8,
  0x7E, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x0F,
  0xFE, 0x3F, 0xFE, 0x7F, 0xFE, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x02, 0x7F, 0xFE, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFC, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x0F, 0xDE, 0x3F, 0xFC, 0xFF, 0xFB, 0xFF, 0xF7, 0xC3, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC1,
  0xEF, 0xC3, 0xDF, 0xFF, 0x9F, 0xFF, 0x1F, 0xFE, 0x0F, 0xF8, 0x03, 0xF0,
  0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xC7, 0xE1, 0xF3, 0xE0, 0x7B, 0xE0,
  0x3D, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x30, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFE, 0x07, 0xC1,
  0x83, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF,
  0xFF, 0xF3, 0xFF, 0xFC, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x03, 0xFC, 0x0F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7E, 0x1F, 0x7C, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x1F,
  0x7C, 0x1F, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xDF, 0x00, 0x1F,
  0x00, 0x1E, 0x60, 0x3E, 0x7F, 0xFE, 0x7F, 0xFC, 0x7F, 0xF8, 0x1F, 0xE0,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xEF, 0x87,
  0xDF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7C, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x08,
  0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0xE0, 0x0F,
  0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7F, 0xFB,
  0xFF, 0xDF, 0xFE, 0xFF, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x07, 0xC0, 0x3E, 0xC1, 0xF7, 0xFF, 0x7F, 0xFB, 0xFF, 0x83,
  0xF0, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x3E, 0x7C, 0x3F, 0x3E, 0x1F,
  0x1F, 0x1F, 0x0F, 0x9F, 0x07, 0xDF, 0x03, 0xEF, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xE0, 0x3E, 0xF8, 0x1F, 0x3E, 0x0F, 0x8F, 0x87, 0xC7, 0xE3,
  0xE1, 0xF1, 0xF0, 0x7C, 0xF8, 0x3F, 0x7C, 0x0F, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x08, 0x0F, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0x80, 0x3F, 0x00, 0x3F, 0x3E, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF,
  0xFF, 0xFF, 0x3C, 0x7F, 0x9E, 0x3F, 0xC7, 0x1F, 0xE3, 0x8F, 0xF1, 0xC7,
  0xF8, 0xE3, 0xFC, 0x71, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xC0, 0x3F, 0xE1, 0xFF, 0xF3,
  0xFF, 0xE7, 0xFF, 0xEF, 0x87, 0xDF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7C, 0x03, 0xE0, 0x07, 0xFE, 0x0F, 0xFF,
  0x87, 0xFF, 0xC7, 0xE3, 0xF3, 0xE0, 0xFB, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xF7, 0xC1, 0xF3, 0xF1, 0xF8,
  0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xF8, 0x01, 0xF0, 0x00, 0x3F, 0xE0, 0xFF,
  0xF8, 0xFF, 0xFC, 0xFF, 0xFC, 0xF8, 0x7E, 0xF8, 0x3E, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3E, 0xF8,
  0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFB, 0xE0, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x03, 0xFC, 0x0F,
  0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x7E, 0x1F, 0x7C, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x1F, 0x7E,
  0x3F, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xDF, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0xF9, 0xFF, 0xF3, 0xFF,
  0xE7, 0xC1, 0x8F, 0x00, 0x1F, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x3F, 0xF0,
  0x0F, 0xF0, 0x03, 0xF0, 0x03, 0xEC, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xF8, 0x3F, 0xC0, 0x01, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x40, 0xFF, 0xF0, 0x7F, 0xF8,
  0x1F, 0xFC, 0x03, 0xFC, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xEF, 0x87, 0xDF, 0xFF, 0x9F, 0xFF, 0x3F, 0xFE,
  0x1F, 0xE0, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xEF, 0x01, 0xE7, 0xC1,
  0xF3, 0xE0, 0xF8, 0xF0, 0x78, 0x7C, 0x7C, 0x3E, 0x3E, 0x0F, 0x3E, 0x07,
  0xDF, 0x03, 0xEF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x01, 0xEE, 0x00, 0x39, 0xE0, 0x0F,
  0x3C, 0x01, 0xE7, 0x8E, 0x3C, 0xF1, 0xE7, 0x9E, 0x7C, 0xF3, 0xCF, 0x9E,
  0x79, 0xF3, 0xCF, 0x7F, 0x70, 0xEE, 0xEE, 0x1D, 0xDD, 0xC3, 0xBB, 0xB8,
  0x7E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xF8, 0x1E, 0x0F, 0x03, 0xC1, 0xE0,
  0xF8, 0x0F, 0xBE, 0x0F, 0x8F, 0x07, 0x87, 0xC7, 0xC1, 0xF7, 0xC0, 0x7F,
  0xC0, 0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x01,
  0xFF, 0x01, 0xF7, 0xC0, 0xF1, 0xF0, 0xF8, 0xF8, 0xF8, 0x3E, 0x78, 0x0F,
  0x7C, 0x07, 0xC0, 0x78, 0x0F, 0xBE, 0x07, 0xDF, 0x03, 0xCF, 0x83, 0xE3,
  0xC1, 0xF1, 0xF0, 0xF0, 0xF8, 0x78, 0x3C, 0x7C, 0x1F, 0x3E, 0x0F, 0x9E,
  0x03, 0xCF, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x10, 0xF8, 0x0F, 0xFC, 0x07,
  0xFC, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF,
  0xFE, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01,
  0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7C, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xF0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xFF, 0xC1, 0xFF,
  0x81, 0xFF, 0x01, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xC0, 0xFF, 0x00, 0x1E, 0x03, 0x0F, 0xE0, 0xE7, 0xFC, 0x7B, 0xFF, 0xFE,
  0xF1, 0xFF, 0x18, 0x3F, 0x80, 0x03, 0xC0,
};

const GFXglyph UbuntuMono_Bold38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 7, 24, 19, 6, -24 },
  { 22, 13, 11, 19, 3, -26 },
  { 40, 17, 24, 19, 1, -24 },
  { 91, 17, 31, 19, 1, -27 },
  { 157, 19, 24, 19, 0, -24 },
  { 214, 17, 24, 19, 1, -24 },
  { 265, 5, 11, 19, 7, -26 },
  { 272, 12, 33, 19, 4, -27 },
  { 322, 13, 33, 19, 3, -27 },
  { 376, 15, 15, 19, 2, -24 },
  { 405, 15, 18, 19, 2, -18 },
  { 439, 8, 13, 19, 5, -7 },
  { 452, 11, 5, 19, 4, -12 },
  { 459, 7, 7, 19, 6, -7 },
  { 466, 15, 33, 19, 2, -27 },
  { 528, 17, 24, 19, 1, -24 },
  { 579, 15, 24, 19, 2, -24 },
  { 624, 16, 24, 19, 2, -24 },
  { 672, 15, 24, 19, 2, -24 },
  { 717, 17, 24, 19, 1, -24 },
  { 768, 16, 24, 19, 1, -24 },
  { 816, 15, 24, 19, 2, -24 },
  { 861, 15, 24, 19, 2, -24 },
  { 906, 17, 24, 19, 1, -24 },
  { 957, 15, 24, 19, 2, -24 },
  { 1002, 7, 19, 19, 6, -19 },
  { 1019, 9, 25, 19, 4, -19 },
  { 1048, 16, 16, 19, 2, -18 },
  { 1080, 15, 12, 19, 2, -15 },
  { 1103, 15, 17, 19, 2, -18 },
  { 1135, 13, 24, 19, 3, -24 },
  { 1174, 17, 29, 19, 1, -24 },
  { 1236, 19, 24, 19, 0, -24 },
  { 1293, 16, 24, 19, 2, -24 },
  { 1341, 17, 24, 19, 1, -24 },
  { 1392, 16, 24, 19, 2, -24 },
  { 1440, 15, 24, 19, 2, -24 },
  { 1485, 15, 24, 19, 2, -24 },
  { 1530, 17, 24, 19, 1, -24 },
  { 1581, 15, 24, 19, 2, -24 },
  { 1626, 15, 24, 19, 2, -24 },
  { 1671, 15, 24, 19, 2, -24 },
  { 1716, 17, 24, 19, 2, -24 },
  { 1767, 14, 24, 19, 3, -24 },
  { 1809, 17, 24, 19, 1, -24 },
  { 1860, 15, 24, 19, 2, -24 },
  { 1905, 17, 24, 19, 1, -24 },
  { 1956, 16, 24, 19, 2, -24 },
  { 2004, 17, 30, 19, 1, -24 },
  { 2068, 17, 24, 19, 2, -24 },
  { 2119, 15, 24, 19, 2, -24 },
  { 2164, 17, 24, 19, 1, -24 },
  { 2215, 17, 24, 19, 1, -24 },
  { 2266, 19, 24, 19, 0, -24 },
  { 2323, 17, 24, 19, 1, -24 },
  { 2374, 19, 24, 19, 0, -24 },
  { 2431, 19, 24, 19, 0, -24 },
  { 2488, 15, 24, 19, 2, -24 },
  { 2533, 11, 33, 19, 4, -27 },
  { 2579, 15, 33, 19, 2, -27 },
  { 2641, 11, 33, 19, 4, -27 },
  { 2687, 18, 12, 19, 1, -24 },
  { 2714, 19, 4, 19, 0, 2 },
  { 2724, 8, 7, 19, 6, -26 },
  { 2731, 15, 18, 19, 2, -18 },
  { 2765, 16, 26, 19, 2, -26 },
  { 2817, 16, 18, 19, 2, -18 },
  { 2853, 15, 26, 19, 1, -26 },
  { 2902, 17, 18, 19, 1, -18 },
  { 2941, 18, 26, 19, 1, -26 },
  { 3000, 16, 24, 19, 1, -18 },
  { 3048, 15, 26, 19, 2, -26 },
  { 3097, 17, 26, 19, 1, -26 },
  { 3153, 13, 32, 19, 2, -26 },
  { 3205, 17, 26, 19, 2, -26 },
  { 3261, 17, 26, 19, 1, -26 },
  { 3317, 17, 18, 19, 1, -18 },
  { 3356, 15, 18, 19, 2, -18 },
  { 3390, 17, 18, 19, 1, -18 },
  { 3429, 16, 24, 19, 2, -18 },
  { 3477, 16, 24, 19, 1, -18 },
  { 3525, 14, 18, 19, 3, -18 },
  { 3557, 15, 18, 19, 2, -18 },
  { 3591, 17, 23, 19, 1, -23 },
  { 3640, 15, 18, 19, 2, -18 },
  { 3674, 17, 18, 19, 1, -18 },
  { 3713, 19, 18, 19, 0, -18 },
  { 3756, 17, 18, 19, 1, -18 },
  { 3795, 17, 24, 19, 1, -18 },
  { 3846, 14, 18, 19, 3, -18 },
  { 3878, 15, 33, 19, 2, -27 },
  { 3940, 5, 33, 19, 7, -27 },
  { 3961, 15, 33, 19, 2, -27 },
  { 4023, 18, 7, 19, 1, -14 },
};

const GFXfont UbuntuMono_Bold38pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Bold38pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Bold38pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _UBUNTUMONO_BOLD38PT7B_H_
