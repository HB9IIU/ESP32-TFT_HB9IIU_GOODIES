#ifndef _UBUNTUMONO_BOLD49PT7B_H_
#define _UBUNTUMONO_BOLD49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Bold.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Bold49pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x3E, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x3C, 0xFE, 0x3F, 0xFE, 0x3F,
  0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0x7C, 0x3F, 0x7C, 0x3F,
  0x7C, 0x3F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1E, 0x7C, 0x1E, 0x38, 0x1E,
  0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80,
  0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C,
  0x3E, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87,
  0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC7, 0xC3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x1F, 0x00,
  0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x0F,
  0xC7, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xC0, 0x78, 0xFC, 0x00, 0x47, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0xC0, 0x07, 0xF7, 0xC0, 0x7F, 0x3F, 0xFF, 0xFB, 0xFF, 0xFF,
  0x9F, 0xFF, 0xF8, 0x7F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3F, 0xC0, 0x0F, 0x3F, 0xC0, 0x1E, 0x7F, 0xE0, 0x3E, 0x79, 0xE0,
  0x3C, 0x79, 0xE0, 0x78, 0x71, 0xE0, 0xF8, 0xF0, 0xF0, 0xF0, 0xF0, 0xF1,
  0xE0, 0x71, 0xE3, 0xE0, 0x79, 0xE3, 0xC0, 0x79, 0xE7, 0x80, 0x7F, 0xEF,
  0x80, 0x3F, 0xCF, 0x00, 0x3F, 0xDE, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x3C,
  0xF8, 0x00, 0x79, 0xFC, 0x00, 0xFB, 0xFE, 0x00, 0xF3, 0xFE, 0x01, 0xE7,
  0xDF, 0x03, 0xE7, 0x8F, 0x03, 0xC7, 0x8F, 0x07, 0x87, 0x8F, 0x0F, 0x87,
  0x8F, 0x0F, 0x07, 0x8F, 0x1E, 0x07, 0x8F, 0x3E, 0x07, 0xDF, 0x3C, 0x03,
  0xFE, 0x78, 0x03, 0xFE, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x01, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x07, 0xE3, 0xF0, 0x0F, 0xC3, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80,
  0x7E, 0x1F, 0x00, 0x7C, 0x7C, 0x00, 0xFD, 0xF8, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0x01, 0xFC, 0x3C, 0x07, 0xF8, 0x7C, 0x1F, 0xF8, 0xF8, 0x7F,
  0xF9, 0xF1, 0xFB, 0xF3, 0xE3, 0xE3, 0xF7, 0xCF, 0x83, 0xFF, 0x9F, 0x03,
  0xFE, 0x3E, 0x03, 0xFC, 0x7C, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xFC, 0x3F,
  0xE1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC3, 0xFF, 0x9F,
  0x81, 0xFC, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x7E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xCF, 0x1E, 0x00, 0x00, 0x08, 0x00, 0x78, 0x01, 0xF0,
  0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x3F,
  0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x20, 0x10, 0x00, 0x38, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7E,
  0x00, 0x3C, 0x00, 0x10, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x30, 0xF8, 0x63, 0x8F, 0x9E, 0x7E, 0xF3, 0xE7, 0xF7,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xC0, 0x1F, 0x80, 0x03,
  0xFE, 0x00, 0x7D, 0xF0, 0x0F, 0xDF, 0x81, 0xF9, 0xFC, 0x3F, 0x8F, 0xC0,
  0xF8, 0xF8, 0x07, 0x07, 0x00, 0x20, 0x40, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x83, 0xF8, 0x7F,
  0x1F, 0xF3, 0xFE, 0x7F, 0xC7, 0xF8, 0xFF, 0x0F, 0xE0, 0x78, 0x1F, 0x07,
  0xE3, 0xF9, 0xFE, 0x3F, 0x83, 0xE0, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3C, 0x3F, 0xBF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFE, 0x3C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF,
  0x83, 0xFF, 0xFC, 0x1F, 0x87, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0x7E, 0xFC,
  0x03, 0xF7, 0xE0, 0x0F, 0xBF, 0x00, 0x7D, 0xF0, 0x03, 0xFF, 0x87, 0x1F,
  0xFC, 0x7C, 0xFF, 0xE3, 0xE7, 0xFF, 0x1F, 0x3F, 0xF8, 0xF9, 0xFF, 0xC7,
  0xCF, 0xFE, 0x1C, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFB,
  0xF0, 0x07, 0xDF, 0x80, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x3F, 0x0F, 0xC3,
  0xF8, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0x3F, 0x80, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0,
  0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x03, 0xCF, 0xC0, 0x30, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0x0F, 0xF0, 0xE0, 0x3F, 0x82,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC3, 0xC1, 0xFC, 0x20, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xC0,
  0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x70, 0x1F, 0xE7, 0xFF,
  0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xF7, 0xE0,
  0x0F, 0x9F, 0x80, 0x7E, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0x87, 0xE0, 0x7E,
  0x1F, 0x81, 0xF0, 0x7E, 0x0F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF0, 0x1F,
  0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x1F, 0xFF,
  0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xFF, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x83,
  0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE7, 0x01, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF,
  0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xE0,
  0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xEF, 0xC0, 0x7F, 0xFF,
  0x07, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFE, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x7E,
  0x03, 0xF7, 0xE0, 0x3F, 0x7F, 0x07, 0xF7, 0xF8, 0xFE, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x83,
  0xFF, 0xFE, 0x3F, 0x87, 0xF1, 0xF8, 0x0F, 0xCF, 0x80, 0x7E, 0x7C, 0x03,
  0xF3, 0xE0, 0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x0F, 0xC7, 0xF8, 0x7E, 0x1F,
  0xF7, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xFE,
  0x0F, 0xCF, 0xF8, 0xFC, 0x1F, 0xEF, 0xC0, 0x7F, 0x7E, 0x01, 0xFB, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xBF, 0xC1, 0xFC,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F,
  0x80, 0x01, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC7, 0xF0, 0xFE, 0x7E, 0x07, 0xE7, 0xE0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xE0, 0x3F,
  0x7F, 0x07, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0x1F, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F,
  0xF8, 0x03, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x3F, 0xBF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFE, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x7F, 0x7F, 0xBF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFC, 0x78, 0x0F, 0x03,
  0xF8, 0xFF, 0x1F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF0, 0xFE, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x1F, 0x87, 0xF8, 0xFF,
  0x1F, 0xF3, 0xFE, 0x7F, 0xC7, 0xF0, 0x7E, 0x03, 0xC0, 0xF8, 0x3E, 0x1F,
  0x8F, 0xF1, 0xFC, 0x3E, 0x07, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0F, 0x00,
  0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x7F, 0xFE,
  0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x60, 0x00, 0x07, 0x80, 0x00, 0x7F,
  0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x03, 0xF0, 0x01, 0xFF,
  0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF0,
  0x07, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0x80, 0x00, 0x60, 0x00, 0x00, 0x07,
  0xF8, 0x0F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xFF, 0xCE, 0x0F,
  0xF2, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x00,
  0x7F, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xC3,
  0xF0, 0x7C, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x00, 0x1F, 0x7C, 0x00, 0x7D,
  0xF0, 0x3F, 0xF7, 0x83, 0xFF, 0xDE, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x8F, 0xC7, 0xFC, 0x7E, 0x1F, 0xF1, 0xF8, 0x7F, 0xC7, 0xC1,
  0xFF, 0x1F, 0x07, 0xFC, 0x7C, 0x1F, 0xF1, 0xF0, 0x7F, 0xC7, 0xE1, 0xFF,
  0x1F, 0x87, 0xFE, 0x3F, 0x1F, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xF7, 0x87,
  0xFF, 0xDE, 0x07, 0xFF, 0x7C, 0x07, 0xF8, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x60, 0x7F, 0xFF, 0x80,
  0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xF7, 0xC0, 0x03, 0xE7, 0xC0, 0x03,
  0xE7, 0xE0, 0x03, 0xE3, 0xE0, 0x07, 0xE3, 0xE0, 0x07, 0xC3, 0xE0, 0x07,
  0xC3, 0xF0, 0x07, 0xC3, 0xF0, 0x0F, 0xC1, 0xF0, 0x0F, 0xC1, 0xF8, 0x0F,
  0x81, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFE, 0x3F,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7F, 0x7E,
  0x00, 0x7F, 0x7F, 0xF0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xCF, 0xC1, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0x7E, 0xFC, 0x07,
  0xEF, 0xC0, 0x7C, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x1F, 0x8F, 0xFF,
  0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFC,
  0x0F, 0xEF, 0xC0, 0x7E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x7F, 0x81, 0xE1, 0xFC, 0x00, 0x8F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x21, 0xFE, 0x03,
  0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0x1F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x8F, 0xC3, 0xFC, 0xFC, 0x1F, 0xCF, 0xC0, 0xFE, 0xFC, 0x07,
  0xEF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF,
  0xC0, 0xFE, 0xFC, 0x1F, 0xCF, 0xC3, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0,
  0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8,
  0xFF, 0xFF, 0x8F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF,
  0xFC, 0xFF, 0xFF, 0x9F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x7F, 0x81, 0xE3, 0xFC, 0x01, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xF7,
  0xE0, 0x0F, 0xDF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFE, 0x03, 0xF1, 0xFE,
  0x0F, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x1F, 0xF8, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F,
  0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x20, 0x0F, 0xE7, 0x83, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF,
  0xCF, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFE, 0x00, 0xFC, 0x03, 0xFB, 0xF0,
  0x1F, 0xCF, 0xC0, 0x7F, 0x3F, 0x03, 0xF8, 0xFC, 0x0F, 0xC3, 0xF0, 0x7F,
  0x0F, 0xC3, 0xF8, 0x3F, 0x0F, 0xC0, 0xFC, 0x7F, 0x03, 0xF3, 0xF8, 0x0F,
  0xCF, 0xC0, 0x3F, 0x7E, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xF7, 0xF8, 0x0F, 0xCF, 0xF0,
  0x3F, 0x1F, 0xC0, 0xFC, 0x3F, 0x83, 0xF0, 0x7F, 0x0F, 0xC1, 0xFC, 0x3F,
  0x03, 0xF8, 0xFC, 0x07, 0xF3, 0xF0, 0x1F, 0xCF, 0xC0, 0x3F, 0xBF, 0x00,
  0xFE, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x01,
  0xF8, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0xFE, 0x7F, 0x03, 0xF9,
  0xFE, 0x0F, 0xE7, 0xF8, 0x7F, 0x9E, 0xE1, 0xFE, 0x7B, 0xC7, 0xF9, 0xEF,
  0x3D, 0xE7, 0x9C, 0xF7, 0x9E, 0x7B, 0xDF, 0x79, 0xFE, 0x7D, 0xE7, 0xF9,
  0xF7, 0xCF, 0xE7, 0xDF, 0x3F, 0x1F, 0x7C, 0xFC, 0x7D, 0xF1, 0xF1, 0xF7,
  0xC7, 0xC7, 0xDF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xFF,
  0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x1F, 0xFD, 0xF1, 0xFF, 0xCF, 0x9F, 0xFC, 0xF9, 0xFF, 0xC7,
  0x9F, 0xFC, 0x7D, 0xFF, 0xC3, 0xDF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0x3F, 0x9F, 0xC0, 0x7E, 0x7E, 0x01,
  0xF9, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0xFE, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x03,
  0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x7E, 0x7F, 0x01, 0xF8, 0xFC, 0x0F, 0xE3,
  0xF8, 0x7F, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xC1, 0xFE, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xE1, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF0, 0x3F, 0x9F, 0xC0, 0x7E, 0x7E, 0x01, 0xF9, 0xF8,
  0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0,
  0x0F, 0xDF, 0x80, 0x7E, 0x7F, 0x01, 0xF8, 0xFC, 0x0F, 0xE3, 0xF8, 0x7F,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x0E,
  0x3F, 0xF0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x7E, 0x1F, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xFC, 0xFC, 0x07, 0xE7,
  0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0xFE, 0x7E, 0x07,
  0xF3, 0xF0, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F,
  0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xC7, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0xFE,
  0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0xC7, 0xE0, 0x7E, 0x3F, 0x01, 0xF9, 0xF8,
  0x0F, 0xCF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xE0, 0x01, 0xFE,
  0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F,
  0x81, 0xE1, 0xF8, 0x01, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF1, 0x00, 0x1F, 0x9E, 0x03, 0xFC, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xE1, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xDF, 0x80, 0x7E,
  0xFE, 0x03, 0xF3, 0xF8, 0x3F, 0x9F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x07, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xF7, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F,
  0x9F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x3E, 0x01, 0xF8, 0x7E, 0x03, 0xF0,
  0xFC, 0x07, 0xC1, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xF0, 0x7E, 0x07,
  0xE0, 0xF8, 0x07, 0xC3, 0xF0, 0x0F, 0x87, 0xE0, 0x1F, 0x8F, 0x80, 0x3F,
  0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0xFC, 0x00, 0xFD, 0xF0, 0x00, 0xFB,
  0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xDF, 0x1F, 0x1F, 0x7C, 0x7C, 0x7D, 0xE3, 0xF1,
  0xF7, 0x8F, 0xE7, 0xDE, 0x3F, 0x9F, 0x79, 0xFE, 0x7D, 0xE7, 0xB9, 0xF7,
  0x9E, 0xF7, 0xDE, 0xF3, 0xDF, 0x7B, 0xC7, 0x79, 0xEF, 0x1F, 0xE7, 0xB8,
  0x7F, 0x9F, 0xE0, 0xFE, 0x7F, 0x83, 0xF9, 0xFC, 0x0F, 0xE3, 0xF0, 0x3F,
  0x8F, 0xC0, 0x7E, 0x3E, 0x01, 0xF8, 0xF8, 0x07, 0xE0, 0xFE, 0x00, 0xFC,
  0xFC, 0x01, 0xF9, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC1, 0xF8, 0x3F, 0x03,
  0xF0, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0xFC, 0xFE, 0x01, 0xF8, 0xFC,
  0x07, 0xE1, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xF8, 0x7E, 0x03, 0xF1,
  0xFC, 0x07, 0xE3, 0xF0, 0x0F, 0xEF, 0xE0, 0x0F, 0xDF, 0x80, 0x1F, 0xC0,
  0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x0F, 0xE7,
  0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F,
  0x83, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x7E, 0x00, 0x7E,
  0xFC, 0x00, 0xFD, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFD, 0xF8, 0x03, 0xFB, 0xF0, 0x07, 0xE3,
  0xF0, 0x1F, 0x87, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x07, 0xE3, 0xF8, 0x0F,
  0xE7, 0xE0, 0x0F, 0xDF, 0xC0, 0x1F, 0xCF, 0x00, 0x1E, 0x06, 0x00, 0x30,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x10, 0x07, 0x80, 0xF8, 0x3F, 0x87, 0xFC, 0x7F, 0xC3,
  0xF8, 0x1E, 0x00, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x81,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x07, 0xFF, 0x00, 0x1C, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xDF,
  0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFE,
  0x0F, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x1F,
  0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x1F, 0xF0, 0x11, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x23, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x3F,
  0xBF, 0x07, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F,
  0x87, 0xF7, 0xF0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xFF,
  0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F,
  0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xF0, 0x3F, 0x3F, 0x83,
  0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F,
  0xF8, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83,
  0xFF, 0xFE, 0x3F, 0x83, 0xF9, 0xF8, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x01,
  0xF7, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFF, 0x00, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xE0, 0x60,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0x00, 0xFF,
  0xFC, 0x7F, 0xFF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0x0F, 0xFF, 0x81,
  0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07,
  0xEF, 0xE0, 0xFD, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF,
  0xC1, 0xFD, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0xB0, 0x0F, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0,
  0x1F, 0xF0, 0x00, 0x1C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0xFC, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFC, 0x1F, 0xDF, 0x81, 0xFB, 0xF0, 0x3F,
  0x7E, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x08, 0x07, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xF0, 0x00,
  0x1E, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x20, 0x1F, 0x8F, 0x0F,
  0xE7, 0xFF, 0xF9, 0xFF, 0xFC, 0x7F, 0xFE, 0x0F, 0xFF, 0x00, 0x7F, 0x00,
  0x1C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0xFF, 0x7E, 0x07,
  0xF3, 0xF0, 0x7F, 0x1F, 0x87, 0xF0, 0xFC, 0x3F, 0x07, 0xE3, 0xF0, 0x3F,
  0x3F, 0x01, 0xFB, 0xF8, 0x0F, 0xDF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xE0, 0x3F, 0x3F, 0x81, 0xF8,
  0xFE, 0x0F, 0xC3, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7F, 0x1F, 0x81, 0xFC,
  0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0xBF, 0x00, 0xFE, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x08, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xC0, 0x07, 0xF0, 0x1F, 0xC7, 0xE3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE3, 0xE3, 0xFF, 0x87, 0x87, 0xFE,
  0x1F, 0x1F, 0xF8, 0x7C, 0x7F, 0xE1, 0xF1, 0xFF, 0x87, 0xC7, 0xFE, 0x1F,
  0x1F, 0xF8, 0x7C, 0x7F, 0xE1, 0xF1, 0xFF, 0x87, 0xC7, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0x0F, 0xF8,
  0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xF8, 0x3F,
  0xBF, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0x00, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFE, 0x1F, 0xE3,
  0xF0, 0x3F, 0x9F, 0xC0, 0x7E, 0x7E, 0x01, 0xFD, 0xF8, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xF7, 0xE0, 0x0F,
  0xDF, 0x80, 0x3F, 0x7E, 0x01, 0xFD, 0xF8, 0x07, 0xE3, 0xF0, 0x3F, 0x8F,
  0xE1, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF,
  0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xC1, 0xFE, 0xFC, 0x0F, 0xEF, 0xC0, 0x7E,
  0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7E, 0xFC, 0x07, 0xEF, 0xE0, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF0, 0xFC, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE,
  0xFF, 0x0F, 0xDF, 0x81, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xBF, 0x87, 0xF7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xF7, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x03, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x2F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x03, 0xFE,
  0x01, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF9, 0xFC, 0x07,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0,
  0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFD, 0x00, 0x1F, 0xFC, 0x07, 0xEF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xBF, 0xFF, 0xE3, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x81, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0x80, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x83,
  0xF7, 0xF0, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC,
  0x1F, 0xF8, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFB, 0xF8, 0x03, 0xF3, 0xF0,
  0x07, 0xE7, 0xE0, 0x1F, 0x8F, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x81,
  0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x1F, 0x80, 0x7C, 0x3F,
  0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x0F, 0x87, 0xBE, 0x1F, 0x0F, 0x7C, 0x3E, 0x3E, 0xF8, 0xFC, 0x7C, 0xF1,
  0xFC, 0xF9, 0xE3, 0xF9, 0xF3, 0xC7, 0xF3, 0xE7, 0x9F, 0xE7, 0x8F, 0x3F,
  0xEF, 0x1F, 0x7B, 0xDE, 0x3F, 0xE7, 0xBC, 0x3F, 0xCF, 0xF8, 0x7F, 0x8F,
  0xF0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x03, 0xE0, 0x7E,
  0x07, 0xC0, 0x78, 0x00, 0xFE, 0x00, 0xFC, 0xFC, 0x03, 0xF0, 0xFC, 0x07,
  0xE0, 0xFC, 0x1F, 0x81, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x01, 0xFB, 0xF0,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x0F, 0xCF, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x1F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0xBF, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01,
  0xF8, 0xFE, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x3F, 0x0F, 0xC0, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x07, 0xE7, 0xE0, 0x1F,
  0x9F, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x04, 0x3F,
  0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF,
  0x7F, 0xFF, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xF0,
  0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFC, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x0F,
  0xFC, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x07,
  0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x00,
  0x0F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xE0,
  0x00, 0x07, 0xC0, 0x30, 0x3F, 0xE0, 0x7C, 0xFF, 0xF1, 0xFB, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0x1F, 0xFE, 0x7C, 0x0F, 0xF8,
  0x18, 0x07, 0xC0,
};

const GFXglyph UbuntuMono_Bold49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 8, 31, 25, 8, -30 },
  { 32, 16, 14, 25, 4, -33 },
  { 60, 23, 30, 25, 1, -30 },
  { 147, 21, 39, 25, 2, -34 },
  { 250, 24, 32, 25, 0, -31 },
  { 346, 23, 31, 25, 1, -31 },
  { 436, 7, 15, 25, 9, -33 },
  { 450, 15, 43, 25, 5, -35 },
  { 531, 16, 43, 25, 4, -35 },
  { 617, 20, 20, 25, 2, -30 },
  { 667, 21, 23, 25, 2, -23 },
  { 728, 11, 17, 25, 6, -8 },
  { 752, 13, 6, 25, 6, -15 },
  { 762, 9, 9, 25, 8, -8 },
  { 773, 20, 42, 25, 2, -34 },
  { 878, 21, 32, 25, 2, -31 },
  { 962, 20, 30, 25, 2, -30 },
  { 1037, 21, 31, 25, 2, -31 },
  { 1119, 20, 32, 25, 2, -31 },
  { 1199, 22, 30, 25, 1, -30 },
  { 1282, 20, 31, 25, 2, -30 },
  { 1360, 20, 31, 25, 2, -30 },
  { 1438, 20, 30, 25, 2, -30 },
  { 1513, 21, 32, 25, 2, -31 },
  { 1597, 20, 31, 25, 2, -31 },
  { 1675, 9, 24, 25, 8, -23 },
  { 1702, 11, 32, 25, 6, -23 },
  { 1746, 21, 21, 25, 2, -23 },
  { 1802, 21, 15, 25, 2, -20 },
  { 1842, 20, 21, 25, 2, -23 },
  { 1895, 18, 32, 25, 3, -31 },
  { 1967, 22, 38, 25, 1, -31 },
  { 2072, 24, 30, 25, 0, -30 },
  { 2162, 20, 32, 25, 3, -31 },
  { 2242, 22, 32, 25, 1, -31 },
  { 2330, 20, 31, 25, 3, -30 },
  { 2408, 20, 30, 25, 3, -30 },
  { 2483, 19, 30, 25, 3, -30 },
  { 2555, 22, 32, 25, 1, -31 },
  { 2643, 20, 30, 25, 2, -30 },
  { 2718, 19, 30, 25, 3, -30 },
  { 2790, 19, 31, 25, 2, -30 },
  { 2864, 22, 30, 25, 2, -30 },
  { 2947, 20, 30, 25, 3, -30 },
  { 3022, 22, 30, 25, 1, -30 },
  { 3105, 20, 30, 25, 2, -30 },
  { 3180, 22, 32, 25, 1, -31 },
  { 3268, 20, 31, 25, 3, -31 },
  { 3346, 22, 40, 25, 1, -31 },
  { 3456, 21, 31, 25, 3, -31 },
  { 3538, 21, 32, 25, 2, -31 },
  { 3622, 22, 30, 25, 1, -30 },
  { 3705, 21, 31, 25, 2, -30 },
  { 3787, 23, 30, 25, 1, -30 },
  { 3874, 22, 30, 25, 1, -30 },
  { 3957, 23, 30, 25, 1, -30 },
  { 4044, 23, 30, 25, 1, -30 },
  { 4131, 20, 30, 25, 2, -30 },
  { 4206, 13, 42, 25, 6, -34 },
  { 4275, 20, 42, 25, 2, -34 },
  { 4380, 14, 42, 25, 5, -34 },
  { 4454, 23, 16, 25, 1, -30 },
  { 4500, 24, 5, 25, 0, 3 },
  { 4515, 11, 9, 25, 7, -34 },
  { 4528, 20, 25, 25, 2, -24 },
  { 4591, 20, 36, 25, 3, -35 },
  { 4681, 21, 25, 25, 2, -24 },
  { 4747, 20, 36, 25, 1, -35 },
  { 4837, 21, 25, 25, 2, -24 },
  { 4903, 22, 35, 25, 2, -35 },
  { 5000, 19, 33, 25, 2, -24 },
  { 5079, 19, 35, 25, 3, -35 },
  { 5163, 21, 35, 25, 2, -34 },
  { 5255, 18, 43, 25, 2, -34 },
  { 5352, 21, 35, 25, 3, -35 },
  { 5444, 21, 35, 25, 2, -34 },
  { 5536, 22, 24, 25, 1, -24 },
  { 5602, 19, 24, 25, 3, -24 },
  { 5659, 22, 25, 25, 1, -24 },
  { 5728, 20, 32, 25, 3, -24 },
  { 5808, 19, 32, 25, 2, -24 },
  { 5884, 18, 24, 25, 4, -24 },
  { 5938, 19, 25, 25, 3, -24 },
  { 5998, 21, 31, 25, 2, -30 },
  { 6080, 18, 24, 25, 3, -23 },
  { 6134, 23, 23, 25, 1, -23 },
  { 6201, 23, 23, 25, 1, -23 },
  { 6268, 23, 23, 25, 1, -23 },
  { 6335, 22, 32, 25, 1, -23 },
  { 6423, 18, 23, 25, 3, -23 },
  { 6475, 18, 42, 25, 3, -34 },
  { 6570, 6, 42, 25, 9, -34 },
  { 6602, 18, 42, 25, 3, -34 },
  { 6697, 23, 9, 25, 1, -17 },
};

const GFXfont UbuntuMono_Bold49pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Bold49pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Bold49pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _UBUNTUMONO_BOLD49PT7B_H_
