#ifndef _UBUNTUMONO_BOLD36PT7B_H_
#define _UBUNTUMONO_BOLD36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Bold.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Bold36pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x79, 0xE7, 0x9E, 0x79, 0xE0,
  0x00, 0x01, 0xEF, 0xFF, 0xFD, 0xE0, 0x39, 0xFF, 0x9F, 0xF9, 0xFF, 0x9F,
  0xF9, 0xFF, 0x8F, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x07, 0x9E, 0x07,
  0x1E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0F, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1E, 0x38, 0x1E, 0x78, 0x1C, 0x78, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x38, 0xF0, 0x38, 0xF0, 0x78, 0xF0, 0x78,
  0xE0, 0x78, 0xE0, 0x79, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x0F,
  0xF0, 0x1F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFE, 0x7C, 0x0C, 0x7C, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x70, 0x3F, 0x7F, 0xFE, 0xFF,
  0xFE, 0x7F, 0xFC, 0x1F, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x3C, 0x03, 0xDF, 0x80, 0xE7, 0xF0, 0x71, 0xDC, 0x3C, 0xE7, 0x0E,
  0x38, 0xC7, 0x0E, 0x73, 0xC1, 0xDC, 0xE0, 0x7F, 0x70, 0x1F, 0xBC, 0x03,
  0xCE, 0x00, 0x07, 0x3C, 0x03, 0xDF, 0x80, 0xEF, 0xE0, 0x73, 0xB8, 0x3C,
  0xC7, 0x0E, 0x31, 0xC7, 0x0C, 0x73, 0xC3, 0xB8, 0xE0, 0xFE, 0x70, 0x1F,
  0xBC, 0x03, 0xC0, 0x07, 0xC0, 0x1F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x7C,
  0xF0, 0x78, 0x70, 0x78, 0xF0, 0x3D, 0xF0, 0x3F, 0xE0, 0x1F, 0x8C, 0x3F,
  0x8F, 0x7F, 0x8E, 0x7B, 0xCE, 0xF1, 0xFE, 0xF0, 0xFE, 0xF0, 0x7C, 0xF0,
  0x7C, 0xF8, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0x8F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0x60, 0x00, 0x40, 0x0E, 0x03, 0xF0, 0x7E, 0x0F,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07,
  0xE0, 0x3F, 0x01, 0xE0, 0x04, 0x20, 0x07, 0x00, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01,
  0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x81, 0xF0, 0x7E,
  0x0F, 0xC0, 0x78, 0x02, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x11, 0xE2,
  0xF3, 0xBF, 0xED, 0xFF, 0xFF, 0xCF, 0xFE, 0x07, 0xC0, 0x7F, 0x83, 0xEF,
  0x1F, 0x3E, 0x3C, 0x70, 0x21, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x3C, 0xFD, 0xFB, 0xF7, 0xE7, 0xC3, 0x8F, 0x7D, 0xF3, 0xC6,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00,
  0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x1E, 0xF8, 0x1E, 0xF1, 0x8F,
  0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF1, 0x8F, 0xF0, 0x0F, 0xF8, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8,
  0x07, 0xE0, 0x01, 0xC0, 0x0F, 0x80, 0x3F, 0x01, 0xFE, 0x0F, 0xFC, 0x1F,
  0xF8, 0x1E, 0xF0, 0x31, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x81,
  0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xC0, 0x0F, 0xC0, 0xFF, 0xE3,
  0xFF, 0xC7, 0xFF, 0xC7, 0x0F, 0x8C, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xC0, 0x7F, 0xE1, 0xFF, 0xE1, 0xFF, 0xE3, 0x07, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F,
  0xC0, 0xFF, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x3E, 0xC0, 0xFD,
  0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0x83, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0xFC,
  0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0x7C, 0x0F, 0x7C,
  0x1E, 0x7C, 0x3C, 0x7C, 0x3C, 0x7C, 0x78, 0x7C, 0xF0, 0x7C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1F, 0xC0, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF,
  0xF0, 0x0F, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E,
  0xC0, 0xFD, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0x78,
  0x0F, 0xE0, 0xFF, 0x87, 0xFE, 0x3F, 0x81, 0xF8, 0x07, 0xC0, 0x1E, 0x00,
  0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFF, 0xF0, 0x7F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF8, 0x3F, 0xE1, 0xF7, 0xFF, 0x9F, 0xFE, 0x3F, 0xF0, 0x3F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x03, 0xE0,
  0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0,
  0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1E, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE,
  0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x7E, 0x3C, 0x3F, 0xF8,
  0x1F, 0xF0, 0x1F, 0xF8, 0x3C, 0xFC, 0x78, 0x3E, 0x78, 0x1E, 0xF8, 0x1F,
  0xF8, 0x1F, 0xFC, 0x3E, 0x7F, 0xFE, 0x7F, 0xFC, 0x3F, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9F, 0xFE, 0xF8, 0x7F, 0xC1, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0xFF, 0xDF, 0xFF, 0x3F, 0xFC, 0x7F,
  0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x3F, 0xC7, 0xFE, 0x1F, 0xF0, 0x7F,
  0x01, 0xE0, 0x00, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00, 0x1E,
  0xFF, 0xFF, 0xFF, 0x78, 0x1E, 0x3F, 0x3F, 0x3F, 0x3F, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x3F, 0x3F, 0x3F, 0x3F, 0x1F, 0x0F, 0x0E, 0x3E,
  0xFC, 0x78, 0x60, 0x00, 0x0C, 0x00, 0x78, 0x03, 0xF0, 0x3F, 0xF1, 0xFF,
  0x8F, 0xFC, 0x3F, 0xC0, 0x7E, 0x00, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0x80, 0x0F, 0x00, 0x06, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x20, 0x00, 0x78, 0x00, 0x7F,
  0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x00,
  0x7F, 0x01, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC0, 0x7F, 0x00, 0x78,
  0x00, 0x20, 0x00, 0x1F, 0xC1, 0xFF, 0xC7, 0xFF, 0x9F, 0xFE, 0x70, 0xFC,
  0x01, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x3C, 0x00, 0x03, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC,
  0x3C, 0x1E, 0x78, 0x0E, 0x70, 0x0F, 0x70, 0x0F, 0xF0, 0xFF, 0xE1, 0xFF,
  0xE3, 0xFF, 0xE7, 0xFF, 0xE7, 0xCF, 0xE7, 0x8F, 0xE7, 0x8F, 0xE7, 0x8F,
  0xE7, 0x8F, 0xE7, 0xCF, 0xE3, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0x70, 0xFE,
  0x78, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x1F, 0xFE, 0x0F, 0xFE, 0x01, 0xFE,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x73, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x01, 0xE1,
  0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC,
  0x3F, 0xFF, 0x1F, 0x03, 0xE7, 0xC0, 0xF9, 0xE0, 0x3E, 0x78, 0x07, 0xBE,
  0x01, 0xF0, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xCF, 0x07, 0xDE,
  0x0F, 0xBC, 0x1F, 0x78, 0x3E, 0xF0, 0xF9, 0xFF, 0xE3, 0xFF, 0x87, 0xFF,
  0xCF, 0xFF, 0xDE, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF,
  0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0x1F, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xFE,
  0x1F, 0xFF, 0x3F, 0xFE, 0x3F, 0x0E, 0x7C, 0x02, 0x78, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x7C, 0x02, 0x7E, 0x06, 0x3F, 0xFE, 0x1F, 0xFF,
  0x0F, 0xFE, 0x03, 0xF8, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0xCF,
  0x0F, 0xDE, 0x0F, 0xBC, 0x0F, 0x78, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0x7F, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1E, 0xF0, 0x7D,
  0xE1, 0xFB, 0xFF, 0xE7, 0xFF, 0x8F, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0xFD,
  0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xCF, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xFF, 0xEF, 0xFF, 0xBF,
  0xFE, 0xFF, 0xFB, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0x0F, 0xFE, 0x1F,
  0xFE, 0x3F, 0xFE, 0x3F, 0x06, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0x78, 0x1F, 0x7C, 0x1F, 0x7E, 0x1F, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F,
  0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFC, 0xFF,
  0xF3, 0xFF, 0xCF, 0xFF, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x40, 0x7D, 0xC3, 0xEF, 0xFF, 0xBF, 0xFC, 0xFF, 0xE0, 0x7E, 0x00,
  0xF0, 0x3E, 0xF0, 0x7C, 0xF0, 0x78, 0xF0, 0xF8, 0xF1, 0xF0, 0xF1, 0xF0,
  0xF3, 0xE0, 0xF7, 0xC0, 0xF7, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0xF7, 0xC0, 0xF3, 0xE0, 0xF3, 0xF0, 0xF1, 0xF0, 0xF0, 0xF8, 0xF0, 0xFC,
  0xF0, 0x7C, 0xF0, 0x3E, 0xF0, 0x3E, 0xF0, 0x3E, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78,
  0x1E, 0x78, 0x1E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7E, 0x7E, 0x7E,
  0x7E, 0xFE, 0x7E, 0xF6, 0xEF, 0xF7, 0xEF, 0xF7, 0xEF, 0xF3, 0xCF, 0xF3,
  0xCF, 0xF3, 0xCF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x83,
  0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0x8F, 0xFF, 0x3F, 0xDC,
  0xFF, 0x7B, 0xFC, 0xEF, 0xF3, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x3F, 0xF0,
  0xFF, 0xC1, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x70, 0x07, 0xE0,
  0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x1E, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1E, 0x7C, 0x3E, 0x3F, 0xFC,
  0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7,
  0xFF, 0xEF, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC1, 0xFF, 0xFF, 0xEF, 0xFF, 0x9F, 0xFE, 0x3F, 0xF0, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x1E,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1E, 0x7C, 0x3E,
  0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0x03, 0xC0, 0x03, 0xF8,
  0x01, 0xFF, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x0E, 0xFF, 0x80, 0xFF, 0xF0,
  0xFF, 0xF8, 0xFF, 0xF8, 0xF0, 0xFC, 0xF0, 0x7C, 0xF0, 0x3C, 0xF0, 0x3C,
  0xF0, 0x7C, 0xF0, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0,
  0xF1, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF0, 0x78, 0xF0, 0x7C, 0xF0, 0x3C,
  0xF0, 0x3E, 0xF0, 0x1E, 0x07, 0xF0, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xFC,
  0x7C, 0x08, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x3F, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x1F,
  0x20, 0x1F, 0x70, 0x3E, 0x7F, 0xFE, 0x7F, 0xFC, 0x7F, 0xF8, 0x1F, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1E, 0x7C, 0x3E, 0x7F, 0xFE, 0x3F, 0xFC,
  0x1F, 0xF8, 0x0F, 0xE0, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0xC0, 0xF9, 0xF0,
  0x3E, 0x7C, 0x0F, 0x8F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x7C, 0x3E, 0x1F,
  0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x0F, 0x3C, 0x03, 0xCF, 0x00,
  0xF3, 0xC0, 0x1C, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF3, 0xCF,
  0xF3, 0xCF, 0xF3, 0xCF, 0xF7, 0xEF, 0xF7, 0xEF, 0xF7, 0xEF, 0xFE, 0x7F,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x1E,
  0x78, 0x1E, 0x7C, 0x07, 0x8F, 0x03, 0xC3, 0xE1, 0xF0, 0x78, 0x78, 0x1F,
  0x3E, 0x03, 0xCF, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0xC0,
  0x3C, 0xF8, 0x1F, 0x3E, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x3E, 0x7C,
  0x0F, 0x9E, 0x01, 0xE0, 0x78, 0x07, 0x9F, 0x03, 0xE7, 0xC0, 0xF8, 0xF0,
  0x3C, 0x3E, 0x1F, 0x07, 0x87, 0x81, 0xF1, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C,
  0x01, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00,
  0x78, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3E,
  0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03,
  0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80,
  0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xC0,
  0x03, 0xF0, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0xF3, 0xE0, 0xF8,
  0xF0, 0xF8, 0x7C, 0x7C, 0x1F, 0x7C, 0x0F, 0xBC, 0x03, 0xC6, 0x01, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x20, 0x38, 0x7C,
  0x7F, 0x1F, 0x02, 0x3F, 0xC1, 0xFF, 0xC7, 0xFF, 0x8F, 0xFE, 0x00, 0x7C,
  0x00, 0xF1, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFC, 0x0F,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0x1F, 0xF0, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xFB, 0xE1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x87, 0xDF, 0x07, 0xFE,
  0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x87,
  0xDF, 0xFF, 0xBF, 0xFE, 0x7F, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xF8,
  0xFF, 0xF3, 0xFF, 0xEF, 0xE0, 0x5F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0xE0, 0x0F, 0xFF, 0x8F, 0xFF,
  0x0F, 0xFF, 0x07, 0xFC, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x0F, 0xBC, 0xFF, 0xF3, 0xFF, 0xDF,
  0xFF, 0x7C, 0x7F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF,
  0x83, 0xFE, 0x0F, 0x7C, 0x3D, 0xFF, 0xF3, 0xFF, 0xC7, 0xFF, 0x07, 0xF8,
  0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x7C, 0x3E, 0x78, 0x1E,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x7C, 0x04, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFE, 0x03, 0xF8, 0x00, 0xFE,
  0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xF8, 0x10, 0x7C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xC0,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0xFC, 0xFF, 0xFB, 0xFF, 0xF7,
  0xC3, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFB, 0xE1, 0xF7, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x87, 0xFF, 0x00, 0x3E,
  0x00, 0x7D, 0x81, 0xF3, 0xFF, 0xE7, 0xFF, 0x8F, 0xFE, 0x07, 0xF0, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFE, 0xF8, 0xFF, 0xE1,
  0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7C, 0x07, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0,
  0x07, 0xC2, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFC, 0x01, 0xE0,
  0x1F, 0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0xF7,
  0xFF, 0x7F, 0xF7, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x61, 0xF7, 0xFF, 0xFF, 0xEF, 0xFC, 0x3F, 0x80, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x7E, 0xF8, 0x7C, 0xF8, 0xF8, 0xF9, 0xF0, 0xF9, 0xE0, 0xFB,
  0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFB, 0xE0, 0xF9,
  0xF0, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x7C, 0xF8, 0x3E, 0xF8, 0x3E, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x07, 0xC2, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00,
  0xFC, 0x7F, 0x7C, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xCF, 0xF3,
  0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x3F,
  0xC3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFE, 0xF8, 0xFF, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0x7C, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F,
  0xFE, 0x7C, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x3E, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F,
  0xF8, 0x07, 0xE0, 0x3F, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x87,
  0xDF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x87, 0xDF, 0xFF, 0xBF, 0xFE, 0x7F, 0xF8, 0xFF, 0xE1, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xF8, 0x3F, 0xFC, 0xFF, 0xFB, 0xFF, 0xF7, 0xC3, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xF7, 0xC3, 0xEF,
  0xFF, 0xCF, 0xFF, 0x8F, 0xFF, 0x0F, 0xBE, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xFB, 0xFF, 0xEF, 0xFF,
  0xBF, 0xFE, 0xF8, 0x0B, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x00, 0x0F, 0xF0, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0xF8, 0x1B, 0xE0, 0x07,
  0xC0, 0x1F, 0xE0, 0x3F, 0xF0, 0x3F, 0xE0, 0x0F, 0xC0, 0x1F, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFC, 0x3F, 0xC0, 0x03, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x82, 0x0F, 0xFF, 0x07, 0xFF, 0x07,
  0xFF, 0x01, 0xFE, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F,
  0xFC, 0x7D, 0xFF, 0xF7, 0xFF, 0xCF, 0xFF, 0x0F, 0xF0, 0x78, 0x07, 0x9F,
  0x01, 0xE7, 0xC0, 0xF8, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x87, 0xC1, 0xE1,
  0xE0, 0x78, 0x78, 0x1F, 0x3E, 0x03, 0xCF, 0x00, 0xF7, 0xC0, 0x3F, 0xE0,
  0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x03, 0xDC, 0x00, 0xE7, 0x00, 0x39, 0xC7, 0x8E, 0x71, 0xE3, 0x9C,
  0x78, 0xE7, 0x1E, 0x79, 0xEF, 0xDE, 0x7B, 0xF7, 0x9E, 0xFD, 0xC3, 0xB7,
  0x70, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xE1, 0xF0, 0x78, 0x78,
  0x1C, 0x1E, 0x00, 0xF8, 0x1F, 0x78, 0x1E, 0x3C, 0x3C, 0x3E, 0x7C, 0x1F,
  0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF8, 0x1E, 0x7C, 0x3C, 0x3C, 0x7C, 0x3E, 0x78, 0x1F, 0xF0,
  0x1F, 0xF8, 0x1F, 0x78, 0x1F, 0x7C, 0x1E, 0x7C, 0x1E, 0x3C, 0x3E, 0x3C,
  0x3C, 0x3E, 0x3C, 0x1E, 0x3C, 0x1E, 0x7C, 0x1F, 0x78, 0x0F, 0x78, 0x0F,
  0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x87, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0x7F,
  0xF9, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x1F, 0xF0, 0x7F, 0xC3, 0xFF,
  0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x03, 0xFC, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF8, 0x03, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x1F, 0x00, 0x7C, 0x3F, 0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0xE0, 0x00, 0x1E,
  0x06, 0x3F, 0xC7, 0x9F, 0xFF, 0xDF, 0xFF, 0xEF, 0x1F, 0xE3, 0x03, 0xE0,
};

const GFXglyph UbuntuMono_Bold36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 6, 22, 18, 6, -22 },
  { 18, 12, 10, 18, 3, -25 },
  { 33, 16, 22, 18, 1, -22 },
  { 77, 16, 28, 18, 1, -25 },
  { 133, 18, 22, 18, 0, -22 },
  { 183, 16, 22, 18, 1, -22 },
  { 227, 4, 11, 18, 7, -25 },
  { 233, 12, 32, 18, 3, -26 },
  { 281, 12, 32, 18, 3, -26 },
  { 329, 14, 14, 18, 2, -22 },
  { 354, 16, 16, 18, 1, -17 },
  { 386, 7, 12, 18, 5, -6 },
  { 397, 10, 4, 18, 4, -11 },
  { 402, 6, 6, 18, 6, -6 },
  { 407, 14, 31, 18, 2, -25 },
  { 462, 16, 22, 18, 1, -22 },
  { 506, 15, 22, 18, 2, -22 },
  { 548, 15, 22, 18, 2, -22 },
  { 590, 15, 22, 18, 1, -22 },
  { 632, 16, 22, 18, 1, -22 },
  { 676, 15, 22, 18, 1, -22 },
  { 718, 14, 22, 18, 2, -22 },
  { 757, 14, 22, 18, 2, -22 },
  { 796, 16, 22, 18, 1, -22 },
  { 840, 14, 22, 18, 2, -22 },
  { 879, 6, 17, 18, 6, -17 },
  { 892, 8, 23, 18, 4, -17 },
  { 915, 15, 16, 18, 2, -17 },
  { 945, 16, 11, 18, 1, -15 },
  { 967, 16, 16, 18, 1, -17 },
  { 999, 14, 22, 18, 2, -22 },
  { 1038, 16, 27, 18, 1, -22 },
  { 1092, 18, 22, 18, 0, -22 },
  { 1142, 15, 22, 18, 2, -22 },
  { 1184, 16, 22, 18, 1, -22 },
  { 1228, 15, 22, 18, 2, -22 },
  { 1270, 15, 22, 18, 2, -22 },
  { 1312, 14, 22, 18, 2, -22 },
  { 1351, 16, 22, 18, 1, -22 },
  { 1395, 14, 22, 18, 2, -22 },
  { 1434, 14, 22, 18, 2, -22 },
  { 1473, 14, 22, 18, 2, -22 },
  { 1512, 16, 22, 18, 2, -22 },
  { 1556, 14, 22, 18, 3, -22 },
  { 1595, 16, 22, 18, 1, -22 },
  { 1639, 14, 22, 18, 2, -22 },
  { 1678, 16, 22, 18, 1, -22 },
  { 1722, 15, 22, 18, 2, -22 },
  { 1764, 16, 28, 18, 1, -22 },
  { 1820, 16, 22, 18, 2, -22 },
  { 1864, 16, 22, 18, 1, -22 },
  { 1908, 16, 22, 18, 1, -22 },
  { 1952, 16, 22, 18, 1, -22 },
  { 1996, 18, 22, 18, 0, -22 },
  { 2046, 16, 22, 18, 1, -22 },
  { 2090, 18, 22, 18, 0, -22 },
  { 2140, 18, 22, 18, 0, -22 },
  { 2190, 14, 22, 18, 2, -22 },
  { 2229, 10, 31, 18, 4, -25 },
  { 2268, 14, 31, 18, 2, -25 },
  { 2323, 10, 31, 18, 4, -25 },
  { 2362, 17, 12, 18, 1, -22 },
  { 2388, 18, 4, 18, 0, 2 },
  { 2397, 8, 6, 18, 5, -25 },
  { 2403, 14, 17, 18, 2, -17 },
  { 2433, 15, 25, 18, 2, -25 },
  { 2480, 15, 17, 18, 2, -17 },
  { 2512, 14, 25, 18, 1, -25 },
  { 2556, 16, 17, 18, 1, -17 },
  { 2590, 17, 25, 18, 1, -25 },
  { 2644, 15, 23, 18, 1, -17 },
  { 2688, 14, 25, 18, 2, -25 },
  { 2732, 16, 25, 18, 1, -25 },
  { 2782, 12, 31, 18, 2, -25 },
  { 2829, 16, 25, 18, 2, -25 },
  { 2879, 16, 25, 18, 1, -25 },
  { 2929, 16, 17, 18, 1, -17 },
  { 2963, 14, 17, 18, 2, -17 },
  { 2993, 16, 17, 18, 1, -17 },
  { 3027, 15, 23, 18, 2, -17 },
  { 3071, 15, 23, 18, 1, -17 },
  { 3115, 14, 17, 18, 3, -17 },
  { 3145, 14, 17, 18, 2, -17 },
  { 3175, 16, 22, 18, 1, -22 },
  { 3219, 14, 17, 18, 2, -17 },
  { 3249, 18, 17, 18, 0, -17 },
  { 3288, 18, 17, 18, 0, -17 },
  { 3327, 16, 17, 18, 1, -17 },
  { 3361, 16, 23, 18, 1, -17 },
  { 3407, 14, 17, 18, 2, -17 },
  { 3437, 14, 31, 18, 2, -25 },
  { 3492, 4, 31, 18, 7, -25 },
  { 3508, 14, 31, 18, 2, -25 },
  { 3563, 17, 6, 18, 1, -13 },
};

const GFXfont UbuntuMono_Bold36pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Bold36pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Bold36pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _UBUNTUMONO_BOLD36PT7B_H_
