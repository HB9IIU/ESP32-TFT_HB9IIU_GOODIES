#ifndef _UBUNTUMONO_BOLD43PT7B_H_
#define _UBUNTUMONO_BOLD43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Bold.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Bold43pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0x3E, 0x7C, 0xF8, 0xF0, 0x00, 0x00, 0x0F, 0x3F, 0xFF, 0xFD,
  0xF9, 0xE0, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3,
  0xFF, 0x87, 0xFE, 0x1E, 0xF8, 0x79, 0xE1, 0xE7, 0x07, 0x9C, 0x1E, 0x03,
  0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x7C, 0x07, 0xC7, 0xC0,
  0x7C, 0x78, 0x07, 0x87, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF1, 0xF0, 0x1F, 0x1F,
  0x01, 0xF1, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3E, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C,
  0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x87, 0xFF, 0xF1,
  0xFF, 0xFE, 0x3F, 0x03, 0x8F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0xF9, 0x00, 0x3F, 0x38, 0x0F, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F,
  0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x01, 0xFC, 0x03, 0xDF, 0xE0, 0x1C,
  0xE7, 0x81, 0xE7, 0x3C, 0x1E, 0x78, 0xE0, 0xF3, 0xC7, 0x0F, 0x1E, 0x38,
  0xF0, 0x73, 0xC7, 0x83, 0x9E, 0x78, 0x1F, 0xE7, 0x80, 0x7F, 0x3C, 0x01,
  0xE3, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0xE7,
  0xF0, 0x0F, 0x7F, 0x80, 0xF3, 0x9E, 0x07, 0x1C, 0xF0, 0x79, 0xE3, 0x87,
  0x8F, 0x1C, 0x38, 0x78, 0xE3, 0xC3, 0xC7, 0x3C, 0x0E, 0x79, 0xE0, 0x73,
  0xDE, 0x03, 0xFD, 0xE0, 0x0F, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0,
  0x3C, 0x1E, 0x03, 0xC3, 0xE0, 0x3E, 0x3E, 0x03, 0xE7, 0xC0, 0x3E, 0xFC,
  0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x3E, 0x1F, 0xE3, 0xE3, 0xFF,
  0x3E, 0x7D, 0xF3, 0xCF, 0x8F, 0xBC, 0xF8, 0x7F, 0xCF, 0x07, 0xFC, 0xF0,
  0x3F, 0x8F, 0x81, 0xF8, 0xF8, 0x1F, 0x8F, 0xC3, 0xFC, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x1F, 0xFB, 0xE0, 0x7E, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xBE, 0x79, 0xE7, 0x9E, 0x70, 0x00, 0x10, 0x01, 0xE0, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3E, 0x00, 0x70, 0x00, 0xC0,
  0x20, 0x01, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00,
  0x7C, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F,
  0xE0, 0x3F, 0x00, 0x78, 0x00, 0x80, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x61, 0xE1, 0x1E, 0x79, 0xE7, 0xFD, 0xFB, 0xFF,
  0xFE, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0x7E,
  0x0F, 0xCF, 0xC1, 0xE3, 0xE0, 0x38, 0x70, 0x04, 0x10, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x0F, 0x07, 0xE3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF1, 0xFC,
  0x3F, 0x07, 0x81, 0xE0, 0xF0, 0xFC, 0x7E, 0x1E, 0x06, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x7E, 0xFE, 0xFF, 0xFF, 0xFE,
  0x7E, 0x3C, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xF1, 0xF8, 0x7C, 0x1F, 0x8F,
  0x81, 0xF3, 0xE0, 0x3E, 0x7C, 0x03, 0xCF, 0x80, 0x7D, 0xE0, 0x0F, 0xBC,
  0x71, 0xF7, 0x8F, 0x3F, 0xF3, 0xE7, 0xFE, 0x7C, 0xFB, 0xC7, 0x9F, 0x78,
  0xE3, 0xEF, 0x00, 0x7D, 0xE0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3C, 0xF8,
  0x0F, 0x9F, 0x81, 0xF1, 0xF0, 0x7E, 0x3F, 0x1F, 0x83, 0xFF, 0xF0, 0x3F,
  0xFC, 0x03, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0,
  0x7D, 0xF0, 0x1C, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0xFF, 0xFF,
  0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0x07, 0xE0, 0x0F, 0xFE, 0x07,
  0xFF, 0xE3, 0xFF, 0xF8, 0x7C, 0x3F, 0x0C, 0x07, 0xC2, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xE0,
  0x3F, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC7, 0x87, 0xF0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0,
  0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3F, 0x60, 0x3F, 0x7F, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0x81, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xDF, 0x80, 0xF3, 0xF0,
  0x3E, 0x7E, 0x0F, 0x8F, 0xC1, 0xF1, 0xF8, 0x7C, 0x3F, 0x0F, 0x07, 0xE3,
  0xE0, 0xFC, 0x78, 0x1F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8,
  0x7F, 0xFE, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFD, 0xC0, 0xFE, 0x7F,
  0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x1F, 0x00, 0x3F,
  0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xF8, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xDF, 0x03, 0xFF, 0xF0, 0xFF,
  0xFF, 0x3F, 0xFF, 0xCF, 0xC1, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03,
  0xEF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0x9F, 0x03, 0xE7, 0xC1, 0xF9,
  0xF8, 0x7C, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x07,
  0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x7E, 0x1F, 0x9F, 0x03, 0xEF, 0x80,
  0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBF, 0x03, 0xE7, 0xE1, 0xF1, 0xFC, 0xFC,
  0x3F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7E, 0xFF, 0x1F,
  0x0F, 0xEF, 0x80, 0xFB, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x3F, 0xFE, 0x1F, 0x9F, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC,
  0x7E, 0x3F, 0x1F, 0x07, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xDF, 0x83, 0xF7, 0xFF,
  0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xF0, 0x3F, 0xF8, 0x0F,
  0xF8, 0x03, 0xF8, 0x00, 0xF0, 0x00, 0x3C, 0x7E, 0xFE, 0xFF, 0xFF, 0xFE,
  0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFE, 0xFF, 0xFF,
  0xFE, 0x7E, 0x3C, 0x0F, 0x07, 0xE3, 0xF8, 0xFF, 0x3F, 0xCF, 0xE1, 0xF8,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC1, 0xF8, 0xFE, 0x3F,
  0x8F, 0xF3, 0xFC, 0x7E, 0x0F, 0x81, 0xE0, 0x78, 0x3C, 0x3E, 0x3F, 0x0F,
  0x81, 0x80, 0x00, 0x01, 0x80, 0x01, 0xE0, 0x03, 0xF8, 0x03, 0xFF, 0x07,
  0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFC,
  0x00, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x60, 0x00,
  0x1E, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xFC, 0x1F,
  0xFE, 0x3F, 0xFE, 0x3F, 0xFC, 0x0F, 0xFC, 0x03, 0xF8, 0x00, 0x78, 0x00,
  0x10, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x70,
  0x7E, 0x40, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x07,
  0x80, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0x83, 0xE1, 0xE0,
  0x3C, 0x78, 0x07, 0x9E, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x3F, 0xEE, 0x1F,
  0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0x3F, 0xE7, 0xC3, 0xFC, 0xF8,
  0x7F, 0x9F, 0x0F, 0xF3, 0xE1, 0xFE, 0x7C, 0x3F, 0xCF, 0x87, 0xF9, 0xF0,
  0xFF, 0x1E, 0x1F, 0xE3, 0xE3, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0x70, 0x7F,
  0xEF, 0x03, 0xFD, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x10, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0x7C, 0x00, 0x7B, 0xE0, 0x07, 0xCF, 0x00, 0x3E, 0x7C,
  0x01, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC3, 0xE0, 0x3E,
  0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0,
  0x3E, 0x7C, 0x01, 0xFB, 0xE0, 0x0F, 0xFF, 0x00, 0x7E, 0x7F, 0xF0, 0x3F,
  0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFC, 0x3F, 0x3F, 0x07, 0xEF, 0xC0,
  0xFB, 0xF0, 0x3E, 0xFC, 0x0F, 0xBF, 0x07, 0xEF, 0xC1, 0xF3, 0xF0, 0xFC,
  0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFE, 0xFC, 0x1F, 0xBF,
  0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF,
  0xF1, 0xFC, 0x1C, 0x7E, 0x00, 0x8F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x02,
  0x1F, 0xC1, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xF0,
  0x7F, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFC, 0x7F, 0x3F,
  0x07, 0xEF, 0xC1, 0xFB, 0xF0, 0x3E, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xBF,
  0x07, 0xEF, 0xC1, 0xFB, 0xF1, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF,
  0x81, 0xFF, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF1, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xFC,
  0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFC, 0x1C, 0x7E, 0x00, 0x8F, 0x80, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xFC, 0x07, 0xDF,
  0x80, 0xF9, 0xF8, 0x1F, 0x1F, 0x83, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0x83,
  0xFF, 0xF0, 0x0F, 0xF8, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x80, 0xFC, 0xF0, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x1F, 0xFE,
  0x03, 0xFC, 0x00, 0xF8, 0x0F, 0xDF, 0x03, 0xF3, 0xE0, 0x7E, 0x7C, 0x1F,
  0x8F, 0x83, 0xF1, 0xF0, 0xFC, 0x3E, 0x1F, 0x07, 0xC7, 0xE0, 0xF9, 0xF8,
  0x1F, 0x7E, 0x03, 0xEF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0,
  0x3F, 0xFC, 0x07, 0xDF, 0xC0, 0xF9, 0xF8, 0x1F, 0x1F, 0x83, 0xE1, 0xF8,
  0x7C, 0x3F, 0x0F, 0x83, 0xF1, 0xF0, 0x7F, 0x3E, 0x07, 0xE7, 0xC0, 0x7E,
  0xF8, 0x0F, 0xDF, 0x01, 0xFB, 0xE0, 0x1F, 0x80, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7E,
  0x07, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xF0, 0xFC, 0x7F, 0x1F, 0xC7,
  0xF1, 0xDE, 0x7F, 0x9D, 0xE7, 0xBB, 0xDE, 0x7B, 0xBD, 0xE7, 0xBF, 0x9E,
  0x79, 0xF9, 0xE7, 0x9F, 0x9E, 0xF9, 0xF1, 0xEF, 0x9F, 0x1E, 0xF8, 0xF1,
  0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x80,
  0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF8,
  0x01, 0xF0, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFE,
  0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xE1,
  0xFF, 0xFC, 0x7F, 0xEF, 0x1F, 0xF9, 0xE7, 0xFE, 0x79, 0xFF, 0x8F, 0x7F,
  0xE3, 0xDF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8,
  0x3F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x01,
  0xFF, 0x80, 0x7C, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF,
  0xC3, 0xF0, 0xF8, 0x7C, 0x1F, 0x9F, 0x01, 0xF3, 0xE0, 0x3F, 0x7C, 0x03,
  0xEF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x0F, 0xDF, 0x01, 0xF1, 0xF0, 0x7E,
  0x3F, 0x0F, 0x83, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0x80,
  0x3F, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFC, 0x1F, 0xBF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE3, 0xFB, 0xFF, 0xFE,
  0xFF, 0xFF, 0x3F, 0xFF, 0x0F, 0xFF, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF,
  0xC3, 0xF0, 0xF8, 0x7C, 0x1F, 0x9F, 0x01, 0xF3, 0xE0, 0x3F, 0x7C, 0x03,
  0xEF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x0F, 0xDF, 0x01, 0xF1, 0xF0, 0x7E,
  0x3F, 0x0F, 0x83, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xC0,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFC,
  0x00, 0x3F, 0x00, 0x00, 0xE0, 0x3F, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8,
  0x7F, 0xFF, 0x8F, 0xC3, 0xF1, 0xF8, 0x3F, 0x3F, 0x03, 0xE7, 0xE0, 0x7C,
  0xFC, 0x0F, 0x9F, 0x81, 0xF3, 0xF0, 0x3E, 0x7E, 0x0F, 0xCF, 0xC3, 0xF1,
  0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0x8F, 0x83,
  0xF1, 0xF8, 0x7E, 0x1F, 0x0F, 0xC3, 0xF1, 0xF8, 0x3E, 0x3F, 0x07, 0xE7,
  0xE0, 0x7C, 0xFC, 0x0F, 0xDF, 0x80, 0xFB, 0xF0, 0x1F, 0x7E, 0x03, 0xF0,
  0x03, 0xFC, 0x07, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xFC, 0x7E, 0x06, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFD, 0x00, 0x3E, 0x78, 0x1F, 0xBF, 0xFF, 0xEF, 0xFF,
  0xF3, 0xFF, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03,
  0xEF, 0xC0, 0xF9, 0xF8, 0x7E, 0x7F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xC0,
  0x1F, 0xC0, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xEF, 0xC0, 0x3E,
  0x7C, 0x03, 0xE7, 0xC0, 0x7E, 0x7C, 0x07, 0xE7, 0xC0, 0x7C, 0x7E, 0x07,
  0xC3, 0xE0, 0x7C, 0x3E, 0x0F, 0xC3, 0xE0, 0xF8, 0x1E, 0x0F, 0x81, 0xF0,
  0xF8, 0x1F, 0x0F, 0x01, 0xF1, 0xF0, 0x0F, 0x1F, 0x00, 0xF9, 0xF0, 0x0F,
  0x9E, 0x00, 0x7B, 0xE0, 0x07, 0xBE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0xF8, 0x01,
  0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x80,
  0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF8,
  0xF1, 0xEF, 0x9F, 0x1E, 0xF9, 0xF9, 0xEF, 0x9F, 0x9E, 0x7B, 0xF9, 0xE7,
  0xBF, 0x9E, 0x7B, 0xBD, 0xE7, 0xB9, 0xDE, 0x7F, 0x9D, 0xE7, 0xF1, 0xDE,
  0x7F, 0x0F, 0xE7, 0xF0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x07,
  0xC7, 0xC0, 0x7C, 0x3C, 0x07, 0xC0, 0x7E, 0x01, 0xF1, 0xF0, 0x1F, 0x8F,
  0xC0, 0xF8, 0x3E, 0x0F, 0xC1, 0xF8, 0x7C, 0x07, 0xC7, 0xE0, 0x3F, 0x3E,
  0x00, 0xFB, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x3E, 0xFC, 0x01, 0xF3, 0xE0, 0x1F, 0x9F, 0x80, 0xF8,
  0x7C, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x87, 0xE0, 0x7E, 0x3E, 0x03, 0xF3,
  0xF0, 0x0F, 0x9F, 0x00, 0x7E, 0xF8, 0x03, 0xFF, 0xC0, 0x3E, 0xFC, 0x03,
  0xE7, 0xC0, 0x7E, 0x7E, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x0F, 0x81, 0xF0,
  0xF8, 0x1F, 0x0F, 0x81, 0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xF9, 0xF0, 0x1F, 0x1F, 0x83,
  0xF0, 0xFC, 0x3E, 0x07, 0xC7, 0xE0, 0x7E, 0xFC, 0x03, 0xF7, 0x80, 0x3E,
  0x18, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x20, 0x38, 0x1F, 0x1F, 0xCF, 0xF1, 0xFC, 0x3C, 0x04, 0x1F,
  0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE2, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x87, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE,
  0x07, 0xDF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0x7F, 0xF0, 0x38, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0xFC, 0x1F, 0xFF, 0x8F,
  0xFF, 0xE7, 0xFF, 0xF3, 0xF0, 0xFD, 0xF0, 0x3E, 0xF8, 0x1F, 0xFC, 0x0F,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xDF, 0x07, 0xEF, 0xFF, 0xE7,
  0xFF, 0xE3, 0xFF, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0xF1, 0xFF,
  0xF8, 0xFF, 0xFE, 0x3F, 0x80, 0x9F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x23, 0xFF,
  0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x01, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC1, 0xFB, 0xE1, 0xFF, 0xF1, 0xFF, 0xF9,
  0xFF, 0xFD, 0xFC, 0x7E, 0xFC, 0x1F, 0x7C, 0x0F, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0x7C,
  0x0F, 0xBE, 0x07, 0xDF, 0x83, 0xE7, 0xE1, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC,
  0x3F, 0xFE, 0x07, 0xFC, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F,
  0xFF, 0xC3, 0xF0, 0xFC, 0xFC, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x1F, 0x7C,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x30, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x7E, 0x0C, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xFE, 0x01, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0x0F, 0xDF, 0x83,
  0xF7, 0xC0, 0xFD, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0x7C, 0x0F, 0xDF, 0x03, 0xF7, 0xE0, 0xFD, 0xFC, 0x3F, 0x3F,
  0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x1F, 0xBF, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x30, 0x3F, 0x9F, 0xFF, 0xC7, 0xFF, 0xE1,
  0xFF, 0xF0, 0x1F, 0xF0, 0x00, 0x38, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF8, 0x7E, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x07, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x08, 0x0F, 0xFF, 0x01, 0xFF,
  0xC0, 0x3F, 0xF0, 0x07, 0xF0, 0x00, 0x78, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x20, 0x7E, 0xF0, 0xF9, 0xFF, 0xF7, 0xFF,
  0xC7, 0xFF, 0x03, 0xFC, 0x00, 0x38, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0xFE, 0xF8, 0x3F, 0x3E, 0x1F,
  0x8F, 0x8F, 0xC3, 0xE3, 0xE0, 0xF9, 0xF0, 0x3E, 0xF8, 0x0F, 0xFE, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xBF, 0x03, 0xE7, 0xE0, 0xF8,
  0xFC, 0x3E, 0x3F, 0x0F, 0x87, 0xE3, 0xE0, 0xFC, 0xF8, 0x3F, 0x3E, 0x07,
  0xEF, 0x80, 0xFC, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x08, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x07,
  0xF0, 0x3F, 0x9F, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x9F,
  0x3F, 0xF3, 0xE3, 0xFE, 0x3C, 0x7F, 0xC7, 0x8F, 0xF8, 0xF1, 0xFF, 0x1E,
  0x3F, 0xE3, 0xC7, 0xFC, 0x78, 0xFF, 0x8F, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1E, 0x3F, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF8,
  0x7E, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x01, 0xF8, 0x00,
  0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC3, 0xF0, 0xFC, 0xFC, 0x0F, 0x9F,
  0x01, 0xFB, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xDF, 0x01, 0xFB, 0xE0, 0x3F, 0x7E,
  0x07, 0xC7, 0xE1, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x03,
  0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0x87,
  0xF7, 0xC1, 0xFB, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x1F, 0x7E, 0x1F, 0xBF, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xC7, 0xDF,
  0x83, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F,
  0x07, 0xDF, 0x81, 0xF7, 0xE0, 0x7D, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xF7, 0xC0, 0x7D,
  0xF0, 0x1F, 0x7E, 0x07, 0xCF, 0xC3, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F,
  0xFF, 0xC1, 0xF9, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x0F, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFE, 0xF8, 0x02, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x03,
  0xFC, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE7, 0xE0, 0x63, 0xE0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x40, 0x0F, 0xB8,
  0x0F, 0xDF, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xC0, 0xFF, 0x80, 0x01, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x0C, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xF8, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0x7F, 0xFF, 0x7F,
  0xFF, 0x3F, 0xFF, 0x0F, 0xF8, 0xF8, 0x03, 0xFF, 0xC0, 0x3E, 0xFC, 0x03,
  0xE7, 0xC0, 0x7E, 0x7C, 0x07, 0xC7, 0xE0, 0x7C, 0x3E, 0x0F, 0xC3, 0xE0,
  0xF8, 0x3F, 0x0F, 0x81, 0xF1, 0xF8, 0x1F, 0x1F, 0x00, 0xF9, 0xF0, 0x0F,
  0xBE, 0x00, 0xFB, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x78, 0x00, 0xFB, 0xC0, 0x07,
  0xDE, 0x00, 0x3E, 0xF0, 0x01, 0xF7, 0x87, 0x8F, 0xBC, 0x3C, 0x79, 0xE3,
  0xE3, 0xCF, 0x1F, 0x9E, 0x78, 0xFC, 0xF3, 0xC7, 0xE7, 0x8F, 0x7F, 0x3C,
  0x7B, 0xBD, 0xE3, 0xDD, 0xEE, 0x1F, 0xE7, 0x70, 0xFF, 0x3F, 0x87, 0xF1,
  0xFC, 0x1F, 0x87, 0xE0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0x80,
  0xFC, 0x03, 0xE7, 0xE0, 0x7C, 0x3E, 0x0F, 0xC3, 0xF0, 0xF8, 0x1F, 0x9F,
  0x00, 0xFB, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0xFB, 0xF0, 0x1F,
  0x9F, 0x01, 0xF1, 0xF8, 0x3E, 0x0F, 0xC7, 0xE0, 0x7C, 0x7C, 0x07, 0xEF,
  0xC0, 0x3E, 0x7C, 0x03, 0xEF, 0x80, 0x7D, 0xF8, 0x1F, 0x9F, 0x03, 0xE3,
  0xE0, 0x7C, 0x7E, 0x0F, 0x8F, 0xC3, 0xF0, 0xF8, 0x7C, 0x1F, 0x8F, 0x81,
  0xF1, 0xF0, 0x3E, 0x7C, 0x07, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xBC, 0x01,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x10, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0xFF,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0x03,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x07,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x01, 0xFF, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0xFF, 0xE0, 0xFF,
  0xC0, 0xFF, 0x80, 0xFF, 0x00, 0x0F, 0x00, 0xC3, 0xFC, 0x0F, 0x3F, 0xF1,
  0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0x8F, 0xFC, 0xF0, 0x3F, 0x83, 0x00,
  0xF0,
};

const GFXglyph UbuntuMono_Bold43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 7, 28, 22, 7, -27 },
  { 26, 14, 12, 22, 4, -29 },
  { 47, 20, 27, 22, 1, -27 },
  { 115, 19, 34, 22, 1, -30 },
  { 196, 21, 29, 22, 0, -28 },
  { 273, 20, 28, 22, 1, -28 },
  { 343, 6, 13, 22, 8, -29 },
  { 353, 14, 38, 22, 4, -31 },
  { 420, 14, 38, 22, 4, -31 },
  { 487, 18, 17, 22, 2, -27 },
  { 526, 18, 18, 22, 2, -20 },
  { 567, 10, 15, 22, 5, -7 },
  { 586, 12, 5, 22, 5, -13 },
  { 594, 8, 8, 22, 7, -7 },
  { 602, 17, 37, 22, 2, -30 },
  { 681, 19, 29, 22, 1, -28 },
  { 750, 18, 27, 22, 2, -27 },
  { 811, 18, 28, 22, 2, -28 },
  { 874, 17, 29, 22, 2, -28 },
  { 936, 19, 27, 22, 1, -27 },
  { 1001, 18, 28, 22, 1, -27 },
  { 1064, 18, 28, 22, 2, -27 },
  { 1127, 17, 27, 22, 2, -27 },
  { 1185, 18, 29, 22, 2, -28 },
  { 1251, 18, 28, 22, 2, -28 },
  { 1314, 8, 21, 22, 7, -20 },
  { 1335, 10, 28, 22, 5, -20 },
  { 1370, 18, 18, 22, 2, -20 },
  { 1411, 18, 12, 22, 2, -17 },
  { 1438, 18, 18, 22, 2, -20 },
  { 1479, 16, 29, 22, 3, -28 },
  { 1537, 19, 34, 22, 1, -28 },
  { 1618, 21, 27, 22, 0, -27 },
  { 1689, 18, 29, 22, 2, -28 },
  { 1755, 19, 29, 22, 1, -28 },
  { 1824, 18, 28, 22, 2, -27 },
  { 1887, 17, 27, 22, 3, -27 },
  { 1945, 16, 27, 22, 3, -27 },
  { 1999, 19, 29, 22, 1, -28 },
  { 2068, 18, 27, 22, 2, -27 },
  { 2129, 17, 27, 22, 2, -27 },
  { 2187, 17, 28, 22, 2, -27 },
  { 2247, 19, 27, 22, 2, -27 },
  { 2312, 17, 27, 22, 3, -27 },
  { 2370, 20, 27, 22, 1, -27 },
  { 2438, 18, 27, 22, 2, -27 },
  { 2499, 19, 29, 22, 1, -28 },
  { 2568, 18, 28, 22, 2, -28 },
  { 2631, 19, 36, 22, 1, -28 },
  { 2717, 19, 28, 22, 2, -28 },
  { 2784, 18, 29, 22, 2, -28 },
  { 2850, 19, 27, 22, 1, -27 },
  { 2915, 18, 28, 22, 2, -27 },
  { 2978, 20, 27, 22, 1, -27 },
  { 3046, 20, 27, 22, 1, -27 },
  { 3114, 21, 27, 22, 0, -27 },
  { 3185, 20, 27, 22, 1, -27 },
  { 3253, 18, 27, 22, 2, -27 },
  { 3314, 12, 37, 22, 5, -30 },
  { 3370, 18, 37, 22, 2, -30 },
  { 3454, 12, 37, 22, 5, -30 },
  { 3510, 20, 13, 22, 1, -27 },
  { 3543, 21, 4, 22, 0, 3 },
  { 3554, 9, 8, 22, 7, -30 },
  { 3563, 17, 22, 22, 2, -21 },
  { 3610, 17, 32, 22, 3, -31 },
  { 3678, 18, 22, 22, 2, -21 },
  { 3728, 17, 32, 22, 1, -31 },
  { 3796, 19, 22, 22, 1, -21 },
  { 3849, 19, 31, 22, 2, -31 },
  { 3923, 18, 29, 22, 1, -21 },
  { 3989, 16, 31, 22, 3, -31 },
  { 4051, 18, 31, 22, 2, -30 },
  { 4121, 15, 38, 22, 2, -30 },
  { 4193, 18, 31, 22, 3, -31 },
  { 4263, 18, 31, 22, 2, -30 },
  { 4333, 19, 21, 22, 1, -21 },
  { 4383, 16, 21, 22, 3, -21 },
  { 4425, 19, 22, 22, 1, -21 },
  { 4478, 17, 28, 22, 3, -21 },
  { 4538, 18, 28, 22, 1, -21 },
  { 4601, 16, 21, 22, 4, -21 },
  { 4643, 17, 22, 22, 2, -21 },
  { 4690, 18, 27, 22, 2, -26 },
  { 4751, 16, 21, 22, 3, -20 },
  { 4793, 20, 20, 22, 1, -20 },
  { 4843, 21, 20, 22, 0, -20 },
  { 4896, 20, 20, 22, 1, -20 },
  { 4946, 19, 28, 22, 1, -20 },
  { 5013, 16, 20, 22, 3, -20 },
  { 5053, 16, 37, 22, 3, -30 },
  { 5127, 5, 37, 22, 8, -30 },
  { 5151, 16, 37, 22, 3, -30 },
  { 5225, 20, 8, 22, 1, -15 },
};

const GFXfont UbuntuMono_Bold43pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Bold43pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Bold43pt7bGlyphs,
  0x20, 0x7E, 43
};

#endif // _UBUNTUMONO_BOLD43PT7B_H_
