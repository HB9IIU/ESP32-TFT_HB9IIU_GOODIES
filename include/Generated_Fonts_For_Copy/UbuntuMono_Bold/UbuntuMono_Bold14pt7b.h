#ifndef _UBUNTUMONO_BOLD14PT7B_H_
#define _UBUNTUMONO_BOLD14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Bold.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Bold14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xA4, 0x87, 0xE0, 0xDE, 0xF6, 0xA0, 0x34, 0x4B, 0xFF, 0xF2,
  0x9F, 0xFF, 0xA4, 0x58, 0x10, 0x71, 0xF3, 0x07, 0x0F, 0x87, 0x02, 0x7C,
  0xE0, 0x40, 0x67, 0x4A, 0xA3, 0x41, 0x05, 0x8A, 0xA5, 0xCC, 0x38, 0xF1,
  0x23, 0x87, 0x5B, 0xB3, 0x7E, 0x76, 0xF0, 0x11, 0x98, 0x8C, 0x63, 0x18,
  0x43, 0x0C, 0x20, 0x43, 0x0C, 0x21, 0x8C, 0x63, 0x11, 0x98, 0x80, 0x25,
  0x7E, 0xA5, 0x00, 0x21, 0x3F, 0xF2, 0x10, 0x7D, 0xA8, 0xFC, 0x5D, 0x00,
  0x18, 0xC6, 0x63, 0x19, 0x8C, 0x66, 0x31, 0x80, 0x38, 0xF9, 0xB2, 0xAD,
  0x68, 0x9B, 0x3E, 0x38, 0x37, 0xBC, 0x63, 0x18, 0xDF, 0xF8, 0x77, 0xE6,
  0x33, 0x33, 0x1F, 0xF8, 0xF7, 0xC6, 0xF7, 0x8C, 0x7F, 0xF0, 0x0C, 0x38,
  0xF3, 0x64, 0xDF, 0xFF, 0x86, 0x0C, 0x7D, 0xF6, 0x1E, 0x7C, 0x30, 0xDF,
  0x78, 0x3B, 0xF1, 0xEF, 0xCF, 0x3F, 0x70, 0xFF, 0xC6, 0x23, 0x11, 0x8C,
  0x60, 0x77, 0xE3, 0xB7, 0x4E, 0x3F, 0xF0, 0x77, 0xE3, 0x9F, 0xBC, 0xFE,
  0xE0, 0x5D, 0x05, 0xD0, 0x5D, 0x05, 0xDA, 0x80, 0x08, 0xDF, 0xCC, 0x71,
  0xE3, 0x08, 0xFF, 0xC1, 0xFF, 0x80, 0x86, 0x3C, 0x71, 0x9F, 0xD8, 0x80,
  0xF7, 0xC6, 0x33, 0x30, 0x0C, 0x60, 0x38, 0xC9, 0x7E, 0xFF, 0x7E, 0xFD,
  0xEF, 0x5C, 0xC0, 0xF0, 0x38, 0x70, 0xA1, 0x46, 0xCF, 0x9F, 0x63, 0xC6,
  0xF3, 0xE9, 0xBE, 0xFA, 0x28, 0xFE, 0xF0, 0x3C, 0xF9, 0x96, 0x0C, 0x18,
  0x19, 0x3E, 0x3C, 0xF3, 0xE9, 0xA3, 0x8E, 0x39, 0xBE, 0xF0, 0xFF, 0xF1,
  0xFF, 0xE3, 0x1F, 0xF8, 0xFF, 0xF1, 0x8F, 0xFF, 0x18, 0xC0, 0x3C, 0xF9,
  0x96, 0x0C, 0x58, 0x99, 0x3E, 0x3C, 0x8C, 0x63, 0xFF, 0xC6, 0x31, 0x88,
  0xFF, 0xC8, 0x42, 0x10, 0x9F, 0xF8, 0xFF, 0xC6, 0x31, 0x8E, 0x7F, 0xF0,
  0x9A, 0x6B, 0x28, 0xE2, 0xC9, 0xA6, 0x8C, 0xC6, 0x31, 0x8C, 0x63, 0x1F,
  0xF8, 0x44, 0xD9, 0xB3, 0x67, 0xDA, 0xF1, 0xE3, 0xC6, 0x8E, 0x73, 0xDA,
  0xDE, 0x73, 0x88, 0x38, 0xF9, 0x16, 0x3C, 0x78, 0xD1, 0x3E, 0x38, 0xF3,
  0xE8, 0xE3, 0xFB, 0xC8, 0x20, 0x80, 0x38, 0xF9, 0x16, 0x3C, 0x78, 0xD1,
  0x3E, 0x38, 0x38, 0x30, 0xF3, 0xE9, 0xA6, 0xFB, 0xC9, 0xA6, 0x8C, 0x7F,
  0xE1, 0xCF, 0x9E, 0x3F, 0xF0, 0xFF, 0xFC, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x8C, 0x63, 0x18, 0xC6, 0x3F, 0x70, 0xC7, 0x8D, 0x13, 0x66, 0xC5,
  0x0A, 0x1C, 0x38, 0xC7, 0x8F, 0x1E, 0xBD, 0x4D, 0x9B, 0x36, 0x44, 0x44,
  0xD8, 0xA1, 0xC3, 0x87, 0x1B, 0x36, 0xC6, 0xC6, 0xC9, 0xB1, 0x43, 0x82,
  0x04, 0x08, 0x10, 0xFF, 0xC4, 0x62, 0x23, 0x1F, 0xF8, 0xFE, 0x49, 0x24,
  0x93, 0xF0, 0xC6, 0x10, 0xC6, 0x30, 0xC6, 0x30, 0xC6, 0x30, 0xFC, 0x92,
  0x49, 0x27, 0xF0, 0x18, 0x71, 0xB3, 0x64, 0x40, 0xFF, 0xFC, 0x4C, 0xF7,
  0xC7, 0xF8, 0xFF, 0xE0, 0xC3, 0x0C, 0x3C, 0xFB, 0x3C, 0xF2, 0xFB, 0xC0,
  0x7B, 0xEC, 0x20, 0xC3, 0xE7, 0xC0, 0x0C, 0x30, 0xDF, 0x7F, 0x3C, 0xF3,
  0x7C, 0xF0, 0x38, 0xF9, 0x17, 0xF4, 0x0F, 0x8F, 0x00, 0x1E, 0x7C, 0xC7,
  0xEF, 0xC6, 0x0C, 0x18, 0x30, 0x60, 0x3D, 0xF4, 0xF3, 0x7D, 0xF0, 0xDF,
  0x78, 0xC6, 0x31, 0xEF, 0xEF, 0x7B, 0xDE, 0xC0, 0x30, 0x60, 0x07, 0x8F,
  0x06, 0x0C, 0x18, 0x3C, 0x3C, 0x31, 0x81, 0xFF, 0x8C, 0x63, 0x1C, 0xFD,
  0xE0, 0xC3, 0x0C, 0x36, 0xD3, 0xCE, 0x3C, 0xDB, 0x30, 0xF1, 0xE0, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x3C, 0x3C, 0xFD, 0xFF, 0x5E, 0xBC, 0x78, 0xF1,
  0x80, 0xF7, 0xF7, 0xBD, 0xEF, 0x60, 0x38, 0xF9, 0x1E, 0x34, 0x6F, 0x8E,
  0x00, 0xF3, 0xEC, 0xB3, 0xCB, 0xEF, 0x30, 0xC0, 0x3D, 0xF4, 0xF3, 0x4D,
  0xF3, 0xC3, 0x0C, 0xFF, 0xF1, 0x8C, 0x63, 0x00, 0x7F, 0xF0, 0xE1, 0xFF,
  0xC0, 0x30, 0x63, 0xF7, 0xE3, 0x06, 0x0C, 0x1E, 0x1E, 0xDE, 0xF7, 0xBD,
  0xFD, 0xE0, 0xC6, 0x89, 0xB3, 0x63, 0x87, 0x0C, 0x00, 0xC7, 0xAF, 0x5B,
  0xE6, 0xCD, 0x9B, 0x00, 0x44, 0xD8, 0xE0, 0xC3, 0x8D, 0x91, 0x00, 0x44,
  0xC9, 0xB1, 0x63, 0x87, 0x06, 0x18, 0xE0, 0xFF, 0xCC, 0x44, 0x7F, 0xE0,
  0x3B, 0xD8, 0xC6, 0x73, 0x8C, 0x63, 0x1E, 0x70, 0xFF, 0xF0, 0xE7, 0x8C,
  0x63, 0x1C, 0xE6, 0x31, 0xBD, 0xC0, 0x76, 0xFF, 0x70,
};

const GFXglyph UbuntuMono_Bold14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 9, 7, 2, -9 },
  { 5, 5, 4, 7, 1, -10 },
  { 8, 7, 9, 7, 0, -9 },
  { 16, 7, 11, 7, 0, -10 },
  { 26, 7, 9, 7, 0, -9 },
  { 34, 7, 9, 7, 0, -9 },
  { 42, 1, 4, 7, 3, -10 },
  { 43, 5, 12, 7, 1, -10 },
  { 51, 5, 12, 7, 1, -10 },
  { 59, 5, 5, 7, 1, -9 },
  { 63, 5, 6, 7, 1, -7 },
  { 67, 3, 5, 7, 2, -3 },
  { 69, 3, 2, 7, 2, -4 },
  { 70, 3, 3, 7, 2, -3 },
  { 72, 5, 12, 7, 1, -10 },
  { 80, 7, 9, 7, 0, -9 },
  { 88, 5, 9, 7, 1, -9 },
  { 94, 5, 9, 7, 1, -9 },
  { 100, 5, 9, 7, 1, -9 },
  { 106, 7, 9, 7, 0, -9 },
  { 114, 6, 9, 7, 0, -9 },
  { 121, 5, 9, 7, 1, -9 },
  { 127, 5, 9, 7, 1, -9 },
  { 133, 5, 9, 7, 1, -9 },
  { 139, 5, 9, 7, 1, -9 },
  { 145, 3, 7, 7, 2, -7 },
  { 148, 3, 9, 7, 2, -7 },
  { 152, 5, 9, 7, 1, -10 },
  { 158, 5, 5, 7, 1, -6 },
  { 162, 5, 9, 7, 1, -10 },
  { 168, 5, 9, 7, 1, -9 },
  { 174, 7, 11, 7, 0, -9 },
  { 184, 7, 9, 7, 0, -9 },
  { 192, 6, 9, 7, 1, -9 },
  { 199, 7, 9, 7, 0, -9 },
  { 207, 6, 9, 7, 1, -9 },
  { 214, 5, 9, 7, 1, -9 },
  { 220, 5, 9, 7, 1, -9 },
  { 226, 7, 9, 7, 0, -9 },
  { 234, 5, 9, 7, 1, -9 },
  { 240, 5, 9, 7, 1, -9 },
  { 246, 5, 9, 7, 1, -9 },
  { 252, 6, 9, 7, 1, -9 },
  { 259, 5, 9, 7, 1, -9 },
  { 265, 7, 9, 7, 0, -9 },
  { 273, 5, 9, 7, 1, -9 },
  { 279, 7, 9, 7, 0, -9 },
  { 287, 6, 9, 7, 1, -9 },
  { 294, 7, 11, 7, 0, -9 },
  { 304, 6, 9, 7, 1, -9 },
  { 311, 5, 9, 7, 1, -9 },
  { 317, 7, 9, 7, 0, -9 },
  { 325, 5, 9, 7, 1, -9 },
  { 331, 7, 9, 7, 0, -9 },
  { 339, 7, 9, 7, 0, -9 },
  { 347, 7, 9, 7, 0, -9 },
  { 355, 7, 9, 7, 0, -9 },
  { 363, 5, 9, 7, 1, -9 },
  { 369, 3, 12, 7, 2, -10 },
  { 374, 5, 12, 7, 1, -10 },
  { 382, 3, 12, 7, 2, -10 },
  { 387, 7, 5, 7, 0, -9 },
  { 392, 7, 2, 7, 0, 0 },
  { 394, 3, 2, 7, 2, -10 },
  { 395, 5, 7, 7, 1, -7 },
  { 400, 6, 10, 7, 1, -10 },
  { 408, 6, 7, 7, 1, -7 },
  { 414, 6, 10, 7, 0, -10 },
  { 422, 7, 7, 7, 0, -7 },
  { 429, 7, 10, 7, 0, -10 },
  { 438, 6, 9, 7, 0, -7 },
  { 445, 5, 10, 7, 1, -10 },
  { 452, 7, 10, 7, 0, -10 },
  { 461, 5, 12, 7, 1, -10 },
  { 469, 6, 10, 7, 1, -10 },
  { 477, 7, 10, 7, 0, -10 },
  { 486, 7, 7, 7, 0, -7 },
  { 493, 5, 7, 7, 1, -7 },
  { 498, 7, 7, 7, 0, -7 },
  { 505, 6, 9, 7, 1, -7 },
  { 512, 6, 9, 7, 0, -7 },
  { 519, 5, 7, 7, 1, -7 },
  { 524, 5, 7, 7, 1, -7 },
  { 529, 7, 9, 7, 0, -9 },
  { 537, 5, 7, 7, 1, -7 },
  { 542, 7, 7, 7, 0, -7 },
  { 549, 7, 7, 7, 0, -7 },
  { 556, 7, 7, 7, 0, -7 },
  { 563, 7, 9, 7, 0, -7 },
  { 571, 5, 7, 7, 1, -7 },
  { 576, 5, 12, 7, 1, -10 },
  { 584, 1, 12, 7, 3, -10 },
  { 586, 5, 12, 7, 1, -10 },
  { 594, 7, 3, 7, 0, -5 },
};

const GFXfont UbuntuMono_Bold14pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Bold14pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Bold14pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _UBUNTUMONO_BOLD14PT7B_H_
