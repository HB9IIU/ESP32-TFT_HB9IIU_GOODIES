#ifndef _UBUNTUMONO_BOLD48PT7B_H_
#define _UBUNTUMONO_BOLD48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Bold.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Bold48pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x3E, 0x00, 0x00,
  0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7C, 0x3F, 0x7C, 0x3E,
  0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x1E, 0x78, 0x1E, 0x38, 0x1E, 0x01, 0xF0,
  0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0,
  0x0F, 0x87, 0xC0, 0x3E, 0x3E, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x87, 0xC0, 0x3E, 0x1F,
  0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x3E, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC7, 0xC7, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0,
  0x0F, 0x87, 0x80, 0x3E, 0x3E, 0x01, 0xF0, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xF8,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0x01,
  0xC7, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF8,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF4, 0x00, 0x3F, 0x7C, 0x07, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0x7F, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0x3F, 0x80, 0x1F, 0x3F, 0xC0, 0x1E, 0x7F, 0xE0, 0x3C, 0x79,
  0xE0, 0x7C, 0x71, 0xE0, 0x78, 0x71, 0xE0, 0xF0, 0xF1, 0xE1, 0xF0, 0xF1,
  0xE1, 0xE0, 0x71, 0xE3, 0xC0, 0x71, 0xE7, 0xC0, 0x79, 0xE7, 0x80, 0x7F,
  0xEF, 0x00, 0x3F, 0xDF, 0x00, 0x3F, 0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x79, 0xFC, 0x00, 0xFB, 0xFC, 0x00, 0xF7, 0xFE, 0x01,
  0xE7, 0x9E, 0x03, 0xE7, 0x9E, 0x03, 0xC7, 0x8E, 0x07, 0x87, 0x8F, 0x0F,
  0x87, 0x8F, 0x0F, 0x07, 0x8E, 0x1E, 0x07, 0x9E, 0x3E, 0x07, 0x9E, 0x3C,
  0x07, 0xFE, 0x78, 0x03, 0xFC, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0xF0, 0x01,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0xFC, 0x7E, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x80,
  0xFC, 0x7C, 0x03, 0xF1, 0xF0, 0x07, 0xCF, 0x80, 0x1F, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0x0F, 0x03, 0xFC, 0x3E, 0x1F, 0xF0, 0xF8, 0xFF, 0xE3,
  0xE7, 0xEF, 0xCF, 0x9F, 0x1F, 0xBC, 0xF8, 0x3F, 0xF3, 0xE0, 0x7F, 0xCF,
  0x80, 0xFE, 0x3E, 0x03, 0xF8, 0xFC, 0x07, 0xE3, 0xF8, 0x7F, 0xC7, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xF3, 0xF0, 0x7F, 0x0F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xF7, 0x9E, 0x79, 0xE0,
  0x00, 0x18, 0x00, 0x70, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80,
  0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x80, 0x7E, 0x00, 0x38, 0x00, 0x20, 0x30, 0x00, 0x38, 0x00, 0x7E,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF,
  0x00, 0x7E, 0x00, 0x3C, 0x00, 0x10, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x30, 0xF0, 0x47, 0x8F, 0x1E, 0x7E, 0xF7,
  0xE7, 0xF7, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0x80, 0x1F,
  0x80, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xDF, 0x01, 0xF9, 0xF8, 0x3F,
  0x9F, 0xC1, 0xF0, 0xF8, 0x07, 0x0E, 0x00, 0x20, 0x40, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0x03, 0xF8, 0xFF, 0x1F, 0xE3, 0xFE, 0x7F, 0xCF, 0xF8,
  0xFF, 0x0F, 0xC0, 0x78, 0x1F, 0x07, 0xC3, 0xF9, 0xFE, 0x3F, 0x83, 0xC0,
  0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0,
  0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xF0, 0xFE, 0x7E, 0x07,
  0xE7, 0xC0, 0x3E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x8F, 0x1F, 0xF8, 0xF1, 0xFF, 0x9F, 0x9F, 0xF9,
  0xF9, 0xFF, 0x8F, 0x1F, 0xF8, 0xF1, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x7C, 0x03, 0xE7, 0xE0, 0x7E,
  0x7F, 0x0F, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x07, 0xFE,
  0x00, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x3F,
  0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x03, 0xCF, 0xC0, 0x30, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x03, 0xF8, 0x01, 0xFF, 0xE0, 0x3F,
  0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xC1, 0xFC, 0x38, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0,
  0x07, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF,
  0xC3, 0xC1, 0xFC, 0x20, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0xF8, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x70, 0x1F, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF,
  0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0x9F, 0x80,
  0x7C, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0x87, 0xE0, 0x7C, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF0, 0x1F, 0x8F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0xF0, 0x03,
  0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x00, 0xFF, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xEC, 0x03, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xC0,
  0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xEF, 0xC0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0xFE, 0x0F, 0xEF, 0xC0, 0x7E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0x7C, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x07, 0xE7,
  0xF0, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xF0,
  0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xF0, 0xFE, 0x7E, 0x07, 0xE7,
  0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E,
  0x7F, 0x8F, 0xC3, 0xFD, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF,
  0x03, 0xFF, 0xFC, 0x7F, 0x7F, 0xC7, 0xE1, 0xFE, 0xFC, 0x07, 0xFF, 0xC0,
  0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFF,
  0x0F, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x0F, 0xFF, 0x00,
  0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC7, 0xF0, 0xFE, 0x7E, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xE0,
  0x3F, 0x7F, 0x07, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xE0, 0x3F, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0,
  0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x0F, 0x07, 0xE3, 0xFC,
  0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0x7E, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x1F, 0x8F, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF1,
  0xFC, 0x3F, 0x07, 0xC1, 0xE0, 0xF8, 0xFC, 0xFE, 0x3F, 0x0F, 0x83, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x1E, 0x00, 0x07, 0xE0, 0x03, 0xFF, 0x00, 0xFF,
  0xF0, 0x3F, 0xFF, 0x1F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xF8,
  0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x07, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x60, 0x00, 0x07, 0x80, 0x00, 0x7F, 0x00, 0x0F,
  0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0xFF,
  0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFC,
  0x00, 0x7E, 0x00, 0x07, 0x80, 0x00, 0x60, 0x00, 0x00, 0x07, 0xF0, 0x0F,
  0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x9E, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x00, 0x7E, 0x00,
  0x1F, 0xFC, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xF8, 0x3F, 0x0F, 0x80,
  0xFC, 0xF8, 0x03, 0xE7, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xC0, 0xFF, 0xDE,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xE3,
  0xFE, 0x3F, 0x1F, 0xF1, 0xF0, 0xFF, 0x8F, 0x87, 0xFC, 0x7C, 0x3F, 0xE3,
  0xE1, 0xFF, 0x1F, 0x0F, 0xF8, 0xF8, 0x7F, 0xC7, 0xE3, 0xFF, 0x1F, 0x1F,
  0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xDE, 0x1F, 0xFE, 0xF0, 0x7F, 0xF7, 0xC0,
  0xFF, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x10,
  0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xEF, 0xC0, 0x03,
  0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xE0, 0x07, 0xC7, 0xE0, 0x07,
  0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F,
  0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0x00, 0xFC, 0x3F,
  0x00, 0xFC, 0x3E, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7F, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xC1, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0,
  0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xF8, 0xFC,
  0x3F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0xFC, 0x1F, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x3E,
  0xFC, 0x03, 0xFF, 0xC0, 0x3E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x1F,
  0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x7F, 0x81, 0xC3, 0xF8, 0x01, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x41, 0xFE, 0x07, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFF, 0x80, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xC3, 0xF8, 0xFC, 0x1F, 0xCF, 0xC0,
  0xFC, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E,
  0xFC, 0x0F, 0xEF, 0xC0, 0xFC, 0xFC, 0x1F, 0xCF, 0xC7, 0xF8, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF,
  0xF8, 0xFF, 0xFF, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF,
  0xFF, 0xBF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xF0, 0x38, 0xFE,
  0x00, 0x47, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xF7,
  0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xE0, 0x3F, 0x3F, 0x01,
  0xF9, 0xFC, 0x0F, 0xC7, 0xF0, 0x7E, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x0F, 0xFC, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F,
  0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x7F, 0x20, 0x0F, 0xC7, 0x07, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF,
  0xCF, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFC, 0x00, 0xFC, 0x03, 0xF7, 0xE0,
  0x3F, 0xBF, 0x01, 0xF9, 0xF8, 0x1F, 0xCF, 0xC1, 0xFC, 0x7E, 0x0F, 0xC3,
  0xF0, 0xFE, 0x1F, 0x87, 0xE0, 0xFC, 0x7E, 0x07, 0xE7, 0xF0, 0x3F, 0x3F,
  0x01, 0xFB, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xEF, 0xF0, 0x3F, 0x3F, 0x81, 0xF8, 0xFE,
  0x0F, 0xC3, 0xF8, 0x7E, 0x1F, 0xC3, 0xF0, 0x7F, 0x1F, 0x81, 0xFC, 0xFC,
  0x0F, 0xE7, 0xE0, 0x3F, 0xBF, 0x01, 0xFD, 0xF8, 0x07, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xF0, 0x3F, 0x1F,
  0xC0, 0xFC, 0x7F, 0x03, 0xF1, 0xFC, 0x1F, 0xE7, 0xF8, 0x7F, 0x9E, 0xE1,
  0xDE, 0x7B, 0x8F, 0x79, 0xEF, 0x3D, 0xE7, 0xBC, 0xF7, 0x9E, 0x77, 0x9E,
  0x79, 0xFE, 0x79, 0xE7, 0xF9, 0xE7, 0x8F, 0xC7, 0x9E, 0x3F, 0x1E, 0x78,
  0xFC, 0x79, 0xE3, 0xF1, 0xE7, 0x87, 0x87, 0x9E, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xF0, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F,
  0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFD, 0xF3, 0xFF, 0xDF,
  0x3F, 0xFC, 0xFB, 0xFF, 0xCF, 0xBF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFE, 0x1F, 0xC3, 0xF0, 0x3F,
  0x1F, 0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F,
  0x00, 0x3E, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0x7C, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E,
  0x01, 0xF8, 0xFC, 0x0F, 0xC3, 0xF8, 0x7F, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0xF0, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xC1, 0xFE,
  0xFC, 0x0F, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0xFC, 0x0F, 0xEF, 0xE1,
  0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF,
  0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFE, 0x1F, 0xC3, 0xF0, 0x3F, 0x1F, 0x80,
  0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x00, 0x3E,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x7C, 0x01,
  0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xF8,
  0xFC, 0x0F, 0xC3, 0xF8, 0x7F, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x1C, 0x3F, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xC3, 0xFC, 0xFC, 0x1F, 0xCF, 0xC0,
  0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xEF, 0xC0, 0xFC, 0xFC,
  0x0F, 0xCF, 0xC1, 0xFC, 0xFC, 0x3F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC0, 0xFC, 0xFC, 0x0F,
  0xCF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0x01,
  0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7,
  0xF0, 0x3C, 0x7E, 0x00, 0x8F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFE,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF6, 0x00, 0x7F, 0x78, 0x0F, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0x7F, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xF7, 0xF0, 0xFE, 0x7F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFC, 0x00,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x7E,
  0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x3E, 0x01,
  0xF8, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x0F, 0x87, 0xC0, 0x3E,
  0x1F, 0x00, 0xFC, 0xFC, 0x01, 0xF3, 0xF0, 0x07, 0xCF, 0x80, 0x1F, 0x3E,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0x9E, 0x1E, 0x1E, 0x78, 0xFC, 0x79, 0xE3,
  0xF1, 0xE7, 0x8F, 0xC7, 0x9E, 0x7F, 0x9E, 0x79, 0xFE, 0x79, 0xE7, 0xF9,
  0xE7, 0x9C, 0xE7, 0x9E, 0xF3, 0xDE, 0x7B, 0xCF, 0x79, 0xEF, 0x1D, 0xE7,
  0xF8, 0x77, 0x9F, 0xE1, 0xFE, 0x7F, 0x83, 0xF9, 0xFC, 0x0F, 0xE3, 0xF0,
  0x3F, 0x8F, 0xC0, 0xFC, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC0, 0xFE, 0x00,
  0xFD, 0xF8, 0x07, 0xE7, 0xF0, 0x1F, 0x8F, 0xC0, 0xFC, 0x3F, 0x83, 0xF0,
  0x7E, 0x1F, 0x80, 0xFC, 0x7C, 0x03, 0xF3, 0xF0, 0x07, 0xEF, 0x80, 0x1F,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xF8, 0x01, 0xFB, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x81, 0xF8,
  0x7E, 0x07, 0xE1, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xE7, 0xE0, 0x1F,
  0x9F, 0x80, 0x7E, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xF7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xF8, 0xFC,
  0x0F, 0xC3, 0xF0, 0x3F, 0x07, 0xE0, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F,
  0x80, 0xFC, 0x7C, 0x03, 0xF3, 0xF0, 0x07, 0xEF, 0x80, 0x1F, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x03, 0xF3, 0xF0, 0x0F, 0xE3, 0xF0, 0x1F,
  0x87, 0xF0, 0x7E, 0x07, 0xE1, 0xFC, 0x07, 0xE3, 0xF0, 0x0F, 0xEF, 0xE0,
  0x0F, 0xCF, 0x80, 0x1F, 0x02, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x10,
  0x07, 0x00, 0xF8, 0x3F, 0x8F, 0xF8, 0x7F, 0xC3, 0xF0, 0x1E, 0x00, 0x80,
  0x0F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC,
  0x20, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x1F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xF7,
  0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x07, 0xFF, 0x00,
  0x1C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFD, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xCF, 0xE1, 0xFC, 0xFC, 0x0F, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF,
  0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x0F,
  0xEF, 0xC1, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF,
  0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xFF, 0x07, 0xFF, 0xF1,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFC, 0x06, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x03, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xFB, 0xF0, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xF8, 0x7F, 0x7F,
  0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xE0, 0x3F,
  0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7F, 0x03, 0xF3, 0xF8, 0x3F, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x1F, 0xC3, 0xF8, 0xFC, 0x07, 0xCF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0,
  0x07, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xEF, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x80, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xC0, 0xE0, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xFF,
  0xF7, 0xFF, 0xFE, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE1, 0xFD, 0xFF, 0xFF,
  0xBF, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFD, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x30, 0x0F, 0xE7, 0xFF, 0xFC,
  0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0x1F, 0xF0, 0x00, 0x1C, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xDF, 0x83, 0xFF,
  0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xF0, 0x7E, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xF0, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x30, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF0, 0x01, 0xFC, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xFE,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE4, 0x03, 0xF3, 0xC3, 0xFB, 0xFF,
  0xF9, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xFC, 0x07, 0xF8, 0x00, 0x1C, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0xFE, 0xFC, 0x1F, 0xCF, 0xC1, 0xFC, 0xFC, 0x3F, 0x8F,
  0xC7, 0xF0, 0xFC, 0x7E, 0x0F, 0xCF, 0xC0, 0xFD, 0xF8, 0x0F, 0xFF, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFD, 0xFC,
  0x0F, 0xCF, 0xE0, 0xFC, 0x7E, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x8F, 0xC1,
  0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFE, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x30,
  0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFC,
  0x1F, 0xC7, 0xC3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFB, 0xE3, 0xE3, 0xEF, 0x8F, 0x8F, 0xBE, 0x3E, 0x1F, 0xF8, 0x78,
  0x7F, 0xE1, 0xE1, 0xFF, 0x87, 0x87, 0xFE, 0x1E, 0x1F, 0xF8, 0x78, 0x7F,
  0xE1, 0xE1, 0xFF, 0x87, 0x87, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0x1F, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF,
  0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0x07, 0xEF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0xFE, 0x1F, 0xC7, 0xF0, 0x3F, 0x9F, 0x80, 0x7E, 0x7E, 0x01,
  0xF9, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xDF, 0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xF8,
  0x07, 0xE7, 0xF0, 0x3F, 0x8F, 0xE1, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xF0, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xC1, 0xFC,
  0xFC, 0x0F, 0xEF, 0xC0, 0xFE, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07,
  0xEF, 0xC0, 0x7E, 0xFC, 0x03, 0xFF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0,
  0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x0F, 0xEF, 0xE1, 0xFC, 0xFF,
  0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFD, 0xFC, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0x0F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xF8, 0x3F, 0x7F, 0x03, 0xF7, 0xF0,
  0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xFF, 0xE0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7,
  0xE0, 0x3F, 0x7F, 0x03, 0xF3, 0xF8, 0x7F, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFB, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x07, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xBF, 0x80, 0x2F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x03, 0xFE, 0x07, 0xFF, 0xE3,
  0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0x80, 0xCF, 0xC0, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF,
  0x03, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF,
  0xF8, 0x1F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x81,
  0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0x00, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFD, 0xFF, 0xFF, 0x7F,
  0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x1F, 0xF0, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xDF, 0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x07,
  0xE3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0x1F, 0x81,
  0xF8, 0x7E, 0x07, 0xE3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0x7D,
  0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE1, 0xE1, 0xFF, 0x87, 0xC7, 0xFE, 0x3F, 0x1F, 0xF8, 0xFC,
  0x7F, 0xE3, 0xF1, 0xE7, 0x8F, 0xE7, 0x9E, 0x7F, 0x9E, 0x79, 0xFE, 0x79,
  0xE7, 0xF9, 0xE7, 0xBD, 0xF7, 0x9F, 0xF3, 0xFE, 0x3F, 0xCF, 0xF0, 0xFE,
  0x3F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x03, 0xF0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x00, 0xFE, 0x01, 0xF9, 0xF8, 0x07, 0xE3, 0xF0, 0x3F,
  0x0F, 0xE1, 0xFC, 0x1F, 0x87, 0xE0, 0x3F, 0x3F, 0x00, 0x7E, 0xFC, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0,
  0x0F, 0xCF, 0xC0, 0x7E, 0x1F, 0x81, 0xF8, 0x7F, 0x0F, 0xC0, 0xFC, 0x7E,
  0x01, 0xF9, 0xF8, 0x07, 0xEF, 0xC0, 0x0F, 0xC0, 0x7E, 0x01, 0xFD, 0xF8,
  0x07, 0xE7, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF0, 0xFC, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7F, 0x1F, 0x80,
  0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x07, 0xE7, 0xC0, 0x1F, 0xBF, 0x00, 0x7E,
  0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x04, 0x3F, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC1, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xFC, 0x03, 0xFC,
  0x00, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0x80, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xC0, 0x0F,
  0xF0, 0x0F, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x0F, 0x80,
  0x30, 0x7F, 0x81, 0xF3, 0xFF, 0x87, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xEF, 0xC7, 0xFF, 0x3E, 0x07, 0xF8, 0x18, 0x07, 0xC0,
};

const GFXglyph UbuntuMono_Bold48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 8, 31, 24, 8, -30 },
  { 32, 16, 13, 24, 4, -33 },
  { 58, 22, 30, 24, 1, -30 },
  { 141, 20, 39, 24, 2, -34 },
  { 239, 24, 32, 24, 0, -31 },
  { 335, 22, 31, 24, 1, -31 },
  { 421, 6, 14, 24, 9, -33 },
  { 432, 15, 42, 24, 5, -34 },
  { 511, 16, 42, 24, 4, -34 },
  { 595, 20, 20, 24, 2, -30 },
  { 645, 20, 21, 24, 2, -23 },
  { 698, 11, 17, 24, 6, -8 },
  { 722, 14, 6, 24, 5, -15 },
  { 733, 8, 9, 24, 8, -8 },
  { 742, 20, 42, 24, 2, -34 },
  { 847, 20, 32, 24, 2, -31 },
  { 927, 20, 30, 24, 2, -30 },
  { 1002, 20, 31, 24, 2, -31 },
  { 1080, 20, 32, 24, 2, -31 },
  { 1160, 22, 30, 24, 1, -30 },
  { 1243, 19, 31, 24, 2, -30 },
  { 1317, 20, 31, 24, 2, -30 },
  { 1395, 20, 30, 24, 2, -30 },
  { 1470, 20, 32, 24, 2, -31 },
  { 1550, 20, 31, 24, 2, -31 },
  { 1628, 8, 24, 24, 8, -23 },
  { 1652, 10, 32, 24, 6, -23 },
  { 1692, 20, 21, 24, 2, -23 },
  { 1745, 20, 14, 24, 2, -19 },
  { 1780, 20, 21, 24, 2, -23 },
  { 1833, 18, 32, 24, 3, -31 },
  { 1905, 21, 37, 24, 1, -31 },
  { 2003, 24, 30, 24, 0, -30 },
  { 2093, 20, 32, 24, 3, -31 },
  { 2173, 22, 32, 24, 1, -31 },
  { 2261, 20, 31, 24, 3, -30 },
  { 2339, 19, 30, 24, 3, -30 },
  { 2411, 18, 30, 24, 3, -30 },
  { 2479, 21, 32, 24, 1, -31 },
  { 2563, 20, 30, 24, 2, -30 },
  { 2638, 18, 30, 24, 3, -30 },
  { 2706, 19, 31, 24, 2, -30 },
  { 2780, 21, 30, 24, 2, -30 },
  { 2859, 19, 30, 24, 3, -30 },
  { 2931, 22, 30, 24, 1, -30 },
  { 3014, 20, 30, 24, 2, -30 },
  { 3089, 22, 32, 24, 1, -31 },
  { 3177, 20, 31, 24, 3, -31 },
  { 3255, 22, 40, 24, 1, -31 },
  { 3365, 20, 31, 24, 3, -31 },
  { 3443, 20, 32, 24, 2, -31 },
  { 3523, 22, 30, 24, 1, -30 },
  { 3606, 20, 31, 24, 2, -30 },
  { 3684, 22, 30, 24, 1, -30 },
  { 3767, 22, 30, 24, 1, -30 },
  { 3850, 22, 30, 24, 1, -30 },
  { 3933, 22, 30, 24, 1, -30 },
  { 4016, 20, 30, 24, 2, -30 },
  { 4091, 14, 42, 24, 5, -34 },
  { 4165, 20, 42, 24, 2, -34 },
  { 4270, 14, 42, 24, 5, -34 },
  { 4344, 23, 15, 24, 1, -30 },
  { 4388, 24, 5, 24, 0, 3 },
  { 4403, 11, 9, 24, 7, -33 },
  { 4416, 19, 25, 24, 2, -24 },
  { 4476, 20, 35, 24, 3, -34 },
  { 4564, 20, 25, 24, 2, -24 },
  { 4627, 20, 35, 24, 1, -34 },
  { 4715, 21, 25, 24, 1, -24 },
  { 4781, 22, 34, 24, 2, -34 },
  { 4875, 19, 33, 24, 2, -24 },
  { 4954, 18, 34, 24, 3, -34 },
  { 5031, 20, 34, 24, 2, -33 },
  { 5116, 17, 42, 24, 2, -33 },
  { 5206, 20, 34, 24, 3, -34 },
  { 5291, 20, 34, 24, 2, -33 },
  { 5376, 22, 24, 24, 1, -24 },
  { 5442, 18, 24, 24, 3, -24 },
  { 5496, 22, 25, 24, 1, -24 },
  { 5565, 20, 32, 24, 3, -24 },
  { 5645, 20, 32, 24, 1, -24 },
  { 5725, 18, 24, 24, 4, -24 },
  { 5779, 18, 25, 24, 3, -24 },
  { 5836, 21, 31, 24, 2, -30 },
  { 5918, 18, 24, 24, 3, -23 },
  { 5972, 22, 23, 24, 1, -23 },
  { 6036, 22, 23, 24, 1, -23 },
  { 6100, 22, 23, 24, 1, -23 },
  { 6164, 22, 32, 24, 1, -23 },
  { 6252, 18, 23, 24, 3, -23 },
  { 6304, 18, 42, 24, 3, -34 },
  { 6399, 6, 42, 24, 9, -34 },
  { 6431, 18, 42, 24, 3, -34 },
  { 6526, 22, 9, 24, 1, -17 },
};

const GFXfont UbuntuMono_Bold48pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Bold48pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Bold48pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _UBUNTUMONO_BOLD48PT7B_H_
