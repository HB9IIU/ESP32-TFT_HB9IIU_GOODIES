#ifndef _UBUNTUMONO_BOLD24PT7B_H_
#define _UBUNTUMONO_BOLD24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Bold.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Bold24pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x66, 0x00, 0x6F, 0x60, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE7, 0x67, 0x66, 0x0C, 0xE0, 0xCE, 0x0C, 0xC1, 0xCC, 0xFF, 0xFF,
  0xFF, 0x19, 0xC1, 0x98, 0x39, 0x8F, 0xFF, 0xFF, 0xF3, 0x38, 0x33, 0x07,
  0x30, 0x73, 0x00, 0x0C, 0x03, 0x03, 0xFD, 0xFE, 0x70, 0xB8, 0x0F, 0x01,
  0xE0, 0x7F, 0x07, 0xE0, 0x3C, 0x07, 0x01, 0xF0, 0x7F, 0xFD, 0xFE, 0x0C,
  0x03, 0x00, 0xC0, 0x78, 0x77, 0x86, 0xCC, 0xCC, 0xCC, 0xCD, 0x87, 0xB0,
  0x7B, 0x00, 0x60, 0x0D, 0xE0, 0xDE, 0x1B, 0x33, 0x33, 0x33, 0x36, 0x1E,
  0xE1, 0xE0, 0x1E, 0x03, 0xF0, 0x33, 0x83, 0x38, 0x33, 0x83, 0xB0, 0x3F,
  0x01, 0xC6, 0x7E, 0xE7, 0x7E, 0x63, 0xC6, 0x1C, 0x71, 0xC7, 0xFE, 0x3E,
  0x60, 0xFF, 0xF6, 0x66, 0x60, 0x02, 0x0F, 0x1E, 0x3C, 0x38, 0x70, 0x70,
  0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0x70, 0x70, 0x38, 0x3C, 0x1E,
  0x0F, 0x02, 0x40, 0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0x0E, 0x06, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x06, 0x0E, 0x0E, 0x1C, 0x3C, 0x78, 0xF0, 0x40, 0x0C,
  0x03, 0x04, 0xCB, 0xFF, 0xFF, 0xC7, 0x83, 0xF1, 0xCE, 0x12, 0x00, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0x3B, 0xDE, 0x71, 0x9F, 0xD8, 0xFF, 0xFF, 0xC0, 0x6F, 0xF6, 0x01, 0xC0,
  0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x81, 0xE0,
  0x70, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0xE0,
  0x00, 0x1E, 0x1F, 0xE7, 0x3B, 0x87, 0xE1, 0xF8, 0x7E, 0xDF, 0xB7, 0xED,
  0xF8, 0x7E, 0x1F, 0x87, 0x73, 0x9F, 0xE1, 0xE0, 0x06, 0x07, 0x83, 0xE3,
  0xF8, 0x7E, 0x13, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x1F, 0xF7, 0xFC, 0x3E, 0x3F, 0xC6, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x81, 0xC0, 0xF0, 0x3F, 0xFF, 0xFC, 0x3E, 0x3F,
  0xC4, 0x38, 0x0E, 0x03, 0x81, 0xE1, 0xF0, 0x7C, 0x03, 0x80, 0x70, 0x1C,
  0x07, 0x83, 0xBF, 0xE7, 0xE0, 0x03, 0x81, 0xE0, 0xF8, 0x7E, 0x1B, 0x8C,
  0xE7, 0x39, 0x8E, 0xE3, 0xBF, 0xFF, 0xFC, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x3F, 0x9F, 0xE7, 0x01, 0xC0, 0x70, 0x1F, 0x07, 0xF0, 0x1E, 0x03, 0xC0,
  0x70, 0x1C, 0x07, 0x83, 0xBF, 0xCF, 0xE0, 0x03, 0x87, 0xE3, 0xC1, 0xE0,
  0x70, 0x1F, 0x0F, 0xFB, 0xCE, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0x73, 0x9F,
  0xE1, 0xE0, 0xFF, 0xFF, 0xF0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x38,
  0x0E, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x80, 0x1F, 0x1F, 0xE7,
  0x3F, 0x87, 0xE1, 0xDC, 0xE7, 0xF1, 0xFC, 0x77, 0xB8, 0x7E, 0x1F, 0x87,
  0xE1, 0xDF, 0xE3, 0xF0, 0x1E, 0x1F, 0xE7, 0x3B, 0x87, 0xE1, 0xF8, 0x7E,
  0x1D, 0xEF, 0x7F, 0xC6, 0xF0, 0x38, 0x1E, 0x0F, 0x1F, 0x87, 0x80, 0x6F,
  0xF6, 0x00, 0x06, 0xFF, 0x60, 0x33, 0xDE, 0x60, 0x00, 0x06, 0x7B, 0xCE,
  0x33, 0x7B, 0x00, 0x00, 0x80, 0xF1, 0xFD, 0xF8, 0xF8, 0x3E, 0x07, 0xE0,
  0x7F, 0x03, 0xC0, 0x20, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x40, 0x3E, 0x0F, 0xE0, 0x7F, 0x07, 0xC1, 0xF1, 0xFB, 0xF8, 0xF8, 0x10,
  0x00, 0x7C, 0xFF, 0x87, 0x07, 0x07, 0x0F, 0x1E, 0x3C, 0x38, 0x38, 0x00,
  0x00, 0x38, 0x3C, 0x38, 0x0F, 0x83, 0xF8, 0xE3, 0xB8, 0x36, 0x3E, 0xCF,
  0xDB, 0x9F, 0x73, 0xEE, 0x7D, 0xCF, 0xB9, 0xB7, 0x36, 0x7E, 0xC7, 0xDC,
  0x01, 0xC0, 0x1F, 0xE0, 0xFC, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF8, 0x1F,
  0x81, 0x98, 0x39, 0xC3, 0x9C, 0x39, 0xC3, 0x9C, 0x7F, 0xE7, 0xFE, 0x70,
  0xE7, 0x0E, 0xE0, 0xF0, 0xFE, 0x3F, 0xEE, 0x3B, 0x87, 0xE1, 0xF8, 0xEF,
  0xF3, 0xFE, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xFF, 0xEF, 0xF0, 0x0F,
  0x8F, 0xF7, 0x87, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0x70, 0x4F, 0xF1, 0xF8, 0xFE, 0x3F, 0xCE, 0x3B, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0xBF, 0xCF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0xFD, 0xFE, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06,
  0x03, 0xFD, 0xFE, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x1F,
  0xCF, 0xF7, 0x8B, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0x71, 0xCF, 0xF1, 0xFC, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7F, 0xFF, 0xFF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1C, 0xFF, 0xFF, 0xF0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x3F, 0xFF, 0xFC, 0x3F, 0xCF, 0xF0, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x43,
  0xBF, 0xC7, 0xE0, 0xE1, 0xDC, 0x73, 0x8E, 0x73, 0x8E, 0xE1, 0xDC, 0x3F,
  0x07, 0xE0, 0xFE, 0x1D, 0xE3, 0x9E, 0x71, 0xCE, 0x3D, 0xC3, 0xB8, 0x78,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0xFF, 0xFE, 0xE1, 0xF8, 0x7F, 0x3F, 0xCF, 0xF3, 0xF7,
  0xBD, 0xEF, 0x7B, 0xDC, 0xF3, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0C,
  0xE1, 0xF8, 0x7F, 0x1F, 0xC7, 0xF9, 0xFE, 0x7E, 0xDF, 0xB7, 0xE7, 0xF9,
  0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0x7E, 0x1C, 0x1E, 0x1F, 0xE7, 0x3B, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0x73, 0x9F,
  0xE1, 0xE0, 0xFE, 0x3F, 0xEE, 0x3F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0xCF,
  0xFF, 0xBF, 0xCE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0x1E, 0x1F, 0xE7,
  0x3B, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0x73, 0x9F, 0xE3, 0xF0, 0x30, 0x0F, 0x01, 0xF0, 0x1C, 0xFE, 0x1F, 0xF3,
  0x8E, 0x70, 0xEE, 0x1D, 0xC3, 0xB8, 0xE7, 0xFC, 0xFF, 0x1C, 0xE3, 0x8E,
  0x71, 0xCE, 0x1D, 0xC3, 0xB8, 0x78, 0x1F, 0x1F, 0xEF, 0x0B, 0x80, 0xE0,
  0x3C, 0x07, 0xC0, 0xFC, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x43, 0xFF, 0xE7,
  0xF0, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xF3,
  0xDF, 0xE3, 0xF0, 0xE0, 0x77, 0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xE3, 0x0C,
  0x39, 0xC3, 0x9C, 0x39, 0xC1, 0x98, 0x1F, 0x81, 0xF8, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF3, 0x3C, 0xCF, 0x7B,
  0xDE, 0xF7, 0xBF, 0x3F, 0xCF, 0xF3, 0xF8, 0x7E, 0x1C, 0x70, 0xE7, 0x0E,
  0x39, 0xC3, 0x9C, 0x1F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x81, 0xF8,
  0x39, 0xC3, 0x9C, 0x78, 0xE7, 0x0E, 0xF0, 0xF0, 0xF0, 0xF7, 0x0E, 0x70,
  0xE3, 0x9C, 0x39, 0xC1, 0x98, 0x1F, 0x80, 0xF8, 0x0F, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xFF, 0xFF, 0xF0, 0x38, 0x1E,
  0x07, 0x03, 0xC0, 0xE0, 0x70, 0x1C, 0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFE, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x3F, 0xFC, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x38,
  0x0E, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0xC0,
  0x70, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0xFF, 0xF1, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xFF,
  0xFC, 0x0F, 0x00, 0xF0, 0x1F, 0x83, 0x9C, 0x78, 0xE7, 0x0E, 0x20, 0x40,
  0xFF, 0xFF, 0xFF, 0x47, 0x1E, 0x20, 0x7E, 0x1F, 0xE0, 0x38, 0x07, 0x3F,
  0xDF, 0xFE, 0x1F, 0x87, 0xE1, 0xDF, 0xF3, 0xFC, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0xF3, 0xFE, 0xF3, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x3F, 0xFE, 0x7E, 0x00, 0x1F, 0xCF, 0xF7, 0x83, 0xC0, 0xE0,
  0x38, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0xF1, 0xFC, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0xFE, 0xFF, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0xCE, 0xFF, 0x3F, 0x80, 0x1E, 0x1F, 0xE7, 0x3B, 0x87, 0xE1, 0xFF, 0xFF,
  0xFF, 0x80, 0xF0, 0x9F, 0xE1, 0xF8, 0x07, 0xC3, 0xFC, 0x70, 0x1E, 0x03,
  0x80, 0x70, 0x3F, 0xF7, 0xFE, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x1F, 0x9F, 0xFF, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0xC7, 0x7F, 0xCF, 0xF0, 0x38, 0x0E, 0xC3, 0xBF, 0xC7,
  0xE0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xF9, 0xFE, 0xC7, 0x61,
  0xB0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0x80, 0x18, 0x0F, 0x03,
  0xC0, 0x60, 0x00, 0x3F, 0x0F, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC4, 0x3F, 0x07, 0xC0, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x03, 0xFD, 0xFE, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0x91, 0xDF, 0xE7, 0xC0, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x7B, 0x1C, 0xCE, 0x37, 0x0F, 0x83, 0xF0, 0xDC, 0x33,
  0x8C, 0x73, 0x1E, 0xC3, 0x80, 0xFC, 0x3F, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC4,
  0x3F, 0x07, 0xC0, 0xFF, 0xBF, 0xFC, 0xCF, 0x33, 0xCC, 0xF3, 0x3C, 0xCF,
  0x03, 0xC0, 0xF0, 0x3C, 0x0C, 0xFE, 0x7F, 0xB1, 0xD8, 0x6C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xE0, 0x1E, 0x1F, 0xEF, 0x3F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xF3, 0xDF, 0xE1, 0xE0, 0xFC, 0x7F, 0xB1, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC7, 0xFF, 0xB7, 0x98, 0x0C, 0x06, 0x03,
  0x00, 0x1F, 0x9F, 0xFF, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xF1,
  0xDF, 0xF3, 0xFC, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x3F, 0xFF, 0xF8, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x00, 0x1F, 0x9F, 0xE7,
  0x09, 0xC0, 0x7C, 0x0F, 0xC0, 0xF8, 0x0F, 0x41, 0xFF, 0xE7, 0xF0, 0x38,
  0x0E, 0x03, 0x83, 0xFF, 0xFF, 0xCE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0x70, 0x1F, 0xC3, 0xF0, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1D, 0x87, 0x71, 0xDF, 0xF3, 0xF8, 0xF0, 0x77, 0x0E, 0x70, 0xE7,
  0x0E, 0x39, 0xC3, 0x9C, 0x1B, 0x81, 0xF8, 0x1F, 0x00, 0xF0, 0x0E, 0x00,
  0xE0, 0x7E, 0x07, 0x66, 0x66, 0x66, 0x6F, 0x66, 0xF6, 0x6F, 0x66, 0xBE,
  0x79, 0xE3, 0x9C, 0x30, 0xC0, 0x70, 0xE3, 0x9C, 0x39, 0xC1, 0xF8, 0x0F,
  0x00, 0xF0, 0x0F, 0x81, 0xF8, 0x39, 0xC7, 0x0E, 0x70, 0xE0, 0x70, 0xEE,
  0x1C, 0xE3, 0x9C, 0xE3, 0x9C, 0x3B, 0x87, 0x60, 0x7C, 0x0F, 0x80, 0xE0,
  0x1C, 0x07, 0x07, 0xE0, 0xF8, 0x3E, 0x00, 0xFF, 0xFF, 0x0F, 0x1E, 0x1C,
  0x3C, 0x78, 0x70, 0xE0, 0xFF, 0xFF, 0x0F, 0x1F, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x30, 0xF0, 0xF0, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x1F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0,
  0xF8, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x0F, 0x0F, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0xF8, 0xF0, 0x38, 0x67, 0xE7, 0x7F,
  0xE6, 0x7E, 0x61, 0xC0,
};

const GFXglyph UbuntuMono_Bold24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 15, 12, 4, -15 },
  { 9, 8, 7, 12, 2, -16 },
  { 16, 12, 15, 12, 0, -15 },
  { 39, 10, 19, 12, 1, -17 },
  { 63, 12, 15, 12, 0, -15 },
  { 86, 12, 15, 12, 0, -15 },
  { 109, 4, 7, 12, 4, -16 },
  { 113, 8, 21, 12, 2, -17 },
  { 134, 8, 21, 12, 2, -17 },
  { 155, 10, 9, 12, 1, -15 },
  { 167, 10, 10, 12, 1, -11 },
  { 180, 5, 8, 12, 3, -4 },
  { 185, 6, 3, 12, 3, -8 },
  { 188, 4, 4, 12, 4, -4 },
  { 190, 10, 21, 12, 1, -17 },
  { 217, 10, 15, 12, 1, -15 },
  { 236, 10, 15, 12, 1, -15 },
  { 255, 10, 15, 12, 1, -15 },
  { 274, 10, 15, 12, 1, -15 },
  { 293, 10, 15, 12, 1, -15 },
  { 312, 10, 15, 12, 1, -15 },
  { 331, 10, 15, 12, 1, -15 },
  { 350, 10, 15, 12, 1, -15 },
  { 369, 10, 15, 12, 1, -15 },
  { 388, 10, 15, 12, 1, -15 },
  { 407, 4, 11, 12, 4, -11 },
  { 413, 5, 15, 12, 3, -11 },
  { 423, 10, 10, 12, 1, -11 },
  { 436, 10, 6, 12, 1, -10 },
  { 444, 10, 10, 12, 1, -11 },
  { 457, 8, 15, 12, 2, -15 },
  { 472, 11, 18, 12, 0, -15 },
  { 497, 12, 15, 12, 0, -15 },
  { 520, 10, 15, 12, 1, -15 },
  { 539, 10, 15, 12, 1, -15 },
  { 558, 10, 15, 12, 1, -15 },
  { 577, 9, 15, 12, 2, -15 },
  { 594, 9, 15, 12, 2, -15 },
  { 611, 10, 15, 12, 1, -15 },
  { 630, 10, 15, 12, 1, -15 },
  { 649, 10, 15, 12, 1, -15 },
  { 668, 10, 15, 12, 1, -15 },
  { 687, 11, 15, 12, 1, -15 },
  { 708, 9, 15, 12, 2, -15 },
  { 725, 10, 15, 12, 1, -15 },
  { 744, 10, 15, 12, 1, -15 },
  { 763, 10, 15, 12, 1, -15 },
  { 782, 10, 15, 12, 1, -15 },
  { 801, 10, 19, 12, 1, -15 },
  { 825, 11, 15, 12, 1, -15 },
  { 846, 10, 15, 12, 1, -15 },
  { 865, 10, 15, 12, 1, -15 },
  { 884, 10, 15, 12, 1, -15 },
  { 903, 12, 15, 12, 0, -15 },
  { 926, 10, 15, 12, 1, -15 },
  { 945, 12, 15, 12, 0, -15 },
  { 968, 12, 15, 12, 0, -15 },
  { 991, 10, 15, 12, 1, -15 },
  { 1010, 6, 21, 12, 3, -17 },
  { 1026, 10, 21, 12, 1, -17 },
  { 1053, 6, 21, 12, 3, -17 },
  { 1069, 12, 7, 12, 0, -15 },
  { 1080, 12, 2, 12, 0, 2 },
  { 1083, 5, 4, 12, 4, -17 },
  { 1086, 10, 11, 12, 1, -11 },
  { 1100, 10, 17, 12, 1, -17 },
  { 1122, 10, 11, 12, 1, -11 },
  { 1136, 9, 17, 12, 1, -17 },
  { 1156, 10, 11, 12, 1, -11 },
  { 1170, 11, 17, 12, 1, -17 },
  { 1194, 10, 15, 12, 1, -11 },
  { 1213, 9, 17, 12, 2, -17 },
  { 1233, 10, 17, 12, 1, -17 },
  { 1255, 9, 21, 12, 1, -17 },
  { 1279, 10, 17, 12, 2, -17 },
  { 1301, 10, 17, 12, 1, -17 },
  { 1323, 10, 11, 12, 1, -11 },
  { 1337, 9, 11, 12, 2, -11 },
  { 1350, 10, 11, 12, 1, -11 },
  { 1364, 9, 15, 12, 2, -11 },
  { 1381, 10, 15, 12, 1, -11 },
  { 1400, 9, 11, 12, 2, -11 },
  { 1413, 10, 11, 12, 1, -11 },
  { 1427, 10, 14, 12, 1, -14 },
  { 1445, 10, 11, 12, 1, -11 },
  { 1459, 12, 11, 12, 0, -11 },
  { 1476, 12, 11, 12, 0, -11 },
  { 1493, 12, 11, 12, 0, -11 },
  { 1510, 11, 15, 12, 0, -11 },
  { 1531, 8, 11, 12, 2, -11 },
  { 1542, 8, 21, 12, 2, -17 },
  { 1563, 3, 21, 12, 5, -17 },
  { 1571, 8, 21, 12, 2, -17 },
  { 1592, 12, 5, 12, 0, -9 },
};

const GFXfont UbuntuMono_Bold24pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Bold24pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Bold24pt7bGlyphs,
  0x20, 0x7E, 24
};

#endif // _UBUNTUMONO_BOLD24PT7B_H_
