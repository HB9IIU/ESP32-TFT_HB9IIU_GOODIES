#ifndef _UBUNTUMONO_BOLD25PT7B_H_
#define _UBUNTUMONO_BOLD25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Bold.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Bold25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x77, 0x77, 0x00, 0x7F, 0x70, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE7, 0x63, 0x63, 0x0E, 0x60, 0xCE, 0x0C, 0xE0, 0xCE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF1, 0x9C, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0x38, 0x33, 0x87,
  0x38, 0x73, 0x00, 0x0E, 0x01, 0xC0, 0xFC, 0x3F, 0xE7, 0xFD, 0xE0, 0xBC,
  0x03, 0xF0, 0x7F, 0x87, 0xF8, 0x1F, 0x00, 0xF4, 0x1F, 0xFF, 0xBF, 0xF1,
  0xFC, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x78, 0x37, 0xC6, 0xCC, 0x6C, 0xCC,
  0xCD, 0x87, 0xF8, 0x7B, 0x00, 0x60, 0x0E, 0xE0, 0xDF, 0x19, 0xB3, 0x9B,
  0x31, 0xB6, 0x1F, 0xE0, 0xE0, 0x3E, 0x0F, 0xE1, 0xFC, 0x31, 0x87, 0x70,
  0xFC, 0x0E, 0x33, 0xE6, 0xEE, 0xD8, 0xFB, 0x0F, 0x71, 0xCF, 0xFD, 0xFF,
  0x8F, 0x38, 0xFF, 0xFF, 0xB0, 0x02, 0x07, 0x0F, 0x1C, 0x3C, 0x38, 0x70,
  0x70, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0x70, 0x70, 0x78, 0x38, 0x1C,
  0x0E, 0x07, 0x02, 0x40, 0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0x0E, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0E, 0x0E, 0x1E, 0x3C, 0x78, 0x70,
  0x60, 0x0E, 0x03, 0x84, 0xCD, 0xF7, 0xFF, 0xC7, 0x83, 0xB9, 0xEE, 0x11,
  0x00, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x00, 0x39, 0xF7, 0xCF, 0x18, 0xEF, 0x38, 0xFF,
  0xFF, 0xF8, 0x77, 0xBC, 0xE0, 0x01, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x81,
  0xE0, 0x70, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0,
  0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x00, 0x1F, 0x07, 0xF1, 0xFF,
  0x78, 0xEE, 0x1D, 0xD9, 0xFB, 0xBF, 0x67, 0xE0, 0xFC, 0x1F, 0x87, 0x78,
  0xE7, 0xFC, 0x7F, 0x07, 0xC0, 0x06, 0x07, 0x87, 0xE3, 0xF8, 0x6E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x7F, 0xDF, 0xF7, 0xFC,
  0x1F, 0x0F, 0xF3, 0xFF, 0x31, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x3F, 0xE7,
  0xF9, 0x0F, 0x01, 0xC0, 0xE1, 0xF8, 0x7E, 0x1F, 0xC0, 0xF0, 0x1C, 0x07,
  0xFF, 0xFF, 0xE7, 0xF0, 0x03, 0x80, 0xF0, 0x3E, 0x0F, 0xC3, 0xB8, 0x67,
  0x1C, 0xE7, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x3F, 0xCF, 0xF3, 0xFD, 0xC0, 0x70, 0x1F, 0x87, 0xF9, 0xFF, 0x07,
  0xC0, 0x70, 0x1E, 0x0F, 0xFF, 0xFF, 0xE7, 0xE0, 0x03, 0xC3, 0xF3, 0xFC,
  0xF0, 0x78, 0x1D, 0x0F, 0xFB, 0xFF, 0xF3, 0xF8, 0x7E, 0x1F, 0xC7, 0x7F,
  0xCF, 0xE1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0x81, 0xE0, 0x70,
  0x3C, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0x80, 0x1F, 0x0F,
  0xF1, 0xFF, 0x78, 0xEE, 0x1C, 0xE3, 0x9F, 0xE1, 0xFC, 0x73, 0xDC, 0x3B,
  0x83, 0xF0, 0xFF, 0xFC, 0xFF, 0x8F, 0xC0, 0x1F, 0x1F, 0xE7, 0xFF, 0xC7,
  0xE1, 0xF8, 0x7F, 0x9D, 0xFF, 0x3F, 0xC3, 0x70, 0x3C, 0x3E, 0x7F, 0x1F,
  0x87, 0x80, 0x77, 0xBC, 0xE0, 0x00, 0x00, 0x77, 0xBC, 0xE0, 0x39, 0xE7,
  0x8E, 0x00, 0x00, 0x00, 0x39, 0xE7, 0x8E, 0x18, 0xEF, 0x30, 0x00, 0x40,
  0x78, 0x3F, 0xBF, 0xCF, 0xC1, 0xE0, 0x3F, 0x03, 0xFC, 0x0F, 0xE0, 0x78,
  0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x40, 0x3C, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0x70, 0xFC, 0xFE, 0xFE,
  0x3C, 0x04, 0x00, 0x7E, 0x7F, 0xBF, 0xF8, 0xF0, 0x38, 0x38, 0x3C, 0x3C,
  0x3C, 0x1C, 0x00, 0x00, 0x03, 0x81, 0xE0, 0xE0, 0x0F, 0x81, 0xFC, 0x38,
  0xE7, 0x06, 0x63, 0xF6, 0x7F, 0x67, 0xFE, 0xE7, 0xEE, 0x7E, 0xE7, 0xEE,
  0x76, 0xE7, 0x67, 0xF6, 0x7F, 0x33, 0xE3, 0x80, 0x1F, 0xE0, 0x7E, 0x0F,
  0x00, 0xF0, 0x0F, 0x81, 0xF8, 0x1D, 0x81, 0xDC, 0x19, 0xC3, 0x9C, 0x38,
  0xE3, 0xFE, 0x7F, 0xE7, 0xFE, 0x70, 0xF7, 0x07, 0xF0, 0x70, 0xFF, 0x1F,
  0xF3, 0xFF, 0x70, 0xEE, 0x1D, 0xC7, 0xBF, 0xE7, 0xFC, 0xFF, 0xDC, 0x3F,
  0x83, 0xF0, 0xFF, 0xFD, 0xFF, 0xBF, 0xC0, 0x0F, 0xC7, 0xFD, 0xFF, 0x3C,
  0x2F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x7C, 0x27,
  0xFC, 0x7F, 0xC7, 0xF0, 0xFE, 0x1F, 0xF3, 0xFF, 0x71, 0xEE, 0x1D, 0xC3,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x87, 0x71, 0xEF, 0xF9, 0xFF, 0x3F,
  0x80, 0xFF, 0xBF, 0xEF, 0xFB, 0x80, 0xE0, 0x3F, 0xCF, 0xF3, 0xFC, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0E, 0x07, 0x03, 0xFD, 0xFE, 0xFF, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x80, 0x0F, 0xE7, 0xF9, 0xFF, 0x3C, 0x2F, 0x01, 0xC0, 0x38, 0x07, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF8, 0xF7, 0xFE, 0x7F, 0xC7, 0xF8, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1C, 0xFF, 0xFF, 0xFF, 0xFC, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0xCF, 0xF3, 0xFC, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1D, 0x0F, 0x7F, 0xBF, 0xE3, 0xE0, 0xE1, 0xDC, 0x7B, 0x8E, 0x73,
  0xCE, 0xF1, 0xDC, 0x3F, 0x07, 0xF0, 0xEE, 0x1D, 0xE3, 0x9E, 0x71, 0xEE,
  0x1D, 0xC3, 0xF8, 0x38, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0xE1,
  0xDE, 0x3B, 0xC7, 0x79, 0xED, 0x3D, 0xB7, 0xB7, 0xBE, 0xF7, 0xCE, 0xF9,
  0xDF, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x38, 0xE0, 0xFC, 0x3F, 0x0F,
  0xE3, 0xF8, 0xFF, 0x3E, 0xCF, 0xBB, 0xE6, 0xF9, 0xFE, 0x3F, 0x8F, 0xE1,
  0xF8, 0x7E, 0x0C, 0x1F, 0x0F, 0xF1, 0xFF, 0x78, 0xEE, 0x1F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xF8, 0xE7, 0xFC, 0xFF, 0x07, 0xC0,
  0xFF, 0x1F, 0xFB, 0xFF, 0x70, 0xFE, 0x0F, 0xC1, 0xF8, 0x7F, 0xFE, 0xFF,
  0xDF, 0xE3, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x1F, 0x0F, 0xF1,
  0xFF, 0x78, 0xEE, 0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x87,
  0xF8, 0xE7, 0xFC, 0xFF, 0x07, 0xC0, 0x70, 0x0F, 0xE0, 0xF8, 0x07, 0x00,
  0xFE, 0x1F, 0xF3, 0xFF, 0x71, 0xEE, 0x1D, 0xC3, 0xB8, 0xF7, 0xFE, 0xFF,
  0x9F, 0xE3, 0x9E, 0x71, 0xCE, 0x1D, 0xC3, 0xB8, 0x38, 0x1F, 0x0F, 0xF9,
  0xFE, 0x78, 0x4E, 0x01, 0xF0, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0x78, 0x07,
  0x20, 0xEF, 0xFD, 0xFF, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0x78, 0xEF, 0xFC, 0xFF, 0x0F, 0xC0,
  0xF0, 0x77, 0x07, 0x70, 0xF7, 0x0E, 0x70, 0xE3, 0x8E, 0x38, 0xE3, 0x9C,
  0x19, 0xC1, 0xDC, 0x1D, 0x81, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x99, 0xF3, 0xBE, 0xF7, 0xDE, 0xFB,
  0x7F, 0x6F, 0x79, 0xEF, 0x1D, 0xE3, 0xB8, 0x70, 0x70, 0x77, 0x8E, 0x38,
  0xE1, 0xDC, 0x1F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x81, 0xFC, 0x1D,
  0xC3, 0x9E, 0x78, 0xE7, 0x0F, 0xF0, 0x70, 0x70, 0x77, 0x0F, 0x70, 0xE3,
  0x8E, 0x39, 0xC1, 0xDC, 0x1F, 0x80, 0xF8, 0x0F, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07,
  0x01, 0xC0, 0xE0, 0x30, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0xFF, 0xFF, 0xE0, 0xF0, 0x1C, 0x07, 0x01,
  0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x80, 0xE0, 0x38, 0x0F,
  0x01, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xC0, 0xFF,
  0xFF, 0xF8, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0xF8, 0x1F, 0x81, 0xDC,
  0x39, 0xE7, 0x8E, 0x70, 0x73, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x47,
  0x9E, 0x30, 0x3F, 0x1F, 0xE7, 0xFC, 0x07, 0x3F, 0xDF, 0xFF, 0xFF, 0x87,
  0xE1, 0xFF, 0xF7, 0xFC, 0xFF, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3F,
  0x8F, 0xF3, 0xFE, 0xE3, 0xB8, 0xFE, 0x1F, 0x87, 0xE3, 0xF8, 0xEF, 0xFB,
  0xFC, 0xFE, 0x00, 0x0F, 0xC7, 0xF9, 0xFF, 0x3C, 0x0F, 0x01, 0xC0, 0x38,
  0x07, 0x80, 0x78, 0x0F, 0xF8, 0xFF, 0x87, 0xE0, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xCF, 0x77, 0xFF, 0xFF, 0xF3, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xFC, 0x7F, 0xFD, 0xFF, 0x1F, 0x80, 0x1F, 0x07, 0xF1, 0xFF, 0x78, 0xEE,
  0x0D, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xCF, 0xF9, 0xFF, 0x0F, 0xC0, 0x07,
  0xE3, 0xFC, 0x7F, 0x8E, 0x13, 0xC1, 0xFF, 0xBF, 0xF7, 0xFE, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x00, 0x1F,
  0xDF, 0xF7, 0xFF, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0xC7, 0xFF, 0xDF, 0xF3,
  0xFC, 0x07, 0x43, 0xFF, 0xEF, 0xF9, 0xF8, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0xF3, 0xFD, 0xFF, 0xE7, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0x80, 0x18, 0x07, 0x80, 0xF0, 0x0C, 0x00, 0x01, 0xF8, 0x3F,
  0x07, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x87, 0xF0,
  0x7F, 0x07, 0xC0, 0x07, 0x03, 0xC1, 0xE0, 0xE0, 0x03, 0xFD, 0xFE, 0xFF,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xA1, 0xDF,
  0xFF, 0xE3, 0xE0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0xEE, 0x7B,
  0xBC, 0xEE, 0x3F, 0x0F, 0x83, 0xF0, 0xEE, 0x3B, 0xCE, 0x7B, 0x8E, 0xE3,
  0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x87, 0xF0, 0x7F, 0x07,
  0xC0, 0xFB, 0xDF, 0xFB, 0xFF, 0xE6, 0x7C, 0xCF, 0x9D, 0xF3, 0xBE, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x70, 0xFE, 0x7F, 0xBF, 0xFC, 0xFE, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x70, 0x1F, 0x0F, 0xF1, 0xFF,
  0x78, 0xEE, 0x1F, 0xC1, 0xF8, 0x3F, 0x0F, 0xF1, 0xCF, 0xF9, 0xFE, 0x0F,
  0x80, 0xFE, 0x3F, 0xCF, 0xFB, 0x8E, 0xE3, 0xF8, 0x7E, 0x1F, 0x8F, 0xE3,
  0xBF, 0xEF, 0xF3, 0xF8, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x1F, 0xDF, 0xF7,
  0xFF, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xF1, 0xFF, 0xF7, 0xFC, 0xFF,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x3F, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x00, 0x1F, 0x9F, 0xE7, 0xF9, 0xC2,
  0x70, 0x1F, 0x81, 0xF8, 0x0F, 0x41, 0xDF, 0xFF, 0xF8, 0xFC, 0x0C, 0x03,
  0x80, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xC7, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xFE, 0x3F, 0xC3, 0xF0, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7,
  0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0x71, 0xDF, 0xF7, 0xFC, 0x7E, 0xF0, 0x77,
  0x07, 0x70, 0xE7, 0x8E, 0x38, 0xE3, 0x9C, 0x3D, 0xC1, 0xF8, 0x1F, 0x80,
  0xF8, 0x0F, 0x00, 0x70, 0xE0, 0x3E, 0x03, 0x67, 0x76, 0x77, 0x67, 0x76,
  0xF7, 0x6F, 0x66, 0xDE, 0x7D, 0xE7, 0x9E, 0x38, 0xE3, 0x8E, 0x70, 0xF3,
  0x8E, 0x3D, 0xC1, 0xFC, 0x0F, 0x80, 0xF0, 0x0F, 0x81, 0xF8, 0x1D, 0xC3,
  0x9E, 0x70, 0xE7, 0x07, 0x70, 0x77, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE1,
  0xDC, 0x1D, 0xC1, 0xDC, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x70, 0x0F, 0x07,
  0xE0, 0x7C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0xE0, 0xE0, 0xE0,
  0xE0, 0x70, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0x8F, 0xCF, 0xE7, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x7C, 0x38, 0x1F, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0F, 0xE3, 0xF0, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xF8, 0x7E, 0x3F, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x07, 0xC0, 0xE1, 0xF1, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x3F, 0x1F,
  0x8F, 0x80, 0x78, 0x6F, 0x9F, 0xFF, 0xE7, 0xEC, 0x38,
};

const GFXglyph UbuntuMono_Bold25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 4, 15, 13, 4, -15 },
  { 9, 8, 7, 13, 2, -17 },
  { 16, 12, 15, 13, 0, -15 },
  { 39, 11, 19, 13, 1, -17 },
  { 66, 12, 15, 13, 0, -15 },
  { 89, 11, 15, 13, 1, -15 },
  { 110, 3, 7, 13, 5, -17 },
  { 113, 8, 22, 13, 2, -18 },
  { 135, 8, 22, 13, 2, -18 },
  { 157, 10, 9, 13, 1, -15 },
  { 169, 11, 11, 13, 1, -12 },
  { 185, 6, 8, 13, 3, -4 },
  { 191, 7, 3, 13, 3, -8 },
  { 194, 5, 4, 13, 4, -4 },
  { 197, 10, 21, 13, 1, -17 },
  { 224, 11, 15, 13, 1, -15 },
  { 245, 10, 15, 13, 1, -15 },
  { 264, 11, 15, 13, 1, -15 },
  { 285, 10, 15, 13, 1, -15 },
  { 304, 11, 15, 13, 1, -15 },
  { 325, 10, 15, 13, 1, -15 },
  { 344, 10, 15, 13, 1, -15 },
  { 363, 10, 15, 13, 1, -15 },
  { 382, 11, 15, 13, 1, -15 },
  { 403, 10, 15, 13, 1, -15 },
  { 422, 5, 12, 13, 4, -12 },
  { 430, 6, 16, 13, 3, -12 },
  { 442, 11, 11, 13, 1, -12 },
  { 458, 11, 8, 13, 1, -10 },
  { 469, 10, 11, 13, 1, -12 },
  { 483, 9, 15, 13, 2, -15 },
  { 500, 12, 18, 13, 0, -15 },
  { 527, 12, 15, 13, 0, -15 },
  { 550, 11, 15, 13, 1, -15 },
  { 571, 11, 15, 13, 1, -15 },
  { 592, 11, 15, 13, 1, -15 },
  { 613, 10, 15, 13, 2, -15 },
  { 632, 9, 15, 13, 2, -15 },
  { 649, 11, 15, 13, 1, -15 },
  { 670, 10, 15, 13, 1, -15 },
  { 689, 10, 15, 13, 1, -15 },
  { 708, 10, 15, 13, 1, -15 },
  { 727, 11, 15, 13, 1, -15 },
  { 748, 10, 15, 13, 2, -15 },
  { 767, 11, 15, 13, 1, -15 },
  { 788, 10, 15, 13, 1, -15 },
  { 807, 11, 15, 13, 1, -15 },
  { 828, 11, 15, 13, 1, -15 },
  { 849, 11, 19, 13, 1, -15 },
  { 876, 11, 15, 13, 1, -15 },
  { 897, 11, 15, 13, 1, -15 },
  { 918, 11, 15, 13, 1, -15 },
  { 939, 11, 15, 13, 1, -15 },
  { 960, 12, 15, 13, 0, -15 },
  { 983, 11, 15, 13, 1, -15 },
  { 1004, 12, 15, 13, 0, -15 },
  { 1027, 12, 15, 13, 0, -15 },
  { 1050, 10, 15, 13, 1, -15 },
  { 1069, 7, 21, 13, 3, -17 },
  { 1088, 10, 21, 13, 1, -17 },
  { 1115, 7, 21, 13, 3, -17 },
  { 1134, 12, 8, 13, 0, -15 },
  { 1146, 12, 3, 13, 0, 1 },
  { 1151, 5, 4, 13, 4, -17 },
  { 1154, 10, 12, 13, 1, -12 },
  { 1169, 10, 17, 13, 2, -17 },
  { 1191, 11, 12, 13, 1, -12 },
  { 1208, 10, 17, 13, 1, -17 },
  { 1230, 11, 12, 13, 1, -12 },
  { 1247, 11, 17, 13, 1, -17 },
  { 1271, 10, 16, 13, 1, -12 },
  { 1291, 9, 17, 13, 2, -17 },
  { 1311, 11, 17, 13, 1, -17 },
  { 1335, 9, 21, 13, 1, -17 },
  { 1359, 10, 17, 13, 2, -17 },
  { 1381, 11, 17, 13, 1, -17 },
  { 1405, 11, 12, 13, 1, -12 },
  { 1422, 9, 12, 13, 2, -12 },
  { 1436, 11, 12, 13, 1, -12 },
  { 1453, 10, 16, 13, 2, -12 },
  { 1473, 10, 16, 13, 1, -12 },
  { 1493, 9, 12, 13, 2, -12 },
  { 1507, 10, 12, 13, 1, -12 },
  { 1522, 11, 15, 13, 1, -15 },
  { 1543, 10, 12, 13, 1, -12 },
  { 1558, 12, 12, 13, 0, -12 },
  { 1576, 12, 12, 13, 0, -12 },
  { 1594, 12, 12, 13, 0, -12 },
  { 1612, 12, 16, 13, 0, -12 },
  { 1636, 9, 12, 13, 2, -12 },
  { 1650, 9, 21, 13, 2, -17 },
  { 1674, 3, 21, 13, 5, -17 },
  { 1682, 9, 21, 13, 2, -17 },
  { 1706, 11, 5, 13, 1, -9 },
};

const GFXfont UbuntuMono_Bold25pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Bold25pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Bold25pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _UBUNTUMONO_BOLD25PT7B_H_
