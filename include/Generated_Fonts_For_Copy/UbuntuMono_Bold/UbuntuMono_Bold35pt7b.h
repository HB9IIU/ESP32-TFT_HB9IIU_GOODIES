#ifndef _UBUNTUMONO_BOLD35PT7B_H_
#define _UBUNTUMONO_BOLD35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Bold.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Bold35pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xE7, 0x9E, 0x79, 0xE0,
  0x00, 0x01, 0xEF, 0xBF, 0xF9, 0xC0, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0x9E,
  0xF1, 0xEF, 0x1E, 0x71, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x07, 0x1E, 0x07,
  0x1C, 0x0F, 0x1C, 0x0F, 0x3C, 0x0E, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1E, 0x78, 0x1C, 0x78, 0x1C, 0x78, 0x3C, 0x70, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x38, 0xF0, 0x78, 0xE0, 0x78,
  0xE0, 0x79, 0xE0, 0x71, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x7F,
  0x01, 0xFF, 0xE7, 0xFF, 0x9F, 0xFF, 0x3E, 0x06, 0x78, 0x00, 0xF8, 0x01,
  0xFC, 0x01, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0x00,
  0x1E, 0x00, 0x3D, 0xC0, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x87, 0xFC,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x03, 0xBF, 0x03,
  0x9F, 0xC1, 0xDE, 0xE1, 0xCE, 0x71, 0xE7, 0x38, 0xE3, 0x9C, 0xE0, 0xCE,
  0xF0, 0x7F, 0x70, 0x3F, 0x70, 0x0F, 0x38, 0x00, 0x3B, 0xC0, 0x3B, 0xF0,
  0x1D, 0xFC, 0x1D, 0xCE, 0x1C, 0xE7, 0x0E, 0x73, 0x8E, 0x39, 0xCE, 0x1C,
  0xE7, 0x07, 0xF7, 0x03, 0xF7, 0x80, 0xF0, 0x0F, 0x80, 0x1F, 0xE0, 0x3F,
  0xF0, 0x7F, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x3D, 0xE0, 0x3F,
  0xC0, 0x1F, 0x98, 0x3F, 0x1E, 0x7F, 0x9E, 0x7B, 0xDE, 0xF3, 0xFE, 0xE1,
  0xFC, 0xE0, 0xFC, 0xF0, 0x7C, 0xF0, 0xFC, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F,
  0xDE, 0x1F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEE, 0x00, 0x40, 0x1E, 0x03,
  0xE0, 0x7E, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x78,
  0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0x40, 0x20, 0x0E, 0x03, 0xF0, 0x3F,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x07, 0x80, 0xF0, 0x3E, 0x07, 0x81, 0xE0, 0x7C, 0x3F, 0x0F, 0xC0, 0xF0,
  0x08, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x11, 0xE2, 0xF7, 0x3B, 0xEF,
  0xFF, 0xFF, 0xDF, 0xFC, 0x0F, 0x80, 0x7F, 0x03, 0xDF, 0x1F, 0x3C, 0x38,
  0xE0, 0x21, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x1E, 0x3F, 0x3F,
  0x3F, 0x3F, 0x1F, 0x0F, 0x0E, 0x3E, 0xFC, 0x78, 0x60, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x7C, 0x01, 0xE0, 0x07,
  0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x00,
  0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE1, 0xFF, 0xE7, 0xC7, 0xCF, 0x07, 0xDE,
  0x07, 0xF8, 0x0F, 0xF1, 0x9F, 0xE7, 0xBF, 0xCF, 0x7F, 0x9E, 0xFF, 0x19,
  0xFE, 0x03, 0xFC, 0x07, 0xBC, 0x0F, 0x78, 0x3E, 0xF8, 0xF8, 0xFF, 0xF1,
  0xFF, 0xC1, 0xFF, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0xFC, 0x0F,
  0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x19, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x07, 0xFF, 0xDF, 0xFF, 0x7F, 0xFD, 0xFF, 0xF0, 0x0F, 0xC0, 0x7F,
  0xE1, 0xFF, 0xE3, 0xFF, 0xE3, 0x87, 0xC4, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF,
  0xEF, 0xFF, 0xC0, 0x0F, 0xC0, 0x7F, 0xE1, 0xFF, 0xE3, 0xFF, 0xC3, 0x07,
  0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x1F, 0xF0, 0x3F, 0x80,
  0x7F, 0xC0, 0xFF, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0xC0,
  0xFD, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0x78, 0x1E,
  0x78, 0x1E, 0x78, 0x3C, 0x78, 0x38, 0x78, 0x78, 0x78, 0xF0, 0x78, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF,
  0xE3, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0xC0, 0x3F, 0xF0, 0x7F, 0xF0,
  0xFF, 0xF0, 0x0F, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3C, 0x80, 0xF9, 0xFF, 0xF7, 0xFF, 0xCF, 0xFF, 0x07, 0xF8, 0x00, 0x00,
  0xF8, 0x0F, 0xE0, 0xFF, 0x87, 0xFE, 0x3F, 0x81, 0xF8, 0x07, 0xC0, 0x3E,
  0x00, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFE, 0xF0, 0x7F, 0xC1, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xE3, 0xE7, 0xFF, 0x9F, 0xFC, 0x3F, 0xE0,
  0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x03,
  0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xFF,
  0xE7, 0xC3, 0xEF, 0x07, 0xDE, 0x07, 0xBC, 0x1E, 0x7C, 0x3C, 0x7F, 0xF0,
  0x7F, 0xC1, 0xFF, 0xC3, 0xCF, 0xCF, 0x07, 0xDE, 0x07, 0xF8, 0x0F, 0xF8,
  0x1F, 0xF8, 0x7D, 0xFF, 0xFB, 0xFF, 0xE3, 0xFF, 0x81, 0xFC, 0x00, 0x0F,
  0x80, 0xFF, 0x87, 0xFF, 0x1F, 0xFE, 0xF8, 0xFB, 0xC1, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0xFF, 0xDF, 0xFF, 0x3F, 0xFC, 0x7F, 0xE0,
  0x07, 0x80, 0x3E, 0x01, 0xF0, 0x3F, 0xC7, 0xFE, 0x1F, 0xF0, 0x7F, 0x01,
  0xE0, 0x00, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0xFF,
  0xFF, 0xFF, 0x78, 0x1E, 0x3F, 0x3F, 0x3F, 0x3F, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x3E, 0x3F, 0x3F, 0x3F, 0x1F, 0x0E, 0x0E, 0x3E, 0xFC,
  0xF8, 0x60, 0x00, 0x08, 0x00, 0xE0, 0x1F, 0xC1, 0xFF, 0x1F, 0xF9, 0xFF,
  0x8F, 0xF0, 0x3F, 0x00, 0xFC, 0x03, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x07,
  0xFC, 0x07, 0xF0, 0x03, 0x80, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x60, 0x00, 0xF0, 0x01, 0xF8, 0x03, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0x00, 0x7E, 0x03, 0xFC, 0x3F, 0xF1,
  0xFF, 0x87, 0xFC, 0x0F, 0xC0, 0x1E, 0x00, 0x30, 0x00, 0x1F, 0xC3, 0xFF,
  0x1F, 0xFC, 0xFF, 0xF6, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0x80, 0x03, 0xE0, 0x1F,
  0xF0, 0x7F, 0xF1, 0xE1, 0xE7, 0x81, 0xEE, 0x01, 0xDC, 0x03, 0xF8, 0x7F,
  0xE3, 0xFF, 0xC7, 0xFF, 0x9F, 0xFF, 0x3C, 0x7E, 0x78, 0xFC, 0xF1, 0xF9,
  0xE3, 0xF3, 0xC7, 0xE7, 0x8F, 0xCF, 0xFF, 0x8F, 0xFF, 0x8F, 0xF7, 0x0F,
  0xCF, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x07, 0xF8,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3B,
  0xC0, 0x3D, 0xE0, 0x1E, 0x70, 0x0F, 0x3C, 0x07, 0x1E, 0x07, 0x8F, 0x03,
  0xC3, 0xC1, 0xE1, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF,
  0x3E, 0x07, 0x9F, 0x03, 0xCF, 0x01, 0xF7, 0x80, 0xFF, 0xC0, 0x7C, 0xFF,
  0x83, 0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0xF0, 0xFB, 0xC1, 0xEF, 0x07, 0xBC,
  0x1E, 0xF0, 0xFB, 0xFF, 0xCF, 0xFE, 0x3F, 0xFE, 0xFF, 0xFF, 0xC1, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF3,
  0xFF, 0x00, 0x01, 0xF8, 0x1F, 0xFC, 0x7F, 0xF9, 0xFF, 0xF3, 0xE0, 0xEF,
  0x80, 0x5E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x02, 0xFC, 0x1C,
  0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0xC3,
  0xFF, 0xC7, 0xFF, 0xCF, 0x0F, 0x9E, 0x0F, 0xBC, 0x1F, 0x78, 0x1E, 0xF0,
  0x3D, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xBC, 0x0F,
  0x78, 0x3E, 0xF0, 0x7D, 0xE3, 0xF3, 0xFF, 0xE7, 0xFF, 0x8F, 0xFC, 0x1F,
  0xE0, 0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xFF, 0xBF, 0xFD, 0xFF,
  0xEF, 0xFF, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xFE, 0x1F, 0xFC, 0x7F, 0xF9, 0xFF,
  0xE7, 0xE0, 0x4F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0x7C,
  0x1E, 0xFC, 0x3C, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xC0, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x20, 0x7D, 0xC3,
  0xF7, 0xFF, 0x9F, 0xFE, 0x7F, 0xF0, 0x7F, 0x00, 0xF0, 0x7D, 0xE0, 0xFB,
  0xC3, 0xE7, 0x87, 0x8F, 0x1F, 0x1E, 0x7C, 0x3C, 0xF0, 0x7B, 0xE0, 0xFF,
  0x81, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x1E, 0xFC, 0x3C, 0xF8,
  0x78, 0xF8, 0xF0, 0xF9, 0xE1, 0xF3, 0xC1, 0xF7, 0x83, 0xEF, 0x03, 0xFE,
  0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x1C, 0x78, 0x3E, 0x78, 0x3E, 0x7C,
  0x3E, 0x7C, 0x7E, 0x7C, 0x7E, 0x7E, 0x6E, 0xFE, 0xEE, 0xF6, 0xEE, 0xF7,
  0xEE, 0xF7, 0xCE, 0xF7, 0xCE, 0xF3, 0xCE, 0xF3, 0x8E, 0xF0, 0x0E, 0xF0,
  0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x83, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF,
  0xE3, 0xFF, 0x8F, 0xFF, 0x3F, 0xDC, 0xFF, 0x7B, 0xFC, 0xEF, 0xF3, 0xFF,
  0xC7, 0xFF, 0x1F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x3F, 0xC0, 0xF0, 0x07, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC,
  0x7C, 0x7E, 0x78, 0x3E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E,
  0x78, 0x3E, 0x7C, 0x7C, 0x7F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0x07, 0xE0,
  0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x07, 0xDE, 0x07, 0xBC,
  0x0F, 0x78, 0x1F, 0xF0, 0x3D, 0xE0, 0x7B, 0xC1, 0xF7, 0xFF, 0xEF, 0xFF,
  0x9F, 0xFE, 0x3F, 0xF0, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8,
  0x3F, 0xFC, 0x7C, 0x7C, 0x78, 0x3E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF0, 0x1E,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF8, 0x1E,
  0xF8, 0x1E, 0x78, 0x3E, 0x7C, 0x7E, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8,
  0x0F, 0xE0, 0x03, 0xC0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x0E, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0xCF, 0x0F, 0x9E,
  0x0F, 0xBC, 0x1F, 0x78, 0x3E, 0xF0, 0x7D, 0xE1, 0xF3, 0xFF, 0xE7, 0xFF,
  0x8F, 0xFE, 0x1F, 0xFC, 0x3C, 0x78, 0x78, 0xF8, 0xF0, 0xF1, 0xE1, 0xF3,
  0xC1, 0xF7, 0x83, 0xEF, 0x03, 0xDE, 0x07, 0xC0, 0x07, 0xF0, 0x3F, 0xF8,
  0xFF, 0xF3, 0xFF, 0xC7, 0xC1, 0x8F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7F,
  0x00, 0x7F, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x0F, 0x40, 0x1E, 0xE0, 0x7D, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0x83,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0x78, 0x3E, 0xF8, 0x7D, 0xFF, 0xF1, 0xFF, 0xE1,
  0xFF, 0x81, 0xFC, 0x00, 0x78, 0x0F, 0xBC, 0x07, 0xDE, 0x03, 0xEF, 0x81,
  0xE7, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x7C, 0x78, 0x3C, 0x3E, 0x1E, 0x0F,
  0x0F, 0x07, 0x87, 0x83, 0xC7, 0x80, 0xE3, 0xC0, 0x79, 0xE0, 0x3C, 0xE0,
  0x1E, 0xF0, 0x07, 0x78, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF3, 0xCE, 0xF3, 0xCE, 0xF7,
  0xCE, 0xF7, 0xCE, 0xF7, 0xEE, 0xF6, 0xEE, 0xFE, 0x6E, 0x7E, 0x6E, 0x7C,
  0x7E, 0x7C, 0x7E, 0x7C, 0x3E, 0x78, 0x3E, 0x78, 0x3E, 0x78, 0x1E, 0x7C,
  0x0F, 0x9E, 0x07, 0x8F, 0x87, 0x83, 0xC3, 0xC1, 0xF3, 0xC0, 0x79, 0xE0,
  0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3D, 0xF0, 0x1E, 0x78, 0x1E, 0x3E, 0x0F,
  0x0F, 0x0F, 0x87, 0xC7, 0x83, 0xE7, 0xC0, 0xFB, 0xC0, 0x7C, 0x78, 0x0F,
  0xBE, 0x07, 0xDF, 0x03, 0xC7, 0x83, 0xE3, 0xE1, 0xE0, 0xF0, 0xF0, 0x78,
  0xF8, 0x3E, 0x78, 0x0F, 0x3C, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x0F,
  0x00, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x07,
  0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1E, 0x78, 0x3E, 0x7C, 0x7C,
  0x3C, 0x78, 0x3E, 0xF8, 0x1F, 0xF0, 0x1F, 0x30, 0x08, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x20, 0x78, 0x7C, 0x7F, 0x1E, 0x06,
  0x3F, 0xC3, 0xFF, 0x9F, 0xFE, 0xFF, 0xF0, 0x0F, 0x80, 0x3C, 0x7F, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xE3, 0xFE, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF7, 0xC3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFF, 0xF8,
  0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x1F, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0xF3,
  0xFF, 0xDF, 0xFE, 0xFC, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x80, 0x3F, 0x01, 0x7F, 0xFC, 0xFF, 0xF1, 0xFF, 0xC1, 0xFE,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x0F, 0xBC, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0xFC, 0x7F, 0xE0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x83, 0xDF, 0x0F, 0x7F,
  0xFC, 0xFF, 0xF1, 0xFF, 0xC3, 0xFE, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3,
  0xFF, 0xE7, 0xC3, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xE0, 0x67, 0xFF, 0xC7, 0xFF, 0x87, 0xFF, 0x03, 0xFC,
  0x00, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0x83, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0xF8, 0x7F, 0xF3, 0xFF, 0xDF, 0xFF, 0x7C, 0x3F, 0xE0, 0xFF, 0x83,
  0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0xC3, 0xDF, 0xFF, 0x7F, 0xFC, 0xFF,
  0xF0, 0xFB, 0xC0, 0x0F, 0x00, 0x3D, 0x81, 0xF7, 0xFF, 0xDF, 0xFE, 0x7F,
  0xF0, 0x7F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xFF, 0xC7, 0xFF, 0xBF, 0xFD, 0xFF, 0xFF, 0x8F,
  0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF,
  0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0x07, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x10, 0x7F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x80, 0x7E, 0x01, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x01, 0xF6, 0x1F, 0xFF, 0xEF, 0xFE, 0xFF, 0xC3, 0xF0,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x7D, 0xF1, 0xF3, 0xE3, 0xC7, 0xCF, 0x0F, 0xBC,
  0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xF7, 0x83, 0xEF, 0x87,
  0xCF, 0x8F, 0x8F, 0x9F, 0x0F, 0x3E, 0x1F, 0x7C, 0x1F, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x10, 0x7F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0x7E, 0x7E, 0x79, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x38, 0xFE, 0x71, 0xFC, 0xE3, 0xF9, 0xE7, 0xF3, 0xCF, 0xE7,
  0x9F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0x3F, 0xC7, 0xFF, 0xBF, 0xFD, 0xFF, 0xFF, 0x8F, 0xFC, 0x3F, 0xE1, 0xFF,
  0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1,
  0xFF, 0x0F, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFC, 0x7C, 0x3E,
  0xF8, 0x1E, 0xF8, 0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1E, 0xF8, 0x3E,
  0x7C, 0x3E, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x3F, 0xC3,
  0xFF, 0xCF, 0xFF, 0xBF, 0xFE, 0xF8, 0xFF, 0xE1, 0xFF, 0x83, 0xFE, 0x0F,
  0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0x3F, 0xF8, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0x07, 0xF8, 0x7F, 0xF3, 0xFF, 0xDF, 0xFF, 0x7C, 0x3F, 0xE0, 0xFF,
  0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x83, 0xDF, 0x1F, 0x7F, 0xFD,
  0xFF, 0xF3, 0xFF, 0xC3, 0xEF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x1F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0xE1, 0xFF, 0xDF, 0xFF, 0xFF,
  0xEF, 0x83, 0x7C, 0x01, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x1F, 0xC0, 0x1F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xF8, 0x03, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x82, 0x0F, 0xFE, 0x07, 0xFE, 0x07, 0xFE,
  0x01, 0xFC, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x1F, 0xF0, 0xF7, 0xFF, 0xBF,
  0xFC, 0xFF, 0xE1, 0xFE, 0x78, 0x0F, 0xBC, 0x07, 0xDF, 0x03, 0xC7, 0x81,
  0xE3, 0xC1, 0xF1, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x78, 0x1F, 0x3C, 0x07,
  0xBC, 0x03, 0xDE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x03, 0xC0, 0xF0, 0x07, 0xB8, 0x03, 0xDC, 0x01, 0xEE, 0x38, 0xF7, 0x1E,
  0x7B, 0x8F, 0x3D, 0xCF, 0x9C, 0xE7, 0xCE, 0x7B, 0xF7, 0x1D, 0xBB, 0x8F,
  0xDD, 0xC7, 0xE7, 0xE3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0x78, 0x38, 0x3C,
  0xF8, 0x1E, 0x78, 0x3E, 0x3C, 0x3C, 0x3E, 0x78, 0x1E, 0xF8, 0x0F, 0xF0,
  0x07, 0xE0, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1E, 0x78,
  0x3C, 0x7C, 0x7C, 0x3C, 0x78, 0x1E, 0xF0, 0x1F, 0xF8, 0x1E, 0x78, 0x1E,
  0x78, 0x1E, 0x7C, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x3C, 0x1E, 0x78,
  0x1E, 0x78, 0x1F, 0x78, 0x0F, 0x70, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x87, 0xC0, 0xFF, 0x80, 0xFF, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF, 0xE0, 0x1F,
  0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x3F, 0xC1, 0xFE, 0x1F,
  0xF0, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x01, 0xF0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x00, 0xF8, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7C,
  0x03, 0xFE, 0x0F, 0xF0, 0x7F, 0x80, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xF8, 0x3F, 0xE1, 0xFF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xFC, 0x07, 0xE0, 0x3F,
  0x03, 0xF8, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x3F, 0xE1, 0xFF, 0x0F, 0xF0, 0x7F, 0x00, 0x1E,
  0x06, 0x7F, 0x8F, 0x7F, 0xFF, 0xFF, 0xFE, 0xF1, 0xFC, 0x60, 0x78,
};

const GFXglyph UbuntuMono_Bold35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 6, 22, 18, 6, -22 },
  { 18, 12, 10, 18, 3, -24 },
  { 33, 16, 22, 18, 1, -22 },
  { 77, 15, 27, 18, 1, -24 },
  { 128, 17, 22, 18, 0, -22 },
  { 175, 16, 22, 18, 1, -22 },
  { 219, 4, 10, 18, 7, -24 },
  { 224, 12, 31, 18, 3, -25 },
  { 271, 11, 31, 18, 3, -25 },
  { 314, 14, 14, 18, 2, -22 },
  { 339, 15, 16, 18, 1, -16 },
  { 369, 8, 12, 18, 4, -6 },
  { 381, 10, 4, 18, 4, -11 },
  { 386, 6, 6, 18, 6, -6 },
  { 391, 14, 30, 18, 2, -24 },
  { 444, 15, 22, 18, 1, -22 },
  { 486, 14, 22, 18, 2, -22 },
  { 525, 15, 22, 18, 1, -22 },
  { 567, 15, 22, 18, 1, -22 },
  { 609, 16, 22, 18, 1, -22 },
  { 653, 15, 22, 18, 1, -22 },
  { 695, 14, 22, 18, 2, -22 },
  { 734, 14, 22, 18, 2, -22 },
  { 773, 15, 22, 18, 1, -22 },
  { 815, 14, 22, 18, 2, -22 },
  { 854, 6, 17, 18, 6, -17 },
  { 867, 8, 23, 18, 4, -17 },
  { 890, 14, 16, 18, 2, -17 },
  { 918, 15, 11, 18, 1, -14 },
  { 939, 15, 16, 18, 1, -17 },
  { 969, 13, 22, 18, 2, -22 },
  { 1005, 15, 27, 18, 1, -22 },
  { 1056, 17, 22, 18, 0, -22 },
  { 1103, 14, 22, 18, 2, -22 },
  { 1142, 15, 22, 18, 1, -22 },
  { 1184, 15, 22, 18, 2, -22 },
  { 1226, 14, 22, 18, 2, -22 },
  { 1265, 13, 22, 18, 2, -22 },
  { 1301, 15, 22, 18, 1, -22 },
  { 1343, 14, 22, 18, 2, -22 },
  { 1382, 14, 22, 18, 2, -22 },
  { 1421, 14, 22, 18, 1, -22 },
  { 1460, 15, 22, 18, 2, -22 },
  { 1502, 14, 22, 18, 2, -22 },
  { 1541, 16, 22, 18, 1, -22 },
  { 1585, 14, 22, 18, 2, -22 },
  { 1624, 16, 22, 18, 1, -22 },
  { 1668, 15, 22, 18, 2, -22 },
  { 1710, 16, 28, 18, 1, -22 },
  { 1766, 15, 22, 18, 2, -22 },
  { 1808, 15, 22, 18, 1, -22 },
  { 1850, 16, 22, 18, 1, -22 },
  { 1894, 15, 22, 18, 1, -22 },
  { 1936, 17, 22, 18, 0, -22 },
  { 1983, 16, 22, 18, 1, -22 },
  { 2027, 17, 22, 18, 0, -22 },
  { 2074, 17, 22, 18, 0, -22 },
  { 2121, 14, 22, 18, 2, -22 },
  { 2160, 10, 30, 18, 4, -24 },
  { 2198, 14, 30, 18, 2, -24 },
  { 2251, 10, 30, 18, 4, -24 },
  { 2289, 16, 12, 18, 1, -22 },
  { 2313, 17, 4, 18, 0, 2 },
  { 2322, 8, 6, 18, 5, -24 },
  { 2328, 13, 16, 18, 2, -16 },
  { 2354, 14, 24, 18, 2, -24 },
  { 2396, 14, 16, 18, 2, -16 },
  { 2424, 14, 24, 18, 1, -24 },
  { 2466, 15, 16, 18, 1, -16 },
  { 2496, 16, 24, 18, 1, -24 },
  { 2544, 14, 22, 18, 1, -16 },
  { 2583, 13, 24, 18, 2, -24 },
  { 2622, 15, 24, 18, 1, -24 },
  { 2667, 12, 30, 18, 2, -24 },
  { 2712, 15, 24, 18, 2, -24 },
  { 2757, 15, 24, 18, 1, -24 },
  { 2802, 15, 16, 18, 1, -16 },
  { 2832, 13, 16, 18, 2, -16 },
  { 2858, 16, 16, 18, 1, -16 },
  { 2890, 14, 22, 18, 2, -16 },
  { 2929, 14, 22, 18, 1, -16 },
  { 2968, 13, 16, 18, 3, -16 },
  { 2994, 13, 16, 18, 2, -16 },
  { 3020, 16, 21, 18, 1, -21 },
  { 3062, 13, 16, 18, 2, -16 },
  { 3088, 17, 16, 18, 0, -16 },
  { 3122, 17, 16, 18, 0, -16 },
  { 3156, 16, 16, 18, 1, -16 },
  { 3188, 16, 22, 18, 1, -16 },
  { 3232, 13, 16, 18, 2, -16 },
  { 3258, 13, 30, 18, 2, -24 },
  { 3307, 4, 30, 18, 7, -24 },
  { 3322, 13, 30, 18, 2, -24 },
  { 3371, 16, 6, 18, 1, -12 },
};

const GFXfont UbuntuMono_Bold35pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Bold35pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Bold35pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _UBUNTUMONO_BOLD35PT7B_H_
