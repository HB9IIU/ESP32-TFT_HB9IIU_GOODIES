#ifndef _UBUNTUMONO_BOLD22PT7B_H_
#define _UBUNTUMONO_BOLD22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Bold.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Bold22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0xEF, 0xDF, 0xBF, 0x7C, 0x78,
  0xC0, 0x0C, 0xC3, 0xB8, 0x66, 0x7F, 0xFF, 0xFE, 0x33, 0x0E, 0xE1, 0xDC,
  0x33, 0x1F, 0xFF, 0xFF, 0x99, 0x87, 0x70, 0xCC, 0x00, 0x1C, 0x0E, 0x0F,
  0xEF, 0xFE, 0x07, 0x03, 0xC0, 0xF8, 0x3F, 0x07, 0xC0, 0xE0, 0x7C, 0x3F,
  0xF9, 0xF8, 0x38, 0x1C, 0x00, 0x70, 0x6F, 0x1B, 0xE6, 0x6C, 0xCD, 0xB0,
  0xFC, 0x1D, 0x80, 0x6E, 0x0F, 0xC3, 0x6C, 0xCD, 0x99, 0xB6, 0x3D, 0x83,
  0x80, 0x1E, 0x07, 0xE1, 0xCC, 0x39, 0x83, 0x70, 0x7C, 0x0F, 0x33, 0xE6,
  0x6E, 0xCC, 0xFB, 0x8E, 0x31, 0xC7, 0xFC, 0x7D, 0x80, 0xFF, 0xFE, 0xD0,
  0x04, 0x1C, 0x71, 0xC7, 0x0E, 0x18, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x0C,
  0x18, 0x38, 0x38, 0x38, 0x38, 0x20, 0x41, 0xC1, 0xC1, 0xC1, 0xC3, 0x83,
  0x07, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x0E, 0x38, 0xE3, 0x82, 0x00,
  0x1C, 0x2E, 0xBA, 0xFF, 0xF1, 0xC1, 0xB1, 0xDC, 0x44, 0x1C, 0x0E, 0x07,
  0x03, 0x8F, 0xFF, 0xFC, 0x70, 0x38, 0x1C, 0x0E, 0x00, 0x73, 0xDE, 0xF3,
  0x3B, 0x98, 0xFF, 0xFF, 0xF8, 0xFF, 0xF0, 0x03, 0x81, 0x81, 0xC0, 0xE0,
  0x70, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x07, 0x03, 0x81, 0xC1, 0xC0,
  0xE0, 0x70, 0x30, 0x38, 0x00, 0x3E, 0x3F, 0x98, 0xDC, 0x7C, 0x1E, 0x4F,
  0x77, 0x93, 0xC1, 0xE0, 0xF8, 0xEC, 0x67, 0xF1, 0xF0, 0x0C, 0x0E, 0x1F,
  0x1F, 0x86, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x87, 0xFB,
  0xFC, 0x3C, 0x7F, 0x91, 0xC0, 0x70, 0x38, 0x38, 0x3C, 0x3C, 0x3C, 0x3C,
  0x1C, 0x1C, 0x0F, 0xFF, 0xFC, 0x7C, 0x7F, 0x91, 0xC0, 0x60, 0x30, 0x38,
  0xF8, 0x7E, 0x07, 0x81, 0xC0, 0xF0, 0x7F, 0xF7, 0xF0, 0x07, 0x07, 0x83,
  0xC3, 0xE3, 0xF1, 0xB9, 0x9D, 0xCE, 0xC7, 0x7F, 0xFF, 0xE0, 0xE0, 0x70,
  0x38, 0x7F, 0x3F, 0x9C, 0x0E, 0x06, 0x03, 0xE1, 0xFC, 0x0E, 0x03, 0x81,
  0xC0, 0xF0, 0xEF, 0xF7, 0xE0, 0x07, 0x0F, 0x8F, 0x0E, 0x06, 0x07, 0xF3,
  0xFD, 0xC7, 0xE3, 0xF1, 0xF8, 0xEC, 0x77, 0xF1, 0xF0, 0xFF, 0xFF, 0xC0,
  0xE0, 0xE0, 0x60, 0x70, 0x30, 0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0x3E, 0x3F, 0xB8, 0xFC, 0x7E, 0x3F, 0x99, 0xFC, 0xFE, 0xE7, 0xF1,
  0xF0, 0x7C, 0x77, 0xF1, 0xF0, 0x3E, 0x3F, 0xB8, 0xDC, 0x7E, 0x3F, 0x1F,
  0x8E, 0xFF, 0x3F, 0x81, 0x81, 0xC3, 0xC7, 0xC3, 0x80, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x77, 0x77, 0x00, 0x07, 0x77, 0x73, 0x7E, 0xC0, 0x01, 0x83,
  0xCF, 0xDF, 0x8E, 0x07, 0xE0, 0xFC, 0x0F, 0x01, 0x80, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFC, 0xC0, 0x78, 0x1F, 0x83, 0xF0, 0x38, 0xFD, 0xF9,
  0xE0, 0xC0, 0x00, 0xFC, 0xFE, 0x8E, 0x07, 0x0E, 0x1E, 0x3C, 0x38, 0x30,
  0x00, 0x00, 0x30, 0x78, 0x30, 0x0F, 0x0F, 0xE3, 0x1D, 0x83, 0x67, 0xDB,
  0xFC, 0xCF, 0x33, 0xCC, 0xF3, 0x3C, 0xCD, 0xBF, 0x67, 0xDC, 0x03, 0x80,
  0x7F, 0x0F, 0xC0, 0x0E, 0x01, 0xC0, 0x7C, 0x0D, 0x81, 0xB0, 0x77, 0x0E,
  0xE1, 0x8C, 0x31, 0x8F, 0xF9, 0xFF, 0x38, 0xE6, 0x0D, 0xC1, 0xC0, 0xFE,
  0x7F, 0xB8, 0xDC, 0x7E, 0x3F, 0x3B, 0xFD, 0xFE, 0xE3, 0xF0, 0xF8, 0x7C,
  0x7F, 0xF7, 0xF0, 0x1F, 0x1F, 0xDC, 0x3C, 0x0E, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x70, 0x38, 0x0E, 0x17, 0xF8, 0xF8, 0xFC, 0x7F, 0xB9, 0xDC, 0x7E,
  0x3F, 0x0F, 0x87, 0xC3, 0xE1, 0xF1, 0xF8, 0xFC, 0xEF, 0xF7, 0xE0, 0xFF,
  0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x03, 0xFD, 0xFE, 0xE0, 0x70, 0x38, 0x1C,
  0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x03, 0xFD, 0xFE,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0x1F, 0x9F, 0xDC, 0x3C, 0x0E,
  0x06, 0x03, 0x0F, 0x87, 0xC3, 0xF1, 0xF8, 0xEE, 0x77, 0xF8, 0xFC, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0xFF, 0xFF, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1C, 0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x8F, 0xFF, 0xFC, 0x7F, 0xBF, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE8, 0xEF, 0xF3, 0xE0, 0xE3,
  0xB8, 0xCE, 0x73, 0xB8, 0xEE, 0x3F, 0x0F, 0x83, 0xF0, 0xEE, 0x3B, 0xCE,
  0x73, 0x8E, 0xE3, 0xB8, 0x70, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0x71, 0xCE, 0x39, 0xC7, 0x3D,
  0xE7, 0xBC, 0xD5, 0x9B, 0xB3, 0x76, 0x6E, 0xCC, 0x19, 0x83, 0x30, 0x66,
  0x0C, 0xC1, 0x80, 0xC1, 0xF0, 0xFC, 0x7E, 0x3F, 0x9E, 0xCF, 0x77, 0x9B,
  0xCD, 0xE3, 0xF1, 0xF8, 0x7C, 0x3E, 0x0C, 0x3E, 0x3F, 0xB8, 0xFC, 0x7C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF8, 0xFC, 0x77, 0xF1, 0xF0, 0xFE,
  0x7F, 0xB8, 0xFC, 0x3E, 0x1F, 0x1F, 0x8F, 0xFE, 0xFE, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x00, 0x3E, 0x3F, 0xB8, 0xFC, 0x7C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF8, 0xFC, 0x77, 0xF1, 0xF0, 0x70, 0x1E, 0x07, 0x80, 0xC0,
  0xFE, 0x3F, 0xCE, 0x7B, 0x8E, 0xE3, 0xB9, 0xEF, 0xF3, 0xF8, 0xE6, 0x39,
  0xCE, 0x33, 0x8E, 0xE3, 0xB8, 0x70, 0x3F, 0x3F, 0xB8, 0x5C, 0x0E, 0x07,
  0x81, 0xF8, 0x3E, 0x07, 0x81, 0xC0, 0xF8, 0x7F, 0xF3, 0xF0, 0xFF, 0xFF,
  0xC7, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x77, 0xF1, 0xF0, 0xE0, 0xEC, 0x19, 0xC7, 0x38, 0xE7,
  0x1C, 0x63, 0x0C, 0x61, 0xDC, 0x3B, 0x83, 0x60, 0x6C, 0x0F, 0x80, 0xE0,
  0x1C, 0x00, 0x60, 0xCC, 0x19, 0x83, 0x30, 0x66, 0x0C, 0xDD, 0x9B, 0xB3,
  0x76, 0x6A, 0xCF, 0x79, 0xEF, 0x38, 0xE7, 0x1C, 0xE3, 0x80, 0x70, 0xCE,
  0x38, 0xE6, 0x1D, 0xC1, 0xF0, 0x3E, 0x03, 0x80, 0x78, 0x1F, 0x07, 0x70,
  0xEE, 0x38, 0xE7, 0x1D, 0xC1, 0xC0, 0xE0, 0xEE, 0x39, 0xC7, 0x18, 0xC3,
  0xB8, 0x37, 0x07, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x00, 0xFF, 0xFF, 0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x78, 0x38,
  0x38, 0x1C, 0x1C, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xFF, 0xF8, 0xE0,
  0x30, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x30, 0x1C, 0x0E, 0x07, 0x01,
  0xC0, 0xE0, 0x70, 0x1C, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0xFF, 0xFC, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0F,
  0xFF, 0xF8, 0x0E, 0x03, 0xE0, 0x6C, 0x1D, 0xC7, 0x1C, 0xE1, 0x88, 0x30,
  0xFF, 0xFF, 0xFC, 0x43, 0x9E, 0x30, 0x7E, 0x3F, 0x80, 0xE0, 0x73, 0xFF,
  0xFF, 0x8F, 0xC7, 0xFF, 0xBF, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0xF3, 0xFD, 0xC7, 0xE3, 0xF0, 0xF8, 0x7C, 0x7E, 0x3F, 0xF9, 0xF8, 0x1F,
  0xBF, 0xDC, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xE0, 0x7F, 0x8F, 0xC0, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x3F, 0x7F, 0xE3, 0xE3, 0xC3, 0xC3, 0xE3, 0xE3,
  0x7F, 0x3F, 0x3E, 0x3F, 0xB8, 0xFC, 0x3F, 0xFF, 0xFF, 0x81, 0xC2, 0x7F,
  0x1F, 0x80, 0x0F, 0xC7, 0xF3, 0x80, 0xE0, 0x38, 0x3F, 0xEF, 0xF8, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x3F, 0x3F, 0xF8,
  0xFC, 0x7C, 0x3E, 0x1F, 0x8F, 0xC7, 0x7F, 0x9F, 0xC0, 0xF0, 0xEF, 0xF7,
  0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0xF3, 0xFD, 0xC6, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8E, 0x38, 0x1C, 0x0E, 0x00, 0x0F, 0x87,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xC8, 0xFC, 0x3E, 0x0E,
  0x0E, 0x0E, 0x00, 0x7F, 0x7F, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x47, 0xFE, 0x7C, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0xEE, 0x73, 0xB8, 0xFC, 0x3E, 0x0F, 0xC3, 0xB8, 0xE7, 0x38, 0xEE,
  0x38, 0xF8, 0x7C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0xC8, 0xFC, 0x3E, 0xF7, 0x7F, 0xF7, 0x7B, 0xBD, 0xDE,
  0xEF, 0x07, 0x83, 0xC1, 0xE0, 0xC0, 0xFE, 0x7F, 0xB8, 0xDC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xC0, 0x3E, 0x3F, 0xB8, 0xFC, 0x7C, 0x1E,
  0x0F, 0x8F, 0xC7, 0x7F, 0x1F, 0x00, 0x7E, 0x7F, 0xB8, 0xFC, 0x7E, 0x1F,
  0x0F, 0x8F, 0xC7, 0xFF, 0x7F, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0x3F, 0x3F,
  0xF8, 0xFC, 0x7C, 0x3E, 0x1F, 0x8F, 0xC7, 0x7F, 0x9F, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x7F, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0x3F, 0x3F, 0xB8, 0x5E, 0x07, 0xE1, 0xF8, 0x1E, 0x87, 0xFF, 0x3F, 0x00,
  0x38, 0x1C, 0x0E, 0x1F, 0xFF, 0xF9, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x03, 0xF1, 0xF8, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8E, 0xC7,
  0x7F, 0x9F, 0x80, 0xE0, 0xEE, 0x19, 0xC7, 0x38, 0xC3, 0x38, 0x77, 0x06,
  0xC0, 0xF8, 0x0E, 0x01, 0xC0, 0xE0, 0xFC, 0x1F, 0xBB, 0xB7, 0x66, 0xEC,
  0xD5, 0x9E, 0xF3, 0xDE, 0x71, 0x86, 0x30, 0x71, 0xC6, 0x30, 0xEE, 0x0F,
  0x80, 0xE0, 0x1E, 0x06, 0xC1, 0xDC, 0x71, 0xCC, 0x38, 0x70, 0xDC, 0x73,
  0x1C, 0xE6, 0x39, 0x86, 0xE1, 0xF0, 0x7C, 0x0F, 0x03, 0x80, 0xE0, 0x30,
  0x7C, 0x3E, 0x00, 0x7F, 0x3F, 0x81, 0xC1, 0xC1, 0xC1, 0xE0, 0xE0, 0xE0,
  0xFF, 0xFF, 0xC0, 0x0F, 0x8F, 0xC7, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x78, 0x3C, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1C, 0x0F, 0xC3,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x7E, 0x07,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x03, 0xC1, 0xE1, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x1C, 0x7E, 0x3E, 0x00, 0x38, 0x4F, 0x9D, 0xFF, 0x33,
  0xE0, 0x38,
};

const GFXglyph UbuntuMono_Bold22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 14, 11, 4, -14 },
  { 7, 7, 6, 11, 2, -15 },
  { 13, 11, 14, 11, 0, -14 },
  { 33, 9, 17, 11, 1, -15 },
  { 53, 11, 14, 11, 0, -14 },
  { 73, 11, 14, 11, 0, -14 },
  { 93, 3, 7, 11, 4, -15 },
  { 96, 7, 20, 11, 2, -16 },
  { 114, 7, 20, 11, 2, -16 },
  { 132, 9, 8, 11, 1, -14 },
  { 141, 9, 10, 11, 1, -10 },
  { 153, 5, 8, 11, 3, -4 },
  { 158, 7, 3, 11, 2, -7 },
  { 161, 3, 4, 11, 4, -4 },
  { 163, 9, 19, 11, 1, -15 },
  { 185, 9, 14, 11, 1, -14 },
  { 201, 9, 14, 11, 1, -14 },
  { 217, 9, 14, 11, 1, -14 },
  { 233, 9, 14, 11, 1, -14 },
  { 249, 9, 14, 11, 1, -14 },
  { 265, 9, 14, 11, 1, -14 },
  { 281, 9, 14, 11, 1, -14 },
  { 297, 9, 14, 11, 1, -14 },
  { 313, 9, 14, 11, 1, -14 },
  { 329, 9, 14, 11, 1, -14 },
  { 345, 3, 11, 11, 4, -11 },
  { 350, 4, 15, 11, 3, -11 },
  { 358, 9, 9, 11, 1, -10 },
  { 369, 9, 6, 11, 1, -9 },
  { 376, 9, 9, 11, 1, -10 },
  { 387, 8, 14, 11, 2, -14 },
  { 401, 10, 17, 11, 0, -14 },
  { 423, 11, 14, 11, 0, -14 },
  { 443, 9, 14, 11, 1, -14 },
  { 459, 9, 14, 11, 1, -14 },
  { 475, 9, 14, 11, 1, -14 },
  { 491, 9, 14, 11, 1, -14 },
  { 507, 9, 14, 11, 1, -14 },
  { 523, 9, 14, 11, 1, -14 },
  { 539, 9, 14, 11, 1, -14 },
  { 555, 9, 14, 11, 1, -14 },
  { 571, 9, 14, 11, 1, -14 },
  { 587, 10, 14, 11, 1, -14 },
  { 605, 8, 14, 11, 2, -14 },
  { 619, 11, 14, 11, 0, -14 },
  { 639, 9, 14, 11, 1, -14 },
  { 655, 9, 14, 11, 1, -14 },
  { 671, 9, 14, 11, 1, -14 },
  { 687, 9, 18, 11, 1, -14 },
  { 708, 10, 14, 11, 1, -14 },
  { 726, 9, 14, 11, 1, -14 },
  { 742, 9, 14, 11, 1, -14 },
  { 758, 9, 14, 11, 1, -14 },
  { 774, 11, 14, 11, 0, -14 },
  { 794, 11, 14, 11, 0, -14 },
  { 814, 11, 14, 11, 0, -14 },
  { 834, 11, 14, 11, 0, -14 },
  { 854, 9, 14, 11, 1, -14 },
  { 870, 7, 19, 11, 2, -15 },
  { 887, 9, 19, 11, 1, -15 },
  { 909, 7, 19, 11, 2, -15 },
  { 926, 11, 7, 11, 0, -14 },
  { 936, 11, 2, 11, 0, 2 },
  { 939, 5, 4, 11, 3, -15 },
  { 942, 9, 10, 11, 1, -10 },
  { 954, 9, 15, 11, 1, -15 },
  { 971, 9, 10, 11, 1, -10 },
  { 983, 8, 15, 11, 1, -15 },
  { 998, 9, 10, 11, 1, -10 },
  { 1010, 10, 15, 11, 1, -15 },
  { 1029, 9, 14, 11, 1, -10 },
  { 1045, 9, 15, 11, 1, -15 },
  { 1062, 9, 15, 11, 1, -15 },
  { 1079, 8, 19, 11, 1, -15 },
  { 1098, 10, 15, 11, 1, -15 },
  { 1117, 9, 15, 11, 1, -15 },
  { 1134, 9, 10, 11, 1, -10 },
  { 1146, 9, 10, 11, 1, -10 },
  { 1158, 9, 10, 11, 1, -10 },
  { 1170, 9, 14, 11, 1, -10 },
  { 1186, 9, 14, 11, 1, -10 },
  { 1202, 8, 10, 11, 2, -10 },
  { 1212, 9, 10, 11, 1, -10 },
  { 1224, 9, 13, 11, 1, -13 },
  { 1239, 9, 10, 11, 1, -10 },
  { 1251, 11, 10, 11, 0, -10 },
  { 1265, 11, 10, 11, 0, -10 },
  { 1279, 11, 10, 11, 0, -10 },
  { 1293, 10, 14, 11, 0, -10 },
  { 1311, 9, 10, 11, 1, -10 },
  { 1323, 9, 19, 11, 1, -15 },
  { 1345, 3, 19, 11, 4, -15 },
  { 1353, 9, 19, 11, 1, -15 },
  { 1375, 11, 5, 11, 0, -8 },
};

const GFXfont UbuntuMono_Bold22pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Bold22pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Bold22pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _UBUNTUMONO_BOLD22PT7B_H_
