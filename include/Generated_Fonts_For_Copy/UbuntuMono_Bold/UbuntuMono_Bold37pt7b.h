#ifndef _UBUNTUMONO_BOLD37PT7B_H_
#define _UBUNTUMONO_BOLD37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Bold.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Bold37pt7bBitmaps[] PROGMEM = {
  0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x79, 0xE7,
  0x80, 0x00, 0x07, 0xBF, 0xFF, 0xF7, 0x80, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF,
  0x8F, 0xF8, 0xF7, 0x8F, 0x78, 0xF7, 0x0F, 0x70, 0xF7, 0x06, 0x07, 0x8F,
  0x03, 0xC7, 0x01, 0xE7, 0x80, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0x8F, 0x03, 0xC7, 0x01,
  0xE7, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9E, 0x78,
  0x0E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xFC, 0x1F, 0xFE, 0x3F,
  0xFE, 0x3F, 0xFE, 0x7E, 0x0E, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7F,
  0x80, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x70, 0x1F, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F,
  0xFC, 0x1F, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x1E,
  0x01, 0xDF, 0xC0, 0xE7, 0xF0, 0x79, 0xDC, 0x1C, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x39, 0xC1, 0xDC, 0xF0, 0x7F, 0x38, 0x1F, 0xDC, 0x01, 0xCF, 0x00,
  0x03, 0x80, 0x01, 0xCF, 0x00, 0xF7, 0xE0, 0x3B, 0xFC, 0x1C, 0xE7, 0x0F,
  0x39, 0xC3, 0x8E, 0x71, 0xC3, 0x9C, 0xF0, 0xE7, 0x38, 0x3F, 0xDC, 0x07,
  0xEF, 0x00, 0xF0, 0x07, 0xC0, 0x0F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x07,
  0xC7, 0x83, 0xC3, 0xC1, 0xE1, 0xE0, 0x79, 0xE0, 0x3D, 0xF0, 0x0F, 0xF0,
  0x07, 0xE3, 0x07, 0xF1, 0xE7, 0xFC, 0xF3, 0xDF, 0x7B, 0xC7, 0xB9, 0xE1,
  0xFC, 0xF0, 0x7E, 0x78, 0x1E, 0x3E, 0x1F, 0x9F, 0xFF, 0xC7, 0xFF, 0xF1,
  0xFF, 0x78, 0x7E, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xDE, 0x73, 0x9C, 0x00,
  0x60, 0x0E, 0x01, 0xF0, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xE0, 0x3E,
  0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xE0, 0x06, 0x20,
  0x07, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03,
  0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x07,
  0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0xC0, 0x78, 0x02, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x02, 0x1C, 0x67, 0x3B, 0xDF, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFC, 0x07, 0xC0, 0x1F, 0xC0, 0x7B, 0xC1, 0xF7, 0xC7, 0xCF, 0x83,
  0x8E, 0x02, 0x08, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x1C, 0x3E, 0x7F, 0x7F, 0x7F, 0x3F, 0x1F, 0x0E, 0x1E, 0x3C, 0xF8, 0xF0,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x39, 0xFB, 0xF7, 0xFF, 0xDF, 0x9E,
  0x00, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x7E, 0x3E, 0x7C,
  0x1E, 0x78, 0x1F, 0x78, 0x0F, 0xF9, 0xCF, 0xFB, 0xCF, 0xF3, 0xCF, 0xF3,
  0xCF, 0xF1, 0xCF, 0xF0, 0x0F, 0xF8, 0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x7C,
  0x1E, 0x7E, 0x3E, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF8, 0x07, 0xE0, 0x01,
  0xC0, 0x07, 0x80, 0x3F, 0x01, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x39, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x03, 0xFF,
  0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x80, 0x0F, 0xC0, 0xFF, 0xE3, 0xFF,
  0xE7, 0xFF, 0xC7, 0x0F, 0xCC, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0xFF, 0xE3, 0xFF, 0xE3, 0xFF, 0xC7, 0x0F,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x1F, 0xE0, 0x3F, 0x80,
  0x7F, 0xC0, 0xFF, 0xC0, 0x1F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7F, 0x01, 0xF7, 0xFF, 0xEF, 0xFF, 0x9F, 0xFE, 0x0F, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0,
  0x1E, 0xF0, 0x1E, 0x78, 0x1F, 0x3C, 0x0F, 0x1E, 0x0F, 0x0F, 0x07, 0x87,
  0x87, 0x83, 0xC7, 0xC1, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x3F, 0xFC, 0x3F, 0xFC,
  0x00, 0xFE, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E,
  0x60, 0x7E, 0x7F, 0xFC, 0x7F, 0xFC, 0xFF, 0xF0, 0x3F, 0xC0, 0x00, 0x7C,
  0x07, 0xF8, 0x1F, 0xF0, 0xFF, 0xE3, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0x3E,
  0x00, 0xFB, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x87, 0xDE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF1, 0xF3, 0xFF, 0xE3,
  0xFF, 0x83, 0xFE, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x00, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x7C, 0x3E,
  0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x7C, 0x1E, 0x3F, 0x3C, 0x3F, 0xFC,
  0x0F, 0xF0, 0x1F, 0xFC, 0x3C, 0xFE, 0x78, 0x3F, 0x78, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0x7C, 0x1F, 0x7F, 0xFF, 0x3F, 0xFE, 0x1F, 0xFC, 0x07, 0xF0,
  0x0F, 0xC0, 0x3F, 0xE1, 0xFF, 0xE3, 0xFF, 0xEF, 0x87, 0xDF, 0x07, 0xBC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF1, 0xFB, 0xFF, 0xF7, 0xFF,
  0xE7, 0xFF, 0x81, 0xFF, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x1F, 0xC3,
  0xFF, 0x07, 0xFC, 0x0F, 0xE0, 0x1F, 0x00, 0x00, 0x39, 0xFB, 0xF7, 0xFF,
  0xDF, 0x9E, 0x00, 0x00, 0x00, 0x01, 0xCF, 0xDF, 0xBF, 0xFE, 0xFC, 0xF0,
  0x0E, 0x1F, 0x8F, 0xC7, 0xF3, 0xF1, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC3, 0xF1, 0xF8, 0xFE, 0x7F, 0x3F, 0x0F, 0x81, 0xC1, 0xE3, 0xE7,
  0xE1, 0xE0, 0xC0, 0x00, 0x04, 0x00, 0x78, 0x03, 0xF8, 0x1F, 0xF0, 0xFF,
  0xCF, 0xFE, 0x3F, 0xF0, 0x7F, 0x00, 0xF8, 0x01, 0xFC, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0x1E, 0x00, 0x04, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x20, 0x00, 0x78,
  0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0x00, 0x1F, 0x00, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x7F, 0xF0, 0x7F,
  0xC0, 0x7E, 0x00, 0x78, 0x00, 0x20, 0x00, 0x3F, 0x87, 0xFF, 0x3F, 0xFD,
  0xFF, 0xF6, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF8, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x3E, 0x03, 0xF8, 0x0F, 0x80, 0x38, 0x00, 0x03, 0xF0, 0x0F,
  0xFC, 0x1F, 0xFE, 0x3E, 0x1E, 0x38, 0x0F, 0x78, 0x0F, 0x70, 0x0F, 0xF0,
  0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xE3, 0xFF, 0xE7, 0xCF, 0xE7, 0x8F, 0xE7,
  0x8F, 0xE7, 0x8F, 0xE7, 0x8F, 0xE7, 0x8F, 0xE7, 0xCF, 0xE3, 0xFF, 0xF3,
  0xFF, 0xF1, 0xFF, 0x70, 0x7E, 0x78, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x1F,
  0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7B, 0xC0, 0x1C, 0xF0, 0x0F,
  0x3C, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x78, 0x78, 0x1E, 0x1F, 0x07, 0x87,
  0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xE7, 0xC0, 0xF9,
  0xF0, 0x1E, 0x7C, 0x07, 0xDE, 0x01, 0xFF, 0x80, 0x7C, 0xFF, 0xC1, 0xFF,
  0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x87, 0xDF, 0x07, 0xBE, 0x0F, 0x7C, 0x1E,
  0xF8, 0x7D, 0xFF, 0xF3, 0xFF, 0x87, 0xFF, 0xCF, 0xFF, 0xDF, 0x0F, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0x1F, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xFF, 0x1F, 0xFF, 0x3F,
  0xFF, 0x3F, 0x07, 0x7E, 0x02, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7C, 0x02, 0x7F, 0x07, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F,
  0xFF, 0x03, 0xF8, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xF8, 0xF8,
  0xFC, 0xF8, 0x7C, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8,
  0x1E, 0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x3E, 0xF8,
  0x3E, 0xF8, 0x7C, 0xF8, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF,
  0x80, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xCF,
  0xFF, 0x9F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x00, 0x01, 0xFF, 0x07, 0xFF, 0x1F, 0xFF, 0x3F, 0xFE, 0x3F, 0x02,
  0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x1F,
  0x7C, 0x1F, 0x7E, 0x1F, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7D, 0x01, 0xF7,
  0x0F, 0xFF, 0xFE, 0xFF, 0xF3, 0xFF, 0x81, 0xFC, 0x00, 0xF0, 0x3E, 0xF0,
  0x7E, 0xF0, 0x7C, 0xF0, 0xF8, 0xF0, 0xF8, 0xF1, 0xF0, 0xF3, 0xE0, 0xF3,
  0xE0, 0xF7, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xF7,
  0xE0, 0xF3, 0xF0, 0xF1, 0xF0, 0xF0, 0xF8, 0xF0, 0xFC, 0xF0, 0x7C, 0xF0,
  0x7E, 0xF0, 0x3E, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x78, 0x1E, 0x3C, 0x0F, 0x1F, 0x07, 0x8F, 0x87, 0xE7, 0xC3, 0xF3, 0xF1,
  0xF9, 0xF9, 0xDC, 0xFC, 0xEE, 0xF7, 0x77, 0x7B, 0xF3, 0xBD, 0xF9, 0xDE,
  0x7C, 0xEF, 0x3E, 0x77, 0x9E, 0x3B, 0xCF, 0x1D, 0xE0, 0x0E, 0xF0, 0x07,
  0x78, 0x03, 0xBC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3E, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF, 0x83,
  0xFF, 0x87, 0xFF, 0x8F, 0xFF, 0x1F, 0xEF, 0x3F, 0xDE, 0x7F, 0x9C, 0xFF,
  0x3D, 0xFE, 0x3B, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC1,
  0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0x80, 0x07, 0xE0, 0x07,
  0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xC7, 0xE3, 0xE3, 0xE0, 0xF9, 0xE0, 0x7D,
  0xF0, 0x1E, 0xF8, 0x0F, 0x7C, 0x07, 0xBE, 0x03, 0xDF, 0x01, 0xFF, 0x80,
  0xF7, 0xC0, 0x7B, 0xE0, 0x3D, 0xF0, 0x1E, 0x78, 0x1F, 0x3E, 0x0F, 0x9F,
  0x8F, 0x87, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0x80, 0xFF, 0xC1,
  0xFF, 0xF3, 0xFF, 0xF7, 0xFF, 0xFF, 0x87, 0xFF, 0x07, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0x3F, 0xF0, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xFC, 0x07, 0xFF,
  0x07, 0xFF, 0xC7, 0xE3, 0xE3, 0xE0, 0xF9, 0xE0, 0x7D, 0xF0, 0x1E, 0xF8,
  0x0F, 0x7C, 0x07, 0xBE, 0x03, 0xDF, 0x01, 0xEF, 0x80, 0xF7, 0xC0, 0x7B,
  0xE0, 0x3D, 0xF0, 0x1E, 0xF8, 0x1F, 0x3E, 0x0F, 0x9F, 0x8F, 0x87, 0xFF,
  0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xC0, 0x07, 0x80, 0x01, 0xF8, 0x00,
  0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xE0, 0x00, 0x60, 0xFF, 0xC0, 0xFF, 0xF0,
  0xFF, 0xF8, 0xFF, 0xFC, 0xF8, 0xFC, 0xF8, 0x7C, 0xF8, 0x3E, 0xF8, 0x3E,
  0xF8, 0x3E, 0xF8, 0x7C, 0xF8, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0,
  0xFF, 0xE0, 0xF9, 0xF0, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x7C, 0xF8, 0x3C,
  0xF8, 0x3E, 0xF8, 0x1E, 0xF8, 0x1F, 0x07, 0xF0, 0x1F, 0xFE, 0x3F, 0xFE,
  0x3F, 0xFC, 0x7C, 0x0C, 0x7C, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x1F, 0x20, 0x1F, 0x78, 0x3F, 0x7F, 0xFE, 0x7F, 0xFE,
  0x7F, 0xFC, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0x78, 0x1F, 0x78, 0x1F, 0x7C, 0x3F, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F,
  0xFC, 0x07, 0xF0, 0x78, 0x07, 0xDE, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x1E,
  0x7C, 0x0F, 0x8F, 0x03, 0xE3, 0xC0, 0xF8, 0xF8, 0x3C, 0x3E, 0x0F, 0x07,
  0x87, 0xC1, 0xE1, 0xF0, 0x78, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF3,
  0xC0, 0x3C, 0xF0, 0x07, 0xBC, 0x01, 0xEE, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E,
  0xF1, 0xC7, 0x79, 0xE3, 0xBC, 0xF9, 0xDE, 0x7C, 0xEF, 0x7E, 0x77, 0xBB,
  0x3B, 0xDD, 0xDC, 0xFC, 0xEE, 0x7E, 0x77, 0x3F, 0x1F, 0x9F, 0x0F, 0xCF,
  0x87, 0xE7, 0xC1, 0xF3, 0xC0, 0xF9, 0xE0, 0x78, 0x7C, 0x07, 0x8F, 0x03,
  0xE3, 0xE0, 0xF0, 0x78, 0x7C, 0x1F, 0x1E, 0x03, 0xCF, 0x80, 0xFB, 0xC0,
  0x1F, 0xF0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3E, 0xF8, 0x0F, 0x3E, 0x07, 0xC7,
  0xC1, 0xE1, 0xF0, 0xF8, 0x3E, 0x3C, 0x0F, 0x9F, 0x01, 0xE7, 0xC0, 0x7C,
  0x7C, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x07,
  0x87, 0xC1, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x3E, 0x03, 0xEF, 0x00, 0x7F,
  0xC0, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07,
  0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F,
  0x80, 0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x03, 0xF0,
  0x01, 0xFC, 0x01, 0xFF, 0x01, 0xF7, 0x80, 0xFB, 0xE0, 0xF8, 0xF8, 0xF8,
  0x7C, 0x7C, 0x1F, 0x7C, 0x07, 0xFE, 0x03, 0xE2, 0x00, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x20, 0x70, 0xF8, 0xFE, 0x7F,
  0x1E, 0x04, 0x3F, 0xE1, 0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0x00, 0x7C, 0x00,
  0xF1, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFC, 0x0F, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0x1F, 0xF8, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFB,
  0xE1, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0xC7, 0xFF, 0x07, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x87, 0xFF,
  0xFF, 0xBF, 0xFE, 0x7F, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xFC, 0xFF,
  0xFB, 0xFF, 0xE7, 0xE0, 0x5F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xE0, 0x2F, 0xFF, 0xCF, 0xFF, 0x8F,
  0xFF, 0x03, 0xFC, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x0F, 0xBE, 0x3F, 0xFC, 0xFF, 0xFB,
  0xFF, 0xF7, 0xC3, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xF7, 0xC3, 0xEF, 0xFF, 0xCF, 0xFF, 0x8F, 0xFF,
  0x07, 0xF8, 0x07, 0xE0, 0x0F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x7C, 0x3E,
  0x78, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x78, 0x00, 0x7C, 0x06, 0x7F, 0xFE, 0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0xF8,
  0x00, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0xFC, 0x18, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF,
  0xFF, 0xE0, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFC, 0x3F, 0xFC, 0xFF, 0xFB,
  0xFF, 0xF7, 0xE1, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7B, 0xE1, 0xF7, 0xFF, 0xE7, 0xFF, 0xC7, 0xFF, 0x87, 0xEF,
  0x00, 0x1E, 0x00, 0x7D, 0x81, 0xFB, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x07,
  0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFF, 0xF8,
  0x7F, 0xE1, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE,
  0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3C, 0x07, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC1, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFE,
  0x00, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xD8, 0x7E, 0xFF, 0xEF, 0xFF, 0x7F,
  0xF0, 0xFE, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x3E, 0xF8, 0x7C, 0xF8,
  0xF8, 0xF9, 0xF0, 0xF9, 0xE0, 0xFB, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF,
  0xC0, 0xFF, 0xE0, 0xFB, 0xE0, 0xF9, 0xF0, 0xF8, 0xF8, 0xF8, 0x7C, 0xF8,
  0x7C, 0xF8, 0x3E, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE1, 0x03,
  0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFE, 0x7F, 0x7C, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF3, 0xCF, 0xF3, 0xC7, 0xF3, 0xC7, 0xF3, 0xC7, 0xF3,
  0xC7, 0xF3, 0xC7, 0xF3, 0xC7, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0x3F, 0xE3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFF,
  0xF8, 0x7F, 0xE1, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83,
  0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3C, 0x07,
  0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7C, 0x3F, 0xF8, 0x1F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0x78, 0x1F, 0x7C,
  0x3F, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x3F, 0xC1, 0xFF,
  0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x87, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x87, 0xFF, 0xFF, 0xBF,
  0xFF, 0x7F, 0xFC, 0xFB, 0xE1, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFC, 0x3F, 0xFC, 0xFF, 0xFB, 0xFF,
  0xF7, 0xE1, 0xEF, 0x83, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xF7, 0xC3, 0xEF, 0xFF, 0xCF, 0xFF, 0x8F, 0xFF, 0x0F,
  0xDE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0xF7, 0xFF,
  0x9F, 0xFE, 0xF8, 0x1B, 0xE0, 0x07, 0xE0, 0x1F, 0xF0, 0x3F, 0xF0, 0x1F,
  0xE0, 0x0F, 0xC0, 0x0F, 0x60, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F,
  0xE0, 0x01, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0xC1, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFE, 0xF8, 0x3F, 0xE0,
  0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0x7C, 0x3D, 0xFF, 0xF7, 0xFF, 0xCF,
  0xFF, 0x0F, 0xF0, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xCF, 0x03, 0xE7,
  0xC1, 0xF3, 0xE0, 0xF0, 0xF0, 0xF8, 0x78, 0x78, 0x3E, 0x3C, 0x0F, 0x3E,
  0x07, 0xDE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0x80, 0x0F,
  0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x03, 0xDC, 0x00, 0xF7, 0x00, 0x3D, 0xC3,
  0x8F, 0x79, 0xE3, 0xDE, 0x7C, 0xF7, 0x9F, 0x39, 0xE7, 0xCE, 0x7B, 0xF3,
  0x9E, 0xFE, 0xE3, 0xBB, 0xF8, 0xFC, 0xFE, 0x3F, 0x3F, 0x0F, 0xC7, 0xC3,
  0xE1, 0xF0, 0x78, 0x7C, 0x1E, 0x0E, 0x00, 0xF8, 0x0F, 0x3E, 0x0F, 0x8F,
  0x0F, 0x87, 0xC7, 0x81, 0xF7, 0x80, 0x7F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0,
  0x03, 0xE0, 0x03, 0xF8, 0x03, 0xFE, 0x03, 0xEF, 0x01, 0xE7, 0xC1, 0xE1,
  0xF1, 0xF0, 0x78, 0xF0, 0x3E, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x78, 0x1F,
  0x7C, 0x1F, 0x7C, 0x1E, 0x3C, 0x1E, 0x3E, 0x1E, 0x3E, 0x3E, 0x1E, 0x3C,
  0x1F, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x87, 0xC0, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xDF,
  0xFE, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C,
  0x0F, 0xF0, 0x3F, 0x00, 0xFC, 0x03, 0xFC, 0x00, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0x07,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0,
  0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x01, 0xF0, 0xFF, 0xC3, 0xFE, 0x0F, 0xF8, 0x3F, 0x80,
  0x1E, 0x02, 0x1F, 0xC3, 0xDF, 0xF1, 0xFF, 0xFF, 0xEF, 0x1F, 0xF3, 0x07,
  0xF0, 0x00, 0xF0,
};

const GFXglyph UbuntuMono_Bold37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 6, 23, 19, 6, -23 },
  { 19, 12, 10, 19, 3, -25 },
  { 34, 17, 23, 19, 1, -23 },
  { 83, 16, 30, 19, 1, -26 },
  { 143, 18, 23, 19, 0, -23 },
  { 195, 17, 23, 19, 1, -23 },
  { 244, 5, 11, 19, 7, -25 },
  { 251, 12, 32, 19, 3, -26 },
  { 299, 12, 32, 19, 3, -26 },
  { 347, 15, 15, 19, 2, -23 },
  { 376, 16, 16, 19, 1, -17 },
  { 408, 8, 13, 19, 5, -7 },
  { 421, 10, 4, 19, 4, -12 },
  { 426, 7, 7, 19, 6, -7 },
  { 433, 15, 32, 19, 2, -26 },
  { 493, 16, 23, 19, 1, -23 },
  { 539, 15, 23, 19, 2, -23 },
  { 583, 15, 23, 19, 2, -23 },
  { 627, 15, 23, 19, 2, -23 },
  { 671, 17, 23, 19, 1, -23 },
  { 720, 16, 23, 19, 1, -23 },
  { 766, 15, 23, 19, 2, -23 },
  { 810, 15, 23, 19, 2, -23 },
  { 854, 16, 23, 19, 1, -23 },
  { 900, 15, 23, 19, 2, -23 },
  { 944, 7, 18, 19, 6, -18 },
  { 960, 9, 24, 19, 4, -18 },
  { 987, 15, 17, 19, 2, -18 },
  { 1019, 16, 11, 19, 1, -15 },
  { 1041, 16, 17, 19, 1, -18 },
  { 1075, 13, 23, 19, 3, -23 },
  { 1113, 16, 28, 19, 1, -23 },
  { 1169, 18, 23, 19, 0, -23 },
  { 1221, 15, 23, 19, 2, -23 },
  { 1265, 16, 23, 19, 1, -23 },
  { 1311, 16, 23, 19, 2, -23 },
  { 1357, 15, 23, 19, 2, -23 },
  { 1401, 14, 23, 19, 2, -23 },
  { 1442, 16, 23, 19, 1, -23 },
  { 1488, 15, 23, 19, 2, -23 },
  { 1532, 15, 23, 19, 2, -23 },
  { 1576, 14, 23, 19, 2, -23 },
  { 1617, 16, 23, 19, 2, -23 },
  { 1663, 14, 23, 19, 3, -23 },
  { 1704, 17, 23, 19, 1, -23 },
  { 1753, 15, 23, 19, 2, -23 },
  { 1797, 17, 23, 19, 1, -23 },
  { 1846, 15, 23, 19, 2, -23 },
  { 1890, 17, 29, 19, 1, -23 },
  { 1952, 16, 23, 19, 2, -23 },
  { 1998, 16, 23, 19, 1, -23 },
  { 2044, 17, 23, 19, 1, -23 },
  { 2093, 16, 23, 19, 1, -23 },
  { 2139, 18, 23, 19, 0, -23 },
  { 2191, 17, 23, 19, 1, -23 },
  { 2240, 18, 23, 19, 0, -23 },
  { 2292, 18, 23, 19, 0, -23 },
  { 2344, 15, 23, 19, 2, -23 },
  { 2388, 10, 32, 19, 4, -26 },
  { 2428, 15, 32, 19, 2, -26 },
  { 2488, 10, 32, 19, 4, -26 },
  { 2528, 17, 12, 19, 1, -23 },
  { 2554, 18, 4, 19, 0, 2 },
  { 2563, 8, 7, 19, 6, -26 },
  { 2570, 14, 17, 19, 2, -17 },
  { 2600, 15, 25, 19, 2, -25 },
  { 2647, 15, 17, 19, 2, -17 },
  { 2679, 15, 25, 19, 1, -25 },
  { 2726, 16, 17, 19, 1, -17 },
  { 2760, 17, 25, 19, 1, -25 },
  { 2814, 15, 23, 19, 1, -17 },
  { 2858, 14, 25, 19, 2, -25 },
  { 2902, 16, 25, 19, 1, -25 },
  { 2952, 13, 31, 19, 2, -25 },
  { 3003, 16, 25, 19, 2, -25 },
  { 3053, 16, 25, 19, 1, -25 },
  { 3103, 16, 17, 19, 1, -17 },
  { 3137, 14, 17, 19, 2, -17 },
  { 3167, 16, 17, 19, 1, -17 },
  { 3201, 15, 23, 19, 2, -17 },
  { 3245, 15, 23, 19, 1, -17 },
  { 3289, 14, 17, 19, 3, -17 },
  { 3319, 14, 17, 19, 2, -17 },
  { 3349, 16, 22, 19, 1, -22 },
  { 3393, 14, 17, 19, 2, -17 },
  { 3423, 17, 17, 19, 1, -17 },
  { 3460, 18, 17, 19, 0, -17 },
  { 3499, 17, 17, 19, 1, -17 },
  { 3536, 16, 23, 19, 1, -17 },
  { 3582, 14, 17, 19, 2, -17 },
  { 3612, 14, 32, 19, 2, -26 },
  { 3668, 5, 32, 19, 7, -26 },
  { 3688, 14, 32, 19, 2, -26 },
  { 3744, 17, 7, 19, 1, -13 },
};

const GFXfont UbuntuMono_Bold37pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Bold37pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Bold37pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _UBUNTUMONO_BOLD37PT7B_H_
