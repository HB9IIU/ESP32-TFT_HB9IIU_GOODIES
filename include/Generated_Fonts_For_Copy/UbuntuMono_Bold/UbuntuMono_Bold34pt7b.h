#ifndef _UBUNTUMONO_BOLD34PT7B_H_
#define _UBUNTUMONO_BOLD34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Bold.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Bold34pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x38, 0x00, 0x77,
  0xFF, 0xF7, 0x00, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC,
  0x7B, 0x8F, 0x71, 0xCC, 0x18, 0x07, 0x1C, 0x1E, 0x38, 0x3C, 0xF0, 0x71,
  0xE0, 0xE3, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x78, 0x38, 0xE0,
  0x71, 0xC0, 0xE3, 0x83, 0xC7, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x38,
  0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0x8F, 0x07, 0x1C, 0x00, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x7F, 0xC1, 0xFF, 0xC7, 0xFF, 0x9F, 0x06, 0x3C, 0x00,
  0x78, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0x7F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFB, 0x81, 0xF7, 0xFF,
  0xDF, 0xFF, 0x0F, 0xFC, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x3C, 0x03, 0xBF, 0x03, 0x9F, 0xC3, 0x9C, 0xE1, 0xCE, 0x71, 0xC7, 0x39,
  0xC3, 0x9C, 0xE0, 0xFE, 0xE0, 0x7E, 0xE0, 0x1E, 0x70, 0x00, 0x70, 0x00,
  0x73, 0xC0, 0x3B, 0xF0, 0x3B, 0xF8, 0x39, 0xCE, 0x1C, 0xE7, 0x1C, 0x73,
  0x9C, 0x39, 0xCE, 0x1F, 0xCE, 0x07, 0xEE, 0x01, 0xE0, 0x0F, 0x80, 0x3F,
  0xC0, 0xFF, 0x83, 0xC7, 0x87, 0x8F, 0x0F, 0x1E, 0x1E, 0x38, 0x1E, 0xF0,
  0x3F, 0xC0, 0x3F, 0x30, 0xFC, 0x7B, 0xFC, 0xEF, 0x7D, 0xDE, 0x7F, 0xB8,
  0x7F, 0x70, 0x7C, 0xF0, 0x79, 0xE1, 0xF9, 0xFF, 0xF3, 0xFE, 0xF1, 0xF1,
  0xE0, 0xFF, 0xFF, 0xFF, 0xBD, 0xCE, 0x73, 0x80, 0x00, 0xC0, 0x38, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x3C, 0x07,
  0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3F, 0x03, 0xF0, 0x1C,
  0x01, 0x80, 0x60, 0x0E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x7C, 0x0F,
  0x03, 0xC1, 0xF8, 0x7E, 0x07, 0x00, 0x40, 0x00, 0x07, 0x80, 0x1E, 0x04,
  0x71, 0xBD, 0xDE, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0x03, 0xE0, 0x1D, 0xC0,
  0xF7, 0x87, 0xDF, 0x0E, 0x38, 0x08, 0x40, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x1C, 0x3E, 0x3F, 0x3F, 0x3F, 0x1F, 0x0E, 0x0E, 0x3E, 0xFC, 0x78, 0x60,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x38, 0xFB, 0xFB, 0xF7, 0xC7, 0x00, 0x00,
  0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C,
  0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01,
  0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0,
  0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE1, 0xE3, 0xC7, 0x83, 0xCF, 0x07, 0xBC,
  0x07, 0x78, 0x0F, 0xF3, 0x9F, 0xE7, 0x3F, 0xCE, 0x7F, 0x9C, 0xFF, 0x39,
  0xFE, 0x03, 0xFC, 0x07, 0x3C, 0x1E, 0x78, 0x3C, 0xF8, 0xF0, 0xFF, 0xE0,
  0xFF, 0x80, 0x7C, 0x00, 0x03, 0x80, 0x1E, 0x01, 0xF8, 0x0F, 0xE0, 0xFF,
  0x83, 0xFE, 0x0F, 0x78, 0x11, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x07,
  0xFF, 0xDF, 0xFF, 0x7F, 0xFC, 0x0F, 0xC0, 0x7F, 0xE3, 0xFF, 0xE3, 0xC7,
  0xC2, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xE0, 0x1F, 0xC1, 0xFF,
  0xC7, 0xFF, 0x8C, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3D, 0x81, 0xF7, 0xFF, 0x9F, 0xFC, 0x3F, 0xC0, 0x00, 0x78,
  0x01, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xEF, 0x03, 0xDE, 0x0F,
  0x3C, 0x1C, 0x78, 0x78, 0xF1, 0xE1, 0xE3, 0xC3, 0xCF, 0x07, 0x9F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x8F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xE0, 0x1F, 0x80, 0x1F, 0x00,
  0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7D, 0x03, 0xE7, 0xFF, 0xBF,
  0xFC, 0x3F, 0x80, 0x00, 0xF0, 0x3F, 0x83, 0xFC, 0x3F, 0x03, 0xE0, 0x3E,
  0x01, 0xE0, 0x1F, 0x00, 0xFF, 0xE7, 0xFF, 0xBF, 0xFF, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7B, 0xC7, 0xDF, 0xFC, 0x7F, 0xC0,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x0F, 0x00, 0xF8,
  0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07,
  0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xE3, 0xE7, 0x83, 0xCF, 0x07,
  0x9E, 0x0F, 0x3E, 0x1E, 0x7E, 0x78, 0x7F, 0xF0, 0x7F, 0x81, 0xFF, 0xC7,
  0xDF, 0xCF, 0x0F, 0xBC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1E, 0xF8, 0x79, 0xFF,
  0xF1, 0xFF, 0xC0, 0xFE, 0x00, 0x0F, 0x80, 0xFF, 0x87, 0xFF, 0x3E, 0x3C,
  0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF,
  0x9F, 0xFE, 0x3F, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x3F,
  0x07, 0xF8, 0x1F, 0xC0, 0x78, 0x00, 0x38, 0xFB, 0xFB, 0xF7, 0xC7, 0x00,
  0x00, 0x00, 0x00, 0xE3, 0xEF, 0xEF, 0xDF, 0x1C, 0x1C, 0x3E, 0x7F, 0x3F,
  0x3E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x3E, 0x7E, 0x7F, 0x3F, 0x1E,
  0x0E, 0x1E, 0x3C, 0xF8, 0xF0, 0xE0, 0x00, 0x18, 0x01, 0xE0, 0x1F, 0x83,
  0xFF, 0x3F, 0xF3, 0xFE, 0x0F, 0xE0, 0x3C, 0x00, 0xFE, 0x03, 0xFE, 0x03,
  0xFF, 0x03, 0xFF, 0x01, 0xF8, 0x01, 0xE0, 0x01, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x60, 0x00, 0xF0, 0x01, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0x80, 0x1F, 0x01, 0xFE, 0x0F, 0xF8, 0xFF, 0xC7, 0xFE,
  0x07, 0xE0, 0x0F, 0x00, 0x18, 0x00, 0x00, 0x1F, 0x87, 0xFF, 0x1F, 0xFC,
  0xC1, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xF8,
  0x07, 0xE0, 0x3E, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xE1,
  0xE1, 0xE7, 0x81, 0xCE, 0x03, 0xFC, 0x7F, 0xF1, 0xFF, 0xE7, 0xFF, 0xCF,
  0x3F, 0x9E, 0x7F, 0x38, 0xFE, 0x71, 0xFC, 0xE3, 0xF9, 0xC7, 0xF3, 0xCF,
  0xE7, 0x9F, 0xC7, 0xFF, 0x8F, 0xFF, 0x87, 0xF7, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x0F, 0xFE, 0x0F, 0xFC, 0x07, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x77, 0x00, 0x3B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0,
  0x0E, 0x38, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xC3, 0xE1, 0xFF,
  0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x7C, 0x1F, 0x3C, 0x07, 0x9E, 0x03, 0xCF,
  0x01, 0xEF, 0x80, 0xF8, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x3C, 0x3E, 0xF0,
  0x7B, 0xC1, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0xF3, 0xFF, 0x8F, 0xFE, 0x3F,
  0xFE, 0xF0, 0x7B, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xC3, 0xEF,
  0xFF, 0xBF, 0xFC, 0xFF, 0xC0, 0x03, 0xF0, 0x1F, 0xF8, 0x7F, 0xF9, 0xF0,
  0x67, 0xC0, 0x4F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x7C, 0x08, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0x80, 0xFF, 0x03, 0xFF,
  0x0F, 0xFF, 0x3C, 0x7C, 0xF0, 0xFB, 0xC1, 0xEF, 0x07, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xFC,
  0x1E, 0xF0, 0xFB, 0xC7, 0xCF, 0xFE, 0x3F, 0xF0, 0xFF, 0x00, 0xFF, 0xFB,
  0xFF, 0xEF, 0xFF, 0xBC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x03, 0xFE,
  0x1F, 0xF8, 0x7F, 0xF1, 0xF0, 0x67, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07,
  0xFE, 0x0F, 0xBC, 0x1F, 0x7C, 0x3E, 0x7C, 0x7C, 0xFF, 0xF8, 0xFF, 0xF0,
  0x7F, 0xE0, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x1F, 0x20, 0x7D, 0xC3, 0xE7, 0xFF, 0x1F, 0xF8, 0x1F,
  0xC0, 0xF0, 0x7D, 0xE1, 0xF3, 0xC3, 0xE7, 0x8F, 0x8F, 0x1E, 0x1E, 0x7C,
  0x3D, 0xF0, 0x7B, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x0F,
  0x7C, 0x1E, 0x7C, 0x3C, 0xF8, 0x78, 0xF8, 0xF0, 0xF9, 0xE1, 0xF3, 0xC1,
  0xF7, 0x83, 0xEF, 0x03, 0xC0, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x78, 0x3C, 0xF0, 0x79, 0xE0, 0xF3,
  0xE3, 0xE7, 0xC7, 0xCD, 0x8D, 0xBB, 0xBB, 0x77, 0x77, 0xEE, 0xEF, 0xCF,
  0xBF, 0xDF, 0x7F, 0xBE, 0xFF, 0x39, 0xFE, 0x73, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xE0, 0xE0, 0x3F,
  0x81, 0xFC, 0x0F, 0xF0, 0x7F, 0xC3, 0xFE, 0x1F, 0xF8, 0xFD, 0xC7, 0xEF,
  0x3F, 0x39, 0xF9, 0xEF, 0xC7, 0x7E, 0x3B, 0xF0, 0xFF, 0x87, 0xFC, 0x1F,
  0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0x80, 0x07, 0xC0, 0x3F,
  0xE0, 0xFF, 0xE3, 0xE3, 0xE7, 0x83, 0xCF, 0x07, 0xBC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFE,
  0x07, 0xFC, 0x1E, 0x78, 0x3C, 0xF8, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0x7C,
  0x00, 0xFF, 0x83, 0xFF, 0xCF, 0xFF, 0xBC, 0x3E, 0xF0, 0x7F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0x8F, 0xBF, 0xFE, 0xFF, 0xF3,
  0xFF, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xE3, 0xE7, 0x83, 0xCF,
  0x07, 0xBC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x1F, 0x78, 0x3C, 0xF8, 0xF8,
  0xFF, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0x78, 0x00, 0xFC, 0x00, 0xFF, 0x00,
  0xFC, 0x00, 0x38, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xC7, 0x8F, 0xCF, 0x0F,
  0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0xF9, 0xE3, 0xF3, 0xFF, 0xC7,
  0xFF, 0x0F, 0xFC, 0x1E, 0x7C, 0x3C, 0x7C, 0x78, 0x78, 0xF0, 0xF9, 0xE0,
  0xF3, 0xC1, 0xF7, 0x81, 0xEF, 0x03, 0xC0, 0x07, 0xF0, 0x3F, 0xF8, 0xFF,
  0xE3, 0xE0, 0xC7, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7F, 0x00,
  0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0x80, 0x0F, 0x80,
  0x1F, 0x40, 0x3E, 0xE0, 0xF9, 0xFF, 0xF3, 0xFF, 0xC1, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83,
  0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1E, 0x78, 0x3C, 0xF8,
  0xF8, 0xFF, 0xE1, 0xFF, 0xC0, 0xFE, 0x00, 0x78, 0x0F, 0x3C, 0x07, 0x9E,
  0x03, 0xCF, 0x01, 0xE7, 0xC1, 0xF1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x3C,
  0x3C, 0x1E, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x80, 0xE3, 0x80, 0x7B,
  0xC0, 0x3D, 0xE0, 0x0E, 0xF0, 0x07, 0x70, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF9, 0xCF, 0xF3, 0x9F, 0xEF, 0xBF, 0x9F,
  0x7F, 0x3E, 0xFE, 0x6C, 0xFD, 0xDD, 0xFB, 0xBB, 0xB6, 0x36, 0x7C, 0x7C,
  0xF8, 0xF9, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xC0, 0x78, 0x0F, 0x1E, 0x0F,
  0x0F, 0x07, 0x83, 0xC7, 0x81, 0xE3, 0xC0, 0x7B, 0xC0, 0x3D, 0xE0, 0x0F,
  0xE0, 0x07, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80,
  0x7B, 0xC0, 0x3D, 0xF0, 0x3C, 0x78, 0x1E, 0x3E, 0x1E, 0x0F, 0x0F, 0x07,
  0xCF, 0x81, 0xE7, 0x80, 0xF0, 0x78, 0x0F, 0x3C, 0x07, 0x9F, 0x07, 0xC7,
  0x83, 0xC3, 0xC1, 0xE0, 0xF1, 0xE0, 0x78, 0xF0, 0x1E, 0x78, 0x0F, 0x78,
  0x03, 0xFC, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x1F, 0x00, 0xF8,
  0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1F,
  0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0xFF, 0xFF, 0xFC, 0xF0,
  0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80,
  0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00,
  0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3C,
  0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xC0,
  0x07, 0xE0, 0x0F, 0xE0, 0x1E, 0xF0, 0x3E, 0x78, 0x3C, 0x78, 0x7C, 0x3C,
  0xF8, 0x3E, 0xF0, 0x1F, 0x30, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x20, 0x70, 0x7C, 0x7E, 0x1E, 0x04, 0x1F, 0xE0, 0xFF, 0xC3, 0xFF,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0xFF, 0xCF, 0xFF, 0x7F, 0xFD, 0xE0,
  0xFF, 0x83, 0xDE, 0x0F, 0x78, 0x3D, 0xFF, 0xF3, 0xFF, 0xC3, 0xFE, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3D,
  0xF0, 0xFF, 0xF3, 0xFF, 0xEF, 0x8F, 0xBC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xBC, 0x3E, 0xFF, 0xF3,
  0xFF, 0x87, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xF8, 0x7F, 0xF1, 0xF0, 0x27,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFE, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC3, 0xFF,
  0x3F, 0xFD, 0xFF, 0xF7, 0xC7, 0xFE, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0x87, 0xDF, 0x1F, 0x3F, 0xFC, 0x7F,
  0xF0, 0xFF, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xE3, 0xE7, 0x83,
  0xDF, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xC0, 0x07, 0xC0, 0x87, 0xFF, 0x87, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x03,
  0xFF, 0x07, 0xFE, 0x0F, 0x82, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0xF8, 0x7F, 0xF3, 0xFF,
  0xDF, 0x0F, 0x78, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0,
  0xFF, 0x83, 0xDF, 0x1F, 0x7F, 0xFC, 0xFF, 0xF0, 0xFB, 0xC0, 0x0F, 0x00,
  0x7C, 0x01, 0xE6, 0x0F, 0x9F, 0xFE, 0x7F, 0xF0, 0xFF, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0xF8, 0xFF,
  0xE7, 0xFF, 0xBC, 0x3D, 0xE1, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xE0,
  0x0F, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3E, 0x20, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0x00, 0x01, 0xC0, 0x3E, 0x03,
  0xE0, 0x3E, 0x01, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x7F, 0xF7, 0xFF, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE4, 0x1E, 0xFF,
  0xEF, 0xFC, 0x3F, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x3E, 0xF0, 0xF9, 0xE3, 0xE3, 0xC7,
  0x87, 0x9E, 0x0F, 0x78, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0xF7, 0xC1,
  0xE7, 0xC3, 0xC7, 0xC7, 0x87, 0x8F, 0x0F, 0x9E, 0x0F, 0xBC, 0x1F, 0x00,
  0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3E, 0x20, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0x00, 0x7E, 0x79, 0xFF, 0xFB,
  0xFF, 0xFF, 0x3C, 0xFE, 0x39, 0xFC, 0x71, 0xF8, 0xE3, 0xF1, 0xC7, 0xE3,
  0x8F, 0xC7, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0x3F, 0xC7, 0xFF, 0x3F, 0xFD, 0xE1, 0xEF, 0x0F, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xE3, 0xE7,
  0x83, 0xDF, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0,
  0xFB, 0xC1, 0xE7, 0xC7, 0xC7, 0xFF, 0x07, 0xFC, 0x03, 0xE0, 0x3F, 0x83,
  0xFF, 0x8F, 0xFF, 0x3C, 0x3E, 0xF0, 0x7B, 0xC1, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xFC, 0x1E, 0xF8, 0xFB, 0xFF, 0xEF, 0xFF,
  0x3D, 0xF0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x00, 0x07, 0xF8, 0x7F, 0xF3, 0xFF, 0xDF, 0x0F, 0x78, 0x3F, 0xE0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x83, 0xDE, 0x0F, 0x7C, 0x7D,
  0xFF, 0xF3, 0xFF, 0xC3, 0xEF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x1F, 0xFF, 0xFF, 0xBF, 0xFD, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0xE1, 0xFF, 0x9F, 0xFD, 0xF0,
  0x6F, 0x00, 0x7C, 0x01, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x3F, 0xC0, 0x3E,
  0x00, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC7, 0xF8, 0x03, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1F, 0x04, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xC0,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xBF, 0xFC, 0xFF,
  0xE3, 0xFC, 0x78, 0x0F, 0x3C, 0x07, 0x9F, 0x03, 0xC7, 0x83, 0xC3, 0xC1,
  0xE1, 0xE0, 0xF0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x7C, 0x07, 0xBC, 0x03,
  0xDE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0xF0, 0x07, 0xF8, 0x03, 0x9C, 0x01, 0xCE, 0x38, 0xE7, 0x1C, 0x73, 0x9F,
  0x39, 0xCF, 0x9C, 0xE7, 0xCE, 0x73, 0xE7, 0x3F, 0xBF, 0x0F, 0xDF, 0x87,
  0xEF, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF0, 0x38, 0x38, 0xF0, 0x1E,
  0xF0, 0x78, 0xF1, 0xE1, 0xF3, 0xC1, 0xEF, 0x01, 0xFC, 0x03, 0xF8, 0x03,
  0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0xC0, 0xF7, 0xC3, 0xC7, 0x8F, 0x07,
  0x9E, 0x0F, 0xF8, 0x0F, 0xF8, 0x1E, 0xF0, 0x7D, 0xE0, 0xF3, 0xE1, 0xE3,
  0xC3, 0xC7, 0x8F, 0x8F, 0x1E, 0x0F, 0x3C, 0x1E, 0x78, 0x3D, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC1,
  0x1F, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x7F, 0xF3,
  0xFF, 0x9F, 0xFC, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xF8, 0x3F, 0xC3, 0xFE, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x03, 0xF0,
  0x1E, 0x00, 0xFE, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0xF0, 0x7F, 0x81,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x07, 0xF8, 0x3F,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xE0, 0x0F, 0x01, 0xF8,
  0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE1, 0xFF, 0x0F, 0xF0, 0x7F, 0x00, 0x1E, 0x0C, 0x7F,
  0x8E, 0x7F, 0xFE, 0xFF, 0xFE, 0xE3, 0xFC, 0x60, 0x78,
};

const GFXglyph UbuntuMono_Bold34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 5, 21, 17, 6, -21 },
  { 15, 11, 10, 17, 3, -23 },
  { 29, 15, 21, 17, 1, -21 },
  { 69, 15, 27, 17, 1, -24 },
  { 120, 17, 21, 17, 0, -21 },
  { 165, 15, 21, 17, 1, -21 },
  { 205, 5, 10, 17, 6, -23 },
  { 212, 11, 30, 17, 3, -24 },
  { 254, 11, 30, 17, 3, -24 },
  { 296, 14, 13, 17, 2, -21 },
  { 319, 15, 15, 17, 1, -16 },
  { 348, 8, 12, 17, 4, -6 },
  { 360, 9, 4, 17, 4, -11 },
  { 365, 7, 6, 17, 5, -6 },
  { 371, 13, 30, 17, 2, -24 },
  { 420, 15, 21, 17, 1, -21 },
  { 460, 14, 21, 17, 2, -21 },
  { 497, 15, 21, 17, 1, -21 },
  { 537, 14, 21, 17, 1, -21 },
  { 574, 15, 21, 17, 1, -21 },
  { 614, 14, 21, 17, 1, -21 },
  { 651, 13, 21, 17, 2, -21 },
  { 686, 13, 21, 17, 2, -21 },
  { 721, 15, 21, 17, 1, -21 },
  { 761, 14, 21, 17, 2, -21 },
  { 798, 7, 16, 17, 5, -16 },
  { 812, 8, 22, 17, 4, -16 },
  { 834, 14, 15, 17, 2, -16 },
  { 861, 15, 9, 17, 1, -14 },
  { 878, 15, 15, 17, 1, -16 },
  { 907, 13, 21, 17, 2, -21 },
  { 942, 15, 26, 17, 1, -21 },
  { 991, 17, 21, 17, 0, -21 },
  { 1036, 14, 21, 17, 2, -21 },
  { 1073, 15, 21, 17, 1, -21 },
  { 1113, 14, 21, 17, 2, -21 },
  { 1150, 14, 21, 17, 2, -21 },
  { 1187, 13, 21, 17, 2, -21 },
  { 1222, 15, 21, 17, 1, -21 },
  { 1262, 13, 21, 17, 2, -21 },
  { 1297, 13, 21, 17, 2, -21 },
  { 1332, 14, 21, 17, 1, -21 },
  { 1369, 15, 21, 17, 2, -21 },
  { 1409, 14, 21, 17, 2, -21 },
  { 1446, 15, 21, 17, 1, -21 },
  { 1486, 13, 21, 17, 2, -21 },
  { 1521, 15, 21, 17, 1, -21 },
  { 1561, 14, 21, 17, 2, -21 },
  { 1598, 15, 26, 17, 1, -21 },
  { 1647, 15, 21, 17, 2, -21 },
  { 1687, 15, 21, 17, 1, -21 },
  { 1727, 15, 21, 17, 1, -21 },
  { 1767, 15, 21, 17, 1, -21 },
  { 1807, 17, 21, 17, 0, -21 },
  { 1852, 15, 21, 17, 1, -21 },
  { 1892, 17, 21, 17, 0, -21 },
  { 1937, 17, 21, 17, 0, -21 },
  { 1982, 13, 21, 17, 2, -21 },
  { 2017, 9, 30, 17, 4, -24 },
  { 2051, 13, 30, 17, 2, -24 },
  { 2100, 9, 30, 17, 4, -24 },
  { 2134, 16, 10, 17, 1, -21 },
  { 2154, 17, 3, 17, 0, 3 },
  { 2161, 8, 6, 17, 5, -24 },
  { 2167, 14, 16, 17, 1, -16 },
  { 2195, 14, 23, 17, 2, -23 },
  { 2236, 15, 16, 17, 1, -16 },
  { 2266, 14, 23, 17, 1, -23 },
  { 2307, 15, 16, 17, 1, -16 },
  { 2337, 16, 23, 17, 1, -23 },
  { 2383, 14, 22, 17, 1, -16 },
  { 2422, 13, 23, 17, 2, -23 },
  { 2460, 15, 23, 17, 1, -23 },
  { 2504, 12, 29, 17, 2, -23 },
  { 2548, 15, 23, 17, 2, -23 },
  { 2592, 15, 23, 17, 1, -23 },
  { 2636, 15, 16, 17, 1, -16 },
  { 2666, 13, 16, 17, 2, -16 },
  { 2692, 15, 16, 17, 1, -16 },
  { 2722, 14, 22, 17, 2, -16 },
  { 2761, 14, 22, 17, 1, -16 },
  { 2800, 13, 16, 17, 3, -16 },
  { 2826, 13, 16, 17, 2, -16 },
  { 2852, 15, 21, 17, 1, -21 },
  { 2892, 13, 16, 17, 2, -16 },
  { 2918, 17, 16, 17, 0, -16 },
  { 2952, 17, 16, 17, 0, -16 },
  { 2986, 15, 16, 17, 1, -16 },
  { 3016, 15, 22, 17, 1, -16 },
  { 3058, 13, 16, 17, 2, -16 },
  { 3084, 13, 30, 17, 2, -24 },
  { 3133, 5, 30, 17, 6, -24 },
  { 3152, 13, 30, 17, 2, -24 },
  { 3201, 16, 6, 17, 1, -12 },
};

const GFXfont UbuntuMono_Bold34pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Bold34pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Bold34pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _UBUNTUMONO_BOLD34PT7B_H_
