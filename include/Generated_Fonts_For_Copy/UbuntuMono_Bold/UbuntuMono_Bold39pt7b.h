#ifndef _UBUNTUMONO_BOLD39PT7B_H_
#define _UBUNTUMONO_BOLD39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Bold.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Bold39pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xEF, 0xBE, 0xF9, 0xE7,
  0x80, 0x00, 0x07, 0xBF, 0xFF, 0xFF, 0xDE, 0x1C, 0xFF, 0xE7, 0xFE, 0x3F,
  0xF1, 0xFF, 0x8F, 0xBC, 0x7D, 0xE3, 0xEF, 0x0F, 0x78, 0x7B, 0xC3, 0x9C,
  0x1C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x8F,
  0x03, 0xC3, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1,
  0xE1, 0xE0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78,
  0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x7F, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE,
  0x7E, 0x07, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFF,
  0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7D, 0xE0, 0x7E, 0xFF, 0xFE, 0x7F, 0xFF,
  0x3F, 0xFF, 0x03, 0xFE, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x1E, 0x00, 0xEF, 0xE0, 0x39, 0xFE, 0x0F, 0x39, 0xC1, 0xCF, 0x38,
  0x71, 0xC7, 0x1E, 0x3C, 0xE3, 0x83, 0x9C, 0xE0, 0x7F, 0xBC, 0x0F, 0xE7,
  0x00, 0x79, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x78, 0x03, 0xDF, 0x80, 0xF7,
  0xF0, 0x1C, 0xEF, 0x07, 0xBC, 0xE1, 0xE7, 0x1C, 0x38, 0xE3, 0x8F, 0x1E,
  0x73, 0xC1, 0xDE, 0x70, 0x3F, 0x9E, 0x03, 0xF7, 0x80, 0x3C, 0x07, 0xC0,
  0x07, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3C, 0x7C, 0x1F, 0x0F, 0x03,
  0xC7, 0x80, 0xF1, 0xE0, 0x3E, 0xF8, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x7E,
  0x1E, 0x3F, 0xC7, 0x9F, 0xF9, 0xE7, 0xBE, 0x7B, 0xC7, 0xFC, 0xF0, 0xFF,
  0x3C, 0x1F, 0xCF, 0x03, 0xE3, 0xE1, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3,
  0xFF, 0x78, 0x3F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFD, 0xEF, 0x7B, 0xDE, 0xE0,
  0x00, 0x40, 0x0E, 0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xE0,
  0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80,
  0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xE0, 0x04, 0x20, 0x03, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F,
  0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x81, 0xFC, 0x0F, 0x80, 0x38, 0x01, 0x80, 0x00, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x63, 0xC6, 0x7B, 0x9E, 0xFD, 0xBE, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x0F, 0xF0, 0x1E, 0xF8, 0x3E, 0x7C, 0x3E,
  0x7C, 0x1C, 0x78, 0x0C, 0x20, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x1F, 0x8F, 0xC7, 0xE3, 0xF9, 0xF8,
  0x7C, 0x1E, 0x0F, 0x1F, 0x3F, 0x1F, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x3C, 0xFF, 0xFF, 0xFF, 0xEF, 0xCF, 0x00, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF,
  0xC3, 0xE3, 0xF3, 0xE0, 0xF9, 0xF0, 0x3E, 0xF0, 0x1F, 0x78, 0x07, 0xFC,
  0xE3, 0xFE, 0x79, 0xFF, 0x3C, 0xFF, 0x9E, 0x7F, 0xCE, 0x3F, 0xE0, 0x1E,
  0xF0, 0x0F, 0x78, 0x0F, 0xBE, 0x07, 0xDF, 0x07, 0xC7, 0xC7, 0xE3, 0xFF,
  0xE0, 0xFF, 0xF0, 0x3F, 0xF0, 0x07, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x07,
  0xE0, 0x1F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7B, 0xE0, 0x63,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x7F,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x0F, 0xC0, 0x3F, 0xF0, 0xFF,
  0xF8, 0xFF, 0xFC, 0x78, 0x7E, 0x60, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xC0, 0x7F, 0xF0, 0xFF,
  0xF8, 0x7F, 0xFC, 0x70, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0xE0, 0x7E, 0xFF,
  0xFC, 0xFF, 0xFC, 0xFF, 0xF0, 0x3F, 0xC0, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3E,
  0xF8, 0x0F, 0x3E, 0x07, 0x8F, 0x83, 0xE3, 0xE0, 0xF0, 0xF8, 0x78, 0x3E,
  0x1E, 0x0F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0xC0, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F,
  0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x1F, 0x60, 0x3F, 0x7F, 0xFE, 0x7F, 0xFC, 0xFF, 0xF8, 0x1F,
  0xE0, 0x00, 0x3C, 0x01, 0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xE0, 0x3F,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF,
  0xFE, 0xFF, 0xFE, 0xF8, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x3E, 0x7C, 0x3E, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x07, 0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE7, 0xE1, 0xF3,
  0xE0, 0x79, 0xF0, 0x3C, 0xF8, 0x1E, 0x7E, 0x1F, 0x1F, 0x9F, 0x07, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0xE1, 0xF7, 0xF9, 0xF0, 0x7C, 0xF0, 0x1F, 0x78,
  0x0F, 0xFC, 0x07, 0xDE, 0x03, 0xEF, 0xC3, 0xF7, 0xFF, 0xF1, 0xFF, 0xF8,
  0x7F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFC,
  0xFC, 0x7E, 0xF8, 0x3E, 0xF8, 0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFE, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x07, 0xF8, 0x7F, 0xF0, 0x7F, 0xC0,
  0x7F, 0x80, 0x7C, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xEF, 0xCF, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xCF, 0xFF, 0xFF, 0xFE, 0xFC, 0xF0, 0x1E, 0x3F, 0x7F,
  0x7F, 0x7F, 0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x3F, 0x7F,
  0x7F, 0x7F, 0x3F, 0x1F, 0x0F, 0x1E, 0x3E, 0xFC, 0xF0, 0xE0, 0x00, 0x06,
  0x00, 0x1E, 0x00, 0xFF, 0x03, 0xFF, 0x1F, 0xFE, 0x7F, 0xF0, 0xFF, 0x80,
  0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0x00, 0xFF, 0x00, 0x1E, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x40, 0x00, 0xF8, 0x00, 0xFE, 0x00,
  0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0x7F,
  0x03, 0xFF, 0x0F, 0xFE, 0x7F, 0xF0, 0xFF, 0xC0, 0xFE, 0x00, 0xF8, 0x00,
  0x40, 0x00, 0x1F, 0xC3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFE, 0x60, 0xFC, 0x01,
  0xF0, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F,
  0x80, 0x3C, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xC0, 0x03, 0xF8, 0x07, 0xFE,
  0x07, 0xFF, 0x87, 0xC1, 0xE3, 0xC0, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0xE0,
  0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xFC, 0x7C, 0xFE, 0x3C, 0x7F,
  0x1E, 0x3F, 0x9F, 0x1F, 0xCF, 0x8F, 0xE3, 0xC7, 0xF1, 0xE3, 0xF8, 0xF9,
  0xFE, 0x7F, 0xFF, 0x1F, 0xFB, 0x87, 0xFD, 0xE1, 0xFC, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xF0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0x78,
  0x01, 0xEF, 0x00, 0x3C, 0xF0, 0x07, 0x9E, 0x01, 0xE3, 0xC0, 0x3C, 0x7C,
  0x07, 0x87, 0x81, 0xF0, 0xF0, 0x3C, 0x1E, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x3F, 0xFF, 0x87, 0xFF, 0xF8, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C,
  0xF8, 0x07, 0xDF, 0x00, 0xFF, 0xC0, 0x1F, 0x7F, 0xC0, 0xFF, 0xF8, 0xFF,
  0xFC, 0xFF, 0xFE, 0xF8, 0x7E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8,
  0x3E, 0xF8, 0x7C, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFE, 0xF8,
  0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xE0, 0x01, 0xFC, 0x03, 0xFF, 0xC3,
  0xFF, 0xE3, 0xFF, 0xF3, 0xF8, 0x33, 0xF0, 0x09, 0xF0, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x47,
  0xE0, 0x73, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFC, 0x03, 0xF8, 0xFF, 0xC0,
  0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF8, 0x7E, 0xF8, 0x3E, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x3E,
  0xF8, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0x80, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF,
  0xBE, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0xC3,
  0xFF, 0xC3, 0xFF, 0xE3, 0xF8, 0x33, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xDF, 0x83, 0xE7,
  0xE1, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFE, 0x7F, 0xFC, 0xFF,
  0xF9, 0xFF, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7D, 0x00, 0xFB, 0x87, 0xEF, 0xFF, 0xDF, 0xFF,
  0x1F, 0xFC, 0x0F, 0xE0, 0xF8, 0x1F, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x0F,
  0x8F, 0x8F, 0xC7, 0xC7, 0xC3, 0xE7, 0xC1, 0xF7, 0xE0, 0xFB, 0xE0, 0x7F,
  0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xEF, 0xC1,
  0xF3, 0xF0, 0xF8, 0xF8, 0x7C, 0x7E, 0x3E, 0x1F, 0x9F, 0x07, 0xCF, 0x83,
  0xF7, 0xC0, 0xFB, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x78, 0x0F, 0x1F, 0x03, 0xC7, 0xC1, 0xF1, 0xF0,
  0x7C, 0x7E, 0x1F, 0x9F, 0x8F, 0xE7, 0xE3, 0xF9, 0xDC, 0xFE, 0x77, 0x7F,
  0x9D, 0xDD, 0xEF, 0x7F, 0x7B, 0xCF, 0xDE, 0xF3, 0xE7, 0xBC, 0xF9, 0xEF,
  0x1E, 0x7B, 0xC7, 0x9E, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xC0,
  0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F,
  0xFF, 0x1F, 0xFF, 0x1F, 0xF7, 0x9F, 0xF7, 0x9F, 0xF3, 0xDF, 0xF3, 0xDF,
  0xF1, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F,
  0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0x03, 0xF0,
  0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xE3, 0xF3, 0xE0, 0xF9, 0xF0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xBE, 0x07,
  0xDF, 0x07, 0xCF, 0xC7, 0xE3, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xF0, 0x07,
  0xE0, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x3F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x3F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xF8, 0xFF, 0xE0, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xE3, 0xF3,
  0xE0, 0xF9, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xBE, 0x07, 0xDF, 0x07, 0xEF, 0xC7, 0xE3, 0xFF, 0xF0, 0xFF, 0xF0,
  0x3F, 0xF0, 0x0F, 0xE0, 0x01, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x0F,
  0xF0, 0x03, 0xF8, 0x00, 0x38, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F,
  0xFF, 0x8F, 0x87, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0x3C, 0xF8, 0x3E,
  0x7C, 0x1F, 0x3E, 0x1F, 0x9F, 0xFF, 0xCF, 0xFF, 0xC7, 0xFF, 0x83, 0xFF,
  0xC1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x3E, 0x3E, 0x1F, 0x9F, 0x07, 0xCF,
  0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x1F, 0x07, 0xF0, 0x1F, 0xFE,
  0x7F, 0xFC, 0x7F, 0xFC, 0xFC, 0x0C, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x40, 0x1F, 0xF0, 0x3F,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xF8, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3E, 0x7F, 0xFE, 0x7F, 0xFC, 0x3F, 0xF8,
  0x0F, 0xE0, 0x7C, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x03, 0xE7,
  0xC0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3C, 0x1E, 0x0F, 0x83,
  0xC1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x3E, 0x03,
  0xE7, 0x80, 0x7C, 0xF0, 0x07, 0x9E, 0x00, 0xF7, 0x80, 0x1F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01,
  0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF1, 0xE7, 0xBC, 0x79, 0xEF, 0x3E, 0x7B,
  0xCF, 0x9E, 0xF3, 0xF7, 0xBC, 0xFD, 0xE7, 0x77, 0x79, 0xDC, 0xFE, 0x77,
  0x3F, 0x9F, 0x8F, 0xE7, 0xE3, 0xF9, 0xF8, 0x7E, 0x7C, 0x1F, 0x9F, 0x07,
  0xC7, 0xC0, 0xF1, 0xE0, 0x3C, 0x7C, 0x03, 0xC7, 0xC0, 0xF8, 0xF8, 0x1E,
  0x0F, 0x87, 0xC1, 0xF1, 0xF0, 0x1F, 0x3E, 0x03, 0xEF, 0x80, 0x3F, 0xF0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3D, 0xF0, 0x0F, 0x9F, 0x01, 0xF3, 0xE0,
  0x7C, 0x3E, 0x0F, 0x87, 0xC3, 0xE0, 0xFC, 0x7C, 0x0F, 0x9F, 0x01, 0xF3,
  0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x79, 0xF0, 0x1F, 0x1F, 0x03, 0xE3,
  0xE0, 0x78, 0x3E, 0x1F, 0x07, 0xC3, 0xC0, 0x78, 0xF8, 0x0F, 0x9F, 0x00,
  0xF3, 0xC0, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xFC,
  0x07, 0xCF, 0x81, 0xF3, 0xE0, 0xF8, 0x7C, 0x7C, 0x1F, 0x1F, 0x03, 0xEF,
  0x80, 0xFD, 0xE0, 0x1E, 0x10, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x20, 0x70, 0x7C, 0xFE, 0x3F, 0x0F, 0x02,
  0x1F, 0xE0, 0x7F, 0xF0, 0xFF, 0xF1, 0xFF, 0xF2, 0x07, 0xE0, 0x07, 0xC0,
  0x07, 0x87, 0xFF, 0x3F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x01,
  0xFF, 0x03, 0xFF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0x1F, 0xF0, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFB, 0xF0, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFE,
  0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3E, 0xFF, 0xFE, 0xFF, 0xFC,
  0xFF, 0xF8, 0x3F, 0xE0, 0x03, 0xFC, 0x0F, 0xFF, 0x3F, 0xFE, 0x7F, 0xFE,
  0x7E, 0x02, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x01, 0x7F, 0xFF, 0x3F, 0xFF,
  0x0F, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x07, 0xDF,
  0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7C, 0x3F, 0xFC, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x1F,
  0x7E, 0x1F, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xFC, 0x03, 0xF0,
  0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xE1, 0xF3, 0xE0, 0x7F, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x18, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x07, 0xE0,
  0x81, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x3F, 0xFF, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x83, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x7E, 0x1F,
  0x7C, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0x7C, 0x1F, 0x7E, 0x1F, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xDF,
  0x00, 0x1F, 0x00, 0x1F, 0x60, 0x3E, 0x7F, 0xFE, 0x7F, 0xFC, 0x7F, 0xF8,
  0x1F, 0xE0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0xE7, 0xFF,
  0xEF, 0xFF, 0xDF, 0x0F, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xF8, 0x07, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x86, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x1F, 0x80, 0x00, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xD0, 0x1E, 0x70, 0xF9, 0xFF, 0xEF, 0xFF, 0x3F, 0xF8, 0x1F,
  0xC0, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x1F, 0xBE, 0x0F,
  0x9F, 0x0F, 0x8F, 0x8F, 0x87, 0xCF, 0x83, 0xE7, 0x81, 0xF7, 0xC0, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0x7E, 0x0F, 0x9F, 0x07, 0xC7, 0xC3,
  0xE1, 0xF1, 0xF0, 0xFC, 0xF8, 0x3E, 0x7C, 0x0F, 0xBE, 0x07, 0xE0, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x86,
  0x07, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xC0, 0x3F, 0x3E, 0x7F,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x7F, 0x8F, 0x3F, 0xC7, 0x9F,
  0xE3, 0xCF, 0xF1, 0xE7, 0xF8, 0xF3, 0xFC, 0x79, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xC0,
  0x3F, 0xE1, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0x87, 0xFF, 0x07, 0xFE,
  0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83,
  0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7C, 0x03, 0xF0,
  0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xE1, 0xF3, 0xE0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xF7,
  0xC0, 0xFB, 0xF0, 0xF8, 0xFF, 0xFC, 0x3F, 0xFC, 0x0F, 0xFC, 0x01, 0xF8,
  0x00, 0x3F, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF8, 0x7E, 0xF8,
  0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFB,
  0xF0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x03, 0xFC, 0x0F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x7E, 0x1F, 0x7C,
  0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0x7C, 0x1F, 0x7E, 0x3F, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x07,
  0xDF, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x0F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x5F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x07,
  0xF8, 0x3F, 0xF9, 0xFF, 0xF3, 0xFF, 0xE7, 0xC0, 0xCF, 0x00, 0x1F, 0x00,
  0x3F, 0xC0, 0x3F, 0xF0, 0x3F, 0xF8, 0x0F, 0xF8, 0x03, 0xF0, 0x03, 0xEE,
  0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF8, 0x3F, 0xC0, 0x01, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01,
  0xF0, 0x20, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x03, 0xFC, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0xC3, 0xEF, 0x87,
  0xDF, 0xFF, 0x9F, 0xFF, 0x1F, 0xFE, 0x1F, 0xF0, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x1F, 0x07, 0xC3, 0xC1, 0xF0,
  0xF8, 0x78, 0x3E, 0x3E, 0x07, 0x8F, 0x81, 0xF7, 0xC0, 0x3D, 0xF0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x8F,
  0x1E, 0xF1, 0xE3, 0xDE, 0x7C, 0x73, 0xCF, 0x8E, 0x79, 0xF9, 0xCF, 0x3F,
  0x78, 0xEF, 0xEF, 0x1D, 0xDF, 0xE3, 0xB9, 0xF8, 0x7F, 0x3F, 0x0F, 0xC7,
  0xE0, 0xF8, 0x7C, 0x1E, 0x0F, 0x83, 0xC1, 0xE0, 0xF8, 0x0F, 0x9F, 0x03,
  0xE3, 0xE1, 0xF0, 0xF8, 0xF8, 0x1F, 0x3C, 0x03, 0xFF, 0x00, 0x7F, 0x80,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F,
  0x7C, 0x07, 0x8F, 0x83, 0xE1, 0xF1, 0xF0, 0x7C, 0x78, 0x0F, 0xBE, 0x03,
  0xF0, 0x7C, 0x0F, 0xBE, 0x07, 0xDF, 0x03, 0xEF, 0x81, 0xE3, 0xE1, 0xF1,
  0xF0, 0xF8, 0xF8, 0x7C, 0x3E, 0x3C, 0x1F, 0x3E, 0x07, 0x9F, 0x03, 0xEF,
  0x01, 0xF7, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x08, 0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x03,
  0xFC, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7C, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xF0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xFF, 0xC1, 0xFF, 0x81, 0xFF,
  0x00, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x7F, 0x80, 0x3F, 0x00, 0x7E, 0x03, 0xFC, 0x07, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF,
  0x00, 0x1E, 0x03, 0x0F, 0xE0, 0xF7, 0xFE, 0x7D, 0xFF, 0xFE, 0xFF, 0xFF,
  0xBC, 0x7F, 0xCF, 0x07, 0xF0, 0x80, 0xF8,
};

const GFXglyph UbuntuMono_Bold39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 6, 24, 20, 7, -24 },
  { 19, 13, 11, 20, 3, -27 },
  { 37, 18, 24, 20, 1, -24 },
  { 91, 17, 31, 20, 1, -27 },
  { 157, 19, 24, 20, 0, -24 },
  { 214, 18, 24, 20, 1, -24 },
  { 268, 5, 12, 20, 7, -27 },
  { 276, 12, 34, 20, 4, -28 },
  { 327, 13, 34, 20, 3, -28 },
  { 383, 16, 15, 20, 2, -24 },
  { 413, 16, 18, 20, 2, -18 },
  { 449, 9, 13, 20, 5, -7 },
  { 464, 11, 5, 20, 4, -12 },
  { 471, 7, 7, 20, 6, -7 },
  { 478, 16, 33, 20, 2, -27 },
  { 544, 17, 24, 20, 1, -24 },
  { 595, 16, 24, 20, 2, -24 },
  { 643, 16, 24, 20, 2, -24 },
  { 691, 16, 24, 20, 2, -24 },
  { 739, 18, 24, 20, 1, -24 },
  { 793, 16, 24, 20, 1, -24 },
  { 841, 16, 24, 20, 2, -24 },
  { 889, 16, 24, 20, 2, -24 },
  { 937, 17, 24, 20, 1, -24 },
  { 988, 16, 24, 20, 2, -24 },
  { 1036, 7, 19, 20, 6, -19 },
  { 1053, 8, 25, 20, 5, -19 },
  { 1078, 16, 16, 20, 2, -18 },
  { 1110, 16, 12, 20, 2, -16 },
  { 1134, 16, 16, 20, 2, -18 },
  { 1166, 14, 24, 20, 3, -24 },
  { 1208, 17, 29, 20, 1, -24 },
  { 1270, 19, 24, 20, 0, -24 },
  { 1327, 16, 24, 20, 2, -24 },
  { 1375, 17, 24, 20, 1, -24 },
  { 1426, 16, 24, 20, 2, -24 },
  { 1474, 16, 24, 20, 2, -24 },
  { 1522, 15, 24, 20, 2, -24 },
  { 1567, 17, 24, 20, 1, -24 },
  { 1618, 16, 24, 20, 2, -24 },
  { 1666, 15, 24, 20, 2, -24 },
  { 1711, 15, 24, 20, 2, -24 },
  { 1756, 17, 24, 20, 2, -24 },
  { 1807, 15, 24, 20, 3, -24 },
  { 1852, 18, 24, 20, 1, -24 },
  { 1906, 16, 24, 20, 2, -24 },
  { 1954, 17, 24, 20, 1, -24 },
  { 2005, 16, 24, 20, 2, -24 },
  { 2053, 17, 30, 20, 1, -24 },
  { 2117, 17, 24, 20, 2, -24 },
  { 2168, 16, 24, 20, 2, -24 },
  { 2216, 18, 24, 20, 1, -24 },
  { 2270, 16, 24, 20, 2, -24 },
  { 2318, 19, 24, 20, 0, -24 },
  { 2375, 18, 24, 20, 1, -24 },
  { 2429, 19, 24, 20, 0, -24 },
  { 2486, 19, 24, 20, 0, -24 },
  { 2543, 16, 24, 20, 2, -24 },
  { 2591, 11, 33, 20, 4, -27 },
  { 2637, 16, 33, 20, 2, -27 },
  { 2703, 11, 33, 20, 4, -27 },
  { 2749, 18, 13, 20, 1, -24 },
  { 2779, 19, 4, 20, 0, 2 },
  { 2789, 8, 7, 20, 6, -27 },
  { 2796, 15, 18, 20, 2, -18 },
  { 2830, 16, 27, 20, 2, -27 },
  { 2884, 16, 18, 20, 2, -18 },
  { 2920, 16, 27, 20, 1, -27 },
  { 2974, 17, 18, 20, 1, -18 },
  { 3013, 18, 27, 20, 1, -27 },
  { 3074, 16, 24, 20, 1, -18 },
  { 3122, 15, 27, 20, 2, -27 },
  { 3173, 17, 27, 20, 1, -27 },
  { 3231, 14, 33, 20, 2, -27 },
  { 3289, 17, 27, 20, 2, -27 },
  { 3347, 17, 27, 20, 1, -27 },
  { 3405, 17, 18, 20, 1, -18 },
  { 3444, 15, 18, 20, 2, -18 },
  { 3478, 17, 18, 20, 1, -18 },
  { 3517, 16, 24, 20, 2, -18 },
  { 3565, 16, 24, 20, 1, -18 },
  { 3613, 15, 18, 20, 3, -18 },
  { 3647, 15, 18, 20, 2, -18 },
  { 3681, 17, 23, 20, 1, -23 },
  { 3730, 15, 18, 20, 2, -18 },
  { 3764, 18, 18, 20, 1, -18 },
  { 3805, 19, 18, 20, 0, -18 },
  { 3848, 18, 18, 20, 1, -18 },
  { 3889, 17, 24, 20, 1, -18 },
  { 3940, 14, 18, 20, 3, -18 },
  { 3972, 15, 33, 20, 2, -27 },
  { 4034, 5, 33, 20, 7, -27 },
  { 4055, 15, 33, 20, 2, -27 },
  { 4117, 18, 8, 20, 1, -14 },
};

const GFXfont UbuntuMono_Bold39pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Bold39pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Bold39pt7bGlyphs,
  0x20, 0x7E, 39
};

#endif // _UBUNTUMONO_BOLD39PT7B_H_
