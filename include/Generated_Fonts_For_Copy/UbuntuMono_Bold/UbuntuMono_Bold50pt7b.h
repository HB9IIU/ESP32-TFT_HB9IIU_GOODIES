#ifndef _UBUNTUMONO_BOLD50PT7B_H_
#define _UBUNTUMONO_BOLD50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Bold.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Bold50pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x1F, 0x8F, 0x87, 0xC3,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0xDF, 0xFF, 0xFF, 0xFD, 0xFC,
  0x7C, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFB,
  0xF1, 0xFD, 0xF8, 0xFC, 0xFC, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07,
  0xCF, 0x83, 0xE3, 0xC1, 0xF1, 0xE0, 0x70, 0x01, 0xF0, 0xF8, 0x03, 0xE1,
  0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x7C, 0x3F,
  0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x7C, 0x01,
  0xF0, 0xF8, 0x07, 0xC3, 0xF0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x83, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x8F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x7E, 0x3F, 0x00, 0xF8, 0x7C,
  0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x1F, 0xE0, 0x38, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF6, 0x00, 0x3F, 0xBE, 0x03, 0xFD, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xE3, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0xE0, 0x07, 0xCF, 0xF8, 0x07, 0xCF, 0xFC, 0x03, 0xC7, 0x9E,
  0x03, 0xE3, 0xCF, 0x83, 0xE1, 0xE3, 0xC1, 0xE1, 0xE1, 0xE1, 0xF0, 0x70,
  0xF0, 0xF0, 0x3C, 0x78, 0xF0, 0x1E, 0x7C, 0xF8, 0x0F, 0x3C, 0x78, 0x07,
  0xFE, 0x78, 0x01, 0xFF, 0x7C, 0x00, 0xFF, 0x3C, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x7F, 0x80, 0x1F, 0x7F,
  0xC0, 0x0F, 0x3F, 0xF0, 0x0F, 0x1E, 0x78, 0x0F, 0x9E, 0x3C, 0x07, 0x8F,
  0x1E, 0x07, 0x87, 0x8F, 0x07, 0xC3, 0xC7, 0x83, 0xC1, 0xE3, 0xC3, 0xE0,
  0xF1, 0xE3, 0xE0, 0x3C, 0xF1, 0xE0, 0x1F, 0xF9, 0xF0, 0x0F, 0xF9, 0xF0,
  0x03, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xF1, 0xF8, 0x0F,
  0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x00, 0x7C,
  0x7E, 0x00, 0xFD, 0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFE,
  0x1E, 0x07, 0xF8, 0x3E, 0x1F, 0xF8, 0x7C, 0x7F, 0xF8, 0xF9, 0xFB, 0xFB,
  0xF3, 0xE3, 0xF7, 0xCF, 0xC3, 0xFF, 0x9F, 0x03, 0xFF, 0x3E, 0x03, 0xFC,
  0x7C, 0x07, 0xF8, 0xFC, 0x07, 0xF1, 0xF8, 0x0F, 0xE1, 0xF8, 0x7F, 0xE3,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x83, 0xFF, 0x1F, 0x81,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x7C, 0xF9, 0xF3,
  0xE7, 0xC7, 0x8E, 0x00, 0x00, 0x08, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0xFE,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x7E, 0x00, 0x3C, 0x00, 0x08, 0x10, 0x00, 0x3C, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x10, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x03, 0x0F, 0x82, 0x1E, 0x7C, 0x79,
  0xF9, 0xEF, 0xCF, 0xFE, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xF0, 0x01, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xEF, 0x80, 0x3F, 0x7E, 0x03,
  0xF9, 0xF8, 0x1F, 0x8F, 0xE0, 0x7C, 0x7C, 0x01, 0xC1, 0xC0, 0x06, 0x04,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x83, 0xF8, 0x7F, 0x9F, 0xF3, 0xFE, 0x3F, 0xC7, 0xF8,
  0xFF, 0x07, 0xE0, 0x7C, 0x0F, 0x03, 0xE3, 0xF9, 0xFE, 0x1F, 0x83, 0xE0,
  0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x3E, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0,
  0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xC7, 0xF1, 0xF8, 0x1F, 0xCF, 0xC0,
  0x7E, 0x7C, 0x01, 0xF7, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x38, 0x7F, 0xE3, 0xE3, 0xFF, 0x1F, 0x1F, 0xF8, 0xF8,
  0xFF, 0xC7, 0xC7, 0xFE, 0x3E, 0x3F, 0xF0, 0xE1, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0x7C, 0x01, 0xF3, 0xF0, 0x1F,
  0x9F, 0xC1, 0xFC, 0x7F, 0x1F, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xF3, 0xF0, 0x0E, 0x1F, 0x80,
  0x40, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x0F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0xF8, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0x0F, 0xF0, 0xE0, 0x1F, 0x82,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x1E, 0x0F, 0xF0, 0x40, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x90, 0x01, 0xFC, 0xE0, 0x1F, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xEF,
  0xC0, 0x0F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF0, 0xFC,
  0x07, 0xE1, 0xF8, 0x0F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0xC1,
  0xF0, 0x1F, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE1, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x03, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x70, 0x1F, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03,
  0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x60, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0x9F, 0xF7, 0xE0, 0x3F, 0xBF, 0x00, 0xFD,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0,
  0x7F, 0x7E, 0x03, 0xF3, 0xF8, 0x1F, 0x8F, 0xE1, 0xFC, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x3F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x3F,
  0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0x83, 0xF9,
  0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7C, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x80,
  0xFC, 0xFE, 0x07, 0xE7, 0xF8, 0x7E, 0x1F, 0xF7, 0xF0, 0x7F, 0xFF, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xCF, 0xF8, 0xFC, 0x1F,
  0xE7, 0xE0, 0x7F, 0x7E, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xE7, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE,
  0x3F, 0x87, 0xF1, 0xF8, 0x1F, 0xCF, 0xC0, 0x7E, 0xFC, 0x03, 0xF7, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xBF, 0x00, 0xFD,
  0xFC, 0x07, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x06, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xFC,
  0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0x3E,
  0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFC, 0x7C, 0x0F, 0x83, 0xF8, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF8,
  0xFE, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x1F, 0xC7, 0xF8, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xC7, 0xF8, 0x7F, 0x03,
  0xC0, 0xF8, 0x3E, 0x1F, 0xCF, 0xF1, 0xFC, 0x3E, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x07, 0x80, 0x00, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x81,
  0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x20, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x80, 0x7F,
  0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x10, 0x00, 0x00, 0x07, 0xF8,
  0x07, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0x70, 0x3F,
  0x88, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x3F, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x7F,
  0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xC1, 0xF8, 0x7C, 0x03, 0xE3, 0xE0, 0x07,
  0xCF, 0x80, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x3F, 0xF7, 0x83, 0xFF, 0xDE,
  0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xC7, 0xFE, 0x3E,
  0x1F, 0xF9, 0xF8, 0x7F, 0xC7, 0xE1, 0xFF, 0x1F, 0x87, 0xFC, 0x7E, 0x1F,
  0xF1, 0xF8, 0x7F, 0xC7, 0xE1, 0xFF, 0x8F, 0x87, 0xFE, 0x3E, 0x1F, 0xF8,
  0xFC, 0x7F, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xDE, 0x0F, 0xFF, 0x7C, 0x1F,
  0xFD, 0xF0, 0x1F, 0xE3, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0x00, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xE0, 0x01, 0xFB, 0xF0,
  0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F,
  0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0,
  0xFC, 0x03, 0xF0, 0x7E, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0x00, 0x7E, 0x1F,
  0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x8F, 0xE0, 0x0F, 0xE7, 0xE0, 0x07, 0xF3,
  0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0x3F, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xC1, 0xFE, 0xFC, 0x0F, 0xEF,
  0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0xFC,
  0xFC, 0x1F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFE, 0xFC, 0x0F, 0xEF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x07, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0xC0, 0xE1, 0xFC, 0x00,
  0x8F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x87, 0xF8, 0x0E, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x3F, 0xC0,
  0x7F, 0xE0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x7E, 0x1F, 0xE3, 0xF0, 0x3F, 0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xF7,
  0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0xFF, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x1F,
  0xDF, 0x80, 0xFE, 0xFC, 0x0F, 0xE7, 0xE0, 0xFF, 0x3F, 0x0F, 0xF1, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFC, 0x00,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFB, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xC1,
  0xE1, 0xFC, 0x00, 0x8F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xDF,
  0xC0, 0x3F, 0x7F, 0x00, 0xFC, 0xFE, 0x03, 0xF3, 0xF8, 0x0F, 0xC7, 0xF8,
  0x3F, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x00, 0x7F, 0xE0, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE2, 0x00, 0xFE, 0x3C, 0x1F, 0xE7, 0xFF,
  0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0xFC,
  0x03, 0xFB, 0xF0, 0x0F, 0xEF, 0xC0, 0x7F, 0x3F, 0x01, 0xFC, 0xFC, 0x0F,
  0xE3, 0xF0, 0x7F, 0x0F, 0xC1, 0xFC, 0x3F, 0x0F, 0xE0, 0xFC, 0x3F, 0x03,
  0xF1, 0xFC, 0x0F, 0xCF, 0xE0, 0x3F, 0x7F, 0x00, 0xFD, 0xF8, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xF7, 0xF8,
  0x0F, 0xCF, 0xF0, 0x3F, 0x1F, 0xC0, 0xFC, 0x3F, 0x83, 0xF0, 0xFF, 0x0F,
  0xC1, 0xFC, 0x3F, 0x03, 0xF8, 0xFC, 0x0F, 0xF3, 0xF0, 0x1F, 0xCF, 0xC0,
  0x3F, 0xBF, 0x00, 0xFE, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F,
  0xC0, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3E, 0x00, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1,
  0xF8, 0x0F, 0xC3, 0xF0, 0x3F, 0x8F, 0xF0, 0x7F, 0x1F, 0xE0, 0xFF, 0x3F,
  0xC3, 0xFE, 0x7F, 0xC7, 0xFC, 0xFF, 0x8F, 0xF9, 0xF7, 0x3D, 0xF3, 0xEF,
  0x7B, 0xE7, 0xDE, 0xF7, 0xCF, 0xBF, 0xEF, 0x9F, 0x3F, 0x9F, 0x3E, 0x7F,
  0x3E, 0x7C, 0xFE, 0x7C, 0xF8, 0xF8, 0xF9, 0xF1, 0xF1, 0xF3, 0xE3, 0xE3,
  0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0x80, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE3, 0xFF, 0xDF, 0x1F, 0xFE, 0xFC, 0xFF, 0xF3, 0xE7,
  0xFF, 0x8F, 0xBF, 0xFC, 0x7D, 0xFF, 0xE1, 0xEF, 0xFF, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xF0, 0xFF,
  0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9,
  0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xDF, 0xC0, 0x1F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80,
  0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0x7E, 0x03, 0xF0, 0xFC, 0x07,
  0xE1, 0xFC, 0x3F, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7E, 0x07, 0xFB, 0xF0, 0x1F,
  0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x1F, 0xDF, 0x83, 0xFE,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF,
  0x80, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xF0, 0xFF, 0x0F,
  0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8,
  0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xDF, 0xC0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F,
  0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1,
  0xFC, 0x3F, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x38, 0x3F, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7E, 0x1F, 0xF3, 0xF0, 0x3F, 0x9F, 0x80,
  0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF,
  0xC0, 0x7E, 0x7E, 0x07, 0xF3, 0xF0, 0xFF, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF,
  0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xC7, 0xF0, 0x7E,
  0x1F, 0x83, 0xF0, 0xFE, 0x1F, 0x83, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7F,
  0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0,
  0x0F, 0xFF, 0x80, 0x3F, 0x01, 0xFE, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xF8,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xC0, 0xE1, 0xF8, 0x01, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC8, 0x00, 0xFE, 0xF8, 0x1F, 0xE7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xFB, 0xF0, 0x1F, 0x9F, 0xC1, 0xFC,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F,
  0x80, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x07,
  0xF7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7E,
  0x3F, 0x01, 0xFC, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC1,
  0xF0, 0x1F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x0F,
  0x83, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x3E, 0x3F, 0x00, 0x7C,
  0x7C, 0x00, 0xFD, 0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xF7, 0xC0, 0x03, 0xEF,
  0x80, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xF9,
  0xF0, 0x01, 0xF3, 0xE3, 0xE3, 0xE7, 0xC7, 0xC7, 0xCF, 0x8F, 0x8F, 0x9F,
  0x3F, 0x9F, 0x3E, 0x7F, 0x3E, 0x7C, 0xFE, 0x7C, 0xFB, 0xFE, 0xF9, 0xF7,
  0xBD, 0xF3, 0xEF, 0x7B, 0xE7, 0xDE, 0x77, 0xCF, 0xF8, 0xFF, 0x9F, 0xF1,
  0xFF, 0x3F, 0xE1, 0xFE, 0x7F, 0x83, 0xFC, 0xFF, 0x07, 0xF8, 0xFE, 0x0F,
  0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0x80, 0x3E,
  0x00, 0xFE, 0x00, 0xFE, 0xFC, 0x01, 0xF9, 0xFC, 0x07, 0xF1, 0xF8, 0x0F,
  0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x7E, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0,
  0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x7E,
  0xFE, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x83,
  0xF8, 0x7F, 0x03, 0xF0, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE7, 0xE0, 0x0F,
  0xDF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0xFD, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xF0, 0x0F, 0xC7, 0xE0, 0x3F,
  0x0F, 0xC0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x87, 0xE0,
  0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x07, 0xEF, 0xC0, 0x07, 0xE7, 0xE0, 0x0F, 0xC7, 0xE0,
  0x1F, 0xC3, 0xF0, 0x1F, 0x83, 0xF8, 0x3F, 0x81, 0xF8, 0x7F, 0x01, 0xFC,
  0x7E, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0x3C, 0x00, 0x7C, 0x0C, 0x00, 0x20,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x20, 0x07, 0x01, 0xF0, 0x7F, 0x8F, 0xF8, 0xFF,
  0x87, 0xF0, 0x3C, 0x01, 0x80, 0x07, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0x7F, 0x03, 0xF7, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x3F, 0xF8, 0x1C, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x3F, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF,
  0xFF, 0x9F, 0xC1, 0xFC, 0xFC, 0x07, 0xF7, 0xE0, 0x3F, 0xBF, 0x00, 0xFD,
  0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80,
  0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xEF,
  0xC0, 0x7F, 0x7E, 0x03, 0xF3, 0xF0, 0x3F, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xC7, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xF0,
  0x18, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFE, 0x01, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x03, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7E, 0xFE, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xF0, 0xFF,
  0x7F, 0x03, 0xFB, 0xF0, 0x1F, 0xDF, 0x80, 0xFE, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFB,
  0xF0, 0x1F, 0xDF, 0x80, 0xFE, 0xFC, 0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0x81,
  0xFC, 0xFF, 0x0F, 0xE7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xC3, 0xF9, 0xF8, 0x0F, 0xDF,
  0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x06,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0x03, 0x81, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xFF,
  0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xF8, 0x3F, 0x7F, 0x03,
  0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0x3F, 0x7F, 0x07, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xE4, 0x00, 0x7E, 0x78, 0x1F, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF,
  0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x1C, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF7, 0xF0, 0x7F, 0xFF,
  0x8F, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xF0, 0xFE, 0xFC, 0x0F,
  0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x0C, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3,
  0xFF, 0xFC, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x20, 0x1F, 0xCF, 0x0F, 0xE7, 0xFF, 0xF9, 0xFF, 0xFC, 0x7F, 0xFF,
  0x0F, 0xFF, 0x80, 0x7F, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x0F,
  0xEF, 0xC0, 0xFE, 0x7E, 0x0F, 0xE3, 0xF0, 0x7F, 0x1F, 0x87, 0xF0, 0xFC,
  0x7F, 0x07, 0xE3, 0xF0, 0x3F, 0x3F, 0x01, 0xFB, 0xF0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFD, 0xFC, 0x07, 0xE7,
  0xF0, 0x3F, 0x1F, 0xC1, 0xF8, 0x7F, 0x0F, 0xC3, 0xF8, 0x7E, 0x0F, 0xE3,
  0xF0, 0x3F, 0x9F, 0x81, 0xFC, 0xFC, 0x07, 0xF7, 0xE0, 0x1F, 0xFF, 0x00,
  0xFE, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x0C, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xF8, 0x1F, 0xC3, 0xE1,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF,
  0x1F, 0x8F, 0xBE, 0x1F, 0x1F, 0x7C, 0x3E, 0x3E, 0xF8, 0x7C, 0x3F, 0xF0,
  0xF8, 0x7F, 0xE1, 0xF0, 0xFF, 0xC3, 0xE1, 0xFF, 0x87, 0xC3, 0xFF, 0x0F,
  0x87, 0xFE, 0x1F, 0x0F, 0xFC, 0x3E, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0x0F, 0xF8, 0x1F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xF8, 0x3F, 0xBF,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x07,
  0xF8, 0x7F, 0x0F, 0xC0, 0x7E, 0x3F, 0x80, 0xFE, 0x7E, 0x00, 0xFC, 0xFC,
  0x01, 0xF9, 0xF8, 0x03, 0xF7, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xDF, 0x80, 0x3F, 0xBF, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01,
  0xF9, 0xFC, 0x07, 0xF1, 0xF8, 0x0F, 0xC3, 0xF8, 0x7F, 0x83, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xCF, 0xC1, 0xFE, 0xFC, 0x0F, 0xEF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7E, 0xFE, 0x0F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8,
  0xFF, 0xFF, 0x0F, 0xCF, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x7F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7,
  0xF8, 0x3F, 0x7F, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0,
  0x3F, 0x7F, 0x07, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0x3F, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x03, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFD, 0xFC, 0x01,
  0xBF, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x01, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE7, 0xFF, 0xF8, 0xFE, 0x07,
  0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80,
  0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xA0, 0x03, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFC, 0x7F, 0xFF, 0x01, 0xFF, 0x00,
  0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x81, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x0F, 0xF8, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xF8,
  0x1F, 0xBF, 0x83, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0x7F,
  0xFF, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x03,
  0xFB, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xE0, 0x3F, 0x8F, 0xC0, 0x7E,
  0x1F, 0x80, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0,
  0xFE, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF9, 0xFC, 0x01, 0xFB, 0xF0, 0x03,
  0xF7, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x0F, 0x87, 0xFE, 0x1F, 0x0F, 0xFC, 0x3E, 0x1F,
  0xF8, 0x7E, 0x3F, 0xF1, 0xFC, 0x79, 0xE3, 0xF8, 0xF3, 0xC7, 0xF1, 0xE7,
  0x8F, 0xF3, 0xCF, 0xBD, 0xEF, 0x9F, 0x7B, 0xDF, 0x3E, 0xF7, 0xBE, 0x7F,
  0xCF, 0xF8, 0x7F, 0x8F, 0xF0, 0xFF, 0x1F, 0xE1, 0xFC, 0x3F, 0xC3, 0xF8,
  0x3F, 0x87, 0xF0, 0x7E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0xFE, 0x00,
  0xFC, 0xFE, 0x01, 0xF8, 0xFC, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xFC, 0x3F,
  0x01, 0xF8, 0xFC, 0x01, 0xFB, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xEF, 0xE0, 0x1F,
  0x8F, 0xC0, 0x7F, 0x1F, 0xC0, 0xFC, 0x1F, 0xC3, 0xF0, 0x1F, 0x8F, 0xE0,
  0x3F, 0x9F, 0x80, 0x3F, 0x7F, 0x00, 0x7F, 0x7E, 0x00, 0xFC, 0xFE, 0x01,
  0xF9, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0x87, 0xF0, 0x3F,
  0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0,
  0x3F, 0x0F, 0xC0, 0x7F, 0x1F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01,
  0xFD, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x02, 0x0F, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF,
  0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xFF,
  0xF0, 0x3F, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xF8,
  0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0xF0,
  0x03, 0xFE, 0x00, 0x0F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF,
  0xF0, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x18, 0x3F, 0xE0,
  0x7C, 0xFF, 0xF1, 0xF9, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xBF, 0x1F, 0xFE, 0x7C, 0x0F, 0xF8, 0x18, 0x03, 0xE0,
};

const GFXglyph UbuntuMono_Bold50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 9, 32, 25, 8, -31 },
  { 37, 17, 14, 25, 4, -34 },
  { 67, 23, 31, 25, 1, -31 },
  { 157, 21, 40, 25, 2, -35 },
  { 262, 25, 33, 25, 0, -32 },
  { 366, 23, 32, 25, 1, -32 },
  { 458, 7, 15, 25, 9, -34 },
  { 472, 16, 43, 25, 5, -35 },
  { 558, 16, 43, 25, 4, -35 },
  { 644, 21, 20, 25, 2, -31 },
  { 697, 21, 23, 25, 2, -24 },
  { 758, 11, 17, 25, 6, -8 },
  { 782, 13, 6, 25, 6, -16 },
  { 792, 9, 9, 25, 8, -8 },
  { 803, 21, 43, 25, 2, -35 },
  { 916, 21, 33, 25, 2, -32 },
  { 1003, 21, 31, 25, 2, -31 },
  { 1085, 21, 32, 25, 2, -32 },
  { 1169, 21, 33, 25, 2, -32 },
  { 1256, 23, 31, 25, 1, -31 },
  { 1346, 20, 32, 25, 2, -31 },
  { 1426, 21, 32, 25, 2, -31 },
  { 1510, 21, 31, 25, 2, -31 },
  { 1592, 21, 33, 25, 2, -32 },
  { 1679, 21, 32, 25, 2, -32 },
  { 1763, 9, 24, 25, 8, -23 },
  { 1790, 11, 32, 25, 6, -23 },
  { 1834, 21, 22, 25, 2, -24 },
  { 1892, 21, 15, 25, 2, -20 },
  { 1932, 21, 22, 25, 2, -24 },
  { 1990, 19, 33, 25, 3, -32 },
  { 2069, 22, 39, 25, 1, -32 },
  { 2177, 25, 31, 25, 0, -31 },
  { 2274, 20, 33, 25, 3, -32 },
  { 2357, 22, 33, 25, 1, -32 },
  { 2448, 21, 32, 25, 3, -31 },
  { 2532, 20, 31, 25, 3, -31 },
  { 2610, 19, 31, 25, 3, -31 },
  { 2684, 22, 33, 25, 1, -32 },
  { 2775, 21, 31, 25, 2, -31 },
  { 2857, 19, 31, 25, 3, -31 },
  { 2931, 20, 32, 25, 2, -31 },
  { 3011, 22, 31, 25, 2, -31 },
  { 3097, 19, 31, 25, 4, -31 },
  { 3171, 23, 31, 25, 1, -31 },
  { 3261, 21, 31, 25, 2, -31 },
  { 3343, 23, 33, 25, 1, -32 },
  { 3438, 21, 32, 25, 3, -32 },
  { 3522, 23, 41, 25, 1, -32 },
  { 3640, 21, 32, 25, 3, -32 },
  { 3724, 21, 33, 25, 2, -32 },
  { 3811, 23, 31, 25, 1, -31 },
  { 3901, 21, 32, 25, 2, -31 },
  { 3985, 23, 31, 25, 1, -31 },
  { 4075, 23, 31, 25, 1, -31 },
  { 4165, 23, 31, 25, 1, -31 },
  { 4255, 23, 31, 25, 1, -31 },
  { 4345, 21, 31, 25, 2, -31 },
  { 4427, 14, 43, 25, 6, -35 },
  { 4503, 21, 43, 25, 2, -35 },
  { 4616, 14, 43, 25, 5, -35 },
  { 4692, 24, 16, 25, 1, -31 },
  { 4740, 25, 5, 25, 0, 3 },
  { 4756, 11, 9, 25, 8, -35 },
  { 4769, 20, 26, 25, 2, -25 },
  { 4834, 21, 36, 25, 3, -35 },
  { 4929, 21, 26, 25, 2, -25 },
  { 4998, 21, 36, 25, 1, -35 },
  { 5093, 21, 26, 25, 2, -25 },
  { 5162, 23, 35, 25, 2, -35 },
  { 5263, 20, 34, 25, 2, -25 },
  { 5348, 19, 35, 25, 3, -35 },
  { 5432, 21, 35, 25, 2, -34 },
  { 5524, 18, 43, 25, 2, -34 },
  { 5621, 21, 35, 25, 3, -35 },
  { 5713, 21, 35, 25, 2, -34 },
  { 5805, 23, 25, 25, 1, -25 },
  { 5877, 19, 25, 25, 3, -25 },
  { 5937, 23, 26, 25, 1, -25 },
  { 6012, 20, 33, 25, 3, -25 },
  { 6095, 20, 33, 25, 2, -25 },
  { 6178, 19, 25, 25, 4, -25 },
  { 6238, 19, 26, 25, 3, -25 },
  { 6300, 22, 32, 25, 2, -31 },
  { 6388, 19, 25, 25, 3, -24 },
  { 6448, 23, 24, 25, 1, -24 },
  { 6517, 23, 24, 25, 1, -24 },
  { 6586, 23, 24, 25, 1, -24 },
  { 6655, 23, 33, 25, 1, -24 },
  { 6750, 19, 24, 25, 3, -24 },
  { 6807, 19, 43, 25, 3, -35 },
  { 6910, 7, 43, 25, 9, -35 },
  { 6948, 19, 43, 25, 3, -35 },
  { 7051, 23, 9, 25, 1, -18 },
};

const GFXfont UbuntuMono_Bold50pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Bold50pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Bold50pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _UBUNTUMONO_BOLD50PT7B_H_
