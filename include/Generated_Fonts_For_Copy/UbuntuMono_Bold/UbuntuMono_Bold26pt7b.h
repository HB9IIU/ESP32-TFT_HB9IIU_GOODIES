#ifndef _UBUNTUMONO_BOLD26PT7B_H_
#define _UBUNTUMONO_BOLD26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Bold.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Bold26pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0x00, 0x3B, 0xEE, 0xF7,
  0xFB, 0xFD, 0xFE, 0x76, 0x33, 0x19, 0x8C, 0x0E, 0x70, 0x73, 0x03, 0x98,
  0x19, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0x98, 0x19, 0xC7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF3, 0x98, 0x19, 0xC0, 0xCE, 0x0E, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x0F, 0xE7, 0xFC, 0xFF, 0xBC, 0x17, 0x80, 0x7C, 0x0F, 0xE0, 0xFF,
  0x07, 0xF0, 0x1E, 0x01, 0xD0, 0x7F, 0xFF, 0xFF, 0xC7, 0xF0, 0x38, 0x07,
  0x00, 0xE0, 0x38, 0x3B, 0xE1, 0xBB, 0x19, 0x99, 0xCC, 0xCC, 0x76, 0xC1,
  0xFE, 0x07, 0x60, 0x06, 0xE0, 0x7F, 0x83, 0x6E, 0x33, 0x33, 0x99, 0x98,
  0xDD, 0x87, 0xDC, 0x1C, 0x1E, 0x07, 0xF0, 0x7F, 0x87, 0x38, 0x63, 0x87,
  0x70, 0x7E, 0x03, 0xCE, 0x7C, 0xEE, 0xEE, 0xC7, 0xCC, 0x3C, 0xE3, 0xCF,
  0xFC, 0x7F, 0xE3, 0xEE, 0xFF, 0xFF, 0xFB, 0x03, 0x03, 0x83, 0xC3, 0xC3,
  0xC1, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x0E, 0x03, 0x81, 0xC0,
  0xE0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x18, 0x60, 0x38, 0x1E, 0x07,
  0x81, 0xE0, 0x70, 0x1C, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x70, 0x38, 0x38,
  0x1C, 0x0E, 0x0E, 0x0F, 0x07, 0x0F, 0x07, 0x03, 0x00, 0x0E, 0x01, 0xC1,
  0xB9, 0x3A, 0xEF, 0xFE, 0x1C, 0x06, 0xE1, 0xDC, 0x3B, 0x82, 0x20, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0xF7, 0xCF, 0x3C, 0x73, 0xBC, 0x60,
  0xFF, 0xFF, 0xF8, 0x77, 0xFF, 0xF7, 0x00, 0x01, 0xE0, 0x38, 0x07, 0x01,
  0xE0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x01,
  0xE0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x01,
  0xE0, 0x00, 0x1F, 0x07, 0xF1, 0xFF, 0x38, 0xEE, 0x0F, 0xC1, 0xFB, 0xBF,
  0x77, 0xEE, 0xFC, 0x1F, 0x83, 0xF0, 0x77, 0x1C, 0xFF, 0x8F, 0xE0, 0xF8,
  0x07, 0x01, 0xE0, 0xFC, 0x7F, 0x87, 0x70, 0x8E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0xFF, 0xDF, 0xFB, 0xFF, 0x1F, 0x0F,
  0xF3, 0xFF, 0x31, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x1C, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x1F, 0xF1, 0xFF,
  0x31, 0xE0, 0x1C, 0x07, 0x87, 0xE0, 0xFC, 0x1F, 0xC0, 0x3C, 0x07, 0x80,
  0xF4, 0x1F, 0xFF, 0xBF, 0xE3, 0xF8, 0x03, 0xC0, 0xF8, 0x3F, 0x07, 0xE1,
  0xFC, 0x77, 0x9C, 0xF3, 0x9E, 0xE3, 0xDF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x3F, 0xC7, 0xF8, 0xFF, 0x18, 0x03, 0x00, 0xFC,
  0x1F, 0xE3, 0xFE, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xF8, 0x3D, 0xFF, 0xBF,
  0xE3, 0xF0, 0x03, 0xC1, 0xF8, 0x7F, 0x1F, 0x07, 0x80, 0xE0, 0x3F, 0xE7,
  0xFE, 0xFF, 0xDC, 0x3F, 0x83, 0xF8, 0x77, 0x1E, 0xFF, 0x8F, 0xE0, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x38, 0x0F,
  0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x1F, 0x07,
  0xF9, 0xFF, 0x78, 0xFE, 0x0F, 0xE3, 0x9E, 0x71, 0xFC, 0x3F, 0x8E, 0x7B,
  0x83, 0xF0, 0x7F, 0x1F, 0xFF, 0xDF, 0xF1, 0xF8, 0x1F, 0x07, 0xF1, 0xFF,
  0x78, 0xEE, 0x1F, 0xC1, 0xFC, 0x3B, 0xFF, 0x7F, 0xE7, 0xFC, 0x07, 0x01,
  0xE0, 0xF8, 0xFE, 0x1F, 0x83, 0xC0, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x77,
  0xFF, 0xF7, 0x00, 0x39, 0xF7, 0xDF, 0x38, 0x00, 0x00, 0x39, 0xF7, 0xDF,
  0x3C, 0x63, 0xBC, 0xC0, 0x00, 0x40, 0x7C, 0x3F, 0x9F, 0xCF, 0xC1, 0xE0,
  0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x7C, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x40, 0x1F, 0x03, 0xF8, 0x1F,
  0xE0, 0x7E, 0x03, 0xC1, 0xF9, 0xFC, 0xFE, 0x1F, 0x01, 0x00, 0x00, 0x7E,
  0x7F, 0xBF, 0xE8, 0xF0, 0x38, 0x1C, 0x1E, 0x1E, 0x1E, 0x1E, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0xF0, 0x78, 0x07, 0x81, 0xFE, 0x38, 0x63, 0x07, 0x70,
  0x76, 0x3F, 0x67, 0xF6, 0x7F, 0xEF, 0x7E, 0xE7, 0xEE, 0x76, 0xE7, 0x67,
  0x76, 0x7F, 0x67, 0xF7, 0x1E, 0x30, 0x03, 0xC0, 0x1F, 0xE0, 0x7F, 0x07,
  0x00, 0x7C, 0x03, 0xE0, 0x1B, 0x01, 0xDC, 0x0E, 0xE0, 0x67, 0x07, 0x1C,
  0x38, 0xE1, 0xFF, 0x0F, 0xF8, 0xFF, 0xE7, 0x07, 0x38, 0x39, 0xC1, 0xDE,
  0x0F, 0xFF, 0x1F, 0xFB, 0xFF, 0x78, 0xEF, 0x1D, 0xE3, 0xBF, 0xE7, 0xFC,
  0xFF, 0xFE, 0x3F, 0xC3, 0xF8, 0x7F, 0x1F, 0xFF, 0xFF, 0xF7, 0xF8, 0x0F,
  0xC7, 0xFD, 0xFF, 0xBC, 0x2F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x78, 0x07, 0x86, 0xFF, 0xCF, 0xF8, 0x7E, 0xFE, 0x1F, 0xF3,
  0xFF, 0x79, 0xEF, 0x1F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0xFF, 0x3D, 0xFF, 0xBF, 0xE7, 0xF0, 0xFF, 0xBF, 0xEF, 0xFB, 0x80,
  0xE0, 0x38, 0x0F, 0xFB, 0xFE, 0xFF, 0xB8, 0x0E, 0x03, 0x80, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x0F, 0xE7, 0xFD,
  0xFF, 0xBC, 0x2F, 0x01, 0xC0, 0x38, 0x07, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF8, 0x77, 0x8E, 0xFF, 0xCF, 0xF8, 0x7F, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE1, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x43, 0xDF, 0xFF, 0xF8, 0xF8, 0xE1,
  0xEE, 0x1C, 0xE3, 0xCE, 0x38, 0xE7, 0x0E, 0xF0, 0xFE, 0x0F, 0xC0, 0xFE,
  0x0E, 0xF0, 0xE7, 0x8E, 0x3C, 0xE3, 0xCE, 0x1E, 0xE1, 0xEE, 0x0F, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xDE, 0x3F, 0xC7, 0xF8,
  0xFD, 0xB7, 0xB6, 0xF6, 0xDE, 0x73, 0xCE, 0x79, 0xCF, 0x01, 0xE0, 0x3C,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFE, 0x1F, 0xC3, 0xFC, 0x7F, 0x8F,
  0xF9, 0xFB, 0x3F, 0x77, 0xE6, 0xFC, 0xFF, 0x8F, 0xF1, 0xFE, 0x1F, 0xC3,
  0xF8, 0x3F, 0x07, 0x1F, 0x07, 0xF1, 0xFF, 0x78, 0xFE, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0x1E, 0xFF, 0x8F, 0xE0,
  0xF8, 0xFF, 0x1F, 0xFB, 0xFF, 0xF8, 0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0x8F,
  0xFF, 0xFF, 0xFB, 0xFC, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x1F,
  0x07, 0xF1, 0xFF, 0x78, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7F, 0x1E, 0xFF, 0x8F, 0xF0, 0xF8, 0x0F, 0x00, 0xFC,
  0x0F, 0x80, 0x70, 0xFF, 0x0F, 0xF8, 0xFF, 0xCF, 0x1C, 0xF1, 0xEF, 0x1E,
  0xF1, 0xCF, 0xFC, 0xFF, 0x8F, 0xF0, 0xF3, 0x8F, 0x3C, 0xF1, 0xCF, 0x1E,
  0xF0, 0xEF, 0x0F, 0x1F, 0x8F, 0xF9, 0xFF, 0x78, 0x4E, 0x01, 0xE0, 0x1F,
  0x83, 0xFC, 0x1F, 0xC0, 0xFC, 0x07, 0x80, 0x74, 0x1F, 0xFF, 0xFF, 0xF1,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7F, 0x1E, 0xFF, 0x9F, 0xF0, 0xF8, 0xF0, 0x7B, 0x83,
  0x9C, 0x1C, 0xE0, 0xE7, 0x8F, 0x1C, 0x70, 0xE3, 0x87, 0x1C, 0x38, 0xE0,
  0xEE, 0x07, 0x70, 0x3B, 0x80, 0xD8, 0x07, 0xC0, 0x3E, 0x00, 0xE0, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF3, 0x9E, 0x73, 0xCE, 0x7B,
  0x6F, 0x6D, 0xED, 0xBF, 0x1F, 0xE3, 0xFC, 0x7F, 0x07, 0x70, 0x73, 0xC7,
  0x8E, 0x38, 0x7B, 0xC1, 0xDC, 0x07, 0xC0, 0x3E, 0x00, 0xE0, 0x0F, 0x80,
  0x7E, 0x07, 0x70, 0x3B, 0xC3, 0x8E, 0x3C, 0x79, 0xC1, 0xDE, 0x0F, 0x70,
  0x7B, 0x83, 0x9E, 0x1C, 0x71, 0xC3, 0x8E, 0x0E, 0xE0, 0x77, 0x01, 0xF0,
  0x0F, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x7F, 0xEF, 0xFD, 0xFF, 0x01, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70,
  0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0xFF, 0xFF, 0xC0, 0xF0, 0x0E, 0x01, 0xC0, 0x3C,
  0x03, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x00,
  0xF0, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1C,
  0x03, 0xC0, 0xFF, 0xFF, 0xF8, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0x00,
  0x7C, 0x03, 0xF0, 0x3B, 0x83, 0xDE, 0x1C, 0x71, 0xE1, 0xCE, 0x0F, 0x30,
  0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x41, 0xCF, 0x8E, 0x18, 0x3F, 0x1F,
  0xF3, 0xFC, 0x07, 0x3F, 0xDF, 0xFF, 0xFF, 0xC7, 0xF1, 0xFF, 0xF7, 0xFC,
  0xFF, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xF3, 0xFE, 0xFF,
  0xF8, 0xFE, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x3F, 0xFE, 0xFF, 0xBF, 0x80,
  0x0F, 0xC7, 0xFD, 0xFF, 0x3C, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x78,
  0x0F, 0xFC, 0xFF, 0x87, 0xF0, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x73, 0xDD, 0xFF, 0xFF, 0xFC, 0xFE, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0x1D,
  0xFF, 0x7F, 0xC7, 0xF0, 0x1F, 0x07, 0xF1, 0xFF, 0x78, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x4F, 0xF8, 0xFF, 0x0F, 0xE0, 0x07, 0xE0, 0xFF,
  0x1F, 0xE1, 0xC0, 0x1C, 0x01, 0xC0, 0xFF, 0xEF, 0xFE, 0xFF, 0xE1, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1F, 0xDF, 0xF7, 0xFF, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0xC7, 0xFF, 0xDF,
  0xF3, 0xFC, 0x07, 0x43, 0xFF, 0xFF, 0xF9, 0xF8, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0xF9, 0xFE, 0xFF, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xC0, 0x1C, 0x07, 0x80, 0xF0, 0x0E, 0x00, 0x01,
  0xFC, 0x3F, 0x87, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x88, 0x7F, 0x0F, 0xE0, 0xF8, 0x03, 0x03, 0xC1, 0xE0, 0x60, 0x03,
  0xFD, 0xFE, 0xFF, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xD0, 0xEF, 0xFF, 0xF1, 0xF0, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0xF7, 0x3C, 0xE7, 0x1D, 0xC3, 0xF0, 0x7E, 0x0F,
  0xE1, 0xDC, 0x39, 0xC7, 0x3C, 0xE3, 0xDC, 0x38, 0xFE, 0x1F, 0xC3, 0xF8,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x88, 0x7F, 0x0F, 0xE0, 0xF8, 0xFB, 0xDF, 0xFF,
  0xFF, 0xE7, 0x7C, 0xE7, 0x9C, 0xF3, 0x9E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x30, 0xFE, 0x7F, 0xBF, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x70, 0x1F, 0x07, 0xF9, 0xFF, 0x78, 0xFE, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xF1, 0xEF, 0xF8, 0xFF, 0x0F, 0x80, 0xFE, 0x3F, 0xEF,
  0xFB, 0x8F, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0xFF, 0xEF, 0xFB, 0xFC,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0x1F, 0xDF, 0xF7, 0xFF, 0xC7, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xF1, 0xFF, 0xF7, 0xFC, 0xFF, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0x1F, 0x9F, 0xF7, 0xFD, 0xC1, 0x78, 0x0F, 0xC1,
  0xFC, 0x07, 0x41, 0xDF, 0xFF, 0xFC, 0xFC, 0x0C, 0x03, 0x80, 0x70, 0x0E,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC2, 0x3F, 0xC7, 0xF8, 0x7F, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xFF, 0xDF, 0xE7, 0xF0, 0xF0, 0x73, 0x83, 0x9C, 0x1C,
  0xF1, 0xC3, 0x8E, 0x1C, 0x70, 0x77, 0x03, 0xB8, 0x1F, 0x80, 0x7C, 0x03,
  0xC0, 0x0E, 0x00, 0xE0, 0x3F, 0x01, 0xD9, 0xCC, 0xCE, 0x66, 0x73, 0x33,
  0xD9, 0xB6, 0xCF, 0xBE, 0x7D, 0xF1, 0xCF, 0x0E, 0x38, 0x71, 0xC0, 0xE0,
  0xE7, 0x1C, 0x7B, 0xC3, 0xB8, 0x1F, 0x00, 0xF0, 0x1F, 0x01, 0xF8, 0x3B,
  0x87, 0x1C, 0xF1, 0xEE, 0x0E, 0xE0, 0xFE, 0x1D, 0xC7, 0xB8, 0xE7, 0x9C,
  0x73, 0x8E, 0xE0, 0xFC, 0x1F, 0x81, 0xE0, 0x3C, 0x07, 0x01, 0xE1, 0xF8,
  0x3F, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x70,
  0x70, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0x8F, 0xC7, 0xE3, 0x81, 0xC0, 0xC0,
  0x60, 0x70, 0x38, 0x7C, 0x38, 0x1F, 0x03, 0x81, 0xC0, 0x60, 0x30, 0x18,
  0x0E, 0x07, 0x03, 0xF1, 0xF8, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF8, 0x7E, 0x3F, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x0E, 0x07, 0xC0, 0xE1, 0xF0, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x1F, 0x8F, 0xC7, 0xC0, 0x38, 0x67, 0xE6, 0xFF, 0xEC, 0x7E, 0xC3, 0xC0,
};

const GFXglyph UbuntuMono_Bold26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 5, 16, 13, 4, -16 },
  { 11, 9, 7, 13, 2, -18 },
  { 19, 13, 16, 13, 0, -16 },
  { 45, 11, 21, 13, 1, -18 },
  { 74, 13, 16, 13, 0, -16 },
  { 100, 12, 16, 13, 1, -16 },
  { 124, 3, 8, 13, 5, -18 },
  { 127, 9, 22, 13, 2, -18 },
  { 152, 9, 22, 13, 2, -18 },
  { 177, 11, 10, 13, 1, -16 },
  { 191, 11, 13, 13, 1, -12 },
  { 209, 6, 9, 13, 3, -5 },
  { 216, 7, 3, 13, 3, -8 },
  { 219, 5, 5, 13, 4, -5 },
  { 223, 11, 22, 13, 1, -18 },
  { 254, 11, 16, 13, 1, -16 },
  { 276, 11, 16, 13, 1, -16 },
  { 298, 11, 16, 13, 1, -16 },
  { 320, 11, 16, 13, 1, -16 },
  { 342, 11, 16, 13, 1, -16 },
  { 364, 11, 16, 13, 1, -16 },
  { 386, 11, 16, 13, 1, -16 },
  { 408, 11, 16, 13, 1, -16 },
  { 430, 11, 16, 13, 1, -16 },
  { 452, 11, 16, 13, 1, -16 },
  { 474, 5, 13, 13, 4, -13 },
  { 483, 6, 17, 13, 3, -13 },
  { 496, 11, 11, 13, 1, -12 },
  { 512, 11, 8, 13, 1, -11 },
  { 523, 11, 11, 13, 1, -12 },
  { 539, 9, 16, 13, 2, -16 },
  { 557, 12, 20, 13, 0, -16 },
  { 587, 13, 16, 13, 0, -16 },
  { 613, 11, 16, 13, 1, -16 },
  { 635, 11, 16, 13, 1, -16 },
  { 657, 11, 16, 13, 1, -16 },
  { 679, 10, 16, 13, 2, -16 },
  { 699, 9, 16, 13, 2, -16 },
  { 717, 11, 16, 13, 1, -16 },
  { 739, 11, 16, 13, 1, -16 },
  { 761, 11, 16, 13, 1, -16 },
  { 783, 10, 16, 13, 1, -16 },
  { 803, 12, 16, 13, 1, -16 },
  { 827, 10, 16, 13, 2, -16 },
  { 847, 11, 16, 13, 1, -16 },
  { 869, 11, 16, 13, 1, -16 },
  { 891, 11, 16, 13, 1, -16 },
  { 913, 11, 16, 13, 1, -16 },
  { 935, 11, 20, 13, 1, -16 },
  { 963, 12, 16, 13, 1, -16 },
  { 987, 11, 16, 13, 1, -16 },
  { 1009, 11, 16, 13, 1, -16 },
  { 1031, 11, 16, 13, 1, -16 },
  { 1053, 13, 16, 13, 0, -16 },
  { 1079, 11, 16, 13, 1, -16 },
  { 1101, 13, 16, 13, 0, -16 },
  { 1127, 13, 16, 13, 0, -16 },
  { 1153, 11, 16, 13, 1, -16 },
  { 1175, 7, 22, 13, 3, -18 },
  { 1195, 11, 22, 13, 1, -18 },
  { 1226, 7, 22, 13, 3, -18 },
  { 1246, 13, 9, 13, 0, -16 },
  { 1261, 13, 3, 13, 0, 1 },
  { 1266, 6, 5, 13, 4, -18 },
  { 1270, 10, 12, 13, 1, -12 },
  { 1285, 10, 18, 13, 2, -18 },
  { 1308, 11, 12, 13, 1, -12 },
  { 1325, 10, 18, 13, 1, -18 },
  { 1348, 11, 12, 13, 1, -12 },
  { 1365, 12, 18, 13, 1, -18 },
  { 1392, 10, 16, 13, 1, -12 },
  { 1412, 9, 18, 13, 2, -18 },
  { 1433, 11, 18, 13, 1, -18 },
  { 1458, 9, 22, 13, 1, -18 },
  { 1483, 11, 18, 13, 2, -18 },
  { 1508, 11, 18, 13, 1, -18 },
  { 1533, 11, 12, 13, 1, -12 },
  { 1550, 9, 12, 13, 2, -12 },
  { 1564, 11, 12, 13, 1, -12 },
  { 1581, 10, 16, 13, 2, -12 },
  { 1601, 10, 16, 13, 1, -12 },
  { 1621, 10, 12, 13, 2, -12 },
  { 1636, 10, 12, 13, 1, -12 },
  { 1651, 11, 16, 13, 1, -16 },
  { 1673, 9, 12, 13, 2, -12 },
  { 1687, 13, 12, 13, 0, -12 },
  { 1707, 13, 12, 13, 0, -12 },
  { 1727, 12, 12, 13, 1, -12 },
  { 1745, 11, 16, 13, 1, -12 },
  { 1767, 9, 12, 13, 2, -12 },
  { 1781, 9, 22, 13, 2, -18 },
  { 1806, 3, 22, 13, 5, -18 },
  { 1815, 9, 22, 13, 2, -18 },
  { 1840, 12, 5, 13, 1, -9 },
};

const GFXfont UbuntuMono_Bold26pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Bold26pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Bold26pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _UBUNTUMONO_BOLD26PT7B_H_
