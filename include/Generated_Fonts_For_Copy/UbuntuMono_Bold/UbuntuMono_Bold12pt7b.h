#ifndef _UBUNTUMONO_BOLD12PT7B_H_
#define _UBUNTUMONO_BOLD12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Bold.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Bold12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x3C, 0xFF, 0x90, 0x28, 0xAF, 0xDE, 0xFD, 0x45, 0x00, 0x31,
  0xE4, 0x18, 0x38, 0x30, 0xFE, 0x30, 0xE6, 0xAF, 0x0C, 0x3D, 0x59, 0xC0,
  0x71, 0x45, 0x1B, 0xDB, 0x67, 0xC0, 0xFD, 0x12, 0x4C, 0xCC, 0xCC, 0x46,
  0x10, 0x86, 0x23, 0x31, 0x33, 0x26, 0xC0, 0x65, 0xBC, 0xCD, 0x00, 0x30,
  0xCF, 0xCC, 0x30, 0xF6, 0xF0, 0xF0, 0x13, 0x32, 0x66, 0x4C, 0xC8, 0x79,
  0x2F, 0xFF, 0xCD, 0x27, 0x80, 0x67, 0x28, 0x42, 0x13, 0xE0, 0xE0, 0x8C,
  0x6E, 0x63, 0xE0, 0x70, 0x46, 0x60, 0x85, 0xE0, 0x18, 0xE7, 0x96, 0xFC,
  0x61, 0x80, 0x7A, 0x1C, 0x30, 0x87, 0xC0, 0x3C, 0x8F, 0x99, 0xF0, 0xF3,
  0x26, 0x64, 0x40, 0x79, 0x24, 0x8C, 0x4B, 0x37, 0x80, 0xF9, 0x9F, 0x13,
  0xC0, 0xF0, 0xF0, 0x6C, 0x06, 0xCA, 0x11, 0xBD, 0x8C, 0x78, 0xC2, 0xFC,
  0x0F, 0xC0, 0x41, 0x87, 0x87, 0x1D, 0xE6, 0x10, 0xF1, 0x36, 0x06, 0x60,
  0x39, 0x2D, 0xEB, 0xAE, 0xBD, 0xD0, 0x38, 0x30, 0xC7, 0x92, 0x79, 0x3C,
  0xC0, 0xF4, 0xA5, 0xC9, 0xCF, 0xC0, 0x39, 0x1C, 0x30, 0xC1, 0x13, 0x80,
  0xE4, 0xA7, 0x39, 0xCB, 0x80, 0xF4, 0x21, 0xE8, 0x43, 0xE0, 0xF8, 0x8F,
  0x88, 0x80, 0x39, 0x0C, 0x33, 0xCD, 0x33, 0xC0, 0x99, 0x9F, 0x99, 0x90,
  0xF6, 0x66, 0x66, 0xF0, 0x78, 0x42, 0x10, 0xA5, 0xC0, 0x95, 0xB9, 0xCA,
  0x5A, 0x60, 0x84, 0x21, 0x08, 0x43, 0xE0, 0x49, 0x27, 0xBF, 0xFF, 0x3C,
  0xC0, 0x9D, 0xDB, 0xB9, 0x90, 0x79, 0x2C, 0xF3, 0xCD, 0x27, 0x80, 0xF4,
  0xE7, 0x3F, 0x42, 0x00, 0x79, 0x2C, 0xF3, 0xCD, 0x27, 0x8C, 0x18, 0xF4,
  0xA5, 0xEB, 0x4A, 0x60, 0x79, 0x04, 0x0E, 0x09, 0x27, 0x80, 0xFC, 0xC3,
  0x0C, 0x30, 0xC3, 0x00, 0xCF, 0x3C, 0xF3, 0xCD, 0x27, 0x80, 0xCD, 0x34,
  0x92, 0x78, 0xC3, 0x00, 0xCF, 0x3F, 0xFF, 0xFD, 0x24, 0x80, 0x49, 0xE3,
  0x0C, 0x79, 0x2C, 0xC0, 0xCD, 0x27, 0x8C, 0x30, 0xC3, 0x00, 0xF3, 0x26,
  0xCC, 0xF0, 0xFC, 0xCC, 0xCC, 0xCC, 0xCF, 0x8C, 0xC4, 0x66, 0x23, 0x31,
  0xF3, 0x33, 0x33, 0x33, 0x3F, 0x31, 0xE4, 0xB3, 0xFC, 0x90, 0xF1, 0xF9,
  0x9F, 0x84, 0x3D, 0x29, 0xCE, 0x5E, 0x74, 0x21, 0x08, 0x3C, 0x08, 0x5E,
  0x9C, 0xE5, 0x2F, 0x39, 0xEC, 0xFF, 0x40, 0xE0, 0x3C, 0x8F, 0x88, 0x20,
  0x82, 0x08, 0x7A, 0x73, 0x94, 0xBC, 0x2E, 0x88, 0xF9, 0x99, 0x99, 0x20,
  0x80, 0x38, 0x20, 0x83, 0x0F, 0x33, 0x0F, 0x33, 0x33, 0x3E, 0x84, 0x25,
  0x4E, 0x52, 0xD3, 0xE0, 0x82, 0x08, 0x20, 0x83, 0x07, 0xFB, 0xFF, 0xFF,
  0xCF, 0x30, 0xFF, 0x99, 0x99, 0x79, 0x2C, 0xF3, 0x49, 0xE0, 0xF4, 0xA7,
  0x39, 0x7A, 0x10, 0x7A, 0x73, 0x94, 0xBC, 0x21, 0xF6, 0x31, 0x8C, 0x60,
  0xF8, 0xE7, 0x1F, 0x20, 0x8F, 0xC8, 0x20, 0x82, 0x0F, 0x99, 0x99, 0x9F,
  0xCD, 0x24, 0x9E, 0x30, 0xC0, 0x86, 0xDF, 0xFE, 0x79, 0x20, 0x49, 0xE3,
  0x0C, 0x79, 0x30, 0x4D, 0x26, 0x9E, 0x30, 0xC3, 0x38, 0xF3, 0x64, 0xCF,
  0x36, 0x44, 0x48, 0x44, 0x47, 0xFF, 0xFF, 0xF0, 0xC6, 0x22, 0x21, 0x22,
  0x2E, 0x66, 0x60,
};

const GFXglyph UbuntuMono_Bold12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 7, 6, 2, -7 },
  { 3, 4, 3, 6, 1, -8 },
  { 5, 6, 7, 6, 0, -7 },
  { 11, 6, 9, 6, 0, -8 },
  { 18, 6, 7, 6, 0, -7 },
  { 24, 6, 7, 6, 0, -7 },
  { 30, 2, 4, 6, 2, -8 },
  { 31, 4, 11, 6, 1, -9 },
  { 37, 4, 11, 6, 1, -9 },
  { 43, 5, 5, 6, 1, -7 },
  { 47, 6, 5, 6, 0, -6 },
  { 51, 2, 4, 6, 2, -2 },
  { 52, 4, 1, 6, 1, -4 },
  { 53, 2, 2, 6, 2, -2 },
  { 54, 4, 10, 6, 1, -8 },
  { 59, 6, 7, 6, 0, -7 },
  { 65, 5, 7, 6, 1, -7 },
  { 70, 5, 7, 6, 1, -7 },
  { 75, 5, 7, 6, 0, -7 },
  { 80, 6, 7, 6, 0, -7 },
  { 86, 5, 7, 6, 0, -7 },
  { 91, 4, 7, 6, 1, -7 },
  { 95, 4, 7, 6, 1, -7 },
  { 99, 6, 7, 6, 0, -7 },
  { 105, 4, 7, 6, 1, -7 },
  { 109, 2, 6, 6, 2, -6 },
  { 111, 3, 8, 6, 1, -6 },
  { 114, 5, 8, 6, 1, -8 },
  { 119, 6, 3, 6, 0, -5 },
  { 122, 6, 8, 6, 0, -8 },
  { 128, 4, 7, 6, 1, -7 },
  { 132, 6, 9, 6, 0, -7 },
  { 139, 6, 7, 6, 0, -7 },
  { 145, 5, 7, 6, 1, -7 },
  { 150, 6, 7, 6, 0, -7 },
  { 156, 5, 7, 6, 1, -7 },
  { 161, 5, 7, 6, 1, -7 },
  { 166, 4, 7, 6, 1, -7 },
  { 170, 6, 7, 6, 0, -7 },
  { 176, 4, 7, 6, 1, -7 },
  { 180, 4, 7, 6, 1, -7 },
  { 184, 5, 7, 6, 0, -7 },
  { 189, 5, 7, 6, 1, -7 },
  { 194, 5, 7, 6, 1, -7 },
  { 199, 6, 7, 6, 0, -7 },
  { 205, 4, 7, 6, 1, -7 },
  { 209, 6, 7, 6, 0, -7 },
  { 215, 5, 7, 6, 1, -7 },
  { 220, 6, 9, 6, 0, -7 },
  { 227, 5, 7, 6, 1, -7 },
  { 232, 6, 7, 6, 0, -7 },
  { 238, 6, 7, 6, 0, -7 },
  { 244, 6, 7, 6, 0, -7 },
  { 250, 6, 7, 6, 0, -7 },
  { 256, 6, 7, 6, 0, -7 },
  { 262, 6, 7, 6, 0, -7 },
  { 268, 6, 7, 6, 0, -7 },
  { 274, 4, 7, 6, 1, -7 },
  { 278, 4, 10, 6, 1, -8 },
  { 283, 4, 10, 6, 1, -8 },
  { 288, 4, 10, 6, 1, -8 },
  { 293, 6, 4, 6, 0, -7 },
  { 296, 6, 1, 6, 0, 1 },
  { 297, 2, 2, 6, 2, -8 },
  { 298, 4, 6, 6, 1, -6 },
  { 301, 5, 8, 6, 1, -8 },
  { 306, 5, 6, 6, 1, -6 },
  { 310, 5, 8, 6, 0, -8 },
  { 315, 6, 6, 6, 0, -6 },
  { 320, 6, 8, 6, 0, -8 },
  { 326, 5, 8, 6, 0, -6 },
  { 331, 4, 8, 6, 1, -8 },
  { 335, 6, 8, 6, 0, -8 },
  { 341, 4, 10, 6, 1, -8 },
  { 346, 5, 8, 6, 1, -8 },
  { 351, 6, 8, 6, 0, -8 },
  { 357, 6, 6, 6, 0, -6 },
  { 362, 4, 6, 6, 1, -6 },
  { 365, 6, 6, 6, 0, -6 },
  { 370, 5, 8, 6, 1, -6 },
  { 375, 5, 8, 6, 0, -6 },
  { 380, 5, 6, 6, 1, -6 },
  { 384, 4, 6, 6, 1, -6 },
  { 387, 6, 8, 6, 0, -8 },
  { 393, 4, 6, 6, 1, -6 },
  { 396, 6, 6, 6, 0, -6 },
  { 401, 6, 6, 6, 0, -6 },
  { 406, 6, 6, 6, 0, -6 },
  { 411, 6, 8, 6, 0, -6 },
  { 417, 4, 6, 6, 1, -6 },
  { 420, 4, 10, 6, 1, -8 },
  { 425, 2, 10, 6, 2, -8 },
  { 428, 4, 10, 6, 1, -8 },
  { 433, 6, 2, 6, 0, -4 },
};

const GFXfont UbuntuMono_Bold12pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Bold12pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Bold12pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _UBUNTUMONO_BOLD12PT7B_H_
