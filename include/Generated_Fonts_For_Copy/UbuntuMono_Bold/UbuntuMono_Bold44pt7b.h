#ifndef _UBUNTUMONO_BOLD44PT7B_H_
#define _UBUNTUMONO_BOLD44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Bold.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Bold44pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x7E, 0xFF, 0xFF, 0x7E, 0x3C, 0xFC, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x1F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0x78, 0x7D, 0xE1, 0xE7, 0x83,
  0x9C, 0x0E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xC3, 0xC0, 0x3C, 0x3C,
  0x03, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0xF8, 0x0F, 0x0F, 0x00, 0xF0,
  0xF0, 0x0F, 0x0F, 0x01, 0xF1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3C, 0x3C, 0x03,
  0xC3, 0xC0, 0x3C, 0x3C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0x80, 0xFF,
  0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0x01, 0xC3, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x20, 0x03,
  0xE3, 0xC0, 0x7E, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0x80, 0xFF,
  0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x00, 0xFE, 0x00, 0xF7, 0xF8, 0x07, 0x9F, 0xF0,
  0x3C, 0x73, 0xC0, 0xF3, 0xC7, 0x07, 0x8F, 0x1C, 0x3C, 0x3C, 0x70, 0xF0,
  0x71, 0xC7, 0x81, 0xCF, 0x3C, 0x07, 0xFC, 0xF0, 0x1F, 0xE7, 0x80, 0x3F,
  0xBC, 0x00, 0x7C, 0xF0, 0x00, 0x07, 0xBE, 0x00, 0x3D, 0xFC, 0x00, 0xF7,
  0xF8, 0x07, 0xBF, 0xE0, 0x3C, 0xF7, 0x80, 0xF3, 0x8E, 0x07, 0x8E, 0x3C,
  0x3C, 0x38, 0xF0, 0xF0, 0xE3, 0xC7, 0x83, 0x8E, 0x3C, 0x0F, 0x78, 0xF0,
  0x3F, 0xE7, 0x80, 0x7F, 0xBC, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x03, 0xF0,
  0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x3E, 0x3E, 0x03, 0xE1,
  0xE0, 0x3E, 0x1E, 0x03, 0xE1, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x1F,
  0x7C, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x1E, 0x1F, 0xE1, 0xE3,
  0xFF, 0x1E, 0x7D, 0xFB, 0xEF, 0x8F, 0xFE, 0xF8, 0x7F, 0xCF, 0x83, 0xFC,
  0xF8, 0x1F, 0xCF, 0x81, 0xF8, 0xF8, 0x0F, 0xCF, 0xC3, 0xFC, 0x7F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x1F, 0xFB, 0xF0, 0x7E, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0x79, 0xE7, 0x9E, 0x78, 0x00, 0x10, 0x01, 0xE0, 0x0F, 0xC0,
  0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03,
  0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x00, 0x78, 0x00,
  0x40, 0x20, 0x01, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x0F, 0xE0, 0x1F, 0x00, 0x78, 0x00, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x61, 0xE1, 0x9E, 0x79, 0xE7, 0xED, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F,
  0x3E, 0x0F, 0xCF, 0xC1, 0xF1, 0xF0, 0x38, 0x70, 0x04, 0x08, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x1E, 0x1F, 0x8F, 0xEF,
  0xF7, 0xF9, 0xFC, 0xFE, 0x3F, 0x07, 0x87, 0x8F, 0xDF, 0xCF, 0xC7, 0xC3,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x7E, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01,
  0xFF, 0xE0, 0xFF, 0xFC, 0x7E, 0x1F, 0x9F, 0x03, 0xE7, 0xC0, 0xFB, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE3, 0x1F, 0xF1, 0xE3,
  0xFC, 0x78, 0xFF, 0x1E, 0x3F, 0xC7, 0x8F, 0xF0, 0xC7, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xF7, 0xC0, 0xF9, 0xF0,
  0x3E, 0x7E, 0x1F, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x1F, 0xF8,
  0x1F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x7D, 0xF8, 0x0C, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3,
  0xFF, 0xFC, 0x07, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0xE3, 0xFF, 0xFC, 0x7C,
  0x3F, 0x0C, 0x07, 0xE2, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x38, 0x3F, 0x08, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x07, 0xFE, 0x01, 0xFE,
  0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x60,
  0x3F, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3E, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8,
  0x0F, 0x8F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0xFF, 0x87, 0xFF, 0xE1,
  0xFF, 0xF8, 0x7F, 0xFE, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFE,
  0x0F, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xFB, 0x80,
  0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x0F,
  0x00, 0x1F, 0xE0, 0x1F, 0xF8, 0x1F, 0xFE, 0x0F, 0xF8, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xDF, 0x81, 0xFF,
  0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xC1, 0xFB, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xDF, 0x03, 0xF7,
  0xE0, 0xF9, 0xFC, 0x7E, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x0F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x7E,
  0x1F, 0x9F, 0x03, 0xEF, 0xC0, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xE7, 0xE0, 0xF9, 0xFE, 0x7C, 0x3F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xE0,
  0xFF, 0xFC, 0x7E, 0xFF, 0x9F, 0x0F, 0xEF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFE, 0x1F, 0xDF, 0xFF,
  0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x03, 0xFF,
  0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7E, 0x3F, 0x9F, 0x07, 0xEF, 0xC0, 0xFB,
  0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFC,
  0x07, 0xDF, 0x83, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC1, 0xFB,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0,
  0x1F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0xF0, 0x00, 0x3C,
  0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x0F, 0x07, 0xE3, 0xFC,
  0xFF, 0x3F, 0xCF, 0xF1, 0xF8, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC1, 0xF8, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0x7F, 0x0F, 0xC1, 0xE0,
  0x78, 0xFC, 0xFF, 0x3F, 0x87, 0x81, 0x80, 0x00, 0x00, 0x80, 0x01, 0xE0,
  0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF,
  0x80, 0xFF, 0x80, 0x3F, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xE0,
  0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x60, 0x00, 0x1E, 0x00, 0x0F, 0xE0, 0x03,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x00,
  0x7F, 0xC0, 0x03, 0xF0, 0x03, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0x8F, 0xFF,
  0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x06, 0x00, 0x00,
  0x0F, 0xE0, 0x7F, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x70, 0x7F, 0x40, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x0F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xC0, 0x07, 0x80, 0x00, 0xFC,
  0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0x07, 0xC3, 0xE0,
  0x3E, 0x3C, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x3F, 0xF7, 0x87, 0xFF, 0xF0,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xF1, 0xFF, 0x1E, 0x1F, 0xF3, 0xE1, 0xFF,
  0x3E, 0x1F, 0xF3, 0xE1, 0xFF, 0x3E, 0x1F, 0xF3, 0xE1, 0xFF, 0x3E, 0x1F,
  0xF1, 0xF1, 0xFF, 0x1F, 0x1F, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0x78, 0x7F,
  0xF7, 0x81, 0xFF, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x04, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFC, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xF3, 0xC0, 0x07, 0xCF, 0x80,
  0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E,
  0x1F, 0x00, 0xF8, 0x7C, 0x07, 0xE1, 0xF8, 0x1F, 0x07, 0xE0, 0x7F, 0xFF,
  0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xF8, 0x07, 0xC7,
  0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xF0, 0x07, 0xEF, 0xC0,
  0x0F, 0x80, 0x3F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F,
  0xC1, 0xF9, 0xF8, 0x1F, 0x3F, 0x03, 0xE7, 0xE0, 0x7C, 0xFC, 0x0F, 0x9F,
  0x81, 0xF3, 0xF0, 0x7E, 0x7E, 0x1F, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC7, 0xFF, 0xFC, 0xFC, 0x1F, 0xDF, 0x81, 0xFB, 0xF0, 0x1F, 0x7E,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xF7, 0xE0, 0x7E, 0xFC,
  0x1F, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xC1, 0xE3,
  0xF8, 0x04, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x04, 0x1F,
  0xC0, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xC3, 0xF1,
  0xF8, 0x3F, 0x3F, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x07, 0xDF, 0x80, 0xFB,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0x7E, 0x03, 0xEF,
  0xC0, 0xFD, 0xF8, 0x1F, 0x3F, 0x07, 0xE7, 0xE3, 0xF8, 0xFF, 0xFF, 0x1F,
  0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF,
  0xFF, 0xDF, 0xFF, 0xEF, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF,
  0xF3, 0xFF, 0xF9, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF1, 0xFC, 0x1C, 0x7E,
  0x00, 0x8F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0,
  0x3E, 0xFC, 0x07, 0xCF, 0x80, 0xF9, 0xF8, 0x1F, 0x1F, 0x83, 0xE3, 0xFF,
  0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xF8, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x80, 0x7E, 0xF0,
  0xFE, 0x7F, 0xFF, 0x7F, 0xFF, 0x1F, 0xFF, 0x01, 0xFC, 0x00, 0xF8, 0x0F,
  0xCF, 0x80, 0xFC, 0xF8, 0x1F, 0x8F, 0x81, 0xF8, 0xF8, 0x3F, 0x0F, 0x87,
  0xE0, 0xF8, 0x7E, 0x0F, 0x8F, 0xC0, 0xF9, 0xF8, 0x0F, 0x9F, 0x80, 0xFB,
  0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F,
  0xBF, 0x80, 0xF9, 0xFC, 0x0F, 0x8F, 0xE0, 0xF8, 0x7E, 0x0F, 0x87, 0xF0,
  0xF8, 0x3F, 0x0F, 0x81, 0xF8, 0xF8, 0x1F, 0xCF, 0x80, 0xFC, 0xF8, 0x0F,
  0xEF, 0x80, 0x7E, 0xF8, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x03, 0xC7, 0xE0, 0x7C, 0x7E, 0x07, 0xE7,
  0xE0, 0x7E, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF1, 0xFE,
  0x7B, 0x9F, 0xE7, 0xB9, 0xDE, 0x7B, 0xBD, 0xE7, 0xBF, 0xDE, 0x79, 0xF9,
  0xE7, 0x9F, 0x9E, 0x79, 0xF9, 0xEF, 0x8F, 0x1F, 0xF8, 0xF1, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF0,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF,
  0xC1, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xBC,
  0x7F, 0xEF, 0x9F, 0xF9, 0xE7, 0xFE, 0x7D, 0xFF, 0x8F, 0x7F, 0xE3, 0xFF,
  0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFE,
  0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7C, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F,
  0x0F, 0xC3, 0xE0, 0x7C, 0x7E, 0x07, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7,
  0xC0, 0x3E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xF7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7E, 0x07, 0xE3, 0xE0,
  0x7C, 0x3F, 0x0F, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF,
  0xC1, 0xFD, 0xF8, 0x1F, 0xBF, 0x01, 0xF7, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7D, 0xF8, 0x1F, 0xBF,
  0x87, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xC0, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0x0F, 0xC3, 0xE0, 0x7C,
  0x7E, 0x07, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xC0, 0x3E, 0x7C,
  0x03, 0xE7, 0xC0, 0x3E, 0x7E, 0x07, 0xE3, 0xE0, 0x7C, 0x3F, 0x0F, 0xC1,
  0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFC, 0x00, 0x0F, 0x00,
  0x00, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x1E, 0x3F, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0xFC, 0x3F, 0x8F, 0xC1, 0xF8, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC,
  0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC1, 0xF8, 0xFC, 0x3F, 0x8F,
  0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xC7, 0xE0,
  0xFC, 0x7E, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF8, 0xFC, 0x0F,
  0x8F, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0,
  0x3E, 0x03, 0xF8, 0x03, 0xFF, 0xC3, 0xFF, 0xF9, 0xFF, 0xFC, 0x7E, 0x07,
  0x3F, 0x00, 0x4F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F,
  0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7D, 0x00, 0x3F, 0x78, 0x1F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xF1, 0xFF, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xFD, 0xF8, 0x7E, 0x7F, 0xFF, 0x8F,
  0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xE0, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7,
  0xE0, 0x7E, 0x3E, 0x07, 0xE3, 0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x7C,
  0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x80, 0xF0, 0xF8, 0x0F, 0x9F,
  0x00, 0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0x79, 0xE0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0xF1, 0xFF, 0x9F, 0x9F, 0xF9, 0xF9, 0xE7, 0x9F,
  0x9E, 0x79, 0xF9, 0xE7, 0xBF, 0xDE, 0x7B, 0xDD, 0xE7, 0xB9, 0xDE, 0x7F,
  0x9F, 0xE7, 0xF8, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7,
  0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x3C, 0x03, 0xE0, 0x7E, 0x01,
  0xF8, 0xFC, 0x07, 0xC3, 0xF0, 0x3F, 0x07, 0xE0, 0xF8, 0x1F, 0x87, 0xE0,
  0x3F, 0x1F, 0x00, 0x7C, 0xFC, 0x01, 0xFB, 0xE0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x7C, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF0,
  0x3F, 0x0F, 0xC0, 0xFC, 0x3E, 0x01, 0xF1, 0xF8, 0x07, 0xE7, 0xE0, 0x1F,
  0x80, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0x7C, 0x03, 0xF7, 0xE0, 0x3E, 0x7E,
  0x07, 0xE3, 0xE0, 0x7C, 0x3F, 0x07, 0xC1, 0xF0, 0xF8, 0x1F, 0x0F, 0x80,
  0xF9, 0xF8, 0x0F, 0x9F, 0x00, 0xFD, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xDF,
  0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xCF, 0x80, 0x7E, 0x3E,
  0x03, 0xE1, 0xF8, 0x3F, 0x07, 0xC3, 0xF0, 0x3F, 0x1F, 0x80, 0xFD, 0xF8,
  0x07, 0xE7, 0x80, 0x1E, 0x0C, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x20, 0x38, 0x1F, 0x1F, 0xCF, 0xF9,
  0xFC, 0x3C, 0x06, 0x1F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0xC7, 0xFF, 0xE1,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x83, 0xFF,
  0xC7, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x83, 0xEF, 0xFF, 0xF7, 0xFF, 0xF9,
  0xFF, 0xFC, 0x1F, 0xF8, 0x38, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0x0F, 0xCF,
  0x81, 0xFB, 0xE0, 0x7E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3E, 0xF8, 0x0F,
  0xBE, 0x07, 0xEF, 0x81, 0xFB, 0xE0, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F,
  0xFF, 0x80, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F,
  0xFF, 0xC3, 0xF8, 0x08, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x01, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xE0, 0x00,
  0x01, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0xF9, 0xF0, 0xFF, 0xFC,
  0x7F, 0xFF, 0x3F, 0xFF, 0xCF, 0xC3, 0xF7, 0xE0, 0x7D, 0xF0, 0x1F, 0x7C,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x81, 0xF7, 0xE0, 0x7C,
  0xFC, 0x1F, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x07, 0xF8, 0x01,
  0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xF0, 0xFC, 0x7C,
  0x0F, 0x9F, 0x80, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFE, 0x03, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xE0, 0x60, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFF, 0x01, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0x87, 0xDF,
  0x81, 0xF7, 0xE0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7D, 0xF8, 0x1F,
  0x7F, 0x0F, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xF7, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xCC, 0x07, 0xE7, 0xFF,
  0xF9, 0xFF, 0xFC, 0x7F, 0xFE, 0x07, 0xFC, 0x00, 0x38, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xFB, 0xF0, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x07, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xC1, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xC0,
  0x00, 0x38, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7C,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x3F, 0xFF,
  0x3F, 0xFF, 0x3F, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3E, 0x20, 0x3E, 0x78, 0x7E, 0x7F, 0xFC, 0xFF, 0xFC,
  0x7F, 0xF8, 0x0F, 0xE0, 0x38, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x81, 0xFB, 0xE0, 0xFC, 0xF8, 0x3F, 0x3E, 0x1F, 0x8F,
  0x8F, 0xC3, 0xE7, 0xE0, 0xF9, 0xF0, 0x3E, 0xF8, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xE0, 0x3E, 0xFC, 0x0F, 0x9F, 0x83, 0xE7, 0xE0, 0xF8, 0xFC,
  0x3E, 0x1F, 0x8F, 0x83, 0xF3, 0xE0, 0xFC, 0xF8, 0x1F, 0xBE, 0x07, 0xFF,
  0x80, 0xFC, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC1, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x01,
  0xFF, 0x80, 0x1F, 0xE0, 0x1F, 0x8F, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xF9, 0xF1, 0xEF, 0x8F, 0x1F, 0xF8, 0xF1, 0xFF, 0x8F, 0x1F,
  0xF8, 0xF1, 0xFF, 0x8F, 0x1F, 0xF8, 0xF1, 0xFF, 0x8F, 0x1F, 0xF8, 0xF1,
  0xFF, 0x8F, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x1F,
  0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x01, 0xF8, 0x00, 0x7F, 0xE0,
  0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0x0F, 0xC7, 0xE0, 0x7E, 0x7E, 0x07,
  0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7E,
  0x07, 0xE3, 0xE0, 0x7E, 0x3F, 0x0F, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0x7F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3,
  0xFF, 0xF8, 0xF8, 0x3F, 0x3E, 0x07, 0xEF, 0x81, 0xFB, 0xE0, 0x3E, 0xF8,
  0x0F, 0xBE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x1F, 0xBE, 0x07, 0xEF, 0xC3, 0xF3,
  0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xBF, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0x07, 0xDF, 0x81,
  0xF7, 0xE0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0x7E,
  0x07, 0xDF, 0x81, 0xF3, 0xF0, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF,
  0xF0, 0x3F, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x0F, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x02, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x03, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xE7, 0xE0, 0x73,
  0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x00,
  0x0F, 0xA0, 0x07, 0xDE, 0x07, 0xEF, 0xFF, 0xF7, 0xFF, 0xF7, 0xFF, 0xF0,
  0x7F, 0xC0, 0x01, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF,
  0xFF, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x06, 0x07,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x1F, 0x7F, 0xFF, 0x7F,
  0xFF, 0x3F, 0xFF, 0x0F, 0xF8, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xF7, 0xC0, 0x3E, 0x7E, 0x03, 0xE7, 0xE0, 0x7E, 0x3E, 0x07, 0xC3, 0xE0,
  0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0xF8, 0x1F, 0x1F, 0x81, 0xF9, 0xF0, 0x0F,
  0x9F, 0x00, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x79, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x78, 0x79,
  0xE1, 0xE1, 0xE7, 0x87, 0xC7, 0x9E, 0x3F, 0x1E, 0x7C, 0xFC, 0xF9, 0xF3,
  0xF3, 0xC3, 0xCF, 0xEF, 0x0F, 0x7F, 0xBC, 0x3D, 0xFE, 0xF0, 0xF7, 0x3B,
  0xC3, 0xFC, 0xFF, 0x0F, 0xF3, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x81,
  0xF8, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0xFC, 0x03, 0xF7, 0xE0,
  0x7E, 0x3E, 0x07, 0xC3, 0xF0, 0xFC, 0x1F, 0x9F, 0x80, 0xF9, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xBF, 0x01, 0xF9, 0xF8,
  0x1F, 0x0F, 0xC3, 0xE0, 0xFC, 0x7E, 0x07, 0xE7, 0xC0, 0x3E, 0xFC, 0x03,
  0xF0, 0x7C, 0x03, 0xF7, 0xE0, 0x3E, 0x7E, 0x03, 0xE3, 0xE0, 0x7E, 0x3E,
  0x07, 0xE3, 0xF0, 0x7C, 0x3F, 0x07, 0xC1, 0xF0, 0xFC, 0x1F, 0x8F, 0x81,
  0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xFD, 0xF8, 0x07, 0xDF, 0x00, 0x7D, 0xF0,
  0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x04, 0x3F,
  0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x7E,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x07, 0xFF, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFF, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x00, 0x0F, 0x00, 0xC3,
  0xFC, 0x0F, 0x3F, 0xF1, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0x8F, 0xFE,
  0xF0, 0x3F, 0xC3, 0x00, 0xF8,
};

const GFXglyph UbuntuMono_Bold44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 8, 28, 22, 7, -27 },
  { 29, 14, 12, 22, 4, -30 },
  { 50, 20, 27, 22, 1, -27 },
  { 118, 20, 35, 22, 1, -31 },
  { 206, 22, 29, 22, 0, -28 },
  { 286, 20, 28, 22, 1, -28 },
  { 356, 6, 13, 22, 8, -30 },
  { 366, 14, 38, 22, 4, -31 },
  { 433, 14, 38, 22, 4, -31 },
  { 500, 18, 17, 22, 2, -27 },
  { 539, 18, 20, 22, 2, -21 },
  { 584, 9, 15, 22, 6, -7 },
  { 601, 12, 5, 22, 5, -14 },
  { 609, 8, 8, 22, 7, -7 },
  { 617, 18, 38, 22, 2, -31 },
  { 703, 18, 29, 22, 2, -28 },
  { 769, 18, 27, 22, 2, -27 },
  { 830, 18, 28, 22, 2, -28 },
  { 893, 18, 29, 22, 2, -28 },
  { 959, 20, 27, 22, 1, -27 },
  { 1027, 18, 28, 22, 2, -27 },
  { 1090, 18, 28, 22, 2, -27 },
  { 1153, 18, 27, 22, 2, -27 },
  { 1214, 18, 29, 22, 2, -28 },
  { 1280, 18, 28, 22, 2, -28 },
  { 1343, 8, 21, 22, 7, -20 },
  { 1364, 10, 28, 22, 5, -20 },
  { 1399, 18, 19, 22, 2, -21 },
  { 1442, 18, 12, 22, 2, -18 },
  { 1469, 18, 19, 22, 2, -21 },
  { 1512, 16, 29, 22, 3, -28 },
  { 1570, 20, 34, 22, 1, -28 },
  { 1655, 22, 27, 22, 0, -27 },
  { 1730, 19, 29, 22, 2, -28 },
  { 1799, 20, 29, 22, 1, -28 },
  { 1872, 19, 28, 22, 2, -27 },
  { 1939, 17, 27, 22, 3, -27 },
  { 1997, 16, 27, 22, 3, -27 },
  { 2051, 19, 29, 22, 1, -28 },
  { 2120, 18, 27, 22, 2, -27 },
  { 2181, 18, 27, 22, 2, -27 },
  { 2242, 17, 28, 22, 2, -27 },
  { 2302, 20, 27, 22, 2, -27 },
  { 2370, 17, 27, 22, 3, -27 },
  { 2428, 20, 27, 22, 1, -27 },
  { 2496, 18, 27, 22, 2, -27 },
  { 2557, 20, 29, 22, 1, -28 },
  { 2630, 19, 28, 22, 2, -28 },
  { 2697, 20, 36, 22, 1, -28 },
  { 2787, 20, 28, 22, 2, -28 },
  { 2857, 18, 29, 22, 2, -28 },
  { 2923, 20, 27, 22, 1, -27 },
  { 2991, 18, 28, 22, 2, -27 },
  { 3054, 20, 27, 22, 1, -27 },
  { 3122, 20, 27, 22, 1, -27 },
  { 3190, 22, 27, 22, 0, -27 },
  { 3265, 20, 27, 22, 1, -27 },
  { 3333, 18, 27, 22, 2, -27 },
  { 3394, 12, 38, 22, 5, -31 },
  { 3451, 18, 38, 22, 2, -31 },
  { 3537, 12, 38, 22, 5, -31 },
  { 3594, 21, 14, 22, 1, -27 },
  { 3631, 22, 4, 22, 0, 3 },
  { 3642, 9, 8, 22, 7, -30 },
  { 3651, 17, 23, 22, 2, -22 },
  { 3700, 18, 32, 22, 3, -31 },
  { 3772, 19, 23, 22, 2, -22 },
  { 3827, 18, 32, 22, 1, -31 },
  { 3899, 19, 23, 22, 1, -22 },
  { 3954, 20, 31, 22, 2, -31 },
  { 4032, 18, 30, 22, 1, -22 },
  { 4100, 16, 31, 22, 3, -31 },
  { 4162, 19, 31, 22, 2, -30 },
  { 4236, 16, 38, 22, 2, -30 },
  { 4312, 18, 31, 22, 3, -31 },
  { 4382, 19, 31, 22, 2, -30 },
  { 4456, 20, 22, 22, 1, -22 },
  { 4511, 16, 22, 22, 3, -22 },
  { 4555, 20, 23, 22, 1, -22 },
  { 4613, 18, 29, 22, 3, -22 },
  { 4679, 18, 29, 22, 1, -22 },
  { 4745, 16, 22, 22, 4, -22 },
  { 4789, 17, 23, 22, 2, -22 },
  { 4838, 19, 28, 22, 2, -27 },
  { 4905, 16, 22, 22, 3, -21 },
  { 4949, 20, 21, 22, 1, -21 },
  { 5002, 22, 21, 22, 0, -21 },
  { 5060, 20, 21, 22, 1, -21 },
  { 5113, 20, 29, 22, 1, -21 },
  { 5186, 16, 21, 22, 3, -21 },
  { 5228, 16, 38, 22, 3, -31 },
  { 5304, 6, 38, 22, 8, -31 },
  { 5333, 16, 38, 22, 3, -31 },
  { 5409, 20, 8, 22, 1, -16 },
};

const GFXfont UbuntuMono_Bold44pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Bold44pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Bold44pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _UBUNTUMONO_BOLD44PT7B_H_
