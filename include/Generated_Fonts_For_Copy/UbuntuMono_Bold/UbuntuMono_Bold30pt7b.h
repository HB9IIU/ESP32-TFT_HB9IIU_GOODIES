#ifndef _UBUNTUMONO_BOLD30PT7B_H_
#define _UBUNTUMONO_BOLD30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Bold.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Bold30pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0x9C, 0xE7, 0x00, 0x0E, 0xFF,
  0xDC, 0xF3, 0xF9, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0x0E, 0x70,
  0x73, 0x83, 0x9C, 0x38, 0xE1, 0xC7, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x38,
  0xE1, 0xC7, 0x0E, 0x79, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xC7, 0x0E, 0x38,
  0x73, 0x83, 0x9C, 0x1C, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x3F, 0xE3,
  0xFF, 0x3F, 0xF9, 0xE0, 0xCF, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7B, 0x03, 0xFF, 0xFD,
  0xFF, 0xC3, 0xFC, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x38, 0x0E, 0xF8, 0x39,
  0xB8, 0x67, 0x31, 0xCE, 0x67, 0x1C, 0xCC, 0x1B, 0xB8, 0x3E, 0xE0, 0x39,
  0x80, 0x07, 0x00, 0x0C, 0xE0, 0x3B, 0xE0, 0xEE, 0xC1, 0x99, 0xC7, 0x33,
  0x9C, 0x67, 0x30, 0xEC, 0xE0, 0xFB, 0x80, 0xE0, 0x1F, 0x01, 0xFC, 0x1F,
  0xF0, 0xF3, 0x87, 0x1C, 0x38, 0xE1, 0xEF, 0x07, 0xF0, 0x3F, 0x01, 0xF1,
  0xDF, 0xCF, 0xEF, 0xEE, 0x3F, 0x70, 0xFB, 0x87, 0x9E, 0x3E, 0xFF, 0xF3,
  0xFF, 0xCF, 0x8E, 0xFF, 0xFE, 0xEE, 0xEE, 0xE0, 0x01, 0x01, 0xE0, 0xF8,
  0x78, 0x3C, 0x0F, 0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xF0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0x80, 0x40, 0x40, 0x78, 0x3E, 0x07, 0x81, 0xE0, 0xF0,
  0x3C, 0x0E, 0x07, 0x83, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x07,
  0x83, 0xC1, 0xC1, 0xE1, 0xE0, 0xF1, 0xF1, 0xF0, 0xF0, 0x20, 0x00, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0xCE, 0x67, 0xBF, 0x3F, 0xFB, 0xFF, 0xE1, 0xF0,
  0x1D, 0xC1, 0xEF, 0x0F, 0x38, 0x11, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x00, 0x39, 0xF7, 0xDF, 0x3C, 0x71, 0xDE, 0xF3,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x70,
  0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03,
  0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0x80, 0x00, 0x0F, 0x81, 0xFF, 0x0F, 0xF8, 0xF1, 0xE7,
  0x07, 0x78, 0x3F, 0xC1, 0xFC, 0xE7, 0xE7, 0x3F, 0x39, 0xF9, 0xCF, 0xC0,
  0x7F, 0x07, 0xF8, 0x3D, 0xC1, 0xCF, 0x1E, 0x3F, 0xE1, 0xFF, 0x03, 0xE0,
  0x03, 0x80, 0x3C, 0x07, 0xE0, 0x7F, 0x07, 0xF8, 0x3F, 0xC1, 0x9E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0x1F, 0x83, 0xFE, 0x3F, 0xF8,
  0xE3, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x7F, 0xFB, 0xFF,
  0xDF, 0xFE, 0x1F, 0x83, 0xFE, 0x1F, 0xF8, 0x43, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x3C, 0x1F, 0xC0, 0xFE, 0x07, 0xFC, 0x03, 0xE0, 0x07, 0x00,
  0x3C, 0x01, 0xC8, 0x1E, 0x7F, 0xF7, 0xFF, 0x0F, 0xE0, 0x01, 0xE0, 0x0F,
  0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0x70, 0x73, 0x87, 0x9C, 0x38, 0xE3,
  0xC7, 0x1C, 0x39, 0xE1, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x3F, 0xF3, 0xFF, 0x3F, 0xF3, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0xF0, 0x3F, 0xC3, 0xFE, 0x03, 0xF0, 0x0F, 0x00, 0x70,
  0x07, 0x00, 0xF4, 0x1F, 0xFF, 0xEF, 0xFC, 0x7F, 0x00, 0x00, 0xF0, 0x3F,
  0x83, 0xFC, 0x3F, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x0F, 0xF8, 0x7F, 0xE7,
  0xFF, 0xBC, 0x3D, 0xE0, 0xFF, 0x07, 0xB8, 0x3D, 0xE1, 0xCF, 0x1E, 0x3F,
  0xF1, 0xFF, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x1E,
  0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00,
  0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x0F,
  0x81, 0xFF, 0x1F, 0xFC, 0xF1, 0xE7, 0x07, 0x38, 0x39, 0xC1, 0xCF, 0x1E,
  0x3F, 0xE0, 0xFE, 0x0F, 0xF8, 0xF3, 0xEF, 0x07, 0xF8, 0x3F, 0xC1, 0xFF,
  0x1F, 0x7F, 0xF1, 0xFF, 0x07, 0xF0, 0x0F, 0x81, 0xFE, 0x1F, 0xF8, 0xF1,
  0xE7, 0x07, 0x78, 0x3B, 0xC1, 0xFE, 0x0F, 0x78, 0x7B, 0xFF, 0xCF, 0xFE,
  0x3F, 0xE0, 0x0F, 0x00, 0xF8, 0x0F, 0x81, 0xF8, 0x3F, 0x81, 0xF8, 0x0F,
  0x00, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x03, 0xBF, 0xFF, 0xB8, 0x39, 0xF7,
  0xDF, 0x38, 0x00, 0x00, 0x00, 0xE7, 0xDF, 0x7C, 0xF1, 0xC6, 0x7B, 0xCC,
  0x00, 0x00, 0x10, 0x07, 0x80, 0xFE, 0x3F, 0xE7, 0xFC, 0x7F, 0x03, 0xE0,
  0x1F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xE0, 0x01, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x40, 0x03, 0xC0, 0x3F, 0x80, 0xFF, 0x81, 0xFF, 0x01, 0xFC,
  0x01, 0xE0, 0x7F, 0x1F, 0xF3, 0xFE, 0x3F, 0x80, 0xF0, 0x04, 0x00, 0x00,
  0x3F, 0x1F, 0xFB, 0xFF, 0x21, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x07,
  0x81, 0xF0, 0x7C, 0x0F, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x3E, 0x07,
  0xC0, 0x78, 0x00, 0x0F, 0xC0, 0xFF, 0x0E, 0x1C, 0xE0, 0x66, 0x03, 0xF1,
  0xFF, 0x9F, 0xFC, 0xFF, 0xCF, 0x3E, 0x71, 0xF3, 0x8F, 0x9C, 0x7C, 0xE3,
  0xE7, 0x1F, 0x3C, 0xFC, 0xFF, 0xE3, 0xFF, 0x0F, 0xDC, 0x00, 0xE0, 0x03,
  0xC0, 0x0F, 0xF8, 0x1F, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7F,
  0x00, 0xEE, 0x01, 0xDC, 0x03, 0xBC, 0x0F, 0x78, 0x1C, 0x70, 0x38, 0xE0,
  0xF1, 0xE1, 0xE3, 0xC3, 0xFF, 0x87, 0xFF, 0x1F, 0xFF, 0x3C, 0x1E, 0x78,
  0x3C, 0xE0, 0x7B, 0xC0, 0x78, 0xFF, 0x0F, 0xFC, 0xFF, 0xEE, 0x1E, 0xE1,
  0xEE, 0x0E, 0xE1, 0xEE, 0x1C, 0xFF, 0xCF, 0xFC, 0xFF, 0xEE, 0x1F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xFF, 0xEF, 0xFC, 0xFF, 0x80, 0x07, 0xF0,
  0xFF, 0xCF, 0xFE, 0xF8, 0x27, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x82,
  0x3F, 0xF8, 0xFF, 0xC1, 0xFC, 0xFE, 0x0F, 0xF8, 0xFF, 0xCE, 0x3E, 0xE1,
  0xEE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE1, 0xEE, 0x3E, 0xFF, 0xCF, 0xF8, 0xFE, 0x00, 0xFF, 0xEF,
  0xFE, 0xFF, 0xEF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xCF,
  0xFC, 0xFF, 0xCF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xFF, 0xDF, 0xFB, 0xFF, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0xF8, 0xFF, 0xCF, 0xFC, 0xF8,
  0x27, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3D, 0xE1, 0xEF, 0x8F, 0x3F, 0xF8, 0xFF, 0xC1,
  0xFE, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF,
  0x87, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xF3, 0xFF, 0x3F, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF6, 0x1F, 0x7F,
  0xEF, 0xFC, 0x3F, 0x80, 0xF0, 0x7B, 0xC3, 0xCF, 0x0F, 0x3C, 0x78, 0xF3,
  0xC3, 0xCF, 0x0F, 0x78, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x3D,
  0xF0, 0xF3, 0xC3, 0xC7, 0x8F, 0x1F, 0x3C, 0x3C, 0xF0, 0xFB, 0xC1, 0xEF,
  0x07, 0xC0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x70, 0x73, 0x83, 0x9E, 0x3D,
  0xF1, 0xEF, 0x8F, 0xFE, 0xFF, 0xB6, 0xFD, 0xB7, 0xEF, 0xBF, 0x7D, 0xF9,
  0xCF, 0xCE, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0E, 0xF0, 0x7F, 0x83, 0xFE, 0x1F, 0xF0, 0xFF, 0xC7, 0xFE, 0x3F,
  0xF9, 0xFF, 0xCF, 0xF7, 0x7F, 0xBB, 0xFC, 0xFF, 0xE7, 0xFF, 0x1F, 0xF8,
  0xFF, 0xC3, 0xFE, 0x1F, 0xF0, 0x7F, 0x83, 0xFC, 0x1E, 0x0F, 0x81, 0xFF,
  0x1F, 0xFC, 0xF1, 0xEF, 0x07, 0x78, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xEF, 0x1E, 0x7F,
  0xF1, 0xFF, 0x03, 0xE0, 0xFF, 0x0F, 0xFC, 0xFF, 0xEE, 0x1F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF, 0x1F, 0xFF, 0xEF, 0xFC, 0xFF, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x0F, 0x81, 0xFF,
  0x0F, 0xFC, 0xF1, 0xE7, 0x07, 0x78, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xEF, 0x1E, 0x7F,
  0xF1, 0xFF, 0x03, 0xE0, 0x0E, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xE0, 0x06,
  0xFF, 0x07, 0xFE, 0x3F, 0xF1, 0xC7, 0xCE, 0x1E, 0x70, 0x73, 0x83, 0x9C,
  0x3C, 0xE3, 0xE7, 0xFF, 0x3F, 0xF1, 0xFF, 0x0E, 0x38, 0x71, 0xE3, 0x87,
  0x9C, 0x3C, 0xE0, 0xF7, 0x07, 0xB8, 0x1C, 0x0F, 0xC1, 0xFF, 0x9F, 0xF8,
  0xF0, 0x47, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0xFF, 0x01,
  0xFC, 0x03, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xEC, 0x1F, 0x7F, 0xF7, 0xFF,
  0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xEF, 0x1E, 0x7F,
  0xF1, 0xFF, 0x07, 0xF0, 0xF0, 0x1E, 0xF0, 0x79, 0xE0, 0xF3, 0xC1, 0xE7,
  0x83, 0xC7, 0x07, 0x0E, 0x0E, 0x1E, 0x3C, 0x3C, 0x78, 0x38, 0xE0, 0x71,
  0xC0, 0xF7, 0x80, 0xEF, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0xE7, 0xE7, 0x3F, 0x7D, 0xFB, 0xEF, 0xDB, 0x7E,
  0xDB, 0xFE, 0xFF, 0xE3, 0xFF, 0x1F, 0x78, 0xF3, 0x83, 0x9C, 0x1C, 0x78,
  0x3C, 0xF0, 0x78, 0xF1, 0xE0, 0xE3, 0xC1, 0xEF, 0x01, 0xDC, 0x03, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x7F, 0x00, 0xEF, 0x03,
  0xDE, 0x0F, 0x1E, 0x1E, 0x3C, 0x78, 0x3C, 0xF0, 0x79, 0xE0, 0xF0, 0x78,
  0x1C, 0xF0, 0x79, 0xE0, 0xF1, 0xE1, 0xC3, 0xC7, 0x83, 0x8F, 0x07, 0x9C,
  0x0F, 0x78, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x7F,
  0xF3, 0xFF, 0x9F, 0xFC, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF0,
  0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0,
  0x70, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03,
  0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xC0, 0x0F, 0x80, 0x3F, 0x80, 0x77, 0x01, 0xEF, 0x07, 0x8F,
  0x0F, 0x0E, 0x3C, 0x1E, 0xF8, 0x1E, 0x20, 0x30, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x43, 0xCF, 0x9F, 0x08, 0x3F, 0x83, 0xFE, 0x3F, 0xF0, 0x0F,
  0x00, 0x71, 0xFF, 0x7F, 0xF7, 0xFF, 0xF8, 0x7F, 0x07, 0xF0, 0x77, 0xFF,
  0x7F, 0xF1, 0xFE, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0xF8, 0xFF, 0xCF, 0xFE, 0xF1, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1E, 0xFF, 0xEF, 0xFC, 0x7F, 0x00, 0x07,
  0xF0, 0xFF, 0xCF, 0xFC, 0xF8, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7F, 0xF1, 0xFF, 0x83, 0xF8, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF1, 0xEF, 0x3F, 0xF7,
  0xFF, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x8F, 0x7F, 0xF3, 0xFF, 0x1F, 0xE0, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xF1,
  0xEF, 0x07, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1E, 0x0C,
  0xFF, 0xE3, 0xFF, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xF0, 0xFF, 0x83, 0xC2,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x3F, 0xFE, 0xFF, 0xFB, 0xFF, 0xE1, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0xE3, 0xFF, 0x7F, 0xF7, 0x8F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x8F, 0x7F, 0xF3, 0xFF,
  0x1F, 0xF0, 0x0F, 0x00, 0xF4, 0x1F, 0x7F, 0xEF, 0xFC, 0x3F, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xF8, 0xFF, 0xDF,
  0xFF, 0xC7, 0xF8, 0xFF, 0x1F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0E, 0x0E, 0x00, 0xF0, 0x07, 0xC0, 0x3C, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x41, 0xFE, 0x0F,
  0xF0, 0x3F, 0x00, 0x01, 0xC0, 0x78, 0x0F, 0x81, 0xE0, 0x1C, 0x00, 0x00,
  0x01, 0xFF, 0x3F, 0xE7, 0xFC, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xD8, 0x7B, 0xFE,
  0x7F, 0xC7, 0xE0, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x3E, 0xF1, 0xE7, 0x9E, 0x3D, 0xE1, 0xFE, 0x0F, 0xE0,
  0x7F, 0x03, 0xFC, 0x1E, 0xF0, 0xF7, 0xC7, 0x9E, 0x3C, 0x79, 0xE1, 0xEF,
  0x0F, 0x00, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x41, 0xFE, 0x0F, 0xF0, 0x3F,
  0x00, 0x7D, 0xE7, 0xFF, 0xBF, 0xFF, 0xCE, 0x7E, 0x73, 0xF3, 0x9F, 0x9C,
  0xFC, 0xE7, 0xE7, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1C,
  0x7F, 0x1F, 0xFB, 0xFF, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xC0, 0x0F, 0x81, 0xFF, 0x1F,
  0xFC, 0xF1, 0xEF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xDE, 0x3C, 0xFF, 0xE3, 0xFE, 0x07, 0xC0, 0x7F, 0x0F, 0xFC, 0xFF, 0xEF,
  0x1E, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xEF,
  0xFE, 0xFF, 0xCF, 0xF8, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00,
  0x0F, 0xE3, 0xFF, 0x7F, 0xF7, 0x8F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF8, 0xF7, 0xFF, 0x3F, 0xF1, 0xFF, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x00, 0x1F, 0xCF, 0xFF, 0xFF, 0x78, 0x2F, 0x01, 0xF8, 0x1F, 0xE1, 0xFE,
  0x07, 0xE0, 0x3F, 0x07, 0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x06, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x21, 0xFF, 0x0F,
  0xF8, 0x3F, 0xC0, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFE, 0x3F, 0xC7, 0xFF, 0xF7, 0xFE, 0x3F, 0x80, 0x70,
  0x1C, 0xF0, 0x79, 0xE0, 0xF1, 0xC1, 0xC3, 0xC7, 0x87, 0x8F, 0x07, 0x1C,
  0x0F, 0x78, 0x1E, 0xE0, 0x1D, 0xC0, 0x3F, 0x80, 0x3E, 0x00, 0x7C, 0x00,
  0x70, 0x00, 0xF0, 0x1F, 0xE0, 0x3D, 0xC0, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x9D, 0xF7, 0x3B, 0xEE, 0x76, 0xDC, 0xFD, 0xF0, 0xFB, 0xE1, 0xE3,
  0xC3, 0xC7, 0x87, 0x0F, 0x00, 0xF0, 0x7B, 0xC3, 0x9E, 0x3C, 0x7B, 0xC1,
  0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0xC1, 0xEF, 0x0E, 0x78, 0xF1,
  0xEF, 0x07, 0xF8, 0x3C, 0xF0, 0x7B, 0x83, 0xDE, 0x1C, 0xF0, 0xE7, 0x8F,
  0x1C, 0x78, 0xF3, 0x87, 0x9C, 0x1F, 0xE0, 0xFE, 0x03, 0xF0, 0x1F, 0x80,
  0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0xFE, 0x07, 0xE0, 0x3E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x81, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x81, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xE1, 0xFC, 0x7F, 0x8F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x7E, 0x0F,
  0x01, 0xF8, 0x07, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0x7F, 0x0F, 0xE0, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x1F, 0xC3, 0xFC, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xF0, 0x1E, 0x0F,
  0xC1, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC7, 0xF0, 0xFE, 0x1F, 0x80, 0x3C, 0x19, 0xFC, 0xEF, 0xFF, 0xBF, 0xFE,
  0xE3, 0xF1, 0x87, 0x80,
};

const GFXglyph UbuntuMono_Bold30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 5, 19, 15, 5, -19 },
  { 13, 9, 8, 15, 3, -20 },
  { 22, 13, 19, 15, 1, -19 },
  { 53, 13, 24, 15, 1, -21 },
  { 92, 15, 19, 15, 0, -19 },
  { 128, 13, 19, 15, 1, -19 },
  { 159, 4, 9, 15, 6, -20 },
  { 164, 10, 26, 15, 3, -21 },
  { 197, 9, 26, 15, 3, -21 },
  { 227, 13, 12, 15, 1, -19 },
  { 247, 13, 13, 15, 1, -14 },
  { 269, 6, 10, 15, 4, -5 },
  { 277, 9, 4, 15, 3, -9 },
  { 282, 5, 5, 15, 5, -5 },
  { 286, 13, 26, 15, 1, -21 },
  { 329, 13, 19, 15, 1, -19 },
  { 360, 13, 19, 15, 1, -19 },
  { 391, 13, 19, 15, 1, -19 },
  { 422, 13, 19, 15, 1, -19 },
  { 453, 13, 19, 15, 1, -19 },
  { 484, 12, 19, 15, 1, -19 },
  { 513, 13, 19, 15, 1, -19 },
  { 544, 13, 19, 15, 1, -19 },
  { 575, 13, 19, 15, 1, -19 },
  { 606, 13, 19, 15, 1, -19 },
  { 637, 5, 14, 15, 5, -14 },
  { 646, 6, 19, 15, 4, -14 },
  { 661, 13, 13, 15, 1, -14 },
  { 683, 13, 9, 15, 1, -12 },
  { 698, 13, 13, 15, 1, -14 },
  { 720, 11, 19, 15, 2, -19 },
  { 747, 13, 23, 15, 1, -19 },
  { 785, 15, 19, 15, 0, -19 },
  { 821, 12, 19, 15, 2, -19 },
  { 850, 13, 19, 15, 1, -19 },
  { 881, 12, 19, 15, 2, -19 },
  { 910, 12, 19, 15, 2, -19 },
  { 939, 11, 19, 15, 2, -19 },
  { 966, 13, 19, 15, 1, -19 },
  { 997, 13, 19, 15, 1, -19 },
  { 1028, 11, 19, 15, 2, -19 },
  { 1055, 12, 19, 15, 1, -19 },
  { 1084, 14, 19, 15, 1, -19 },
  { 1118, 12, 19, 15, 2, -19 },
  { 1147, 13, 19, 15, 1, -19 },
  { 1178, 13, 19, 15, 1, -19 },
  { 1209, 13, 19, 15, 1, -19 },
  { 1240, 12, 19, 15, 2, -19 },
  { 1269, 13, 24, 15, 1, -19 },
  { 1308, 13, 19, 15, 2, -19 },
  { 1339, 13, 19, 15, 1, -19 },
  { 1370, 13, 19, 15, 1, -19 },
  { 1401, 13, 19, 15, 1, -19 },
  { 1432, 15, 19, 15, 0, -19 },
  { 1468, 13, 19, 15, 1, -19 },
  { 1499, 15, 19, 15, 0, -19 },
  { 1535, 15, 19, 15, 0, -19 },
  { 1571, 13, 19, 15, 1, -19 },
  { 1602, 9, 26, 15, 3, -21 },
  { 1632, 13, 26, 15, 1, -21 },
  { 1675, 9, 26, 15, 3, -21 },
  { 1705, 15, 10, 15, 0, -19 },
  { 1724, 15, 3, 15, 0, 2 },
  { 1730, 6, 5, 15, 5, -21 },
  { 1734, 12, 14, 15, 1, -14 },
  { 1755, 12, 21, 15, 2, -21 },
  { 1787, 13, 14, 15, 1, -14 },
  { 1810, 12, 21, 15, 1, -21 },
  { 1842, 13, 14, 15, 1, -14 },
  { 1865, 14, 21, 15, 1, -21 },
  { 1902, 12, 19, 15, 1, -14 },
  { 1931, 11, 21, 15, 2, -21 },
  { 1960, 13, 21, 15, 1, -21 },
  { 1995, 11, 26, 15, 1, -21 },
  { 2031, 13, 21, 15, 2, -21 },
  { 2066, 13, 21, 15, 1, -21 },
  { 2101, 13, 14, 15, 1, -14 },
  { 2124, 11, 14, 15, 2, -14 },
  { 2144, 13, 14, 15, 1, -14 },
  { 2167, 12, 19, 15, 2, -14 },
  { 2196, 12, 19, 15, 1, -14 },
  { 2225, 11, 14, 15, 3, -14 },
  { 2245, 11, 14, 15, 2, -14 },
  { 2265, 13, 18, 15, 1, -18 },
  { 2295, 11, 14, 15, 2, -14 },
  { 2315, 15, 14, 15, 0, -14 },
  { 2342, 15, 14, 15, 0, -14 },
  { 2369, 13, 14, 15, 1, -14 },
  { 2392, 13, 19, 15, 1, -14 },
  { 2423, 11, 14, 15, 2, -14 },
  { 2443, 11, 26, 15, 2, -21 },
  { 2479, 3, 26, 15, 6, -21 },
  { 2489, 11, 26, 15, 2, -21 },
  { 2525, 14, 6, 15, 1, -11 },
};

const GFXfont UbuntuMono_Bold30pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Bold30pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Bold30pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _UBUNTUMONO_BOLD30PT7B_H_
