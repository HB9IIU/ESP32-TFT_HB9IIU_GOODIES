#ifndef _UBUNTUMONO_BOLD41PT7B_H_
#define _UBUNTUMONO_BOLD41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Bold.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Bold41pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3C, 0x00, 0x00, 0x03, 0xCF, 0xDF, 0xFF, 0xFE, 0x78, 0xF8,
  0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFE, 0x1F,
  0xF0, 0xF7, 0x87, 0x9C, 0x1C, 0xE0, 0xE0, 0x03, 0xC7, 0x80, 0x78, 0xF0,
  0x1F, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0xF8, 0x0F, 0x1E, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3C, 0x78, 0x07, 0x8F, 0x01,
  0xF1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x9E, 0x1E, 0x03, 0xC7, 0xC0, 0x78, 0xF0, 0x1F,
  0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF,
  0xFE, 0x3F, 0x03, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x78, 0x0F, 0xDF, 0xFF, 0xE7, 0xFF, 0xF1, 0xFF, 0xF8, 0x0F, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0xF3, 0xF0, 0x0E, 0x7F, 0x81, 0xE7, 0x38, 0x3C, 0xF3, 0xC3, 0x8F, 0x3C,
  0x78, 0xF3, 0xCF, 0x0F, 0x3C, 0xE0, 0x73, 0x9E, 0x07, 0xFB, 0xC0, 0x3F,
  0x38, 0x01, 0xE7, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x7C, 0x01, 0xEF, 0xE0,
  0x3D, 0xFE, 0x03, 0x9E, 0xF0, 0x79, 0xC7, 0x0F, 0x1C, 0x70, 0xE1, 0xC7,
  0x1E, 0x1C, 0x73, 0xC1, 0xEF, 0x38, 0x1F, 0xE7, 0x80, 0xFE, 0xF0, 0x07,
  0xC0, 0x07, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xE3,
  0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE3, 0xE0, 0x3E, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0x80, 0x07, 0xE1, 0xE3, 0xFC, 0x3C, 0xFF, 0xCF, 0x9F, 0x7D,
  0xE7, 0xC7, 0xFC, 0xF0, 0xFF, 0x9E, 0x0F, 0xF3, 0xC0, 0xFC, 0x7C, 0x0F,
  0x8F, 0x87, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xBE, 0x0F, 0xC3,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x9C, 0xE0, 0x00, 0x20, 0x07,
  0x80, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x01,
  0xF0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0x7C, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3C, 0x00, 0x40, 0x30, 0x00, 0xE0, 0x07,
  0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F,
  0x00, 0xFC, 0x07, 0xE0, 0x7F, 0x01, 0xF8, 0x03, 0x80, 0x04, 0x00, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x0C, 0x78, 0x47, 0x9C, 0xF3, 0xEF, 0xFB,
  0xFF, 0xFD, 0xFF, 0xFF, 0x03, 0xE0, 0x07, 0xF8, 0x07, 0xDE, 0x07, 0xEF,
  0x83, 0xE3, 0xE0, 0xF1, 0xC0, 0x10, 0x40, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x0E, 0x1F,
  0x8F, 0xE7, 0xF3, 0xF9, 0xFC, 0x3E, 0x0F, 0x07, 0x07, 0x8F, 0x9F, 0x8F,
  0x83, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x79, 0xFB, 0xFF,
  0xFF, 0xFF, 0x9E, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x03,
  0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0x1F, 0x9F, 0x83, 0xE7, 0xC0,
  0x79, 0xF0, 0x1F, 0x78, 0x07, 0xDE, 0x01, 0xFF, 0x8E, 0x7F, 0xE7, 0x9F,
  0xF9, 0xF7, 0xFE, 0x79, 0xFF, 0x8E, 0x7D, 0xE0, 0x1F, 0x78, 0x07, 0xDF,
  0x01, 0xF7, 0xC0, 0x79, 0xF8, 0x3E, 0x3F, 0x1F, 0x8F, 0xFF, 0xC1, 0xFF,
  0xE0, 0x3F, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x01, 0xFC,
  0x01, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0xFB, 0xE0, 0x71,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x03, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x80,
  0x0F, 0xE0, 0x1F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xC7, 0x87, 0xE1, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x7F, 0xF8, 0xFF, 0xFC,
  0x7F, 0xFE, 0x70, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7E, 0x0F, 0xFC, 0x0F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xE0, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3D, 0xF0,
  0x1F, 0x7C, 0x0F, 0x9F, 0x03, 0xC7, 0xC1, 0xF1, 0xF0, 0xF8, 0x7C, 0x3C,
  0x1F, 0x1F, 0x07, 0xC7, 0x81, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3,
  0xFF, 0xE1, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xF0, 0x07, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF6,
  0x03, 0xFB, 0xFF, 0xF9, 0xFF, 0xF9, 0xFF, 0xF8, 0x1F, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3F, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF,
  0xCF, 0xFF, 0xF7, 0xC1, 0xFB, 0xE0, 0x7D, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x07, 0xCF, 0x83, 0xE7, 0xE3, 0xF3, 0xFF, 0xF0, 0xFF, 0xF8,
  0x3F, 0xF0, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xC3, 0xF7, 0xC0, 0xFB,
  0xE0, 0x3D, 0xF0, 0x3E, 0xF8, 0x1F, 0x3F, 0x0F, 0x1F, 0xCF, 0x87, 0xFF,
  0x81, 0xFF, 0x81, 0xFF, 0xE1, 0xF3, 0xFD, 0xF0, 0x7E, 0xF8, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xFF, 0xF9, 0xFF, 0xF8,
  0x7F, 0xF8, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x0F,
  0xFF, 0xC7, 0xC3, 0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x1E, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x83, 0xF7, 0xFF, 0xF9, 0xFF, 0xFC, 0x7F,
  0xFC, 0x1F, 0xBE, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x3F, 0x80,
  0x7F, 0x83, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x00, 0x3C, 0x00, 0x00, 0x79,
  0xFB, 0xFF, 0xFF, 0xFF, 0x9E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x9F, 0xBF,
  0xFF, 0xFF, 0xF9, 0xE0, 0x1E, 0x1F, 0x8F, 0xE7, 0xF3, 0xF9, 0xF8, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE1, 0xF8, 0xFE, 0x7F, 0x3F, 0x9F,
  0xC7, 0xE0, 0xE0, 0xF0, 0xF8, 0xF9, 0xF8, 0xF8, 0x70, 0x00, 0x00, 0x03,
  0x00, 0x07, 0x80, 0x1F, 0xC0, 0x3F, 0xF0, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF,
  0x81, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x0F, 0xFC, 0x01, 0xFC, 0x00, 0x1E, 0x00, 0x03, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x40, 0x00, 0x3C, 0x00, 0x3F, 0x80, 0x1F, 0xF8, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0x80, 0x7F, 0xC0, 0xFF,
  0xE3, 0xFF, 0xCF, 0xFF, 0x07, 0xFE, 0x03, 0xF8, 0x00, 0xF0, 0x00, 0x40,
  0x00, 0x00, 0x1F, 0xC1, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF, 0xE7, 0x0F, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x0F,
  0x00, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7C, 0x3E, 0x3C, 0x07,
  0x8E, 0x00, 0xF7, 0x80, 0x3D, 0xE1, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF,
  0x1F, 0xFF, 0xCF, 0x8F, 0xF3, 0xE3, 0xFC, 0xF0, 0xFE, 0x3C, 0x3F, 0x8F,
  0x0F, 0xE3, 0xC3, 0xF8, 0xF0, 0xFF, 0x3E, 0x3F, 0xCF, 0x8F, 0xF1, 0xFF,
  0xFC, 0x7F, 0xF7, 0x0F, 0xFD, 0xE0, 0xFF, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x02, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF8, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xE0, 0x03, 0xDE, 0x00, 0x79, 0xE0, 0x07, 0x9F, 0x00, 0x79, 0xF0,
  0x0F, 0x8F, 0x00, 0xF0, 0xF8, 0x0F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x07,
  0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xE0,
  0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xF7, 0xC0, 0x3F, 0xFC,
  0x01, 0xF0, 0x7F, 0xE0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0x83,
  0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x1F, 0x3F,
  0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0xE7, 0xFF, 0xFB, 0xE0, 0x7F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0xFF,
  0xFB, 0xFF, 0xF9, 0xFF, 0xF8, 0x7F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0xFF,
  0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0x83, 0x8F, 0xC0, 0x27, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x02, 0x3F, 0x83, 0x87, 0xFF, 0xF0, 0xFF, 0xFC,
  0x1F, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F,
  0xFF, 0xCF, 0x87, 0xF7, 0xC1, 0xFB, 0xE0, 0x7D, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x07, 0xDF, 0x07, 0xEF,
  0x87, 0xE7, 0xFF, 0xF3, 0xFF, 0xF1, 0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFF, 0xFC, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xFF, 0xF7, 0xFF, 0xEF,
  0xFF, 0xDF, 0xFF, 0xBE, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x00, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0x81, 0x8F,
  0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xFC, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7D, 0xF8, 0x1F, 0x3F, 0x07, 0xC7,
  0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F,
  0xFF, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x40, 0x3F, 0x70, 0x7E, 0xFF,
  0xFE, 0xFF, 0xFC, 0x7F, 0xF8, 0x1F, 0xE0, 0xF8, 0x1F, 0xBE, 0x07, 0xCF,
  0x83, 0xF3, 0xE0, 0xF8, 0xF8, 0x7E, 0x3E, 0x3F, 0x0F, 0x8F, 0x83, 0xE7,
  0xE0, 0xFB, 0xF0, 0x3E, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xC0,
  0x3F, 0xF8, 0x0F, 0xBF, 0x03, 0xE7, 0xE0, 0xF8, 0xFC, 0x3E, 0x3F, 0x0F,
  0x87, 0xE3, 0xE0, 0xFC, 0xF8, 0x3F, 0x3E, 0x07, 0xEF, 0x81, 0xFB, 0xE0,
  0x3E, 0xF8, 0x0F, 0xC0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7C, 0x07, 0x8F, 0x81, 0xF1, 0xF0,
  0x3E, 0x3F, 0x07, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x9D, 0xC7, 0xF3, 0xB9,
  0xFE, 0x77, 0x3B, 0xCE, 0x77, 0x79, 0xCF, 0xEF, 0x39, 0xF9, 0xEF, 0x3F,
  0x3D, 0xE3, 0xE7, 0xBC, 0x7C, 0xF7, 0x8F, 0x1E, 0xF0, 0x03, 0xDF, 0x00,
  0x7B, 0xE0, 0x0F, 0x7C, 0x01, 0xEF, 0x80, 0x3D, 0xF0, 0x07, 0xBE, 0x00,
  0xF7, 0xC0, 0x1F, 0xF8, 0x03, 0xE0, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF,
  0x8F, 0xFB, 0xC7, 0xFC, 0xF3, 0xFE, 0x79, 0xFF, 0x1E, 0xFF, 0x8F, 0x7F,
  0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x07,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0x80,
  0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x3E, 0x1F, 0x9F,
  0x03, 0xE7, 0xC0, 0x7D, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x3E, 0x3E, 0x1F, 0x8F,
  0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xF0, 0x00, 0xFF, 0xF0, 0x7F,
  0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xE0, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC,
  0x3E, 0x1F, 0x9F, 0x03, 0xE7, 0xC0, 0x7D, 0xF0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x3E,
  0x3E, 0x1F, 0x8F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00,
  0x78, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01,
  0xFC, 0x00, 0x0E, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8,
  0xF8, 0x7F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E,
  0x07, 0xCF, 0x87, 0xF3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFE, 0x0F, 0xFF,
  0x83, 0xE3, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x8F, 0x83, 0xE3, 0xE0, 0xFC,
  0xF8, 0x1F, 0x3E, 0x07, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x07, 0xC0,
  0x07, 0xF8, 0x0F, 0xFF, 0x8F, 0xFF, 0x8F, 0xFF, 0xCF, 0xC0, 0x47, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x03, 0xE8, 0x03, 0xF7, 0x03, 0xF7, 0xFF, 0xFB, 0xFF,
  0xF9, 0xFF, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xEF, 0xC3, 0xF3,
  0xFF, 0xF9, 0xFF, 0xF8, 0x7F, 0xF8, 0x07, 0xF0, 0x00, 0xF8, 0x03, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0x7C, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F,
  0x03, 0xF3, 0xE0, 0x7C, 0x3C, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x3C, 0x1F,
  0x0F, 0x81, 0xE1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0x80, 0x78, 0xF0, 0x0F,
  0x3E, 0x01, 0xF7, 0x80, 0x3E, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0x7C, 0x01, 0xEF, 0x80, 0x3D, 0xF0, 0x07, 0xBC,
  0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x3C, 0x7B, 0xC7, 0xCF, 0x78,
  0xF9, 0xEF, 0x3F, 0x3D, 0xE7, 0xE7, 0x9C, 0xEE, 0xF3, 0xBD, 0xDE, 0x77,
  0x3B, 0xCE, 0xE7, 0xF9, 0xDC, 0x7F, 0x3F, 0x0F, 0xE7, 0xE1, 0xFC, 0xFC,
  0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x07, 0x80, 0x7E, 0x03, 0xE3,
  0xE0, 0x3E, 0x3F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x8F, 0x80, 0xF8, 0xF8,
  0x07, 0xDF, 0x00, 0x7D, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xDF, 0x00, 0xF9, 0xF8, 0x0F, 0x8F, 0x81, 0xF0, 0xFC, 0x1F,
  0x07, 0xC3, 0xE0, 0x7E, 0x3E, 0x03, 0xE7, 0xE0, 0x3E, 0x7C, 0x03, 0xF0,
  0xF8, 0x03, 0xFF, 0x00, 0xFB, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0xF8,
  0x7C, 0x1F, 0x0F, 0x87, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x01, 0xE7, 0xC0,
  0x3E, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x03, 0xF0, 0x03,
  0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x03, 0xFE, 0x00, 0xFB, 0xE0, 0x3F, 0x7C, 0x07, 0xC7, 0xC1,
  0xF0, 0xFC, 0x7E, 0x0F, 0x8F, 0x80, 0xFB, 0xF0, 0x1F, 0xBC, 0x01, 0xE1,
  0x80, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x20, 0x1C, 0x1F, 0x1F, 0xE3, 0xF8, 0x78, 0x0C, 0x1F, 0xF0, 0x3F, 0xFC,
  0x3F, 0xFE, 0x3F, 0xFE, 0x20, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x0F, 0xFF,
  0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xFC, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x0F, 0xFC, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFB, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE,
  0xF8, 0x7E, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x7E, 0xFF, 0xFE,
  0xFF, 0xFC, 0xFF, 0xF8, 0x3F, 0xE0, 0x01, 0xFE, 0x07, 0xFF, 0xC7, 0xFF,
  0xC7, 0xFF, 0xE7, 0xF0, 0x13, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01,
  0xFC, 0x00, 0x7F, 0xFF, 0x1F, 0xFF, 0x87, 0xFF, 0xC0, 0x7F, 0xC0, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x83, 0xF7, 0xC7, 0xFF, 0xE7, 0xFF,
  0xF7, 0xFF, 0xFB, 0xF0, 0xFD, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x7D, 0xF0, 0x3E,
  0xFC, 0x1F, 0x3F, 0xFF, 0x9F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0x80, 0x03,
  0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x3E, 0x1F, 0x9F, 0x03,
  0xE7, 0xC0, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x10, 0xFF, 0xFE, 0x1F,
  0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x0F,
  0xFF, 0x81, 0xFF, 0xF0, 0x7E, 0x0C, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFC, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xFE, 0x07, 0xFF, 0xC7, 0xFF, 0xE7, 0xFF, 0xF7, 0xF0, 0xFB,
  0xE0, 0x7D, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFF, 0x03,
  0xEF, 0x81, 0xF7, 0xC0, 0xFB, 0xF0, 0xFD, 0xFF, 0xFE, 0x7F, 0xFF, 0x1F,
  0xFF, 0x83, 0xF7, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF9, 0x01, 0xF9,
  0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xFC, 0x0F, 0xF0, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0xE7, 0xFF, 0xEF, 0xFF, 0xDF, 0x0F, 0xFE,
  0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83,
  0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xF0, 0x03, 0x80, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC3, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0x70, 0x03, 0xE0, 0x1F, 0xC0, 0x7F,
  0x00, 0xF8, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF,
  0xCF, 0xFF, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7D, 0x01, 0xF7, 0x0F, 0xDF,
  0xFE, 0xFF, 0xFB, 0xFF, 0xC1, 0xFC, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x1F, 0xBE, 0x1F, 0x9F, 0x0F, 0x8F, 0x8F, 0x87, 0xCF,
  0x83, 0xEF, 0x81, 0xF7, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F,
  0xFC, 0x0F, 0xBF, 0x07, 0xCF, 0x83, 0xE3, 0xE1, 0xF1, 0xF8, 0xF8, 0x7E,
  0x7C, 0x1F, 0x3E, 0x0F, 0xDF, 0x03, 0xF0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xC3, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFC, 0x3F, 0x9F,
  0x3F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xE3, 0xFC, 0x78, 0xFF,
  0x1E, 0x3F, 0xC7, 0x8F, 0xF1, 0xE3, 0xFC, 0x78, 0xFF, 0x1E, 0x3F, 0xC7,
  0x8F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3C, 0x3F, 0xE1, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF,
  0xEF, 0x87, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xF8, 0x03, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xF0,
  0xFF, 0xFE, 0x7E, 0x1F, 0x9F, 0x03, 0xF7, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0x7C, 0x07, 0xDF, 0x03,
  0xF7, 0xE1, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0x80,
  0x3F, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF8, 0x7E, 0xF8, 0x3F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x7E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8,
  0xFB, 0xF0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x03, 0xFE, 0x07, 0xFF, 0xC7, 0xFF, 0xE7, 0xFF,
  0xF7, 0xF0, 0xFB, 0xF0, 0x7D, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF8, 0x7E,
  0x7F, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFB, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x1F, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xEF, 0x80, 0x5F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x00,
  0x07, 0xFC, 0x1F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFE, 0x7C, 0x0E, 0x7C, 0x00,
  0x7C, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0xFF,
  0x00, 0x3F, 0x00, 0x1F, 0x70, 0x1F, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC,
  0x1F, 0xF0, 0x01, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0x7C,
  0x1F, 0x7C, 0x1F, 0x7E, 0x1F, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x07,
  0xF8, 0xF8, 0x03, 0xFF, 0x00, 0xFB, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0,
  0xF8, 0xF8, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0xF8, 0x3E, 0x1F, 0x03, 0xE3,
  0xE0, 0x7C, 0xF8, 0x07, 0x9F, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0xF0, 0xF7,
  0x8F, 0x9E, 0x78, 0xF9, 0xE7, 0x8F, 0x9E, 0x79, 0xF9, 0xE7, 0x9F, 0xDE,
  0x39, 0xFD, 0xE3, 0xDD, 0xDE, 0x3F, 0xDD, 0xC3, 0xF9, 0xFC, 0x3F, 0x8F,
  0xC1, 0xF0, 0xFC, 0x1F, 0x0F, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x80, 0xFC,
  0x07, 0xCF, 0x81, 0xF0, 0xF8, 0x3E, 0x1F, 0x8F, 0x81, 0xF3, 0xE0, 0x1F,
  0x7C, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x3E, 0x7C, 0x07, 0xC7, 0xC1, 0xF0,
  0xFC, 0x7C, 0x0F, 0x8F, 0x80, 0xFB, 0xE0, 0x1F, 0x00, 0x7C, 0x07, 0xDF,
  0x01, 0xF7, 0xC0, 0x7D, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xF0,
  0xF8, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xE7, 0xC0, 0xF9, 0xE0, 0x3E, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x11, 0xF8, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0xFF, 0xFD, 0xFF, 0xFB,
  0xFF, 0xF7, 0xFF, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x07, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0x80, 0xFF, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF8, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xFE, 0x0F, 0xFC,
  0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFE, 0x07, 0xF0, 0x00, 0x0F,
  0x01, 0x87, 0xF8, 0x3D, 0xFF, 0x8F, 0xBF, 0xFF, 0xEF, 0xFF, 0xFD, 0xF3,
  0xFF, 0x3C, 0x1F, 0xE1, 0x80, 0xF0,
};

const GFXglyph UbuntuMono_Bold41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 7, 25, 21, 7, -25 },
  { 23, 13, 12, 21, 4, -28 },
  { 43, 19, 25, 21, 1, -25 },
  { 103, 18, 33, 21, 1, -29 },
  { 178, 20, 25, 21, 0, -25 },
  { 241, 19, 25, 21, 1, -25 },
  { 301, 5, 12, 21, 8, -28 },
  { 309, 13, 36, 21, 4, -29 },
  { 368, 14, 36, 21, 3, -29 },
  { 431, 17, 15, 21, 2, -25 },
  { 463, 17, 18, 21, 2, -19 },
  { 502, 9, 14, 21, 5, -7 },
  { 518, 11, 5, 21, 5, -13 },
  { 525, 7, 7, 21, 7, -7 },
  { 532, 17, 36, 21, 2, -29 },
  { 609, 18, 25, 21, 1, -25 },
  { 666, 17, 25, 21, 2, -25 },
  { 720, 17, 25, 21, 2, -25 },
  { 774, 16, 25, 21, 2, -25 },
  { 824, 18, 25, 21, 1, -25 },
  { 881, 17, 25, 21, 1, -25 },
  { 935, 17, 25, 21, 2, -25 },
  { 989, 17, 25, 21, 2, -25 },
  { 1043, 17, 25, 21, 2, -25 },
  { 1097, 17, 25, 21, 2, -25 },
  { 1151, 7, 19, 21, 7, -19 },
  { 1168, 9, 26, 21, 5, -19 },
  { 1198, 17, 17, 21, 2, -19 },
  { 1235, 17, 12, 21, 2, -17 },
  { 1261, 17, 17, 21, 2, -19 },
  { 1298, 15, 25, 21, 3, -25 },
  { 1345, 18, 31, 21, 1, -25 },
  { 1415, 20, 25, 21, 0, -25 },
  { 1478, 17, 25, 21, 2, -25 },
  { 1532, 18, 25, 21, 1, -25 },
  { 1589, 17, 25, 21, 2, -25 },
  { 1643, 16, 25, 21, 3, -25 },
  { 1693, 15, 25, 21, 3, -25 },
  { 1740, 18, 25, 21, 1, -25 },
  { 1797, 17, 25, 21, 2, -25 },
  { 1851, 16, 25, 21, 2, -25 },
  { 1901, 16, 25, 21, 2, -25 },
  { 1951, 18, 25, 21, 2, -25 },
  { 2008, 16, 25, 21, 3, -25 },
  { 2058, 19, 25, 21, 1, -25 },
  { 2118, 17, 25, 21, 2, -25 },
  { 2172, 18, 25, 21, 1, -25 },
  { 2229, 17, 25, 21, 2, -25 },
  { 2283, 18, 32, 21, 1, -25 },
  { 2355, 18, 25, 21, 2, -25 },
  { 2412, 17, 25, 21, 2, -25 },
  { 2466, 18, 25, 21, 1, -25 },
  { 2523, 17, 25, 21, 2, -25 },
  { 2577, 19, 25, 21, 1, -25 },
  { 2637, 19, 25, 21, 1, -25 },
  { 2697, 20, 25, 21, 0, -25 },
  { 2760, 19, 25, 21, 1, -25 },
  { 2820, 17, 25, 21, 2, -25 },
  { 2874, 11, 36, 21, 5, -29 },
  { 2924, 17, 36, 21, 2, -29 },
  { 3001, 12, 36, 21, 4, -29 },
  { 3055, 19, 13, 21, 1, -25 },
  { 3086, 20, 4, 21, 0, 3 },
  { 3096, 9, 7, 21, 6, -28 },
  { 3104, 16, 19, 21, 2, -19 },
  { 3142, 16, 28, 21, 3, -28 },
  { 3198, 17, 19, 21, 2, -19 },
  { 3239, 17, 28, 21, 1, -28 },
  { 3299, 18, 19, 21, 1, -19 },
  { 3342, 19, 28, 21, 1, -28 },
  { 3409, 17, 26, 21, 1, -19 },
  { 3465, 15, 28, 21, 3, -28 },
  { 3518, 18, 28, 21, 1, -28 },
  { 3581, 14, 35, 21, 2, -28 },
  { 3643, 17, 28, 21, 3, -28 },
  { 3703, 18, 28, 21, 1, -28 },
  { 3766, 18, 19, 21, 1, -19 },
  { 3809, 15, 19, 21, 3, -19 },
  { 3845, 18, 19, 21, 1, -19 },
  { 3888, 16, 26, 21, 3, -19 },
  { 3940, 17, 26, 21, 1, -19 },
  { 3996, 15, 19, 21, 4, -19 },
  { 4032, 16, 19, 21, 2, -19 },
  { 4070, 18, 25, 21, 1, -25 },
  { 4127, 16, 19, 21, 2, -19 },
  { 4165, 19, 19, 21, 1, -19 },
  { 4211, 20, 19, 21, 0, -19 },
  { 4259, 19, 19, 21, 1, -19 },
  { 4305, 18, 26, 21, 1, -19 },
  { 4364, 15, 19, 21, 3, -19 },
  { 4400, 15, 36, 21, 3, -29 },
  { 4468, 5, 36, 21, 8, -29 },
  { 4491, 15, 36, 21, 3, -29 },
  { 4559, 19, 8, 21, 1, -15 },
};

const GFXfont UbuntuMono_Bold41pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Bold41pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Bold41pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _UBUNTUMONO_BOLD41PT7B_H_
