#ifndef _NOTOSANS_SEMICONDENSED_ITALIC52PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0x80, 0x10, 0x00, 0x3E, 0x1F, 0x3E, 0x1E, 0x3C, 0x1E, 0x3C, 0x3E, 0x3C,
  0x3E, 0x3C, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x38, 0x78, 0x38, 0x70,
  0x78, 0x70, 0x78, 0xF0, 0x70, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x38, 0x0E,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xE0, 0x38, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1C,
  0x07, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x70, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x38,
  0x0E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xE0, 0x38,
  0x00, 0x07, 0x03, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x70,
  0x1C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x0E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x38, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xE7, 0x0E, 0x07,
  0xC7, 0x00, 0x07, 0x87, 0x00, 0x07, 0x87, 0x00, 0x07, 0x87, 0x00, 0x07,
  0x8E, 0x00, 0x07, 0x8E, 0x00, 0x07, 0x8E, 0x00, 0x07, 0xCE, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x39, 0xF0, 0x00, 0x38, 0xF0, 0x00,
  0x38, 0xF8, 0x00, 0x38, 0xF8, 0x00, 0x70, 0x78, 0x00, 0x70, 0xF8, 0x00,
  0x70, 0xF0, 0x80, 0x71, 0xF0, 0xC0, 0x73, 0xE0, 0xFC, 0xEF, 0xE0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3C, 0x0F, 0xF8,
  0x00, 0x78, 0x1F, 0xFC, 0x00, 0xF0, 0x1E, 0x3C, 0x00, 0xE0, 0x3C, 0x1C,
  0x01, 0xE0, 0x38, 0x1C, 0x03, 0xC0, 0x78, 0x1C, 0x03, 0x80, 0x70, 0x1C,
  0x07, 0x80, 0xF0, 0x1C, 0x0F, 0x00, 0xF0, 0x1C, 0x0E, 0x00, 0xF0, 0x3C,
  0x1E, 0x00, 0xF0, 0x3C, 0x3C, 0x00, 0xE0, 0x3C, 0x38, 0x00, 0xE0, 0x38,
  0x78, 0x00, 0xE0, 0x78, 0xF0, 0xF0, 0xE0, 0x78, 0xF3, 0xFC, 0xE0, 0x71,
  0xE7, 0xFE, 0xE0, 0xF3, 0xC7, 0xFE, 0xF1, 0xE3, 0xCF, 0x0F, 0xFF, 0xC7,
  0x9E, 0x0F, 0x7F, 0xCF, 0x1E, 0x0F, 0x3F, 0x8F, 0x3C, 0x0F, 0x1C, 0x1E,
  0x3C, 0x0F, 0x00, 0x3C, 0x3C, 0x0F, 0x00, 0x3C, 0x38, 0x0F, 0x00, 0x78,
  0x78, 0x0E, 0x00, 0xF0, 0x78, 0x0E, 0x00, 0xF0, 0x78, 0x1E, 0x01, 0xE0,
  0x78, 0x1E, 0x03, 0xC0, 0x78, 0x1C, 0x03, 0xC0, 0x70, 0x3C, 0x07, 0x80,
  0x78, 0x3C, 0x0F, 0x00, 0x78, 0x78, 0x0F, 0x00, 0x78, 0xF8, 0x1E, 0x00,
  0x3F, 0xF0, 0x3C, 0x00, 0x3F, 0xE0, 0x7C, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0xF0, 0x1E, 0x00, 0x1F, 0x01, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x01,
  0xE0, 0x01, 0xE0, 0x3E, 0x00, 0x1E, 0x07, 0xC0, 0x01, 0xF0, 0x78, 0x00,
  0x1F, 0x1F, 0x80, 0x00, 0xF3, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0xF0, 0xF9, 0xF0, 0x1F, 0x1F, 0x0F, 0x81, 0xE3, 0xE0,
  0x78, 0x3E, 0x7C, 0x07, 0xC3, 0xC7, 0x80, 0x3C, 0x7C, 0xF8, 0x03, 0xE7,
  0x8F, 0x80, 0x1F, 0xF8, 0xF0, 0x01, 0xFF, 0x0F, 0x00, 0x0F, 0xE0, 0xF0,
  0x00, 0xFC, 0x0F, 0x80, 0x0F, 0xC0, 0xF8, 0x01, 0xFE, 0x0F, 0xC0, 0x3F,
  0xE0, 0x7E, 0x1F, 0xDF, 0x07, 0xFF, 0xF9, 0xF0, 0x3F, 0xFE, 0x0F, 0x80,
  0xFF, 0xC0, 0xFC, 0x01, 0x80, 0x00, 0x00, 0x7D, 0xF7, 0xDE, 0x79, 0xE7,
  0x3C, 0xF3, 0xCE, 0x38, 0xE0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x20, 0x1C, 0x01, 0xC0, 0xE0, 0x0F, 0x87, 0x00, 0xFF, 0x30, 0x01, 0xFF,
  0xBF, 0xC1, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0x87, 0x81, 0xFC, 0x00,
  0x1E, 0x70, 0x01, 0xE3, 0x80, 0x1F, 0x1E, 0x01, 0xF0, 0xF0, 0x0F, 0x03,
  0xC0, 0x30, 0x1E, 0x00, 0x80, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC3, 0xE0,
  0xF8, 0x7C, 0x1F, 0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x03, 0xC0,
  0xE0, 0x00, 0x7F, 0xFB, 0xFF, 0xBF, 0xFD, 0xFF, 0xE0, 0x79, 0xFF, 0xFF,
  0xFF, 0xE2, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0x8F, 0xC0, 0x7E, 0x0F, 0x80,
  0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x3C, 0x3C,
  0x00, 0x78, 0xF8, 0x00, 0xF1, 0xE0, 0x01, 0xE7, 0xC0, 0x07, 0xCF, 0x80,
  0x0F, 0x9E, 0x00, 0x1F, 0x3C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00,
  0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0xCF, 0x00, 0x0F, 0x9E, 0x00, 0x1F,
  0x7C, 0x00, 0x3C, 0xF8, 0x00, 0x79, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7,
  0xC0, 0x07, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3C, 0x3E, 0x00, 0xF8, 0x3C,
  0x01, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x1F, 0x00, 0xFC, 0xFC, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x3C, 0x03, 0xF0, 0x1F, 0xC1, 0xFF, 0x0F, 0xF8, 0x7F, 0xE7, 0xF7, 0xBF,
  0x3E, 0xF8, 0xF9, 0x83, 0xC4, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFE, 0x3F, 0x80, 0x3C, 0x03, 0xE0,
  0x04, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0x83, 0xF0,
  0x0F, 0x00, 0xF8, 0x02, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x80, 0x01, 0xF0, 0x70, 0x01, 0xF8, 0x3F, 0x07, 0xF8, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xB8, 0x00, 0x07, 0xBC, 0x00,
  0x07, 0x9E, 0x00, 0x07, 0xCF, 0x00, 0x03, 0xCF, 0x80, 0x03, 0xC7, 0x80,
  0x03, 0xC3, 0xC0, 0x03, 0xE1, 0xE0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF8,
  0x01, 0xE0, 0x78, 0x01, 0xF0, 0x3C, 0x01, 0xF0, 0x1E, 0x00, 0xF0, 0x1F,
  0x00, 0xF0, 0x0F, 0x80, 0xF0, 0x07, 0x80, 0xF8, 0x03, 0xC0, 0x78, 0x01,
  0xE0, 0x78, 0x01, 0xF0, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xBE, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x04, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x80, 0x03, 0xF0, 0xC0, 0x07, 0xE0, 0xF8, 0x3F, 0xC0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0,
  0x0F, 0xE0, 0x40, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x3F, 0xC0, 0x7D, 0xFF,
  0xC0, 0xF7, 0xFF, 0xC1, 0xFF, 0x3F, 0x87, 0xF8, 0x0F, 0x8F, 0xC0, 0x1F,
  0x1F, 0x80, 0x1E, 0x3E, 0x00, 0x3C, 0x7C, 0x00, 0x78, 0xF0, 0x00, 0xF1,
  0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x8F, 0x00, 0x1F, 0x1E,
  0x00, 0x3C, 0x3C, 0x00, 0xF8, 0x78, 0x01, 0xF0, 0xF8, 0x07, 0xC1, 0xF8,
  0x1F, 0x01, 0xF8, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0x83, 0xF0,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x3C, 0x07, 0x80, 0x1F, 0x03, 0xC0, 0x0F,
  0x81, 0xE0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x3C, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x07, 0x81, 0xF0, 0x03, 0xE1, 0xF0, 0x00, 0xFB,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x7E, 0x1F, 0x00, 0x7E, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x3C,
  0x00, 0xF8, 0x3E, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x8F,
  0x80, 0x07, 0xC7, 0xC0, 0x03, 0xC3, 0xE0, 0x01, 0xE1, 0xF0, 0x01, 0xF0,
  0x7C, 0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0x1F,
  0x80, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0x80, 0x1E, 0x1F, 0x00, 0x3C,
  0x3C, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xC0, 0x03, 0xE7,
  0x80, 0x07, 0xCF, 0x00, 0x0F, 0x1E, 0x00, 0x3E, 0x3C, 0x00, 0x7C, 0x7C,
  0x01, 0xF8, 0xF8, 0x03, 0xF0, 0xF8, 0x1F, 0xE1, 0xFD, 0xFF, 0x81, 0xFF,
  0xEF, 0x01, 0xFF, 0x9E, 0x01, 0xFC, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x03,
  0x87, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x83, 0xF0, 0xFC, 0x3F, 0x0F,
  0x83, 0xE0, 0x60, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x01,
  0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x3E, 0x1F, 0xC6, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x0E, 0x0F, 0x00,
  0x3F, 0x80, 0xF0, 0xF0, 0x0F, 0xFE, 0x0F, 0x1E, 0x03, 0xFF, 0xE0, 0xF1,
  0xE0, 0x7C, 0x1E, 0x0F, 0x3C, 0x07, 0x81, 0xC0, 0x73, 0xC0, 0xF0, 0x3C,
  0x0F, 0x38, 0x1E, 0x03, 0xC0, 0xF7, 0x81, 0xC0, 0x3C, 0x0F, 0x78, 0x3C,
  0x03, 0x80, 0xF7, 0x03, 0xC0, 0x78, 0x0E, 0x70, 0x38, 0x07, 0x80, 0xEF,
  0x07, 0x80, 0x78, 0x1E, 0xF0, 0x78, 0x0F, 0x01, 0xEF, 0x07, 0x80, 0xF0,
  0x1C, 0xF0, 0x78, 0x0F, 0x03, 0xCF, 0x07, 0x81, 0xF0, 0x38, 0xF0, 0x78,
  0x3F, 0x07, 0x8F, 0x07, 0xC7, 0x70, 0xF0, 0xF0, 0x3F, 0xF7, 0xFE, 0x0F,
  0x03, 0xFE, 0x3F, 0xC0, 0x70, 0x1F, 0xC1, 0xF8, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x80, 0x00,
  0xFC, 0x00, 0x78, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1E,
  0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x01, 0xE0, 0xF8, 0x00,
  0x78, 0x3E, 0x00, 0x3E, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x07, 0xC0, 0x78,
  0x01, 0xE0, 0x1E, 0x00, 0xF8, 0x07, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xF0, 0x01, 0xE0, 0x7C,
  0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xC0, 0x01, 0xF1,
  0xF0, 0x00, 0x7C, 0x78, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0xF7, 0xC0, 0x00, 0x3D, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xC0, 0x0F, 0x80, 0x78, 0x00, 0xF8, 0x0F,
  0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x00, 0x0F,
  0x01, 0xE0, 0x03, 0xE0, 0x3C, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x01, 0xF0,
  0x07, 0xC0, 0x3C, 0x07, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xE0, 0x07, 0xC1, 0xFE, 0x00, 0xF0, 0x07, 0xE0, 0x1E, 0x00,
  0x7C, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x1E, 0x00, 0x1F, 0x03,
  0xC0, 0x03, 0xE0, 0x78, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01,
  0xF0, 0x78, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x81, 0xE0, 0x03, 0xE0, 0x7C,
  0x01, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xF8, 0x78, 0x03, 0xF8, 0x01,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x04, 0x00, 0x7F,
  0xDF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0x01, 0xFC, 0x00, 0xF8,
  0x03, 0xF0, 0x07, 0x80, 0x0F, 0x80, 0x3C, 0x00, 0x3E, 0x03, 0xE0, 0x01,
  0xF0, 0x1F, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0,
  0x3C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0xF0,
  0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x3E, 0x07, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x01,
  0xF0, 0x1E, 0x00, 0x1F, 0x80, 0xF0, 0x01, 0xF8, 0x07, 0x80, 0x3F, 0x80,
  0x7C, 0x07, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xF8, 0x7F, 0x00, 0xFE, 0x00, 0x30, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0xF1, 0xF0, 0x03, 0xFF, 0x8F,
  0x80, 0x1F, 0xFC, 0x7C, 0x00, 0xFF, 0xE3, 0xE0, 0x00, 0x1F, 0x1F, 0x00,
  0x00, 0xF0, 0xF8, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0xF0, 0x7C, 0x00, 0x07, 0x81,
  0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x7E, 0x00, 0x1E, 0x01, 0xFC,
  0x00, 0xF0, 0x07, 0xFE, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x01,
  0xE0, 0x1F, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x1F,
  0x00, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x78, 0x07, 0xC0, 0x00, 0xF0,
  0x0F, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x0F, 0x00,
  0xF8, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF8, 0x07,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0xF0, 0x0F, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0xC0, 0x3C, 0x00,
  0x0F, 0x80, 0x78, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3C, 0x03, 0xE0, 0x00,
  0x78, 0x07, 0x80, 0x01, 0xF0, 0x0F, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x07,
  0x80, 0x7C, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x7C,
  0x03, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x08, 0x3F, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0xFC, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8,
  0x01, 0xF0, 0x0F, 0xC0, 0x07, 0x80, 0x3E, 0x00, 0x1E, 0x01, 0xF0, 0x00,
  0x78, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3C,
  0x1F, 0x00, 0x00, 0xF0, 0xFC, 0x00, 0x03, 0xC7, 0xE0, 0x00, 0x1F, 0x1F,
  0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x07, 0xBE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFB, 0xC0, 0x00,
  0x0F, 0xCF, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0,
  0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0xF0, 0x07,
  0xC0, 0x03, 0xC0, 0x1F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF,
  0xFE, 0xFF, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x07, 0xBC, 0x03, 0xDE, 0x00, 0x0F,
  0xFC, 0x03, 0xDE, 0x00, 0x0F, 0x7C, 0x03, 0xDE, 0x00, 0x1F, 0x78, 0x03,
  0xCE, 0x00, 0x1E, 0x78, 0x07, 0xCF, 0x00, 0x3C, 0x78, 0x07, 0xCF, 0x00,
  0x3C, 0xF8, 0x07, 0x8F, 0x00, 0x78, 0xF8, 0x07, 0x8F, 0x00, 0x78, 0xF0,
  0x07, 0x8F, 0x00, 0xF0, 0xF0, 0x0F, 0x8F, 0x00, 0xF1, 0xF0, 0x0F, 0x0F,
  0x01, 0xE1, 0xF0, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x03, 0xC1,
  0xE0, 0x0F, 0x0F, 0x03, 0xC1, 0xE0, 0x1F, 0x07, 0x07, 0x83, 0xE0, 0x1E,
  0x07, 0x87, 0x83, 0xE0, 0x1E, 0x07, 0x8F, 0x03, 0xC0, 0x1E, 0x07, 0x8F,
  0x03, 0xC0, 0x1E, 0x07, 0x9E, 0x03, 0xC0, 0x3E, 0x07, 0x9E, 0x07, 0xC0,
  0x3C, 0x07, 0xBC, 0x07, 0xC0, 0x3C, 0x07, 0xBC, 0x07, 0x80, 0x3C, 0x07,
  0xF8, 0x07, 0x80, 0x7C, 0x07, 0xF8, 0x0F, 0x80, 0x78, 0x03, 0xF0, 0x0F,
  0x80, 0x78, 0x03, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x7E, 0x00, 0x07, 0x80, 0x3F, 0x00, 0x03, 0xC0, 0x3F, 0x80,
  0x01, 0xE0, 0x1F, 0xC0, 0x01, 0xF0, 0x0F, 0xF0, 0x00, 0xF0, 0x07, 0xF8,
  0x00, 0x78, 0x03, 0xFC, 0x00, 0x3C, 0x03, 0xDF, 0x00, 0x1E, 0x01, 0xE7,
  0x80, 0x1F, 0x00, 0xF3, 0xC0, 0x0F, 0x00, 0x79, 0xF0, 0x07, 0x80, 0x7C,
  0x78, 0x03, 0xC0, 0x3C, 0x3C, 0x03, 0xE0, 0x1E, 0x1E, 0x01, 0xF0, 0x0F,
  0x0F, 0x80, 0xF0, 0x07, 0x83, 0xC0, 0x78, 0x07, 0xC1, 0xE0, 0x3C, 0x03,
  0xC0, 0xF8, 0x3E, 0x01, 0xE0, 0x3C, 0x1F, 0x00, 0xF0, 0x1E, 0x0F, 0x00,
  0x78, 0x0F, 0x87, 0x80, 0x7C, 0x03, 0xC3, 0xC0, 0x3C, 0x01, 0xE3, 0xE0,
  0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x00, 0x7C, 0xF0, 0x07, 0x80, 0x1E, 0x78,
  0x07, 0xC0, 0x0F, 0x3C, 0x03, 0xC0, 0x07, 0xFE, 0x01, 0xE0, 0x01, 0xFE,
  0x00, 0xF0, 0x00, 0xFF, 0x00, 0xF8, 0x00, 0x7F, 0x80, 0x7C, 0x00, 0x1F,
  0xC0, 0x3C, 0x00, 0x0F, 0xE0, 0x1E, 0x00, 0x07, 0xE0, 0x0F, 0x00, 0x03,
  0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xE1, 0xFE,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x3E, 0x0F,
  0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x3E, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1F, 0x7C, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0xFC, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7E, 0x0F, 0x80,
  0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xF0, 0x1F, 0x80, 0x78, 0x03, 0xE0,
  0x1E, 0x00, 0x78, 0x07, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01,
  0xF0, 0x3C, 0x00, 0x7C, 0x0F, 0x00, 0x1F, 0x03, 0xC0, 0x07, 0x81, 0xF0,
  0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1E, 0x00, 0x7C, 0x07, 0x80, 0x3F, 0x03,
  0xE0, 0x1F, 0x80, 0xF8, 0x7F, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xE1, 0xFE, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0,
  0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x07,
  0xE0, 0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xF0, 0x1F,
  0x80, 0x78, 0x03, 0xE0, 0x1E, 0x00, 0x7C, 0x07, 0x80, 0x1F, 0x03, 0xE0,
  0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3C, 0x00, 0x7C, 0x0F, 0x00, 0x1F, 0x03,
  0xC0, 0x07, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1E, 0x00, 0x7C,
  0x07, 0x80, 0x7F, 0x03, 0xE0, 0x7F, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x7C,
  0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0xF8, 0x01, 0xE0, 0x3E, 0x00,
  0xF8, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x7C, 0x03, 0xC0, 0x0F,
  0x00, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x07, 0x80,
  0x07, 0x81, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xF3,
  0xF0, 0x1F, 0x80, 0x38, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x80, 0x03, 0xF0, 0x70, 0x03, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01,
  0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x3E, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0x81,
  0xF0, 0x00, 0x3C, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1E, 0x03, 0xE0,
  0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xFE, 0xFF,
  0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xDE, 0x00, 0x03, 0xEF, 0x00, 0x03, 0xE7, 0x80, 0x01, 0xF3, 0xE0,
  0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E,
  0x00, 0x3C, 0x1F, 0x00, 0x3E, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x1F, 0x01,
  0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x07, 0xC0,
  0x1E, 0x03, 0xC0, 0x0F, 0x03, 0xE0, 0x07, 0x81, 0xE0, 0x03, 0xC1, 0xF0,
  0x01, 0xF0, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x78, 0x00, 0x3E, 0x7C,
  0x00, 0x0F, 0x3C, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0xF8, 0x00, 0xFC, 0x00, 0x3C, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0xF8, 0x01, 0xFC, 0x00, 0x78, 0xF8,
  0x01, 0xDC, 0x00, 0xF8, 0xF8, 0x03, 0xDC, 0x00, 0xF0, 0xF8, 0x03, 0xDC,
  0x01, 0xF0, 0xF8, 0x07, 0x9C, 0x01, 0xE0, 0xF8, 0x07, 0x9C, 0x03, 0xE0,
  0xF8, 0x0F, 0x1E, 0x03, 0xE0, 0xF8, 0x0F, 0x1E, 0x03, 0xC0, 0xF8, 0x1E,
  0x1E, 0x07, 0xC0, 0xF8, 0x1E, 0x1E, 0x07, 0x80, 0xF8, 0x1E, 0x1E, 0x0F,
  0x80, 0xF8, 0x3C, 0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x1E, 0x0F, 0x00, 0x78,
  0x78, 0x1E, 0x1F, 0x00, 0x78, 0x78, 0x1E, 0x1E, 0x00, 0x78, 0xF0, 0x1E,
  0x3E, 0x00, 0x78, 0xF0, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x1E, 0x7C, 0x00,
  0x79, 0xE0, 0x1E, 0x78, 0x00, 0x79, 0xE0, 0x1E, 0x78, 0x00, 0x7B, 0xC0,
  0x1E, 0xF8, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x00, 0x7B, 0x80, 0x1E, 0xF0,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x1E, 0x07,
  0xC0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x0F, 0x1F,
  0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3E, 0xF0,
  0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xF8, 0x78,
  0x00, 0x01, 0xF0, 0x78, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x07, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x07, 0xC7, 0x80, 0x0F, 0x0F,
  0x00, 0x3E, 0x1E, 0x00, 0xF8, 0x3E, 0x01, 0xE0, 0x7C, 0x07, 0xC0, 0x78,
  0x1F, 0x00, 0xF0, 0x3E, 0x01, 0xE0, 0xF8, 0x03, 0xC1, 0xE0, 0x07, 0xC7,
  0xC0, 0x07, 0x9F, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0xF8, 0x00, 0x3D, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x01,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x03, 0xC0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0xF3, 0x80, 0x00, 0xF3, 0xC0, 0x01, 0xE3,
  0xC0, 0x01, 0xE1, 0xE0, 0x03, 0xC1, 0xE0, 0x03, 0xC0, 0xF0, 0x07, 0x80,
  0xF0, 0x07, 0x80, 0x70, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x78, 0x1E, 0x00,
  0x3C, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x78, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xF8, 0xF8, 0x78, 0x7C, 0x3C, 0x3C, 0x1E, 0x0F, 0x00, 0x7F, 0x07, 0x01,
  0xFF, 0x8F, 0x03, 0xFF, 0xCF, 0x07, 0xF3, 0xFE, 0x0F, 0xC0, 0xFE, 0x0F,
  0x80, 0x7E, 0x1F, 0x00, 0x7E, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0x3C, 0x3E,
  0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x78,
  0x00, 0x78, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8,
  0x00, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF0, 0xF8,
  0x07, 0xF0, 0xF8, 0x07, 0xE0, 0x78, 0x0F, 0xE0, 0x7E, 0x3D, 0xE0, 0x7F,
  0xF9, 0xE0, 0x3F, 0xF1, 0xE0, 0x1F, 0xE1, 0xC0, 0x02, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC3, 0xF8, 0x07, 0xCF, 0xFC, 0x07, 0xDF, 0xFE, 0x07, 0xBE, 0xFE, 0x07,
  0xF8, 0x3E, 0x07, 0xF0, 0x1F, 0x0F, 0xE0, 0x1F, 0x0F, 0xC0, 0x1F, 0x0F,
  0x80, 0x0F, 0x0F, 0x80, 0x0F, 0x0F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F,
  0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3E,
  0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x7E,
  0x00, 0x78, 0x7E, 0x00, 0xF8, 0x7E, 0x01, 0xF0, 0x7F, 0x03, 0xF0, 0x7F,
  0x87, 0xE0, 0xF3, 0xFF, 0xC0, 0xF3, 0xFF, 0x80, 0xE0, 0xFF, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0x9E,
  0x0F, 0xC0, 0x20, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x10, 0x7F, 0x0E, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x07, 0xF0, 0xF0, 0x03,
  0xFF, 0x1E, 0x00, 0xFF, 0xF7, 0xC0, 0x3F, 0x9F, 0xF0, 0x0F, 0xC0, 0xFE,
  0x01, 0xF0, 0x0F, 0xC0, 0x7C, 0x01, 0xF8, 0x0F, 0x80, 0x3F, 0x03, 0xE0,
  0x03, 0xC0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0,
  0x7C, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x03, 0xE0, 0x01, 0xE0, 0x7C, 0x00,
  0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xE0, 0x3E, 0x00, 0x7C, 0x07,
  0xC0, 0x0F, 0x80, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0xFE, 0x03, 0xE0, 0x1F,
  0x80, 0x7C, 0x07, 0xF0, 0x07, 0xE3, 0xDE, 0x00, 0xFF, 0xF3, 0xC0, 0x0F,
  0xFC, 0x78, 0x00, 0xFF, 0x0E, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0x3F, 0x0F, 0xC0, 0xF0, 0xF8,
  0x0F, 0x1F, 0x00, 0xF1, 0xE0, 0x0F, 0x3E, 0x00, 0xF3, 0xC0, 0x1F, 0x7C,
  0x03, 0xE7, 0xC1, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F,
  0xFC, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x08, 0x7F, 0x07,
  0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0x84, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x8F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC1, 0xC0, 0x1F,
  0xF8, 0xF0, 0x0F, 0xFF, 0x3C, 0x07, 0xF3, 0xFE, 0x03, 0xF0, 0x3F, 0x80,
  0xF8, 0x07, 0xE0, 0x7C, 0x01, 0xF8, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x1F,
  0x03, 0xE0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00,
  0x1F, 0x07, 0x80, 0x07, 0x83, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0xF8, 0x3E,
  0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0,
  0x3E, 0x00, 0xFC, 0x0F, 0x80, 0x7F, 0x03, 0xE0, 0x3F, 0x80, 0xF8, 0x1F,
  0xE0, 0x1F, 0x8F, 0x78, 0x07, 0xFF, 0xBE, 0x00, 0xFF, 0xCF, 0x80, 0x1F,
  0xE3, 0xC0, 0x00, 0x80, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x03, 0x00, 0x3F, 0x00, 0xF8, 0x3F, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC3, 0xF8, 0x03, 0xCF, 0xFC, 0x07,
  0xDF, 0xFE, 0x07, 0xBE, 0x7E, 0x07, 0xF8, 0x3E, 0x07, 0xE0, 0x1F, 0x0F,
  0xE0, 0x1F, 0x0F, 0xC0, 0x1E, 0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x1E, 0x0F,
  0x00, 0x1E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1E, 0x00, 0x3C, 0x1E,
  0x00, 0x3C, 0x1E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x78, 0x3C,
  0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x78,
  0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0xF8, 0x01, 0xF0, 0xF8,
  0x01, 0xF0, 0xF0, 0x01, 0xE0, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xE0, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x07,
  0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F,
  0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C,
  0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x8F, 0xC0, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x1F, 0x07, 0xC0,
  0x3E, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x07, 0x81, 0xF0, 0x07, 0x83,
  0xE0, 0x0F, 0x87, 0xC0, 0x0F, 0x8F, 0x80, 0x0F, 0x1F, 0x00, 0x0F, 0x1E,
  0x00, 0x0F, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x1E, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x3F, 0x3E, 0x00, 0x3E, 0x1E,
  0x00, 0x3C, 0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x7C, 0x0F, 0x00, 0x7C, 0x0F,
  0x80, 0x78, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x78, 0x07, 0xC0, 0xF8, 0x03,
  0xC0, 0xF8, 0x03, 0xE0, 0xF0, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7C,
  0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00,
  0x03, 0x87, 0xF0, 0x1F, 0xE0, 0x1C, 0x7F, 0xC1, 0xFF, 0x81, 0xE7, 0xFF,
  0x1F, 0xFC, 0x0F, 0x7D, 0xF9, 0xF7, 0xF0, 0x7F, 0x03, 0xFE, 0x0F, 0x83,
  0xF0, 0x1F, 0xC0, 0x3C, 0x3F, 0x00, 0xFE, 0x01, 0xE1, 0xF8, 0x07, 0xE0,
  0x0F, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x7C, 0x01, 0xF0, 0x07, 0xC3, 0xC0,
  0x0F, 0x00, 0x3E, 0x3E, 0x00, 0x78, 0x01, 0xE1, 0xF0, 0x07, 0xC0, 0x0F,
  0x0F, 0x00, 0x3E, 0x00, 0x78, 0x78, 0x01, 0xE0, 0x07, 0xC3, 0xC0, 0x0F,
  0x00, 0x3C, 0x3E, 0x00, 0x78, 0x01, 0xE1, 0xF0, 0x07, 0xC0, 0x0F, 0x0F,
  0x00, 0x3E, 0x00, 0xF8, 0x78, 0x01, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x00,
  0x3C, 0x3E, 0x00, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0xC0, 0x0F, 0x0F, 0x00,
  0x3E, 0x00, 0xF8, 0x78, 0x01, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x00, 0x3C,
  0x3E, 0x00, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x00,
  0x40, 0x03, 0xC7, 0xF8, 0x07, 0x8F, 0xFC, 0x07, 0x9F, 0xFE, 0x07, 0xBF,
  0xFE, 0x07, 0xF8, 0x3F, 0x07, 0xF0, 0x1F, 0x0F, 0xE0, 0x1F, 0x0F, 0xC0,
  0x1F, 0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x1E, 0x1F, 0x00, 0x3E, 0x1F, 0x00,
  0x3E, 0x1F, 0x00, 0x3E, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x3E, 0x00,
  0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x78, 0x3C, 0x00,
  0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF0, 0x78, 0x00,
  0xF0, 0x78, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF0, 0x01,
  0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFC, 0xFE,
  0x0F, 0xC0, 0xF8, 0x3E, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0x80, 0x0F, 0x3E,
  0x00, 0x3C, 0xF0, 0x00, 0xF7, 0xC0, 0x03, 0xDF, 0x00, 0x0F, 0x78, 0x00,
  0x3D, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7B,
  0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3C, 0xF8, 0x01, 0xF3, 0xE0,
  0x07, 0x87, 0x80, 0x3E, 0x1F, 0x01, 0xF0, 0x7F, 0x1F, 0x80, 0xFF, 0xFC,
  0x01, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x70, 0x7F, 0x00, 0x0E, 0x3F,
  0xF0, 0x03, 0xCF, 0xFF, 0x00, 0x7B, 0xE7, 0xE0, 0x0F, 0xF0, 0x3C, 0x01,
  0xFC, 0x07, 0xC0, 0x7F, 0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x01, 0xF0, 0x01,
  0xE0, 0x3E, 0x00, 0x3C, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3E,
  0x00, 0x3E, 0x07, 0x80, 0x07, 0xC0, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x1E,
  0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1E, 0x03, 0xC0,
  0x07, 0xC0, 0x7C, 0x00, 0xF0, 0x1F, 0x80, 0x3E, 0x03, 0xF0, 0x0F, 0x80,
  0x7F, 0x03, 0xF0, 0x0F, 0xF0, 0xFC, 0x03, 0xEF, 0xFF, 0x00, 0x7C, 0xFF,
  0xC0, 0x0F, 0x0F, 0xF0, 0x01, 0xE0, 0x20, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x07,
  0x01, 0xFF, 0x8F, 0x03, 0xFF, 0xCF, 0x07, 0xF3, 0xFE, 0x0F, 0xC0, 0xFE,
  0x0F, 0x80, 0x7E, 0x1F, 0x00, 0x7E, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0x7C,
  0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C,
  0x78, 0x00, 0x78, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8,
  0xF8, 0x00, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF0,
  0xF8, 0x07, 0xF0, 0xF8, 0x07, 0xE0, 0xF8, 0x1F, 0xE0, 0x7E, 0x3D, 0xE0,
  0x7F, 0xFB, 0xE0, 0x3F, 0xF3, 0xE0, 0x1F, 0xE3, 0xC0, 0x02, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x03, 0x87, 0xE0,
  0x71, 0xFC, 0x1E, 0x7F, 0x83, 0xDF, 0xE0, 0x7F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0,
  0xFE, 0x3E, 0x0F, 0x80, 0x41, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x88, 0x01, 0xF0, 0xF0, 0x7F, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07,
  0xFF, 0x00, 0x01, 0x00, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0xF0, 0x07, 0xFF, 0xBF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF8,
  0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3F, 0x10, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0x08, 0x00, 0x07,
  0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x0F,
  0x00, 0x1E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1E, 0x00, 0x3C, 0x1E,
  0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x78, 0x3C,
  0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C,
  0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0xF8,
  0x03, 0xF0, 0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x1F, 0xE0, 0x7C,
  0x7D, 0xE0, 0x7F, 0xF9, 0xE0, 0x3F, 0xF1, 0xC0, 0x1F, 0xC3, 0xC0, 0x02,
  0x00, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3D, 0xE0, 0x03,
  0xEF, 0x00, 0x1E, 0x78, 0x01, 0xF3, 0xC0, 0x0F, 0x1F, 0x00, 0xF8, 0xF8,
  0x07, 0x87, 0xC0, 0x7C, 0x1E, 0x03, 0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xE0,
  0x3C, 0x1F, 0x01, 0xE0, 0xF0, 0x0F, 0x0F, 0x80, 0x78, 0x78, 0x03, 0xC7,
  0xC0, 0x1E, 0x3C, 0x00, 0xF3, 0xE0, 0x07, 0x9E, 0x00, 0x3D, 0xF0, 0x01,
  0xEF, 0x00, 0x07, 0x78, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xF8, 0x01, 0xF0, 0x07,
  0xFC, 0x01, 0xF8, 0x03, 0xDE, 0x00, 0xFC, 0x03, 0xEF, 0x00, 0xFE, 0x01,
  0xE7, 0x80, 0x77, 0x01, 0xF3, 0xC0, 0x7B, 0x80, 0xF9, 0xE0, 0x3D, 0xC0,
  0x78, 0xF0, 0x3C, 0xE0, 0x7C, 0x78, 0x1E, 0x70, 0x3C, 0x3C, 0x0E, 0x38,
  0x3E, 0x1E, 0x0F, 0x1C, 0x1E, 0x0F, 0x07, 0x0E, 0x0F, 0x07, 0x87, 0x87,
  0x0F, 0x03, 0xC3, 0xC3, 0x87, 0x81, 0xE3, 0xC1, 0xC7, 0xC0, 0xF1, 0xE0,
  0xE3, 0xC0, 0x78, 0xE0, 0x73, 0xE0, 0x3C, 0xF0, 0x39, 0xE0, 0x1E, 0x70,
  0x1C, 0xF0, 0x0F, 0x78, 0x0E, 0xF0, 0x07, 0xBC, 0x07, 0x78, 0x03, 0xDC,
  0x03, 0xBC, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x07, 0xC0, 0x78, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x07, 0xC0,
  0x7C, 0x00, 0xF0, 0x3E, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x87, 0x80, 0x01,
  0xE3, 0xC0, 0x00, 0x79, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x1F,
  0x78, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xC3, 0xC0, 0x01, 0xF0, 0xF0, 0x00,
  0xF8, 0x3E, 0x00, 0x7C, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x0F, 0x80, 0x7C,
  0x07, 0xC0, 0x0F, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x07,
  0x80, 0x07, 0xC0, 0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x03, 0xE0, 0x0F, 0x80,
  0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0xF8,
  0x00, 0x78, 0x07, 0x80, 0x03, 0xC0, 0x7C, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0xF0, 0x3E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE7, 0xC0,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x08, 0x7E, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x1F, 0xC0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xF8,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x0F, 0x80, 0x00, 0x0E, 0x00, 0x02, 0x7F, 0xC0, 0x0D, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xD8, 0x03, 0xFF, 0x20, 0x00, 0xFC,
  0x00,
};

const GFXglyph NotoSans_SemiCondensed_Italic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 13, 38, 13, 1, -37 },
  { 63, 16, 13, 19, 5, -37 },
  { 89, 29, 37, 29, 1, -37 },
  { 224, 24, 42, 26, 1, -39 },
  { 350, 32, 39, 38, 4, -38 },
  { 506, 28, 39, 30, 1, -38 },
  { 643, 6, 13, 11, 6, -37 },
  { 653, 16, 45, 14, 2, -37 },
  { 743, 17, 45, 14, -4, -37 },
  { 839, 21, 22, 25, 5, -40 },
  { 897, 23, 25, 27, 3, -31 },
  { 969, 10, 13, 12, -2, -6 },
  { 986, 13, 4, 15, 1, -16 },
  { 993, 6, 7, 12, 1, -6 },
  { 999, 24, 37, 18, -2, -37 },
  { 1110, 23, 39, 26, 2, -38 },
  { 1223, 14, 37, 26, 7, -37 },
  { 1288, 26, 38, 26, -1, -38 },
  { 1412, 25, 39, 26, 0, -38 },
  { 1534, 25, 37, 26, 0, -37 },
  { 1650, 24, 38, 26, 1, -37 },
  { 1764, 23, 39, 26, 3, -38 },
  { 1877, 24, 37, 26, 3, -37 },
  { 1988, 25, 39, 26, 1, -38 },
  { 2110, 23, 39, 26, 2, -38 },
  { 2223, 10, 29, 12, 1, -28 },
  { 2260, 14, 35, 12, -3, -28 },
  { 2322, 23, 25, 27, 3, -31 },
  { 2394, 22, 14, 27, 3, -25 },
  { 2433, 23, 25, 27, 3, -31 },
  { 2505, 18, 39, 20, 3, -38 },
  { 2593, 36, 42, 39, 2, -37 },
  { 2782, 26, 37, 26, -3, -37 },
  { 2903, 27, 37, 28, 1, -37 },
  { 3028, 27, 39, 27, 3, -38 },
  { 3160, 29, 37, 31, 1, -37 },
  { 3295, 25, 37, 24, 1, -37 },
  { 3411, 25, 37, 22, 1, -37 },
  { 3527, 29, 39, 32, 3, -38 },
  { 3669, 31, 37, 32, 1, -37 },
  { 3813, 21, 37, 16, -2, -37 },
  { 3911, 22, 47, 13, -8, -37 },
  { 4041, 30, 37, 26, 1, -37 },
  { 4180, 18, 37, 22, 1, -37 },
  { 4264, 40, 37, 40, 1, -37 },
  { 4449, 33, 37, 33, 1, -37 },
  { 4602, 29, 39, 33, 3, -38 },
  { 4744, 26, 37, 26, 1, -37 },
  { 4865, 29, 47, 33, 3, -38 },
  { 5036, 26, 37, 27, 1, -37 },
  { 5157, 25, 39, 24, 0, -38 },
  { 5279, 23, 37, 23, 4, -37 },
  { 5386, 29, 38, 31, 3, -37 },
  { 5524, 25, 37, 26, 5, -37 },
  { 5640, 40, 37, 41, 5, -37 },
  { 5825, 32, 37, 24, -3, -37 },
  { 5973, 23, 37, 24, 5, -37 },
  { 6080, 27, 37, 24, -1, -37 },
  { 6205, 20, 45, 15, -1, -37 },
  { 6318, 10, 37, 18, 5, -37 },
  { 6365, 20, 45, 15, -4, -37 },
  { 6478, 24, 22, 26, 1, -37 },
  { 6544, 20, 3, 19, -5, 5 },
  { 6552, 8, 8, 14, 8, -40 },
  { 6560, 24, 29, 27, 2, -28 },
  { 6647, 24, 41, 27, 1, -40 },
  { 6770, 20, 29, 21, 2, -28 },
  { 6843, 27, 41, 27, 2, -40 },
  { 6982, 20, 29, 24, 2, -28 },
  { 7055, 27, 52, 15, -6, -40 },
  { 7231, 26, 40, 27, 0, -28 },
  { 7361, 24, 40, 27, 1, -40 },
  { 7481, 12, 38, 12, 1, -38 },
  { 7538, 20, 50, 12, -7, -38 },
  { 7663, 24, 40, 23, 1, -40 },
  { 7783, 13, 40, 12, 1, -40 },
  { 7848, 37, 28, 41, 1, -28 },
  { 7978, 24, 29, 27, 1, -29 },
  { 8065, 22, 28, 26, 2, -28 },
  { 8142, 27, 40, 27, -2, -28 },
  { 8277, 24, 40, 27, 2, -28 },
  { 8397, 19, 28, 18, 1, -28 },
  { 8464, 20, 29, 20, 0, -28 },
  { 8537, 15, 35, 16, 2, -34 },
  { 8603, 24, 29, 27, 2, -28 },
  { 8690, 21, 28, 22, 3, -28 },
  { 8764, 33, 28, 34, 3, -28 },
  { 8880, 26, 28, 22, -2, -28 },
  { 8971, 29, 40, 22, -5, -28 },
  { 9116, 21, 28, 20, -1, -28 },
  { 9190, 20, 45, 18, 1, -37 },
  { 9303, 4, 52, 25, 11, -40 },
  { 9329, 19, 45, 18, -2, -37 },
  { 9436, 23, 7, 27, 3, -22 },
};

const GFXfont NotoSans_SemiCondensed_Italic52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic52pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC52PT7B_H_
