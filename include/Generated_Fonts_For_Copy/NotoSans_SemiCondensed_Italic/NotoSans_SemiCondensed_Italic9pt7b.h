#ifndef _NOTOSANS_SEMICONDENSED_ITALIC9PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x20, 0xF8, 0x2B, 0xD5, 0xF5, 0x30, 0x17, 0x66, 0x35, 0xE4,
  0x4E, 0xB5, 0xFD, 0xB6, 0x60, 0x22, 0x94, 0xCA, 0xCB, 0xE0, 0xC0, 0x29,
  0x49, 0x20, 0x24, 0x92, 0xB0, 0x4F, 0x4A, 0x5D, 0x20, 0xC0, 0xC0, 0x80,
  0x32, 0x44, 0x88, 0x25, 0x59, 0x99, 0x60, 0x79, 0x24, 0x80, 0x25, 0x11,
  0x24, 0xF0, 0x25, 0x16, 0x11, 0xE0, 0x13, 0x59, 0xF2, 0x74, 0x61, 0x1E,
  0x12, 0x47, 0x99, 0x60, 0xF2, 0x44, 0x88, 0x25, 0x52, 0xD9, 0x60, 0x25,
  0x55, 0x71, 0xE0, 0x40, 0x80, 0x40, 0xA0, 0x73, 0x10, 0xFC, 0xC5, 0xC0,
  0x25, 0x12, 0x40, 0xC0, 0x3C, 0xB6, 0xAD, 0x5B, 0xC8, 0x0E, 0x00, 0x18,
  0xCA, 0x74, 0xE4, 0x7A, 0x5C, 0xA9, 0x78, 0x34, 0x88, 0x88, 0xE0, 0x7A,
  0x52, 0x99, 0x70, 0x7A, 0x1C, 0x88, 0x70, 0x7A, 0x1C, 0x88, 0x40, 0x25,
  0x8A, 0x99, 0xE0, 0x4D, 0x27, 0x92, 0x8A, 0x40, 0x69, 0x25, 0x80, 0x24,
  0x94, 0x94, 0x4A, 0x98, 0xC9, 0x48, 0x49, 0x29, 0xC0, 0x66, 0xCD, 0xAB,
  0x6B, 0x52, 0x80, 0x65, 0x96, 0x96, 0x9A, 0x60, 0x22, 0xA3, 0x19, 0x4B,
  0x80, 0x7A, 0x54, 0xC8, 0x40, 0x22, 0xA3, 0x19, 0x4B, 0x84, 0x20, 0x7A,
  0x54, 0xC9, 0x48, 0x25, 0x46, 0x11, 0xE0, 0xF4, 0x48, 0x88, 0x9C, 0xA5,
  0x29, 0x70, 0x9A, 0xAC, 0xC8, 0x97, 0x6A, 0xD6, 0xC9, 0x92, 0x00, 0x2C,
  0xA1, 0x0C, 0x53, 0x20, 0xBA, 0xC4, 0x88, 0x78, 0x88, 0x88, 0x70, 0x69,
  0x29, 0x30, 0xAA, 0x90, 0x32, 0x22, 0x22, 0xC0, 0x25, 0xD0, 0xF0, 0x90,
  0x2A, 0xA5, 0x27, 0x00, 0x44, 0x75, 0x59, 0xE0, 0x34, 0x88, 0x60, 0x08,
  0x5A, 0xA9, 0x49, 0xC0, 0x35, 0xE8, 0x60, 0x19, 0x1C, 0x42, 0x21, 0x08,
  0xC0, 0x6A, 0xA5, 0x27, 0x13, 0x80, 0x44, 0x75, 0x59, 0x90, 0x45, 0x68,
  0x20, 0x92, 0x92, 0x80, 0x44, 0x56, 0x6A, 0xA0, 0x55, 0x68, 0x7C, 0xA5,
  0x54, 0xA9, 0x40, 0x75, 0x59, 0x90, 0x35, 0x99, 0x60, 0x75, 0x59, 0xE8,
  0x80, 0x2A, 0xA5, 0x27, 0x08, 0x80, 0x74, 0x48, 0x80, 0x71, 0x1E, 0x5D,
  0x29, 0x80, 0x55, 0x59, 0xF0, 0x99, 0x66, 0x40, 0xAF, 0x7D, 0x6A, 0x00,
  0x56, 0x46, 0xA0, 0x4A, 0x4C, 0x62, 0x13, 0x00, 0x72, 0x44, 0xE0, 0x34,
  0x48, 0x44, 0x40, 0xFF, 0x80, 0x69, 0x14, 0xA0, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Italic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 3, 2, 3, 1, -6 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 4, 8, 4, 0, -7 },
  { 12, 5, 7, 7, 1, -7 },
  { 17, 5, 7, 5, 0, -7 },
  { 22, 1, 2, 2, 1, -6 },
  { 23, 3, 7, 3, 0, -6 },
  { 26, 3, 7, 3, -1, -6 },
  { 29, 4, 4, 4, 1, -7 },
  { 31, 3, 4, 5, 1, -5 },
  { 33, 1, 2, 2, 0, -1 },
  { 34, 2, 1, 3, 0, -3 },
  { 35, 1, 1, 2, 0, -1 },
  { 36, 4, 6, 3, 0, -6 },
  { 39, 4, 7, 4, 0, -7 },
  { 43, 3, 6, 4, 1, -6 },
  { 46, 4, 7, 4, 0, -7 },
  { 50, 4, 7, 4, 0, -7 },
  { 54, 4, 6, 4, 0, -6 },
  { 57, 4, 6, 4, 0, -6 },
  { 60, 4, 7, 4, 0, -7 },
  { 64, 4, 6, 4, 1, -6 },
  { 67, 4, 7, 4, 0, -7 },
  { 71, 4, 7, 4, 0, -7 },
  { 75, 2, 5, 2, 0, -5 },
  { 77, 2, 6, 2, 0, -5 },
  { 79, 3, 4, 5, 1, -5 },
  { 81, 3, 2, 5, 1, -4 },
  { 82, 3, 4, 5, 1, -5 },
  { 84, 4, 7, 3, 0, -7 },
  { 88, 7, 7, 7, 0, -6 },
  { 95, 5, 6, 5, -1, -6 },
  { 99, 5, 6, 5, 0, -6 },
  { 103, 4, 7, 5, 1, -7 },
  { 107, 5, 6, 5, 0, -6 },
  { 111, 5, 6, 4, 0, -6 },
  { 115, 5, 6, 4, 0, -6 },
  { 119, 4, 7, 5, 1, -7 },
  { 123, 6, 6, 5, 0, -6 },
  { 128, 3, 6, 3, 0, -6 },
  { 131, 3, 8, 2, -1, -6 },
  { 134, 5, 6, 5, 0, -6 },
  { 138, 3, 6, 4, 0, -6 },
  { 141, 7, 6, 7, 0, -6 },
  { 147, 6, 6, 6, 0, -6 },
  { 152, 5, 7, 6, 1, -7 },
  { 157, 5, 6, 5, 0, -6 },
  { 161, 5, 9, 6, 1, -7 },
  { 167, 5, 6, 5, 0, -6 },
  { 171, 4, 7, 4, 0, -7 },
  { 175, 4, 6, 4, 1, -6 },
  { 178, 5, 6, 5, 1, -6 },
  { 182, 4, 6, 4, 1, -6 },
  { 185, 7, 6, 7, 1, -6 },
  { 191, 6, 6, 4, -1, -6 },
  { 196, 4, 6, 4, 1, -6 },
  { 199, 5, 6, 4, 0, -6 },
  { 203, 3, 7, 3, 0, -6 },
  { 206, 2, 6, 3, 1, -6 },
  { 208, 4, 7, 3, -1, -6 },
  { 212, 4, 3, 5, 0, -6 },
  { 214, 4, 1, 3, -1, 1 },
  { 215, 2, 2, 2, 1, -7 },
  { 216, 5, 5, 5, 0, -5 },
  { 220, 4, 7, 5, 0, -7 },
  { 224, 4, 5, 4, 0, -5 },
  { 227, 5, 7, 5, 0, -7 },
  { 232, 4, 5, 4, 0, -5 },
  { 235, 5, 9, 3, -1, -7 },
  { 241, 5, 7, 5, 0, -5 },
  { 246, 4, 7, 5, 0, -7 },
  { 250, 2, 7, 2, 0, -7 },
  { 252, 3, 9, 2, -1, -7 },
  { 256, 4, 7, 4, 0, -7 },
  { 260, 2, 7, 2, 0, -7 },
  { 262, 7, 5, 7, 0, -5 },
  { 267, 4, 5, 5, 0, -5 },
  { 270, 4, 5, 5, 0, -5 },
  { 273, 4, 7, 5, 0, -5 },
  { 277, 5, 7, 5, 0, -5 },
  { 282, 4, 5, 3, 0, -5 },
  { 285, 3, 5, 4, 0, -5 },
  { 287, 3, 6, 3, 0, -6 },
  { 290, 4, 5, 5, 0, -5 },
  { 293, 4, 5, 4, 0, -5 },
  { 296, 5, 5, 6, 1, -5 },
  { 300, 4, 5, 4, 0, -5 },
  { 303, 5, 7, 4, -1, -5 },
  { 308, 4, 5, 3, 0, -5 },
  { 311, 4, 7, 3, 0, -6 },
  { 315, 1, 9, 4, 2, -7 },
  { 317, 3, 7, 3, 0, -6 },
  { 320, 3, 1, 5, 1, -4 },
};

const GFXfont NotoSans_SemiCondensed_Italic9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic9pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC9PT7B_H_
