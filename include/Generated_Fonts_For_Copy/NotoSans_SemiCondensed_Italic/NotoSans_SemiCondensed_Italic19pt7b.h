#ifndef _NOTOSANS_SEMICONDENSED_ITALIC19PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC6, 0x23, 0x18, 0xC4, 0x23, 0x00, 0x0E, 0x60, 0x4D, 0x2C,
  0xB6, 0x90, 0x06, 0x40, 0x88, 0x12, 0x06, 0x43, 0xFE, 0x7F, 0xC6, 0x40,
  0x88, 0x13, 0x1F, 0xF8, 0x88, 0x11, 0x02, 0x60, 0xC8, 0x00, 0x02, 0x07,
  0x87, 0xE6, 0x83, 0x41, 0xA0, 0x70, 0x1C, 0x0B, 0x05, 0x82, 0xDB, 0xC7,
  0xC0, 0x80, 0x40, 0x18, 0x22, 0xC6, 0x4C, 0x44, 0xC8, 0xCD, 0x8C, 0x90,
  0xCA, 0xFD, 0x69, 0x65, 0x90, 0x91, 0x19, 0x31, 0x12, 0x21, 0x26, 0x1C,
  0x07, 0x01, 0xF0, 0x66, 0x08, 0xC1, 0x90, 0x3C, 0x03, 0x01, 0xE1, 0x66,
  0x48, 0xDB, 0x0E, 0x61, 0x86, 0x78, 0xF9, 0x80, 0x5F, 0x80, 0x0C, 0x61,
  0x08, 0x61, 0x0C, 0x30, 0x82, 0x08, 0x20, 0x82, 0x08, 0x30, 0x40, 0x10,
  0x20, 0x82, 0x0C, 0x30, 0xC3, 0x08, 0x21, 0x86, 0x10, 0xC6, 0x10, 0x80,
  0x10, 0x08, 0x98, 0xF0, 0x1F, 0x28, 0xE8, 0x4C, 0x08, 0x08, 0x08, 0x08,
  0xFF, 0x08, 0x08, 0x08, 0x08, 0x36, 0x6C, 0x7F, 0xC0, 0xF8, 0x00, 0x80,
  0xC0, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x0C, 0x06,
  0x06, 0x00, 0x0E, 0x3F, 0x33, 0x61, 0x41, 0x43, 0xC3, 0xC3, 0xC3, 0x82,
  0x86, 0xC6, 0xCC, 0x78, 0x0C, 0x77, 0xB2, 0x18, 0x61, 0x84, 0x30, 0xC3,
  0x08, 0x21, 0x80, 0x0E, 0x1F, 0xC4, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x0C,
  0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x17, 0xF0, 0x0E, 0x1F, 0xC4, 0x60, 0x30,
  0x18, 0x18, 0x78, 0x3C, 0x03, 0x01, 0x80, 0xC0, 0x68, 0x67, 0xE0, 0x01,
  0x81, 0xC0, 0xE0, 0xA0, 0xD0, 0xD8, 0x4C, 0x46, 0x62, 0x61, 0x3F, 0xE0,
  0xC0, 0x60, 0x20, 0x0F, 0x8F, 0xC4, 0x02, 0x03, 0x01, 0x80, 0xF8, 0x06,
  0x03, 0x00, 0x80, 0xC0, 0x68, 0x67, 0xE0, 0x07, 0x1F, 0x30, 0x20, 0x60,
  0x48, 0xFE, 0xE2, 0xC3, 0xC2, 0xC2, 0xC6, 0xCC, 0x78, 0x7F, 0xBF, 0xC0,
  0xC0, 0x60, 0x60, 0x30, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x06,
  0x00, 0x07, 0x0F, 0xC4, 0x26, 0x13, 0x18, 0xD8, 0x38, 0x3C, 0x63, 0x21,
  0xB0, 0x48, 0x66, 0x31, 0xF0, 0x1C, 0x3E, 0x63, 0x43, 0x43, 0xC3, 0xC3,
  0x6F, 0x3A, 0x06, 0x06, 0x0C, 0x98, 0xF0, 0x33, 0x00, 0x00, 0x00, 0xEC,
  0x18, 0xC0, 0x00, 0x00, 0x00, 0x33, 0x11, 0x80, 0x01, 0x07, 0x1C, 0x70,
  0xC0, 0x38, 0x0E, 0x03, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x70,
  0x1C, 0x07, 0x03, 0x0E, 0x38, 0xE0, 0x80, 0x38, 0xF8, 0x18, 0x30, 0x41,
  0x86, 0x18, 0x60, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x80, 0x7F, 0x06,
  0x04, 0x40, 0x36, 0x3C, 0xA2, 0x47, 0x22, 0x33, 0x13, 0x91, 0x94, 0x88,
  0xA6, 0xE9, 0x19, 0x8C, 0x00, 0x20, 0x00, 0xEE, 0x01, 0xC0, 0x01, 0x00,
  0xE0, 0x38, 0x1E, 0x05, 0x83, 0x60, 0x98, 0x66, 0x1F, 0x8F, 0xE2, 0x09,
  0x82, 0x40, 0xB0, 0x30, 0x1E, 0x07, 0xF1, 0x8C, 0x43, 0x10, 0xCC, 0x33,
  0xF0, 0xFC, 0x21, 0x98, 0x66, 0x19, 0x86, 0x47, 0x3F, 0x80, 0x07, 0x87,
  0xF3, 0x80, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0x62, 0x0F, 0x80, 0x1E, 0x03, 0xF0, 0x63, 0x08, 0x31, 0x06, 0x60,
  0xCC, 0x19, 0x03, 0x20, 0x4C, 0x19, 0x83, 0x30, 0xC4, 0xF1, 0xF8, 0x00,
  0x1F, 0xC7, 0xE1, 0x80, 0x40, 0x10, 0x0C, 0x03, 0xF0, 0xFC, 0x20, 0x18,
  0x06, 0x01, 0x80, 0x40, 0x3F, 0x80, 0x1F, 0xC7, 0xE1, 0x80, 0x40, 0x10,
  0x0C, 0x03, 0x00, 0xFC, 0x20, 0x18, 0x06, 0x01, 0x80, 0x40, 0x30, 0x00,
  0x07, 0x83, 0xFC, 0xE0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x1E, 0xC4,
  0x98, 0x13, 0x06, 0x60, 0xC6, 0x18, 0x7E, 0x00, 0x30, 0x66, 0x0C, 0xC1,
  0x10, 0x62, 0x0C, 0xC1, 0x9F, 0xE3, 0xFC, 0x41, 0x98, 0x33, 0x06, 0x60,
  0x88, 0x11, 0x06, 0x00, 0x1F, 0x0E, 0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18,
  0x18, 0x10, 0x10, 0x30, 0x30, 0xF8, 0x03, 0x03, 0x03, 0x02, 0x02, 0x06,
  0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0xF0, 0xC0,
  0x18, 0x63, 0x18, 0x62, 0x08, 0xC1, 0x30, 0x6C, 0x0F, 0x01, 0xE0, 0x26,
  0x0C, 0xC1, 0x88, 0x31, 0x84, 0x31, 0x83, 0x00, 0x18, 0x30, 0x60, 0x81,
  0x06, 0x0C, 0x10, 0x20, 0xC1, 0x83, 0x04, 0x1F, 0xC0, 0x1C, 0x0E, 0x38,
  0x1C, 0x70, 0x70, 0xE0, 0xA3, 0x43, 0xC6, 0x85, 0x8D, 0x1B, 0x12, 0x24,
  0x24, 0xC8, 0xC9, 0x31, 0x9E, 0x63, 0x38, 0x84, 0x71, 0x18, 0xC6, 0x00,
  0x18, 0x11, 0x81, 0x1C, 0x31, 0x43, 0x34, 0x23, 0x62, 0x36, 0x62, 0x26,
  0x23, 0x66, 0x34, 0x61, 0x46, 0x1C, 0x41, 0xCC, 0x1C, 0x07, 0x03, 0xF8,
  0xC3, 0x10, 0x36, 0x06, 0x80, 0xF0, 0x1E, 0x02, 0xC0, 0xD8, 0x1B, 0x02,
  0x60, 0xC6, 0x30, 0x7C, 0x00, 0x1E, 0x07, 0xE1, 0x8C, 0x43, 0x10, 0xCC,
  0x33, 0x18, 0xFC, 0x3C, 0x18, 0x06, 0x01, 0x80, 0x40, 0x30, 0x00, 0x07,
  0x03, 0xF8, 0xC3, 0x10, 0x36, 0x06, 0x80, 0xF0, 0x1E, 0x02, 0xC0, 0xD8,
  0x1B, 0x02, 0x60, 0xC6, 0x30, 0x7C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x1E,
  0x07, 0xE1, 0x8C, 0x43, 0x10, 0xCC, 0x23, 0x18, 0xFC, 0x26, 0x19, 0x86,
  0x21, 0x8C, 0x43, 0x30, 0x60, 0x0F, 0x0F, 0xCC, 0x06, 0x03, 0x01, 0x80,
  0x60, 0x1C, 0x06, 0x01, 0x80, 0xC0, 0x48, 0xE7, 0xE0, 0xFF, 0xFF, 0x10,
  0x10, 0x30, 0x30, 0x30, 0x20, 0x60, 0x60, 0x60, 0x40, 0x40, 0xC0, 0x30,
  0x66, 0x0C, 0x81, 0x10, 0x66, 0x0C, 0xC1, 0x98, 0x22, 0x04, 0x41, 0x98,
  0x33, 0x06, 0x61, 0x86, 0x70, 0xFC, 0x00, 0x81, 0xC0, 0xE0, 0xD8, 0x6C,
  0x66, 0x33, 0x31, 0x98, 0xC8, 0x6C, 0x34, 0x1E, 0x06, 0x03, 0x00, 0xC3,
  0x07, 0x0C, 0x3C, 0x70, 0xF1, 0x46, 0xC5, 0x1B, 0x34, 0x4C, 0x93, 0x36,
  0x48, 0xD1, 0x63, 0xC5, 0x8E, 0x14, 0x28, 0x70, 0xE1, 0x83, 0x06, 0x00,
  0x18, 0x23, 0x0C, 0x23, 0x06, 0x40, 0xD8, 0x0E, 0x01, 0x80, 0x30, 0x0A,
  0x03, 0x60, 0xCC, 0x11, 0x86, 0x11, 0x83, 0x00, 0x83, 0xC3, 0xC6, 0xC4,
  0x4C, 0x58, 0x58, 0x70, 0x60, 0x60, 0x60, 0x40, 0x40, 0xC0, 0x1F, 0xCF,
  0xE0, 0x18, 0x0C, 0x02, 0x01, 0x80, 0xC0, 0x20, 0x18, 0x0C, 0x06, 0x01,
  0x80, 0xC0, 0x3F, 0x80, 0x1E, 0x3C, 0x40, 0x83, 0x06, 0x08, 0x10, 0x20,
  0xC1, 0x82, 0x04, 0x18, 0x30, 0x60, 0xF0, 0x9B, 0x64, 0x92, 0x6D, 0x92,
  0x40, 0x1E, 0x3C, 0x10, 0x20, 0xC1, 0x83, 0x04, 0x08, 0x30, 0x60, 0x81,
  0x02, 0x0C, 0x18, 0xE0, 0x08, 0x18, 0x1C, 0x24, 0x24, 0x46, 0x42, 0x83,
  0xFE, 0xD9, 0x80, 0x3D, 0xB1, 0x98, 0xD8, 0x6C, 0x36, 0x12, 0x19, 0x0C,
  0xCE, 0x3A, 0x00, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x79, 0xCC, 0xC6, 0x63,
  0x61, 0xB0, 0xD8, 0x6C, 0x66, 0x66, 0xF0, 0x3E, 0xC1, 0x06, 0x0C, 0x10,
  0x20, 0x40, 0xC4, 0xF0, 0x00, 0x80, 0xC0, 0x60, 0x33, 0xD3, 0x19, 0x8D,
  0x86, 0xC3, 0x61, 0x21, 0x90, 0xCC, 0xE3, 0xA0, 0x3E, 0xC5, 0x0E, 0x3F,
  0xDC, 0x20, 0x40, 0xC4, 0xF8, 0x00, 0x80, 0xF0, 0x60, 0x18, 0x04, 0x07,
  0xC0, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00,
  0xC0, 0x30, 0x0C, 0x0E, 0x03, 0x00, 0x1E, 0xCC, 0x63, 0x19, 0x86, 0x61,
  0x98, 0x44, 0x31, 0x0C, 0x67, 0x0E, 0xC0, 0x20, 0x18, 0x86, 0x3F, 0x03,
  0x00, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x79, 0xCC, 0xC6, 0x43, 0x21, 0xB0,
  0x98, 0x48, 0x64, 0x36, 0x10, 0x18, 0xC0, 0x03, 0x18, 0xC4, 0x63, 0x18,
  0x84, 0x60, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x83, 0x04, 0x08, 0x30, 0x60,
  0x81, 0x06, 0x0C, 0x18, 0x21, 0xC2, 0x00, 0x18, 0x0C, 0x04, 0x02, 0x03,
  0x19, 0x98, 0xD8, 0x58, 0x78, 0x3E, 0x1B, 0x08, 0x84, 0x66, 0x30, 0x18,
  0xC4, 0x23, 0x18, 0xC4, 0x23, 0x18, 0x84, 0x60, 0x37, 0x3C, 0xE7, 0x33,
  0x18, 0xC8, 0x63, 0x61, 0x0D, 0x84, 0x26, 0x31, 0x90, 0xC6, 0x42, 0x1B,
  0x08, 0x40, 0x3F, 0x9C, 0xCC, 0x66, 0x36, 0x1B, 0x09, 0x8C, 0x86, 0x43,
  0x61, 0x80, 0x3E, 0x63, 0x43, 0xC3, 0xC3, 0x83, 0x82, 0x86, 0xCC, 0x78,
  0x1B, 0xC7, 0x31, 0x8C, 0x63, 0x10, 0xCC, 0x33, 0x0C, 0xC6, 0x33, 0x1B,
  0xC6, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x00, 0x3D, 0xB1, 0x98, 0xD8, 0x6C,
  0x36, 0x12, 0x19, 0x0C, 0xCE, 0x3A, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x20,
  0x36, 0x70, 0xC1, 0x06, 0x0C, 0x18, 0x20, 0x41, 0x80, 0x3E, 0xC5, 0x83,
  0x03, 0x83, 0x83, 0x06, 0x8D, 0xF0, 0x11, 0x09, 0xF6, 0x31, 0x08, 0xC6,
  0x21, 0x8E, 0x00, 0x61, 0x61, 0x43, 0x43, 0xC2, 0xC2, 0xC6, 0x86, 0xCE,
  0xF4, 0xC3, 0xC6, 0xC6, 0xCC, 0xCC, 0xD8, 0x58, 0x70, 0x70, 0x60, 0xC6,
  0x3C, 0x63, 0xCA, 0x6C, 0xA6, 0xDA, 0x4D, 0x2C, 0xF2, 0x8E, 0x38, 0xE3,
  0x0C, 0x30, 0x31, 0xC6, 0x61, 0xB0, 0x38, 0x0C, 0x03, 0x01, 0xE0, 0xD8,
  0x62, 0x30, 0xC0, 0x18, 0x63, 0x18, 0x63, 0x0C, 0xC0, 0x98, 0x16, 0x02,
  0xC0, 0x50, 0x0E, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x01, 0xE0, 0x10, 0x00,
  0x3E, 0x0C, 0x30, 0x41, 0x86, 0x08, 0x30, 0xC1, 0xF8, 0x03, 0x0E, 0x0C,
  0x08, 0x18, 0x18, 0x18, 0x30, 0xE0, 0x60, 0x30, 0x20, 0x20, 0x20, 0x60,
  0x60, 0x30, 0xFF, 0xFF, 0xE0, 0x10, 0x38, 0x10, 0x20, 0xC1, 0x82, 0x06,
  0x06, 0x1C, 0x60, 0x81, 0x06, 0x0C, 0x30, 0xE0, 0x71, 0xDF, 0x82,
};

const GFXglyph NotoSans_SemiCondensed_Italic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 14, 5, 0, -14 },
  { 10, 6, 5, 7, 2, -14 },
  { 14, 11, 14, 11, 0, -14 },
  { 34, 9, 15, 9, 0, -14 },
  { 51, 12, 14, 14, 1, -14 },
  { 72, 11, 14, 11, 0, -14 },
  { 92, 2, 5, 4, 2, -14 },
  { 94, 6, 17, 5, 1, -14 },
  { 107, 6, 17, 5, -1, -14 },
  { 120, 8, 8, 9, 2, -15 },
  { 128, 8, 9, 10, 1, -11 },
  { 137, 4, 4, 4, -1, -2 },
  { 139, 5, 2, 6, 0, -6 },
  { 141, 3, 2, 4, 0, -2 },
  { 142, 9, 14, 7, -1, -14 },
  { 158, 8, 14, 9, 1, -14 },
  { 172, 6, 14, 9, 2, -14 },
  { 183, 9, 14, 9, 0, -14 },
  { 199, 9, 14, 9, 0, -14 },
  { 215, 9, 14, 9, 0, -14 },
  { 231, 9, 14, 9, 0, -14 },
  { 247, 8, 14, 9, 1, -14 },
  { 261, 9, 14, 9, 1, -14 },
  { 277, 9, 14, 9, 0, -14 },
  { 293, 8, 14, 9, 1, -14 },
  { 307, 4, 10, 5, 0, -10 },
  { 312, 5, 12, 5, -1, -10 },
  { 320, 8, 9, 10, 1, -11 },
  { 329, 8, 5, 10, 1, -9 },
  { 334, 8, 9, 10, 1, -11 },
  { 343, 7, 14, 7, 1, -14 },
  { 356, 13, 16, 14, 1, -14 },
  { 382, 10, 14, 10, -1, -14 },
  { 400, 10, 14, 10, 0, -14 },
  { 418, 10, 14, 10, 1, -14 },
  { 436, 11, 14, 11, 0, -14 },
  { 456, 10, 14, 9, 0, -14 },
  { 474, 10, 14, 8, 0, -14 },
  { 492, 11, 14, 12, 1, -14 },
  { 512, 11, 14, 12, 1, -14 },
  { 532, 8, 14, 6, -1, -14 },
  { 546, 8, 18, 5, -3, -14 },
  { 564, 11, 14, 10, 0, -14 },
  { 584, 7, 14, 8, 0, -14 },
  { 597, 15, 14, 15, 0, -14 },
  { 624, 12, 14, 12, 0, -14 },
  { 645, 11, 14, 12, 1, -14 },
  { 665, 10, 14, 10, 0, -14 },
  { 683, 11, 17, 12, 1, -14 },
  { 707, 10, 14, 10, 0, -14 },
  { 725, 9, 14, 9, 0, -14 },
  { 741, 8, 14, 8, 2, -14 },
  { 755, 11, 14, 11, 1, -14 },
  { 775, 9, 14, 9, 2, -14 },
  { 791, 14, 14, 15, 2, -14 },
  { 816, 11, 14, 9, -1, -14 },
  { 836, 8, 14, 9, 2, -14 },
  { 850, 10, 14, 9, 0, -14 },
  { 868, 7, 17, 5, 0, -14 },
  { 883, 3, 14, 7, 2, -14 },
  { 889, 7, 17, 5, -1, -14 },
  { 904, 8, 8, 10, 1, -14 },
  { 912, 7, 1, 7, -2, 2 },
  { 913, 3, 3, 5, 3, -15 },
  { 915, 9, 10, 10, 1, -10 },
  { 927, 9, 14, 10, 0, -14 },
  { 943, 7, 10, 8, 1, -10 },
  { 952, 9, 14, 10, 1, -14 },
  { 968, 7, 10, 9, 1, -10 },
  { 977, 10, 20, 5, -2, -15 },
  { 1002, 10, 15, 10, 0, -10 },
  { 1021, 9, 14, 10, 0, -14 },
  { 1037, 5, 14, 4, 0, -14 },
  { 1046, 7, 19, 4, -2, -14 },
  { 1063, 9, 14, 8, 0, -14 },
  { 1079, 5, 14, 4, 0, -14 },
  { 1088, 14, 10, 15, 0, -10 },
  { 1106, 9, 10, 10, 0, -10 },
  { 1118, 8, 10, 10, 1, -10 },
  { 1128, 10, 15, 10, -1, -10 },
  { 1147, 9, 15, 10, 1, -10 },
  { 1164, 7, 10, 7, 0, -10 },
  { 1173, 7, 10, 7, 0, -10 },
  { 1182, 5, 13, 6, 1, -13 },
  { 1191, 8, 10, 10, 1, -10 },
  { 1201, 8, 10, 8, 1, -10 },
  { 1211, 12, 10, 12, 1, -10 },
  { 1226, 10, 10, 8, -1, -10 },
  { 1239, 11, 15, 8, -2, -10 },
  { 1260, 7, 10, 7, 0, -10 },
  { 1269, 8, 17, 7, 0, -14 },
  { 1286, 1, 19, 9, 4, -14 },
  { 1289, 7, 17, 7, -1, -14 },
  { 1304, 8, 3, 10, 1, -8 },
};

const GFXfont NotoSans_SemiCondensed_Italic19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic19pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC19PT7B_H_
