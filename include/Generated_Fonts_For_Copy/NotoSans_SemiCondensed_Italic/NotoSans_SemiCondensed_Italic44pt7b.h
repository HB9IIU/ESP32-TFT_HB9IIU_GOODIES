#ifndef _NOTOSANS_SEMICONDENSED_ITALIC44PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1E,
  0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x02, 0x00, 0x78, 0xFB, 0xC7,
  0x9E, 0x3C, 0xE1, 0xC7, 0x0E, 0x78, 0x73, 0x87, 0x9C, 0x38, 0xE1, 0xC7,
  0x0E, 0x30, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C,
  0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x70, 0x38, 0x00, 0x70, 0x70,
  0x00, 0x70, 0x70, 0x00, 0xE0, 0x70, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x01, 0xC0, 0xE0, 0x01, 0xC1, 0xC0, 0x01, 0xC1, 0xC0,
  0x03, 0x81, 0xC0, 0x03, 0x83, 0x80, 0x03, 0x83, 0x80, 0x07, 0x03, 0x80,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x0E, 0x07, 0x00,
  0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x1C, 0x00,
  0x1C, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xF0, 0x00, 0xFF,
  0xE0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x79, 0xC2, 0x0F, 0x18, 0x00, 0xE1,
  0x80, 0x0E, 0x18, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0xF3, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x06, 0xF8, 0x00, 0xE7, 0x80, 0x0E, 0x38, 0x00, 0xC3, 0x80, 0x0C, 0x38,
  0x00, 0xC3, 0x80, 0x1C, 0x78, 0xC1, 0xCF, 0x0F, 0x9B, 0xF0, 0xFF, 0xFE,
  0x0F, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x41, 0xFC, 0x00,
  0x70, 0x7F, 0xC0, 0x1C, 0x0E, 0x38, 0x07, 0x83, 0x87, 0x80, 0xE0, 0x70,
  0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x03, 0x83, 0x81, 0xC0, 0x70, 0x70, 0x70,
  0x1E, 0x0E, 0x1E, 0x03, 0x81, 0xC3, 0x80, 0x70, 0x38, 0xE0, 0x0E, 0x0F,
  0x3C, 0x01, 0xC1, 0xC7, 0x1F, 0x38, 0x39, 0xC7, 0xF7, 0x0E, 0x39, 0xEF,
  0xF3, 0xCE, 0x70, 0xEF, 0xF3, 0x8E, 0x1D, 0xFC, 0x73, 0x83, 0x8F, 0x1C,
  0x70, 0x70, 0x07, 0x0E, 0x0E, 0x00, 0xE3, 0x81, 0xC0, 0x38, 0x70, 0x38,
  0x0E, 0x0E, 0x07, 0x01, 0xC1, 0xC1, 0xC0, 0x70, 0x38, 0x38, 0x1E, 0x07,
  0x07, 0x03, 0x80, 0xE1, 0xC0, 0xE0, 0x1C, 0x38, 0x3C, 0x03, 0xDE, 0x07,
  0x00, 0x3F, 0x81, 0xC0, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0xE0, 0x01, 0xF1, 0xE0, 0x01, 0xC0, 0xE0, 0x03, 0xC0, 0xE0,
  0x03, 0xC0, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0x81, 0xE0, 0x03, 0x81, 0xE0,
  0x03, 0xC3, 0xC0, 0x03, 0xC7, 0x80, 0x01, 0xDF, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0x78, 0x0F,
  0x3E, 0x3C, 0x1E, 0x3C, 0x3C, 0x1E, 0x78, 0x1E, 0x3C, 0xF0, 0x1F, 0x3C,
  0xF0, 0x0F, 0x78, 0xF0, 0x07, 0xF0, 0xE0, 0x07, 0xF0, 0xF0, 0x03, 0xE0,
  0xF0, 0x03, 0xC0, 0xF0, 0x0F, 0xE0, 0xF8, 0x1F, 0xF0, 0x7F, 0xFE, 0xF0,
  0x3F, 0xF8, 0x78, 0x1F, 0xE0, 0x7C, 0x7B, 0xDE, 0xE7, 0x7B, 0x9C, 0xE7,
  0x30, 0x00, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80,
  0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00,
  0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0,
  0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x03,
  0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x40, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x18, 0x07, 0xCE, 0x03, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0xFF, 0xF0, 0x3E, 0xFC, 0x1F, 0x80, 0x0F, 0x70,
  0x07, 0x9C, 0x03, 0xC3, 0x80, 0xF0, 0xE0, 0x18, 0x3C, 0x02, 0x07, 0x00,
  0x01, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x0F, 0x0F, 0x1E, 0x1E, 0x1E, 0x3C, 0x38, 0x78,
  0x70, 0x70, 0xE0, 0x7F, 0xFF, 0xFB, 0xFF, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF,
  0x20, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x78, 0x3E, 0x1F,
  0x03, 0xC3, 0xC0, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE7, 0x80, 0x3C, 0xF0,
  0x07, 0x9E, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0,
  0x0F, 0x70, 0x01, 0xFE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00,
  0x3D, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x0F, 0x1E, 0x01,
  0xE3, 0xC0, 0x78, 0x78, 0x1F, 0x07, 0x87, 0xC0, 0xFF, 0xF0, 0x0F, 0xFC,
  0x00, 0xFF, 0x00, 0x01, 0xF0, 0x3F, 0x07, 0xE1, 0xFE, 0x3F, 0xEF, 0xDE,
  0xF9, 0xE6, 0x1C, 0x43, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFC, 0x0F, 0xF7,
  0xE0, 0x38, 0x0F, 0x80, 0x80, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x04, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xE7,
  0xE0, 0x38, 0x0F, 0x81, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x11,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xF1, 0x00, 0x0F, 0x0E, 0x01, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xB8, 0x00, 0x3F, 0xC0, 0x03, 0xDE, 0x00,
  0x1C, 0xE0, 0x01, 0xE7, 0x00, 0x1E, 0x78, 0x01, 0xE3, 0xC0, 0x0E, 0x1E,
  0x00, 0xE0, 0xE0, 0x0F, 0x0F, 0x00, 0xF0, 0x78, 0x0F, 0x03, 0xC0, 0x70,
  0x1C, 0x07, 0x80, 0xE0, 0x78, 0x0F, 0x07, 0x80, 0x78, 0x38, 0x03, 0xC3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFC, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x80, 0x0F, 0x0C, 0x03, 0xF0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xE6, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x38, 0x03, 0x9F, 0xE0, 0x7B, 0xFF, 0x07, 0xF9, 0xF8,
  0x7E, 0x07, 0x87, 0xC0, 0x3C, 0x78, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03,
  0xCF, 0x00, 0x3C, 0xF0, 0x03, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00,
  0x78, 0xF0, 0x0F, 0x07, 0x81, 0xF0, 0x7C, 0x3E, 0x03, 0xFF, 0xC0, 0x3F,
  0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xE7, 0xE0, 0x7C, 0x0F, 0x03,
  0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0xE0, 0x0F, 0x07, 0x00, 0x70, 0x38, 0x07,
  0x81, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0x3C, 0x3C, 0x01, 0xF7, 0xC0, 0x07,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x7E, 0xF8, 0x07, 0xC3, 0xE0,
  0x78, 0x0F, 0x07, 0x80, 0x3C, 0x3C, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00,
  0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xF0, 0x0F, 0x07,
  0xC0, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x3E,
  0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x7E, 0x7E, 0x07, 0x81, 0xE0, 0xF0,
  0x1E, 0x0E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xC0, 0x0F, 0x3C,
  0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x1E, 0x3C, 0x01, 0xE1,
  0xE0, 0x3E, 0x1E, 0x07, 0xE1, 0xFF, 0xFE, 0x0F, 0xFD, 0xC0, 0x7F, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x80, 0xFC, 0x0F, 0xFF,
  0x80, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x07, 0x0F, 0x1F, 0x1F, 0x1F, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0xF8, 0xF8, 0xF8, 0xF0, 0x40, 0x00, 0xE0, 0x1E, 0x03, 0xF0,
  0x3E, 0x03, 0xE0, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0x80, 0x00, 0x70, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x80, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0x80, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x00, 0x03, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x1F, 0x7E, 0x10, 0x1F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xC1, 0xF8, 0x00,
  0xF8, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xC0, 0x3C, 0x00, 0x03, 0x81, 0xE0,
  0x00, 0x0E, 0x0F, 0x00, 0x00, 0x1C, 0x78, 0x07, 0xE0, 0x71, 0xC0, 0x7F,
  0xE1, 0xCF, 0x03, 0xFF, 0x07, 0x38, 0x1C, 0x1C, 0x1C, 0xE0, 0xE0, 0x70,
  0x77, 0x07, 0x83, 0xC1, 0xDC, 0x1C, 0x0E, 0x07, 0x70, 0xE0, 0x38, 0x1F,
  0x83, 0x80, 0xE0, 0x7E, 0x0E, 0x07, 0x83, 0xB8, 0x38, 0x1C, 0x0E, 0xE1,
  0xC0, 0x70, 0x3B, 0x87, 0x03, 0xC1, 0xCE, 0x1E, 0x0F, 0x07, 0x38, 0x38,
  0x7C, 0x38, 0xE0, 0xF7, 0xBB, 0xC3, 0x83, 0xFC, 0xFE, 0x0E, 0x07, 0xC1,
  0xF0, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x02, 0x00, 0x1F, 0x80, 0x70, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xEF, 0x00, 0x01, 0xDE, 0x00, 0x07, 0x9C, 0x00, 0x0E,
  0x38, 0x00, 0x3C, 0x70, 0x00, 0x70, 0xE0, 0x01, 0xE1, 0xC0, 0x03, 0x83,
  0x80, 0x0F, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x78, 0x1E, 0x00, 0xE0, 0x3C,
  0x03, 0xC0, 0x78, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x3C,
  0x00, 0x38, 0x78, 0x00, 0x71, 0xE0, 0x00, 0xE3, 0xC0, 0x01, 0xEF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0x80, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0xF0, 0x1F, 0x03, 0xC0, 0x3C, 0x0E, 0x00, 0xF0, 0x78, 0x03,
  0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1C, 0x00, 0xF0, 0xF0, 0x07, 0xC3,
  0xC0, 0x3E, 0x0F, 0x01, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x1E, 0x07, 0xE0, 0x78, 0x07, 0x81, 0xE0, 0x0F, 0x07, 0x00, 0x3C,
  0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x38,
  0x01, 0xF1, 0xE0, 0x07, 0x87, 0x80, 0x3E, 0x1E, 0x07, 0xF0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xE0, 0x08, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x03, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xC0, 0xFC, 0x03,
  0xC0, 0x3E, 0x03, 0x80, 0x1E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x0F, 0x07,
  0x80, 0x0F, 0x07, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F,
  0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E,
  0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1C, 0x00, 0x3E, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x78, 0x38, 0x00, 0xF8, 0x38,
  0x01, 0xF0, 0x78, 0x03, 0xE0, 0x78, 0x0F, 0xC0, 0x78, 0x7F, 0x80, 0x7F,
  0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x03,
  0xFF, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xE0, 0x0E, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x07, 0xFC, 0xF0, 0x07, 0xFC, 0xF0, 0x0F, 0xF8, 0xF0, 0x0F,
  0xF8, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0x70, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF8, 0x00,
  0xE0, 0x7C, 0x01, 0xE0, 0x7E, 0x01, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C,
  0x00, 0x3C, 0x0F, 0x00, 0x0E, 0x03, 0xC0, 0x07, 0x80, 0xE0, 0x01, 0xE0,
  0x78, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x01, 0xC0, 0x03,
  0xC0, 0x70, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0E, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1E, 0x00, 0x1E, 0x07,
  0x80, 0x07, 0x01, 0xE0, 0x03, 0xC0, 0x70, 0x00, 0xF0, 0x3C, 0x00, 0x3C,
  0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0x80, 0xF0, 0x01, 0xE0, 0x38, 0x00,
  0x78, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xC0, 0x70,
  0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xF8, 0x07, 0xFF,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xE0, 0x0F, 0x81, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x0F,
  0x80, 0x3C, 0x0F, 0x80, 0x1C, 0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x0F, 0x07,
  0x80, 0x07, 0x87, 0x80, 0x03, 0x87, 0x80, 0x03, 0xC7, 0x80, 0x01, 0xE7,
  0xC0, 0x00, 0xF7, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3B, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xBC, 0x00, 0x0F, 0x9E, 0x00, 0x07, 0x8F, 0x00, 0x03,
  0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x3C, 0x00,
  0x78, 0x1E, 0x00, 0x38, 0x0F, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0,
  0x0F, 0x00, 0xF8, 0x07, 0x00, 0x3C, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x0F,
  0x80, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x03,
  0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xDE, 0x07, 0x38, 0x01,
  0xEE, 0x03, 0x9C, 0x01, 0xE7, 0x03, 0xCE, 0x00, 0xF7, 0x81, 0xE7, 0x00,
  0xF3, 0xC0, 0xF3, 0x80, 0x79, 0xE0, 0x71, 0xC0, 0x78, 0xE0, 0x38, 0xE0,
  0x38, 0xF0, 0x3C, 0x70, 0x3C, 0x78, 0x1E, 0x3C, 0x1C, 0x3C, 0x0F, 0x1E,
  0x1E, 0x1E, 0x07, 0x0F, 0x0E, 0x0E, 0x03, 0x83, 0x8F, 0x0F, 0x03, 0xC1,
  0xC7, 0x07, 0x81, 0xE0, 0xE7, 0x83, 0xC0, 0xE0, 0x73, 0x81, 0xE0, 0x70,
  0x3B, 0xC0, 0xE0, 0x78, 0x1D, 0xC0, 0xF0, 0x3C, 0x0F, 0xE0, 0x78, 0x1E,
  0x07, 0xE0, 0x3C, 0x0E, 0x03, 0xF0, 0x1C, 0x07, 0x01, 0xF0, 0x1E, 0x07,
  0x80, 0xF8, 0x0F, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xE0,
  0x7E, 0x00, 0x3C, 0x0F, 0xC0, 0x07, 0x81, 0xF8, 0x00, 0xF0, 0x3F, 0x00,
  0x1C, 0x0F, 0xF0, 0x03, 0x81, 0xFE, 0x00, 0xF0, 0x3D, 0xC0, 0x1E, 0x07,
  0x3C, 0x03, 0xC0, 0xE7, 0x80, 0x70, 0x3C, 0x70, 0x0E, 0x07, 0x8E, 0x03,
  0xC0, 0xF1, 0xE0, 0x78, 0x1C, 0x3C, 0x0F, 0x03, 0x83, 0x81, 0xC0, 0xF0,
  0x78, 0x78, 0x1E, 0x0F, 0x0F, 0x03, 0xC0, 0xE1, 0xE0, 0x70, 0x1E, 0x38,
  0x0E, 0x03, 0xC7, 0x03, 0xC0, 0x39, 0xE0, 0x78, 0x07, 0x3C, 0x0F, 0x00,
  0xF7, 0x81, 0xC0, 0x1E, 0xE0, 0x78, 0x01, 0xDC, 0x0F, 0x00, 0x3F, 0x81,
  0xE0, 0x07, 0xF0, 0x38, 0x00, 0x7E, 0x07, 0x00, 0x0F, 0x81, 0xE0, 0x01,
  0xF0, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xC0, 0x7E, 0x0F, 0x80, 0x3E, 0x0F,
  0x00, 0x1E, 0x1E, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x3C,
  0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3C, 0xF0,
  0x00, 0x3C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF0, 0xF8,
  0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x7E, 0x0F, 0xC0, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0xF0, 0x3E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xE0, 0x78, 0x03,
  0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1C, 0x00, 0xE0, 0xF0, 0x07, 0x83,
  0xC0, 0x1E, 0x0F, 0x00, 0xF8, 0x3C, 0x07, 0xC0, 0xE0, 0x3E, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xC0, 0x7E, 0x0F, 0x80,
  0x3E, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x3C, 0x00,
  0x0F, 0x3C, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3E, 0xF0, 0x00,
  0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0xF0, 0xF8, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x7E, 0x0F, 0xC0, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0xF0, 0x3E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xF0, 0x78, 0x03, 0xC1,
  0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1C, 0x00, 0xE0, 0xF0, 0x07, 0x83, 0xC0,
  0x1E, 0x0F, 0x00, 0xF0, 0x3C, 0x07, 0xC0, 0xE0, 0xFE, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xE1, 0xE0, 0x07, 0x07, 0x80, 0x3C,
  0x0E, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x38, 0x07,
  0x81, 0xE0, 0x1E, 0x07, 0x80, 0x78, 0x1E, 0x00, 0xF0, 0x70, 0x03, 0xC3,
  0xC0, 0x0F, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0x80,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7C, 0x03, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE1, 0x00, 0x1F, 0x0E, 0x03, 0xF0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x0F,
  0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0E, 0x00, 0x0E, 0x1E, 0x00, 0x1E, 0x1E,
  0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1C, 0x00, 0x1C, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x38, 0x78,
  0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x70,
  0x00, 0x70, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0,
  0x00, 0xF0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0,
  0x03, 0xC0, 0xF0, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0x7F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xEF, 0x00,
  0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x3C,
  0x1C, 0x00, 0xF0, 0x70, 0x07, 0x81, 0xC0, 0x1E, 0x07, 0x00, 0xF0, 0x1C,
  0x03, 0xC0, 0x78, 0x1E, 0x01, 0xE0, 0x78, 0x07, 0x81, 0xC0, 0x1E, 0x0F,
  0x00, 0x78, 0x38, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x00, 0x1E, 0x3C, 0x00,
  0x78, 0xE0, 0x01, 0xE7, 0x80, 0x03, 0x9E, 0x00, 0x0E, 0xF0, 0x00, 0x3B,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xFC,
  0x00, 0x78, 0x01, 0xEF, 0x00, 0x3E, 0x00, 0x7B, 0xC0, 0x0F, 0x80, 0x3C,
  0xF0, 0x07, 0xE0, 0x0F, 0x3C, 0x01, 0xF8, 0x03, 0xC7, 0x00, 0xFE, 0x01,
  0xE1, 0xC0, 0x3B, 0x80, 0x78, 0x70, 0x1E, 0xE0, 0x3C, 0x1C, 0x07, 0x38,
  0x0F, 0x07, 0x01, 0xCE, 0x03, 0x81, 0xC0, 0xF3, 0x81, 0xE0, 0x70, 0x38,
  0xE0, 0x78, 0x1C, 0x1E, 0x38, 0x3C, 0x07, 0x07, 0x0E, 0x0F, 0x01, 0xC3,
  0xC3, 0x87, 0x80, 0x70, 0xE0, 0xE1, 0xE0, 0x1C, 0x38, 0x38, 0x70, 0x07,
  0x1C, 0x0E, 0x3C, 0x01, 0xC7, 0x03, 0x8E, 0x00, 0x73, 0xC0, 0xE7, 0x80,
  0x1C, 0xE0, 0x39, 0xE0, 0x07, 0x78, 0x0E, 0x70, 0x01, 0xDC, 0x03, 0xBC,
  0x00, 0x77, 0x00, 0xEE, 0x00, 0x1F, 0x80, 0x3B, 0x80, 0x07, 0xE0, 0x0F,
  0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x78,
  0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x1E, 0x00,
  0x1C, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0xF0,
  0x00, 0x0E, 0x78, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDE, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x0F,
  0x00, 0x0F, 0x03, 0xC0, 0x07, 0x80, 0x70, 0x01, 0xE0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x00,
  0xF0, 0x01, 0xFF, 0x00, 0x1E, 0x70, 0x03, 0xC7, 0x00, 0x78, 0x78, 0x07,
  0x87, 0x80, 0xF0, 0x78, 0x0F, 0x03, 0x81, 0xE0, 0x38, 0x3C, 0x03, 0xC3,
  0xC0, 0x3C, 0x78, 0x03, 0xC7, 0x00, 0x1C, 0xF0, 0x01, 0xDE, 0x00, 0x1D,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0xE1,
  0xC3, 0x87, 0x8F, 0x1E, 0x1C, 0x38, 0x70, 0xE1, 0xE3, 0xC7, 0x87, 0x0E,
  0x1C, 0x38, 0x78, 0xF1, 0xE1, 0xC3, 0x87, 0x0E, 0x1E, 0x3C, 0x78, 0x70,
  0xE1, 0xC3, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFC, 0x00, 0x00, 0x30, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x1D, 0xC0, 0x01, 0xDE, 0x00, 0x38, 0xE0, 0x03, 0x8F,
  0x00, 0x70, 0x70, 0x07, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xC0,
  0x3C, 0x1C, 0x01, 0xC3, 0x80, 0x1E, 0x38, 0x00, 0xE7, 0x80, 0x0F, 0xF0,
  0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xC0, 0xF8, 0xF1, 0xE1,
  0xE1, 0xC3, 0xC3, 0x80, 0x00, 0xF8, 0x70, 0x3F, 0xC7, 0x07, 0xFE, 0xF0,
  0xF8, 0x7E, 0x1F, 0x03, 0xE1, 0xE0, 0x3E, 0x3C, 0x03, 0xE3, 0xC0, 0x1E,
  0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03,
  0xCF, 0x00, 0x38, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x0F, 0x8F, 0x00,
  0xF8, 0xF0, 0x1F, 0x0F, 0x03, 0xF0, 0xF8, 0x77, 0x07, 0xFE, 0xF0, 0x7F,
  0xCE, 0x03, 0xF8, 0xE0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x70, 0xF8, 0x07, 0x3F, 0xC0, 0xF7, 0xFE, 0x0F, 0xF1,
  0xF0, 0xFC, 0x0F, 0x0F, 0x80, 0xF1, 0xF0, 0x0F, 0x1F, 0x00, 0xF1, 0xE0,
  0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x3C,
  0x00, 0xE3, 0xC0, 0x1E, 0x38, 0x01, 0xE7, 0x80, 0x3C, 0x78, 0x03, 0xC7,
  0x80, 0x7C, 0x7C, 0x07, 0x8F, 0xE1, 0xF0, 0xFF, 0xFF, 0x0E, 0x7F, 0xE0,
  0xE3, 0xF8, 0x00, 0x00, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0x83, 0x1F,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x08, 0x7F, 0xF8, 0x3F,
  0xF8, 0x1F, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x03, 0xE3, 0xC0, 0x3F, 0xCF, 0x01, 0xFF, 0xBC,
  0x0F, 0x87, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3E, 0x0F, 0x00, 0xF8, 0x3C,
  0x01, 0xE1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1C, 0x00, 0xF0, 0xF0, 0x03,
  0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x83,
  0xC0, 0x3E, 0x0F, 0x00, 0xF0, 0x3C, 0x07, 0xC0, 0xF0, 0x3F, 0x03, 0xE1,
  0xFC, 0x07, 0xFE, 0xF0, 0x1F, 0xF3, 0x80, 0x3F, 0x8E, 0x00, 0x00, 0xFC,
  0x01, 0xFF, 0x81, 0xFF, 0xC1, 0xF1, 0xF1, 0xE0, 0x79, 0xF0, 0x3C, 0xF0,
  0x1E, 0xF0, 0x0F, 0x78, 0x0F, 0x3C, 0x0F, 0xBC, 0x7F, 0x9F, 0xFF, 0x8F,
  0xFE, 0x07, 0xF0, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x60, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x1C, 0x03, 0xFC, 0x70, 0x1F, 0xFB, 0xC0, 0xF8, 0x7E, 0x07, 0xC0,
  0xF8, 0x1E, 0x03, 0xE0, 0xF0, 0x0F, 0x83, 0xC0, 0x3E, 0x1E, 0x00, 0xF0,
  0x78, 0x03, 0xC1, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0,
  0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x03, 0xE0, 0xF0, 0x0F,
  0x83, 0xC0, 0x7C, 0x0F, 0x03, 0xF0, 0x3E, 0x1F, 0xC0, 0x7F, 0xEF, 0x01,
  0xFF, 0x38, 0x03, 0xF8, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x0C, 0x03, 0xE0,
  0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70,
  0xF8, 0x07, 0x3F, 0xC0, 0xF7, 0xFE, 0x0F, 0xF1, 0xF0, 0xFC, 0x0F, 0x0F,
  0x80, 0xF1, 0xF0, 0x0F, 0x1F, 0x00, 0xF1, 0xE0, 0x0E, 0x1E, 0x01, 0xE1,
  0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xC3, 0xC0, 0x3C,
  0x38, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0x87, 0x80, 0x38, 0x70, 0x07,
  0x87, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x70, 0xF0, 0x0F, 0x00, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x01, 0x00, 0x00, 0x00, 0x00, 0x07, 0x01, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1E, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x0F,
  0x07, 0x01, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0x80, 0xF0, 0xF0, 0x0E, 0x1F,
  0x01, 0xE3, 0xE0, 0x1E, 0x3C, 0x01, 0xE7, 0x80, 0x1C, 0xF0, 0x01, 0xDE,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xC7, 0x80, 0x38,
  0x78, 0x07, 0x87, 0x80, 0x78, 0x3C, 0x07, 0x83, 0xC0, 0x70, 0x3C, 0x0F,
  0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x00, 0x01, 0xE0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0,
  0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x0F, 0x80, 0xF8,
  0x0E, 0x7F, 0x87, 0xF8, 0x3D, 0xFF, 0x9F, 0xF8, 0x77, 0x9F, 0x79, 0xF0,
  0xFC, 0x1F, 0xC1, 0xE1, 0xF0, 0x3F, 0x01, 0xC7, 0xC0, 0x7C, 0x03, 0x8F,
  0x80, 0xF8, 0x0F, 0x1E, 0x01, 0xE0, 0x1E, 0x3C, 0x03, 0xC0, 0x3C, 0x70,
  0x07, 0x00, 0x71, 0xE0, 0x0E, 0x00, 0xE3, 0xC0, 0x3C, 0x03, 0xC7, 0x80,
  0x78, 0x07, 0x8E, 0x00, 0xF0, 0x0F, 0x1C, 0x01, 0xC0, 0x1C, 0x78, 0x07,
  0x80, 0x78, 0xF0, 0x0F, 0x00, 0xF1, 0xE0, 0x1E, 0x01, 0xE3, 0x80, 0x3C,
  0x03, 0xCF, 0x00, 0x70, 0x07, 0x1E, 0x01, 0xE0, 0x1E, 0x3C, 0x03, 0xC0,
  0x3C, 0x78, 0x07, 0x80, 0x78, 0x07, 0x0F, 0x80, 0xF3, 0xFE, 0x0F, 0x7F,
  0xE0, 0xFF, 0x1F, 0x0F, 0xC0, 0xF0, 0xF8, 0x0F, 0x1F, 0x00, 0xF1, 0xF0,
  0x0F, 0x1E, 0x00, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE3, 0xC0, 0x1E, 0x3C,
  0x01, 0xE3, 0xC0, 0x3C, 0x3C, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7,
  0x80, 0x3C, 0x78, 0x07, 0x87, 0x80, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x78,
  0xF0, 0x07, 0x8F, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE,
  0x07, 0xC7, 0xC1, 0xF0, 0x3C, 0x7C, 0x07, 0x8F, 0x00, 0x73, 0xC0, 0x0F,
  0x78, 0x01, 0xEF, 0x00, 0x3F, 0xC0, 0x07, 0x78, 0x01, 0xEF, 0x00, 0x3D,
  0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1C, 0xF0, 0x07, 0x9E, 0x00, 0xF3,
  0xC0, 0x3C, 0x78, 0x0F, 0x07, 0x83, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00,
  0x7F, 0x00, 0x01, 0xC3, 0xE0, 0x07, 0x3F, 0xC0, 0x3D, 0xFF, 0x80, 0xEF,
  0x1F, 0x03, 0xF0, 0x3C, 0x0F, 0x80, 0xF0, 0x3C, 0x03, 0xC1, 0xF0, 0x0F,
  0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC3, 0xC0, 0x0F, 0x0F,
  0x00, 0x3C, 0x3C, 0x00, 0xE0, 0xF0, 0x07, 0x83, 0x80, 0x1E, 0x1E, 0x00,
  0xF0, 0x78, 0x03, 0xC1, 0xE0, 0x1F, 0x07, 0xC0, 0x78, 0x1F, 0x87, 0xC0,
  0xF7, 0xFF, 0x03, 0xDF, 0xF8, 0x0F, 0x3F, 0x80, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xF8, 0x70, 0x3F, 0xC7, 0x07, 0xFE, 0xF0, 0xF8, 0x7E, 0x1F, 0x03,
  0xE1, 0xE0, 0x3E, 0x3C, 0x03, 0xE3, 0xC0, 0x3E, 0x78, 0x03, 0xC7, 0x80,
  0x3C, 0x70, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x78, 0xF0,
  0x07, 0x8F, 0x00, 0x78, 0xF0, 0x0F, 0x8F, 0x00, 0xF0, 0xF0, 0x1F, 0x0F,
  0x03, 0xF0, 0xF8, 0x7F, 0x07, 0xFE, 0xF0, 0x7F, 0xCE, 0x03, 0xF8, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x1F, 0x07, 0x3F, 0x0F, 0x7F, 0x0E, 0xFE,
  0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0xC3, 0xE0,
  0xE1, 0xE0, 0x10, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x8C, 0x07,
  0xC7, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0x80, 0x30, 0x07, 0x00,
  0x70, 0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x01, 0xE0, 0x1C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0x07,
  0xF0, 0x3F, 0x00, 0x0E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xE1, 0xE0,
  0x0E, 0x1C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1C, 0x3C,
  0x01, 0xC3, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0x87,
  0x80, 0x78, 0x70, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x0F, 0x8F, 0x00, 0xF0,
  0xF0, 0x1F, 0x0F, 0x03, 0xF0, 0xF0, 0x7F, 0x0F, 0xFE, 0xE0, 0x7F, 0xCE,
  0x03, 0xF8, 0xE0, 0xF0, 0x01, 0xFE, 0x00, 0x7B, 0xC0, 0x0F, 0x38, 0x03,
  0xC7, 0x00, 0x78, 0xE0, 0x1E, 0x1C, 0x03, 0xC3, 0x80, 0xF0, 0x70, 0x1E,
  0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF1, 0xE0,
  0x1E, 0x3C, 0x03, 0xCF, 0x00, 0x39, 0xE0, 0x07, 0x78, 0x00, 0xEE, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0xE0, 0x1F, 0x00, 0xFE, 0x01, 0xF0, 0x1E, 0xE0, 0x1F, 0x01, 0xEE, 0x03,
  0xF0, 0x1C, 0xE0, 0x3F, 0x03, 0xCE, 0x07, 0x70, 0x3C, 0xE0, 0x77, 0x07,
  0x8E, 0x0F, 0x70, 0x78, 0xE0, 0xE7, 0x0F, 0x0E, 0x0E, 0x70, 0xF0, 0xE1,
  0xC7, 0x0E, 0x0E, 0x1C, 0x71, 0xE0, 0xE3, 0x87, 0x1C, 0x0E, 0x38, 0x73,
  0xC0, 0xE7, 0x87, 0x3C, 0x0E, 0x70, 0x73, 0x80, 0xEF, 0x07, 0x78, 0x0E,
  0xE0, 0x77, 0x00, 0xEE, 0x07, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x07,
  0xE0, 0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x00,
  0x07, 0x80, 0x3C, 0x0F, 0x01, 0xF0, 0x3C, 0x07, 0x80, 0x70, 0x3C, 0x01,
  0xE1, 0xE0, 0x07, 0x87, 0x00, 0x0E, 0x3C, 0x00, 0x3D, 0xE0, 0x00, 0xFF,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x03, 0xDE, 0x00, 0x1E,
  0x38, 0x00, 0xF0, 0xF0, 0x03, 0xC1, 0xC0, 0x1E, 0x07, 0x80, 0xF0, 0x1E,
  0x07, 0xC0, 0x38, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x07,
  0x80, 0x70, 0x03, 0xC0, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x01,
  0xE0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xF0,
  0x78, 0x00, 0x78, 0x3C, 0x00, 0x1C, 0x3C, 0x00, 0x0E, 0x1E, 0x00, 0x07,
  0x1E, 0x00, 0x03, 0x8F, 0x00, 0x01, 0xCF, 0x00, 0x00, 0xE7, 0x80, 0x00,
  0x77, 0x80, 0x00, 0x3B, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC1, 0xFF,
  0xF0, 0x7F, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x1F, 0x00,
  0xFE, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xE8, 0x03, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_Italic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 11, 32, 11, 1, -31 },
  { 45, 13, 11, 16, 5, -31 },
  { 63, 24, 31, 25, 1, -31 },
  { 156, 20, 36, 22, 1, -33 },
  { 246, 27, 32, 32, 3, -32 },
  { 354, 24, 32, 26, 1, -32 },
  { 450, 5, 11, 9, 5, -31 },
  { 457, 14, 39, 12, 1, -32 },
  { 526, 14, 39, 12, -3, -32 },
  { 595, 18, 19, 21, 4, -34 },
  { 638, 19, 21, 23, 3, -26 },
  { 688, 8, 11, 10, -2, -5 },
  { 699, 11, 4, 13, 1, -14 },
  { 705, 5, 6, 10, 1, -5 },
  { 709, 21, 31, 15, -2, -31 },
  { 791, 19, 32, 22, 2, -32 },
  { 867, 12, 31, 22, 6, -31 },
  { 914, 21, 32, 22, 0, -32 },
  { 998, 21, 32, 22, 0, -32 },
  { 1082, 21, 32, 22, 0, -32 },
  { 1166, 20, 31, 22, 1, -31 },
  { 1244, 20, 32, 22, 2, -32 },
  { 1324, 20, 31, 22, 3, -31 },
  { 1402, 21, 32, 22, 1, -32 },
  { 1486, 20, 32, 22, 1, -32 },
  { 1566, 8, 25, 10, 1, -24 },
  { 1591, 12, 30, 10, -2, -24 },
  { 1636, 19, 21, 23, 3, -26 },
  { 1686, 18, 13, 23, 3, -22 },
  { 1716, 19, 21, 23, 3, -26 },
  { 1766, 16, 33, 17, 2, -32 },
  { 1832, 30, 36, 33, 2, -32 },
  { 1967, 23, 31, 22, -3, -31 },
  { 2057, 22, 31, 24, 1, -31 },
  { 2143, 22, 32, 23, 3, -32 },
  { 2231, 24, 31, 26, 1, -31 },
  { 2324, 21, 31, 20, 1, -31 },
  { 2406, 21, 31, 19, 1, -31 },
  { 2488, 24, 32, 27, 3, -32 },
  { 2584, 26, 31, 27, 1, -31 },
  { 2685, 17, 31, 13, -1, -31 },
  { 2751, 19, 39, 11, -7, -31 },
  { 2844, 25, 31, 22, 1, -31 },
  { 2941, 15, 31, 19, 1, -31 },
  { 3000, 33, 31, 34, 1, -31 },
  { 3128, 27, 31, 28, 1, -31 },
  { 3233, 24, 32, 28, 3, -32 },
  { 3329, 22, 31, 22, 1, -31 },
  { 3415, 24, 39, 28, 3, -32 },
  { 3532, 22, 31, 23, 1, -31 },
  { 3618, 21, 32, 20, 0, -32 },
  { 3702, 19, 31, 19, 4, -31 },
  { 3776, 24, 31, 26, 3, -31 },
  { 3869, 22, 31, 22, 4, -31 },
  { 3955, 34, 31, 34, 4, -31 },
  { 4087, 26, 31, 21, -2, -31 },
  { 4188, 20, 31, 20, 4, -31 },
  { 4266, 23, 31, 20, -1, -31 },
  { 4356, 17, 39, 13, -1, -32 },
  { 4439, 7, 31, 15, 5, -31 },
  { 4467, 17, 39, 13, -3, -32 },
  { 4550, 20, 19, 22, 1, -32 },
  { 4598, 17, 3, 16, -4, 4 },
  { 4605, 7, 7, 12, 6, -34 },
  { 4612, 20, 24, 23, 2, -24 },
  { 4672, 20, 33, 23, 1, -33 },
  { 4755, 16, 24, 18, 2, -24 },
  { 4803, 22, 33, 23, 2, -33 },
  { 4894, 17, 24, 20, 2, -24 },
  { 4945, 23, 45, 13, -5, -34 },
  { 5075, 22, 35, 23, 0, -24 },
  { 5172, 20, 33, 23, 1, -33 },
  { 5255, 10, 32, 10, 1, -32 },
  { 5295, 17, 43, 10, -6, -32 },
  { 5387, 20, 33, 20, 1, -33 },
  { 5470, 11, 33, 10, 1, -33 },
  { 5516, 31, 24, 34, 1, -24 },
  { 5609, 20, 24, 23, 1, -24 },
  { 5669, 19, 24, 22, 2, -24 },
  { 5726, 22, 34, 23, -1, -24 },
  { 5820, 20, 35, 23, 2, -24 },
  { 5908, 16, 24, 16, 1, -24 },
  { 5956, 17, 24, 17, 0, -24 },
  { 6007, 12, 29, 13, 2, -29 },
  { 6051, 20, 24, 23, 2, -24 },
  { 6111, 19, 24, 18, 2, -24 },
  { 6168, 28, 24, 29, 3, -24 },
  { 6252, 22, 24, 19, -2, -24 },
  { 6318, 25, 35, 18, -4, -24 },
  { 6428, 18, 24, 17, -1, -24 },
  { 6482, 16, 38, 15, 1, -31 },
  { 6558, 3, 44, 21, 10, -33 },
  { 6575, 16, 38, 15, -2, -31 },
  { 6651, 19, 5, 23, 3, -18 },
};

const GFXfont NotoSans_SemiCondensed_Italic44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic44pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC44PT7B_H_
