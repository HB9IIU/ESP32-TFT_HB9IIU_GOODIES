#ifndef _NOTOSANS_SEMICONDENSED_ITALIC30PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C, 0x18,
  0x18, 0x18, 0x38, 0x30, 0x00, 0x00, 0x20, 0x70, 0xF0, 0x70, 0x73, 0xB9,
  0x98, 0xCC, 0x66, 0x76, 0x33, 0x18, 0x01, 0x86, 0x01, 0x8C, 0x03, 0x0C,
  0x03, 0x0C, 0x03, 0x0C, 0x07, 0x18, 0x3F, 0xFF, 0x7F, 0xFF, 0x06, 0x30,
  0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x60, 0x18, 0x62, 0xFF, 0xFC, 0xFF, 0xFC,
  0x38, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x31, 0x80, 0x61, 0x80, 0x61, 0x80,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x0F, 0xF0, 0xFF, 0x8E, 0xC4, 0xE6, 0x07,
  0x30, 0x39, 0x01, 0xD8, 0x07, 0xC0, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x1B,
  0x80, 0xCE, 0x06, 0x60, 0x23, 0x21, 0x39, 0xFF, 0x8F, 0xF8, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x43, 0xE0, 0x30, 0xCC, 0x0C,
  0x38, 0xC3, 0x86, 0x18, 0x60, 0xC7, 0x18, 0x30, 0xC7, 0x06, 0x18, 0xC0,
  0xC3, 0x30, 0x18, 0x6E, 0xFB, 0x19, 0xBF, 0x77, 0x66, 0x77, 0xDD, 0x86,
  0x63, 0x30, 0xC0, 0xC6, 0x38, 0x39, 0x86, 0x06, 0x30, 0xC1, 0x86, 0x18,
  0x70, 0xC6, 0x0C, 0x18, 0xC3, 0x03, 0xF0, 0xE0, 0x3C, 0x00, 0x01, 0xE0,
  0x07, 0xF0, 0x07, 0x38, 0x0E, 0x38, 0x0C, 0x38, 0x0C, 0x38, 0x0C, 0x30,
  0x0C, 0x70, 0x0E, 0xE0, 0x0F, 0xC0, 0x0F, 0x00, 0x1F, 0x00, 0x3B, 0x87,
  0x71, 0xC6, 0xE1, 0xCE, 0xC0, 0xFC, 0xC0, 0xF8, 0xC0, 0x78, 0xC0, 0x70,
  0xE1, 0xF8, 0xFF, 0x9C, 0x7F, 0x1E, 0x77, 0x66, 0x6C, 0xC0, 0x03, 0xC0,
  0xC0, 0x60, 0x38, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x06, 0x01,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xE0,
  0x38, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x00, 0x07, 0x01, 0x80, 0xE0, 0x70,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x1C, 0x0C,
  0x06, 0x07, 0x03, 0x03, 0x81, 0x81, 0xC0, 0xC0, 0xE0, 0xE0, 0x60, 0x60,
  0x00, 0x03, 0x00, 0x30, 0x03, 0x04, 0x20, 0xF6, 0x07, 0xFF, 0x07, 0xF0,
  0xE0, 0x1B, 0x07, 0x30, 0x71, 0x82, 0x1C, 0x01, 0x00, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x03, 0xFF, 0xFF, 0xFF, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x39, 0xDC,
  0xE6, 0x63, 0x00, 0xFF, 0xFC, 0x5F, 0xF0, 0x00, 0x1C, 0x00, 0xE0, 0x03,
  0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x0C,
  0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38,
  0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x3F, 0x83,
  0xFE, 0x1C, 0x71, 0xC1, 0x9C, 0x0C, 0xE0, 0x66, 0x03, 0x70, 0x1B, 0x80,
  0xD8, 0x06, 0xC0, 0x76, 0x03, 0xF0, 0x1F, 0x80, 0xDC, 0x0E, 0xE0, 0x77,
  0x07, 0x18, 0x38, 0xE3, 0x87, 0xF8, 0x1F, 0x80, 0x07, 0x1F, 0x3F, 0x77,
  0xE6, 0x4E, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x38,
  0x38, 0x38, 0x30, 0x70, 0x70, 0x01, 0xE0, 0x1F, 0xE0, 0xFF, 0xC3, 0x07,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x18, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x01, 0xE0, 0x1F, 0xE0,
  0xFF, 0xC3, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x7C, 0x03, 0xF0, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x00, 0x0E,
  0x00, 0x30, 0x00, 0xC0, 0x07, 0x30, 0x38, 0xFF, 0xC1, 0xFE, 0x00, 0x00,
  0x1C, 0x00, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xD8, 0x06, 0x60, 0x3B, 0x81,
  0xCE, 0x06, 0x30, 0x30, 0xC1, 0x83, 0x0E, 0x1C, 0x70, 0x71, 0x81, 0x8F,
  0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0,
  0x0F, 0xFC, 0x3F, 0xE0, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80,
  0x0E, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x88, 0x1C, 0x3F, 0xE0, 0xFF,
  0x00, 0x00, 0x3C, 0x07, 0xF0, 0x3F, 0x81, 0xC0, 0x0E, 0x00, 0x70, 0x01,
  0x80, 0x0E, 0x00, 0x30, 0x81, 0xDF, 0x87, 0xFF, 0x1E, 0x1C, 0x70, 0x31,
  0x80, 0xC6, 0x03, 0x38, 0x0C, 0xE0, 0x71, 0x81, 0xC6, 0x06, 0x1C, 0x38,
  0x3F, 0xC0, 0x7E, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00,
  0x60, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xC0,
  0x0E, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0xC0, 0xF7, 0x87, 0x07, 0x1C, 0x1C,
  0x60, 0x71, 0x81, 0xC7, 0x0E, 0x1C, 0x70, 0x3B, 0x80, 0x7C, 0x07, 0xF0,
  0x38, 0xE1, 0xC1, 0x8E, 0x07, 0x38, 0x1C, 0xC0, 0x73, 0x01, 0xCE, 0x07,
  0x38, 0x38, 0x7F, 0xC0, 0xFE, 0x00, 0x01, 0xC0, 0x3F, 0x87, 0xFC, 0x38,
  0x73, 0x83, 0x98, 0x0D, 0xC0, 0x6E, 0x03, 0x70, 0x3B, 0x81, 0xDC, 0x1E,
  0x71, 0xF3, 0xFB, 0x0F, 0x98, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00,
  0x70, 0x07, 0x0F, 0xF0, 0x7F, 0x00, 0x1C, 0x71, 0xC2, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x21, 0xCF, 0x38, 0x0E, 0x0F, 0x0E, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x38, 0x70, 0x60, 0x60,
  0xC0, 0xC0, 0x00, 0x08, 0x01, 0xC0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xC0, 0x1C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0x80,
  0x0C, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x07, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F,
  0x00, 0x60, 0x00, 0x0E, 0x1F, 0xE7, 0xFD, 0x07, 0x00, 0xC0, 0x30, 0x1C,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0C, 0x07, 0x01, 0x80, 0x00,
  0x00, 0x04, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0x9F,
  0x01, 0xE0, 0x18, 0x1C, 0x00, 0x60, 0xC0, 0x03, 0x0C, 0x04, 0x0C, 0xC1,
  0xFC, 0x66, 0x1C, 0xE3, 0x61, 0x86, 0x1B, 0x1C, 0x30, 0xD8, 0xC1, 0x86,
  0xC6, 0x18, 0x6C, 0x70, 0xC3, 0x63, 0x06, 0x1B, 0x1C, 0x71, 0x98, 0x67,
  0x9C, 0xE3, 0xE7, 0xC3, 0x0E, 0x18, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x0E, 0x00, 0x3F, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0x60, 0x0E, 0xC0, 0x19, 0x80, 0x73, 0x00,
  0xC6, 0x03, 0x8C, 0x07, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0xFF, 0xE1, 0xFF,
  0xC7, 0x03, 0x8E, 0x07, 0x38, 0x06, 0x70, 0x0D, 0xC0, 0x1B, 0x80, 0x3E,
  0x00, 0x60, 0x0F, 0xF8, 0x1F, 0xF8, 0x30, 0x78, 0xE0, 0x71, 0xC0, 0xE3,
  0x81, 0xC6, 0x03, 0x8C, 0x0E, 0x38, 0x78, 0x7F, 0xC0, 0xFF, 0xC1, 0x81,
  0xC3, 0x03, 0x8E, 0x03, 0x1C, 0x06, 0x38, 0x0C, 0x60, 0x38, 0xC0, 0x73,
  0x83, 0xC7, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0xF0, 0x07, 0xFC, 0x1F, 0xF8,
  0x70, 0x21, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC1, 0x03, 0xFE, 0x03, 0xFC, 0x00,
  0x0F, 0xF8, 0x0F, 0xFC, 0x0C, 0x1E, 0x1C, 0x0E, 0x1C, 0x07, 0x1C, 0x07,
  0x18, 0x07, 0x18, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x07, 0x30, 0x07,
  0x30, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x1C, 0x60, 0x38, 0x60, 0x78,
  0xE1, 0xF0, 0xFF, 0xC0, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xFF, 0xC3,
  0xFE, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01,
  0x80, 0x0E, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF0, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0xFE, 0x0F, 0xF8, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60,
  0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x00, 0x78, 0x03, 0xFF,
  0x07, 0xFF, 0x0E, 0x02, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x7E, 0xE0, 0xFE, 0xE0, 0x0C,
  0xC0, 0x0C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x18, 0xF0, 0x18, 0x78, 0x38,
  0x3F, 0xF8, 0x1F, 0xF0, 0x0E, 0x01, 0xC3, 0x80, 0x60, 0xC0, 0x38, 0x30,
  0x0E, 0x1C, 0x03, 0x87, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x1C, 0x38, 0x07,
  0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xC0, 0x38, 0x30, 0x0E, 0x1C, 0x03, 0x87,
  0x00, 0xC1, 0xC0, 0x30, 0x60, 0x1C, 0x18, 0x07, 0x0E, 0x01, 0xC3, 0x80,
  0x60, 0xC0, 0x38, 0x00, 0x0F, 0xF0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00,
  0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x07, 0xF0, 0xFE, 0x00,
  0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80,
  0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80,
  0x1C, 0x00, 0xE0, 0x7E, 0x03, 0xE0, 0x3C, 0x00, 0x0E, 0x07, 0x86, 0x07,
  0x03, 0x07, 0x03, 0x87, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x63, 0x80, 0x33,
  0x80, 0x3B, 0x80, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0x30, 0x03, 0x1C, 0x03,
  0x8E, 0x01, 0xC3, 0x00, 0xE1, 0xC0, 0x60, 0xE0, 0x30, 0x70, 0x38, 0x1C,
  0x1C, 0x0E, 0x0C, 0x07, 0x00, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x07, 0x01,
  0xC0, 0x60, 0x18, 0x0E, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x3C, 0x3C,
  0x01, 0xF0, 0xF0, 0x07, 0xC7, 0xC0, 0x3F, 0x1F, 0x00, 0xD8, 0x6C, 0x07,
  0x61, 0xB8, 0x1B, 0x86, 0xE0, 0xEE, 0x3B, 0x83, 0x38, 0xE6, 0x1C, 0xC3,
  0x18, 0x63, 0x0C, 0x63, 0x9C, 0x31, 0x8C, 0x71, 0xC6, 0x71, 0xC7, 0x19,
  0x86, 0x18, 0x6E, 0x38, 0x61, 0xB0, 0xE3, 0x87, 0xC3, 0x8E, 0x1E, 0x0C,
  0x38, 0x78, 0x30, 0xC0, 0xC1, 0xC0, 0x0E, 0x00, 0xC3, 0xC0, 0x30, 0xF0,
  0x1C, 0x7C, 0x07, 0x1F, 0x81, 0x86, 0xE0, 0x61, 0x98, 0x38, 0x66, 0x0E,
  0x39, 0xC3, 0x8E, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x9C, 0x30, 0x67, 0x1C,
  0x19, 0x87, 0x07, 0x61, 0x81, 0xD8, 0x60, 0x3E, 0x38, 0x0F, 0x8E, 0x03,
  0xC3, 0x80, 0x70, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x03, 0xFC, 0x0F, 0xFE,
  0x1E, 0x0F, 0x1C, 0x07, 0x38, 0x07, 0x70, 0x03, 0x70, 0x03, 0x70, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0E,
  0xC0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x38, 0x78, 0x78, 0x3F, 0xF0,
  0x1F, 0xC0, 0x0F, 0xF0, 0x3F, 0xE0, 0xC1, 0xC7, 0x03, 0x1C, 0x0C, 0x70,
  0x31, 0x80, 0xC6, 0x07, 0x38, 0x1C, 0xE0, 0xE3, 0xFF, 0x0F, 0xF8, 0x3F,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x03, 0xFC, 0x0F, 0xFE, 0x1E, 0x0F, 0x1C,
  0x07, 0x38, 0x07, 0x70, 0x03, 0x70, 0x03, 0x70, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x06, 0xC0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x1C, 0xE0, 0x38, 0x78, 0x78, 0x3F, 0xF0, 0x1F, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x0F, 0xF0, 0x3F,
  0xF0, 0xC1, 0xC7, 0x03, 0x1C, 0x0C, 0x70, 0x31, 0x80, 0xC6, 0x07, 0x38,
  0x1C, 0xE1, 0xE3, 0xFF, 0x0F, 0xF0, 0x31, 0xC1, 0xC7, 0x07, 0x0C, 0x1C,
  0x38, 0x60, 0xE1, 0x81, 0x8E, 0x07, 0x38, 0x1C, 0xC0, 0x70, 0x00, 0xE0,
  0x1F, 0xF0, 0xFF, 0xC7, 0x81, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x30, 0x78, 0xFF, 0xC3, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x81, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x00,
  0x1C, 0x03, 0x8C, 0x01, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0x80,
  0x30, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x06, 0x18, 0x03, 0x0C,
  0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x61, 0x80, 0x70, 0xC0, 0x38,
  0x70, 0x38, 0x3C, 0x3C, 0x0F, 0xFC, 0x03, 0xF8, 0x00, 0xC0, 0x1F, 0x80,
  0x3B, 0x00, 0xE7, 0x01, 0xCE, 0x07, 0x1C, 0x0E, 0x38, 0x38, 0x70, 0x70,
  0xE0, 0xC1, 0xC3, 0x83, 0x86, 0x03, 0x1C, 0x06, 0x30, 0x0C, 0xE0, 0x19,
  0x80, 0x37, 0x00, 0x6C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x00, 0xE0, 0x38, 0x0F, 0xC0, 0xF0, 0x3B, 0x81, 0xE0, 0x77, 0x07, 0xC0,
  0xCE, 0x0D, 0x83, 0x9C, 0x1B, 0x06, 0x38, 0x66, 0x1C, 0x70, 0xCC, 0x38,
  0xE3, 0x98, 0x61, 0xC6, 0x31, 0xC3, 0x9C, 0x63, 0x07, 0x30, 0xCE, 0x0E,
  0x61, 0x98, 0x1D, 0x83, 0x70, 0x3B, 0x06, 0xE0, 0x7E, 0x0D, 0x80, 0xF8,
  0x1F, 0x01, 0xF0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xE0, 0x0E, 0x01,
  0xC0, 0x00, 0x07, 0x01, 0xC0, 0xC0, 0xE0, 0x38, 0x30, 0x0E, 0x1C, 0x01,
  0x8E, 0x00, 0x73, 0x00, 0x1D, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xCC, 0x00, 0x73, 0x00,
  0x38, 0xE0, 0x1C, 0x38, 0x07, 0x06, 0x03, 0x81, 0xC1, 0xC0, 0x70, 0xF0,
  0x1C, 0x00, 0xC0, 0x3F, 0x03, 0xB8, 0x19, 0xC1, 0xC6, 0x1C, 0x30, 0xE1,
  0xCE, 0x0E, 0x60, 0x37, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00,
  0x00, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0x07, 0xE0, 0xF8, 0x38, 0x07,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03,
  0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x01,
  0xC0, 0x38, 0x06, 0x00, 0xFC, 0x1F, 0x00, 0xE7, 0x18, 0xC6, 0x31, 0x8E,
  0x71, 0x8C, 0x63, 0x18, 0xE7, 0x18, 0xC6, 0x31, 0x80, 0x07, 0xE0, 0xFC,
  0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E,
  0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0xFC, 0x1F, 0x80, 0x03, 0x00, 0x18,
  0x01, 0xE0, 0x0F, 0x00, 0xDC, 0x06, 0x60, 0x73, 0x83, 0x0C, 0x38, 0x61,
  0x81, 0x9C, 0x0C, 0xC0, 0x7E, 0x01, 0x80, 0x7F, 0xFF, 0xFE, 0xE3, 0x8C,
  0x71, 0x80, 0x07, 0xCC, 0x3F, 0xB1, 0xC3, 0xCE, 0x0E, 0x30, 0x39, 0xC0,
  0xE7, 0x03, 0x98, 0x0C, 0xE0, 0x33, 0x81, 0xCE, 0x07, 0x38, 0x3C, 0xE0,
  0xE3, 0x87, 0x87, 0xF6, 0x0F, 0x98, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x3E, 0x1B, 0xF9, 0xF1, 0xCF, 0x06,
  0x70, 0x33, 0x81, 0x98, 0x0D, 0xC0, 0x6E, 0x07, 0x60, 0x3B, 0x01, 0xB8,
  0x1D, 0xE0, 0xEF, 0x0E, 0x6F, 0xE3, 0x3E, 0x00, 0x07, 0xF0, 0xFE, 0x1C,
  0x03, 0x80, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x07, 0x08, 0x7F, 0x83, 0xF8, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x03, 0xEE, 0x1F,
  0xFC, 0x38, 0x78, 0xE0, 0xE1, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x18, 0x0C,
  0x70, 0x18, 0xE0, 0x71, 0xC0, 0xE3, 0x83, 0xC7, 0x07, 0x0E, 0x1E, 0x0F,
  0xEC, 0x0F, 0x98, 0x00, 0x07, 0xE0, 0xFF, 0x1C, 0x73, 0x87, 0x70, 0x77,
  0x06, 0x61, 0xEF, 0xF8, 0xFE, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07,
  0x04, 0x7F, 0xC3, 0xF8, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xC8, 0x07, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x70, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0x00, 0x06,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x80, 0x1E, 0x00,
  0x00, 0x03, 0xE6, 0x1F, 0xEC, 0x38, 0x78, 0xE0, 0xE1, 0x81, 0xC7, 0x03,
  0x8E, 0x07, 0x18, 0x0C, 0x70, 0x18, 0xE0, 0x71, 0xC0, 0xE3, 0x83, 0xC7,
  0x07, 0x0E, 0x1E, 0x0F, 0xEC, 0x0F, 0xB8, 0x00, 0x70, 0x00, 0xC0, 0x03,
  0x80, 0x07, 0x0C, 0x1C, 0x1F, 0xF0, 0x1F, 0xC0, 0x00, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x3E, 0x1B, 0xF9,
  0xF1, 0xCF, 0x06, 0x70, 0x73, 0x83, 0x98, 0x1D, 0xC0, 0xCE, 0x06, 0x60,
  0x33, 0x03, 0xB8, 0x1D, 0xC0, 0xCE, 0x06, 0x60, 0x73, 0x03, 0x80, 0x0C,
  0x1C, 0x30, 0x00, 0x00, 0x06, 0x0C, 0x38, 0x70, 0xC1, 0x83, 0x0E, 0x1C,
  0x30, 0x61, 0xC3, 0x87, 0x0C, 0x18, 0x00, 0x00, 0x60, 0x07, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x0F,
  0x80, 0xF0, 0x00, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x07, 0x18, 0x71, 0xC7, 0x0E, 0x70, 0x67, 0x03, 0x30,
  0x1B, 0x01, 0xFC, 0x0F, 0xE0, 0x73, 0x03, 0x1C, 0x38, 0xE1, 0xC3, 0x0E,
  0x1C, 0x60, 0xE3, 0x03, 0x80, 0x0E, 0x1C, 0x30, 0x61, 0xC3, 0x87, 0x0C,
  0x18, 0x70, 0xE1, 0x83, 0x06, 0x1C, 0x38, 0x60, 0xC3, 0x87, 0x0E, 0x18,
  0x30, 0x00, 0x19, 0xF1, 0xF0, 0xDF, 0x9F, 0xCF, 0x8F, 0x8E, 0x78, 0x78,
  0x73, 0x83, 0x83, 0x9C, 0x1C, 0x1C, 0xC0, 0xC0, 0xEE, 0x06, 0x06, 0x70,
  0x70, 0x33, 0x03, 0x83, 0x98, 0x18, 0x1D, 0xC0, 0xC0, 0xCE, 0x06, 0x06,
  0x70, 0x70, 0x33, 0x03, 0x83, 0x98, 0x18, 0x1C, 0x0C, 0xF8, 0x37, 0xF1,
  0xF1, 0xC7, 0x83, 0x1C, 0x1C, 0x70, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x18,
  0xC0, 0xE3, 0x03, 0x9C, 0x0E, 0x70, 0x31, 0xC0, 0xC6, 0x07, 0x38, 0x1C,
  0x07, 0xE0, 0xFF, 0x87, 0x1C, 0x70, 0x77, 0x03, 0xB8, 0x1D, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xB8, 0x1D, 0xC0, 0xEE, 0x0E, 0x38, 0xF1, 0xFF,
  0x07, 0xE0, 0x06, 0x7C, 0x0D, 0xFC, 0x3E, 0x38, 0x78, 0x30, 0xE0, 0x61,
  0xC0, 0xC3, 0x01, 0x8E, 0x03, 0x1C, 0x0E, 0x30, 0x1C, 0x60, 0x31, 0xC0,
  0xE3, 0xC1, 0xC7, 0x87, 0x0D, 0xFC, 0x19, 0xF0, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x07, 0xCC,
  0x7F, 0xB1, 0xC3, 0xCE, 0x0E, 0x30, 0x39, 0xC0, 0xE7, 0x03, 0x98, 0x0C,
  0xE0, 0x33, 0x81, 0xCE, 0x07, 0x38, 0x3C, 0xE0, 0xE3, 0x87, 0x87, 0xF6,
  0x0F, 0xB8, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0x19, 0xE3, 0x78, 0xF8, 0x1E, 0x03, 0x80, 0x70, 0x0C,
  0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06,
  0x00, 0x0F, 0xE3, 0xFC, 0xE0, 0x98, 0x03, 0x00, 0x70, 0x07, 0x00, 0xF8,
  0x07, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x1D, 0x07, 0x3F, 0xE7, 0xF0, 0x04,
  0x06, 0x03, 0x03, 0x87, 0xFF, 0xFC, 0xE0, 0x70, 0x38, 0x18, 0x0C, 0x0E,
  0x07, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x1F, 0x0F, 0x80, 0x18, 0x1C,
  0xE0, 0x73, 0x81, 0x8E, 0x06, 0x30, 0x38, 0xC0, 0xE7, 0x03, 0x9C, 0x0C,
  0x70, 0x31, 0x81, 0xC6, 0x07, 0x38, 0x38, 0xE0, 0xE3, 0x87, 0x87, 0xF6,
  0x1F, 0xB8, 0xC0, 0x7C, 0x06, 0xC0, 0xEC, 0x0C, 0xC1, 0xCC, 0x18, 0xC3,
  0x8E, 0x30, 0xE7, 0x0E, 0x60, 0xEE, 0x0E, 0xC0, 0x7C, 0x07, 0x80, 0x78,
  0x07, 0x00, 0xC0, 0xE0, 0xF8, 0x3C, 0x1B, 0x07, 0x87, 0x61, 0xB0, 0xCC,
  0x36, 0x39, 0x8E, 0xC7, 0x31, 0x98, 0xC6, 0x33, 0x38, 0xCC, 0x66, 0x19,
  0x8D, 0xC3, 0x61, 0xB0, 0x6C, 0x36, 0x0F, 0x87, 0x81, 0xE0, 0xF0, 0x3C,
  0x1E, 0x07, 0x03, 0x80, 0x1C, 0x0E, 0x18, 0x38, 0x38, 0xE0, 0x33, 0x80,
  0x66, 0x00, 0xFC, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3F,
  0x00, 0xE6, 0x03, 0x8E, 0x06, 0x1C, 0x1C, 0x18, 0x70, 0x38, 0x06, 0x03,
  0x83, 0x01, 0x81, 0x81, 0xC0, 0xC0, 0xC0, 0x70, 0xE0, 0x38, 0x60, 0x1C,
  0x70, 0x0E, 0x30, 0x03, 0x38, 0x01, 0x98, 0x00, 0xDC, 0x00, 0x6C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x0F,
  0xF8, 0x7F, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0x80, 0x38, 0x01, 0xFF, 0x1F,
  0xF8, 0x00, 0xF0, 0x1E, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00,
  0x70, 0x06, 0x00, 0x60, 0x0E, 0x07, 0xC0, 0x70, 0x0F, 0x80, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0x01, 0xF0, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0xC0, 0x0E, 0x07, 0xC1, 0xC0, 0x70, 0x0E, 0x01,
  0x80, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x03, 0xC0, 0xF0, 0x18, 0x00,
  0x10, 0x0F, 0xF0, 0x7F, 0xFF, 0x07, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Italic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 8, 21, 8, 0, -21 },
  { 22, 9, 7, 11, 3, -21 },
  { 30, 16, 21, 17, 1, -21 },
  { 72, 13, 25, 15, 1, -23 },
  { 113, 19, 22, 22, 2, -22 },
  { 166, 16, 22, 17, 1, -22 },
  { 210, 4, 7, 6, 3, -21 },
  { 214, 10, 26, 8, 1, -21 },
  { 247, 9, 26, 8, -2, -21 },
  { 277, 12, 13, 14, 3, -23 },
  { 297, 13, 15, 16, 2, -18 },
  { 322, 5, 7, 7, -1, -3 },
  { 327, 7, 2, 9, 1, -9 },
  { 329, 3, 4, 7, 1, -4 },
  { 331, 14, 21, 10, -1, -21 },
  { 368, 13, 22, 15, 1, -22 },
  { 404, 8, 21, 15, 4, -21 },
  { 425, 14, 22, 15, 0, -22 },
  { 464, 14, 22, 15, 0, -22 },
  { 503, 14, 21, 15, 0, -21 },
  { 540, 14, 21, 15, 1, -21 },
  { 577, 14, 22, 15, 1, -22 },
  { 616, 13, 21, 15, 2, -21 },
  { 651, 14, 22, 15, 1, -22 },
  { 690, 13, 22, 15, 1, -22 },
  { 726, 6, 16, 7, 0, -16 },
  { 738, 8, 20, 7, -1, -16 },
  { 758, 13, 14, 16, 2, -18 },
  { 781, 13, 9, 16, 2, -15 },
  { 796, 13, 14, 16, 2, -18 },
  { 819, 10, 22, 11, 2, -22 },
  { 847, 21, 24, 23, 1, -21 },
  { 910, 15, 21, 15, -2, -21 },
  { 950, 15, 21, 16, 1, -21 },
  { 990, 15, 22, 15, 2, -22 },
  { 1032, 16, 21, 18, 1, -21 },
  { 1074, 14, 21, 14, 1, -21 },
  { 1111, 14, 21, 13, 1, -21 },
  { 1148, 16, 22, 18, 2, -22 },
  { 1192, 18, 21, 18, 1, -21 },
  { 1240, 12, 21, 9, -1, -21 },
  { 1272, 13, 27, 7, -5, -21 },
  { 1316, 17, 21, 15, 1, -21 },
  { 1361, 10, 21, 13, 1, -21 },
  { 1388, 22, 21, 23, 1, -21 },
  { 1446, 18, 21, 19, 1, -21 },
  { 1494, 16, 22, 19, 2, -22 },
  { 1538, 14, 21, 15, 1, -21 },
  { 1575, 16, 27, 19, 2, -22 },
  { 1629, 14, 21, 15, 1, -21 },
  { 1666, 14, 22, 14, 0, -22 },
  { 1705, 13, 21, 13, 3, -21 },
  { 1740, 17, 21, 18, 2, -21 },
  { 1785, 15, 21, 15, 3, -21 },
  { 1825, 23, 21, 23, 3, -21 },
  { 1886, 18, 21, 14, -2, -21 },
  { 1934, 13, 21, 14, 3, -21 },
  { 1969, 16, 21, 14, -1, -21 },
  { 2011, 11, 26, 9, 0, -21 },
  { 2047, 5, 21, 11, 3, -21 },
  { 2061, 11, 26, 9, -2, -21 },
  { 2097, 13, 13, 15, 1, -22 },
  { 2119, 12, 2, 11, -3, 3 },
  { 2122, 5, 5, 8, 4, -23 },
  { 2126, 14, 16, 15, 1, -16 },
  { 2154, 13, 23, 16, 1, -23 },
  { 2192, 12, 16, 12, 1, -16 },
  { 2216, 15, 23, 16, 1, -23 },
  { 2260, 12, 16, 14, 1, -16 },
  { 2284, 15, 30, 9, -3, -23 },
  { 2341, 15, 23, 16, 0, -16 },
  { 2385, 13, 23, 16, 1, -23 },
  { 2423, 7, 22, 7, 1, -22 },
  { 2443, 12, 29, 7, -4, -22 },
  { 2487, 13, 23, 13, 1, -23 },
  { 2525, 7, 23, 7, 1, -23 },
  { 2546, 21, 16, 23, 1, -16 },
  { 2588, 14, 16, 16, 0, -16 },
  { 2616, 13, 16, 15, 1, -16 },
  { 2642, 15, 23, 16, -1, -16 },
  { 2686, 14, 23, 16, 1, -16 },
  { 2727, 11, 16, 11, 1, -16 },
  { 2749, 11, 16, 12, 0, -16 },
  { 2771, 9, 20, 9, 1, -20 },
  { 2794, 14, 16, 16, 1, -16 },
  { 2822, 12, 16, 13, 2, -16 },
  { 2846, 19, 16, 20, 2, -16 },
  { 2884, 15, 16, 13, -1, -16 },
  { 2914, 17, 23, 13, -3, -16 },
  { 2963, 13, 16, 12, -1, -16 },
  { 2989, 12, 26, 10, 0, -21 },
  { 3028, 2, 30, 14, 7, -23 },
  { 3036, 11, 26, 10, -1, -21 },
  { 3072, 13, 4, 16, 2, -13 },
};

const GFXfont NotoSans_SemiCondensed_Italic30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic30pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC30PT7B_H_
