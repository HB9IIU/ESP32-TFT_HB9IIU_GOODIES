#ifndef _NOTOSANS_SEMICONDENSED_ITALIC66PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC66PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF0, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x3F, 0x87, 0xE7, 0xE0, 0xFC,
  0xFC, 0x1F, 0x9F, 0x83, 0xE3, 0xE0, 0x7C, 0x7C, 0x1F, 0x9F, 0x83, 0xF3,
  0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3C, 0x3C, 0x07, 0x87,
  0x81, 0xF1, 0xF0, 0x3E, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x00,
  0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x3E,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x3C, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0x7C, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x1E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xC0, 0x3E, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x07,
  0xC0, 0x3C, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x1E, 0x00,
  0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0x80,
  0x7C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x80, 0x78,
  0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x3E,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x07, 0x80, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x3C, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0x7C, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0xE3, 0xF0, 0x0F, 0xE3, 0xC0,
  0xC0, 0x1F, 0x87, 0x80, 0x80, 0x3E, 0x0F, 0x00, 0x00, 0xFC, 0x1C, 0x00,
  0x01, 0xF0, 0x78, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0xC1, 0xE0, 0x00,
  0x0F, 0x83, 0xC0, 0x00, 0x1F, 0x87, 0x00, 0x00, 0x3F, 0x1E, 0x00, 0x00,
  0x3F, 0xBC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x77, 0xF0, 0x00, 0x01,
  0xE7, 0xF0, 0x00, 0x03, 0xC7, 0xE0, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x0E,
  0x0F, 0x80, 0x00, 0x3C, 0x1F, 0x80, 0x00, 0x78, 0x3E, 0x00, 0x00, 0xF0,
  0x7C, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x03, 0x83, 0xF0, 0x40, 0x0F, 0x07,
  0xE0, 0x60, 0x1E, 0x3F, 0x80, 0xFC, 0x3D, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0x80, 0x7C, 0x1F,
  0x00, 0x0F, 0x80, 0x3E, 0x07, 0x80, 0x0F, 0x80, 0x3E, 0x03, 0xC0, 0x07,
  0xC0, 0x1F, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x78, 0x03, 0xE0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x03, 0xC0, 0x1E,
  0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x81, 0xF0,
  0x00, 0xF8, 0x07, 0xC1, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0xF8, 0x00, 0x3C,
  0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x00, 0xF8,
  0x7C, 0x1F, 0x0F, 0x80, 0x78, 0x7C, 0x3F, 0xE7, 0xC0, 0x7C, 0x7C, 0x3F,
  0xF9, 0xE0, 0x3C, 0x3E, 0x3F, 0xFC, 0xF0, 0x3E, 0x3E, 0x3F, 0x3F, 0x7C,
  0x3E, 0x3E, 0x3E, 0x0F, 0xBF, 0x7F, 0x1F, 0x1F, 0x03, 0xCF, 0xFF, 0x1F,
  0x1F, 0x01, 0xE7, 0xFF, 0x1F, 0x0F, 0x80, 0xF1, 0xFF, 0x0F, 0x87, 0x80,
  0x78, 0x3E, 0x0F, 0x87, 0xC0, 0x3C, 0x00, 0x0F, 0x83, 0xC0, 0x1E, 0x00,
  0x07, 0xC1, 0xE0, 0x0F, 0x00, 0x07, 0xC1, 0xF0, 0x0F, 0x80, 0x03, 0xC0,
  0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x3C, 0x01,
  0xE0, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0x80, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x00, 0xF8, 0x01,
  0xE0, 0x3E, 0x00, 0xF8, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x00, 0x78, 0x1F,
  0x00, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0x80, 0x3C,
  0x00, 0x07, 0xFF, 0x80, 0x3E, 0x00, 0x03, 0xFF, 0x80, 0x3E, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x3E, 0x0F, 0xE0,
  0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFB, 0xF8, 0x03, 0xF0, 0xFE, 0x1F,
  0x80, 0x3E, 0x0F, 0xC0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC0, 0x7C, 0x3F,
  0x00, 0x7E, 0x0F, 0xC3, 0xE0, 0x07, 0xE0, 0xF8, 0x7E, 0x00, 0x3F, 0x1F,
  0x87, 0xC0, 0x03, 0xF9, 0xF0, 0x7C, 0x00, 0x1F, 0xBF, 0x0F, 0xC0, 0x01,
  0xFF, 0xE0, 0xFC, 0x00, 0x0F, 0xFC, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0xFC,
  0x00, 0x07, 0xF8, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x0F, 0xF8,
  0x07, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0x00, 0x7F, 0xFC, 0x07, 0xFC, 0x1F,
  0xEF, 0xC0, 0x3F, 0xFF, 0xFC, 0x7E, 0x01, 0xFF, 0xFF, 0x87, 0xF0, 0x0F,
  0xFF, 0xE0, 0x3F, 0x00, 0x7F, 0xF8, 0x03, 0xF8, 0x00, 0x74, 0x00, 0x00,
  0x00, 0x3F, 0x9F, 0x8F, 0xC7, 0xE3, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x07, 0x83, 0xC3, 0xE1, 0xE0, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x06, 0x00, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0xFE,
  0x0F, 0x00, 0x3F, 0xE3, 0x80, 0x0F, 0xFE, 0xE0, 0x04, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFC,
  0x01, 0x01, 0xFF, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x7C, 0x78, 0x00, 0x3F,
  0x1F, 0x00, 0x1F, 0x83, 0xC0, 0x1F, 0xC0, 0xF8, 0x03, 0xE0, 0x3E, 0x00,
  0x78, 0x0F, 0xC0, 0x0C, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0,
  0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E,
  0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFE, 0x1C, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C,
  0x38, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x7F,
  0x87, 0xF0, 0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x03, 0xF8, 0x03,
  0xF0, 0x1F, 0x80, 0x0F, 0x81, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0,
  0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x7E, 0x7E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0xF9,
  0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF3, 0xE0,
  0x00, 0x1F, 0x9F, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x7E, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x1F, 0x80, 0x01, 0xF8,
  0xFC, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xE1, 0xF0,
  0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x7C, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x1F, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0x7E, 0x7F, 0x9F, 0x3F, 0xC7,
  0xCF, 0xC3, 0xF1, 0xE0, 0xFC, 0x70, 0x3E, 0x08, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0x0F,
  0xF0, 0x00, 0xF8, 0x01, 0xFC, 0x00, 0x38, 0x00, 0x7E, 0x00, 0x10, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xF8, 0x1F, 0xF0, 0x0F, 0x80, 0x1F, 0xC0, 0x18, 0x00, 0x3F,
  0x00, 0x40, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0x82, 0x00, 0x00, 0xFE, 0x0E, 0x00, 0x0F, 0xF0, 0x3F,
  0x80, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00,
  0x3E, 0xFC, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x01,
  0xF8, 0xF8, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07,
  0xE1, 0xF0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x1F,
  0x03, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0xFC,
  0x03, 0xE0, 0x00, 0xF8, 0x07, 0xE0, 0x01, 0xF0, 0x07, 0xE0, 0x03, 0xF0,
  0x07, 0xC0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xBF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x80, 0x00, 0x3F, 0x81, 0xC0, 0x01, 0xFE,
  0x03, 0xF8, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x60, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x1E, 0x00, 0x07,
  0xC3, 0xFF, 0x00, 0x3F, 0x3F, 0xFE, 0x00, 0xFD, 0xFF, 0xFC, 0x03, 0xEF,
  0xFF, 0xF8, 0x0F, 0xFC, 0x0F, 0xE0, 0x7F, 0xE0, 0x1F, 0xC1, 0xFE, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x01, 0xF0, 0x7E, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF0,
  0xFC, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3E, 0x0F, 0xC0,
  0x01, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFC, 0x0F, 0xF0,
  0x0F, 0xC0, 0x1F, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7C, 0x07,
  0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x1F, 0x03, 0xF0,
  0x00, 0x7C, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0xC0, 0x7C, 0x00,
  0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0,
  0x3F, 0x80, 0xFE, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x03,
  0xF0, 0x7C, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E,
  0x3E, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0x07, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x07, 0xF0,
  0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x01,
  0xF0, 0xFC, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x7E, 0x00, 0x03, 0xE3,
  0xF0, 0x00, 0x1F, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x8F, 0xC0, 0x01,
  0xFC, 0x7E, 0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xFE, 0x0F, 0xC0, 0x1F, 0xF0,
  0x7F, 0x83, 0xFF, 0x81, 0xFF, 0xFE, 0xFC, 0x0F, 0xFF, 0xE7, 0xC0, 0x3F,
  0xFE, 0x3E, 0x00, 0x7F, 0xC3, 0xF0, 0x00, 0x30, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x01, 0xE0, 0x7F, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x83,
  0xFC, 0x0F, 0xC0, 0x7E, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x3F, 0x01, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF0, 0x3F, 0x81,
  0xF8, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0,
  0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC3, 0xF0, 0x7F, 0x87, 0x00,
  0x3F, 0x88, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x7E,
  0x00, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xFF, 0x80, 0x7C, 0x1E, 0x00, 0x3F,
  0xFF, 0x01, 0xE1, 0xF0, 0x07, 0xFF, 0xF8, 0x0F, 0x1F, 0x00, 0x7F, 0xFF,
  0xC0, 0x78, 0xF8, 0x07, 0xE0, 0x3C, 0x03, 0xC7, 0x80, 0x7E, 0x03, 0xE0,
  0x1E, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF3, 0xE0, 0x3E, 0x00, 0xF8, 0x07,
  0xBE, 0x03, 0xE0, 0x07, 0x80, 0x3D, 0xF0, 0x1F, 0x00, 0x7C, 0x03, 0xEF,
  0x80, 0xF0, 0x03, 0xE0, 0x1F, 0x78, 0x0F, 0x80, 0x1E, 0x00, 0xFF, 0xC0,
  0x7C, 0x01, 0xF0, 0x07, 0xBE, 0x03, 0xC0, 0x0F, 0x80, 0x3D, 0xF0, 0x3E,
  0x00, 0x7C, 0x03, 0xEF, 0x81, 0xF0, 0x03, 0xC0, 0x1E, 0x7C, 0x0F, 0x80,
  0x3E, 0x00, 0xF3, 0xC0, 0x7C, 0x01, 0xF0, 0x0F, 0x9E, 0x03, 0xE0, 0x1F,
  0x80, 0x78, 0xF0, 0x1F, 0x00, 0xFC, 0x07, 0xC7, 0x80, 0xF8, 0x0F, 0xE0,
  0x7C, 0x3C, 0x07, 0xC0, 0xFF, 0x07, 0xE1, 0xF0, 0x1F, 0x8F, 0x7C, 0x7E,
  0x0F, 0x80, 0xFF, 0xF1, 0xFF, 0xE0, 0x7C, 0x03, 0xFF, 0x0F, 0xFE, 0x03,
  0xE0, 0x0F, 0xF0, 0x3F, 0xE0, 0x1F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00, 0x3E, 0xF0, 0x00,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF8,
  0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x03, 0xE3,
  0xF0, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x0F,
  0x9F, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x07, 0xF8, 0x03, 0xF0,
  0x00, 0xFE, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7C,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0xF8, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x07, 0xF8, 0x03, 0xF0, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00,
  0xFC, 0x0F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x3F, 0x83, 0xF0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x0F, 0xC0, 0xF8, 0x00,
  0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0x00,
  0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFE, 0x0F,
  0xC0, 0x07, 0xFC, 0x00, 0x70, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x30, 0x00, 0x7F, 0xF0, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x01, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x07,
  0xE0, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0x00, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00,
  0x7E, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F,
  0x80, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x00,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xFC,
  0x1F, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x7C, 0x00,
  0x07, 0xF0, 0x0F, 0x80, 0x01, 0xFE, 0x03, 0xF0, 0x00, 0xFF, 0x80, 0x7E,
  0x00, 0x3F, 0xE0, 0x0F, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0x81, 0xFE, 0x00, 0x7F, 0xC0, 0x01, 0xE0, 0x0F, 0xF0, 0x00, 0x04,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xF8,
  0xFC, 0x00, 0x1F, 0xFF, 0x8F, 0xC0, 0x01, 0xFF, 0xF8, 0xFC, 0x00, 0x1F,
  0xFF, 0x8F, 0xC0, 0x01, 0xFF, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7C, 0x0F, 0xE0,
  0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x7F, 0x80, 0x00, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0x80, 0x1F, 0xE0, 0x01,
  0xF8, 0x01, 0xFF, 0xE3, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x3D, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xC0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x1F,
  0xC0, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x1F,
  0x81, 0xFC, 0x00, 0x00, 0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xC0, 0xFC, 0x00,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x1F, 0x8F,
  0xE0, 0x00, 0x00, 0xF8, 0xFE, 0x00, 0x00, 0x07, 0xCF, 0xE0, 0x00, 0x00,
  0x7E, 0xFE, 0x00, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xDF, 0x80, 0x00, 0x03, 0xFC, 0x7E, 0x00, 0x00, 0x1F, 0xC3, 0xF0, 0x00,
  0x00, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xBE, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xDF, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x3E,
  0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0x03, 0xF7, 0xE0, 0x0F,
  0x9F, 0x00, 0x01, 0xF3, 0xF0, 0x07, 0xCF, 0x80, 0x01, 0xF9, 0xF0, 0x07,
  0xE7, 0xC0, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x00, 0xFC, 0xFC, 0x01,
  0xF1, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0xF8, 0xF8, 0x00, 0x7E, 0x3F, 0x00,
  0xFC, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0x3F, 0x0F, 0x80,
  0x3E, 0x0F, 0x80, 0x1F, 0x0F, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x87, 0xE0,
  0x0F, 0x83, 0xE0, 0x0F, 0x83, 0xF0, 0x0F, 0xC1, 0xF0, 0x0F, 0xC1, 0xF0,
  0x07, 0xE0, 0xF8, 0x07, 0xC1, 0xF8, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xFC,
  0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7E, 0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x3E,
  0x00, 0xFC, 0x0F, 0x81, 0xF0, 0x1F, 0x00, 0x7E, 0x07, 0xC1, 0xF0, 0x1F,
  0x80, 0x3E, 0x01, 0xE0, 0xF8, 0x0F, 0xC0, 0x1F, 0x00, 0xF8, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7C, 0x7C, 0x03, 0xE0, 0x0F, 0xC0, 0x3E, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x3E, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xBE, 0x00,
  0xFC, 0x01, 0xF0, 0x07, 0xDF, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xFF, 0x00,
  0x3E, 0x00, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xFF, 0x80,
  0x1F, 0x80, 0x3E, 0x00, 0x7F, 0xC0, 0x0F, 0xC0, 0x1F, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xE0, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00,
  0x0F, 0x80, 0x1F, 0xE0, 0x00, 0x07, 0xC0, 0x0F, 0xF0, 0x00, 0x03, 0xE0,
  0x07, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x00, 0x01, 0xF8, 0x03, 0xFF,
  0x00, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x00,
  0x7E, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0x00,
  0x3E, 0x7C, 0x00, 0x0F, 0x80, 0x1F, 0x3F, 0x00, 0x07, 0xC0, 0x0F, 0x8F,
  0x80, 0x07, 0xE0, 0x07, 0xC7, 0xC0, 0x03, 0xF0, 0x07, 0xE3, 0xF0, 0x01,
  0xF0, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x00,
  0xF8, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x07,
  0xC0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x01, 0xF8, 0x0F,
  0xC0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x0F, 0xC0, 0x3E, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0x81, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x3E,
  0x00, 0x7E, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x1F,
  0x00, 0x0F, 0xCF, 0xC0, 0x1F, 0x80, 0x07, 0xE7, 0xE0, 0x0F, 0xC0, 0x01,
  0xF3, 0xE0, 0x07, 0xC0, 0x00, 0xF9, 0xF0, 0x03, 0xE0, 0x00, 0x7E, 0xF8,
  0x01, 0xF0, 0x00, 0x1F, 0x7C, 0x01, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0x00, 0x3E, 0x00, 0x00,
  0xFF, 0x80, 0x1F, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0x80, 0x00, 0x3F, 0xC0,
  0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x07, 0xC0, 0x00, 0x07, 0xF0, 0x03, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xC0,
  0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00,
  0x7E, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFE, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFC, 0x03, 0xFE, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xF8, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x3F, 0x01, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x00,
  0x7E, 0x03, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xFC, 0x07, 0xE0, 0x03,
  0xF8, 0x07, 0xE0, 0x0F, 0xF0, 0x07, 0xC0, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x00, 0x7E, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x01, 0xF3, 0xF0, 0x00,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x03, 0xF8, 0xFC,
  0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFE,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0xFC, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01,
  0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0xFE, 0x03,
  0xE0, 0x01, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0xF8, 0x07,
  0xE0, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F,
  0x80, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x3E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x7F, 0xE1, 0xFC, 0x00, 0xFF, 0x00, 0x1C, 0x00, 0xFE, 0x00, 0x04, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0xC0,
  0x00, 0x7F, 0x80, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0xCF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x7C,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x7C, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03,
  0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x01,
  0xF8, 0x0F, 0x80, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0xFC, 0x03, 0xE0, 0x00,
  0x7E, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0xF8,
  0x03, 0xF0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x1F,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x03,
  0xE0, 0x7E, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7F, 0x00, 0x01,
  0xFB, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x3E, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xFF, 0x00,
  0x07, 0xE3, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7C, 0x3E, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xDF,
  0x00, 0x0F, 0xC3, 0xE0, 0x01, 0xF7, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0x7D,
  0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x0F,
  0x9F, 0x00, 0x3F, 0x03, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x80, 0xF8, 0x01,
  0xF1, 0xF0, 0x07, 0xE0, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x0F, 0x80,
  0x3E, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x3F, 0x00, 0xF8,
  0x07, 0xC1, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x7C, 0x07, 0xE0, 0x0F,
  0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0xFC, 0x00,
  0xF8, 0x1F, 0x01, 0xF0, 0x3F, 0x00, 0x3E, 0x07, 0xC0, 0x7C, 0x1F, 0x80,
  0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xE0, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0,
  0x00, 0xF8, 0x7E, 0x01, 0xF0, 0xFC, 0x00, 0x3E, 0x1F, 0x00, 0x7C, 0x3E,
  0x00, 0x0F, 0x87, 0xC0, 0x1F, 0x1F, 0x80, 0x03, 0xE3, 0xE0, 0x07, 0xC7,
  0xC0, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x7C,
  0xFC, 0x00, 0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x07,
  0xCF, 0x80, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00,
  0x7D, 0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x3F, 0x00,
  0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x00,
  0xF8, 0xFC, 0x00, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x00, 0xFD, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x1F, 0x00, 0x01, 0xFC, 0x7C, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x07,
  0xE0, 0x3E, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x00, 0x7C, 0x07, 0xE0, 0x01,
  0xF0, 0x1F, 0x80, 0x07, 0xC0, 0xFC, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0xF8, 0xFC, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x0F, 0x9F,
  0x80, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0x0F, 0xBE, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07,
  0x87, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF0, 0x3E, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF0,
  0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0x1F, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF8,
  0x7E, 0x0F, 0xC1, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0xE1, 0xF0, 0x07, 0xFF, 0xC7, 0xC0, 0x3F, 0xFF, 0x1F,
  0x01, 0xFF, 0xFE, 0xF8, 0x0F, 0xE0, 0x7B, 0xE0, 0x7F, 0x00, 0xFF, 0x83,
  0xF8, 0x01, 0xFE, 0x0F, 0xC0, 0x07, 0xF8, 0x7E, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x0F, 0x87, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x01, 0xF0,
  0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xFC, 0x3E,
  0x00, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0xFE, 0x0F, 0x80,
  0x03, 0xF8, 0x3E, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0xFF, 0x03, 0xF0, 0x07,
  0xFC, 0x0F, 0xE0, 0x3D, 0xF0, 0x1F, 0xC3, 0xF7, 0xC0, 0x7F, 0xFF, 0x9E,
  0x00, 0xFF, 0xFC, 0x78, 0x01, 0xFF, 0xC3, 0xE0, 0x03, 0xFE, 0x0F, 0x80,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x07, 0xE0, 0x00, 0xFC, 0x3F, 0xF0, 0x01, 0xF8, 0xFF, 0xF0, 0x03, 0xE7,
  0xFF, 0xF0, 0x07, 0xDF, 0xFF, 0xE0, 0x0F, 0xBC, 0x0F, 0xE0, 0x3F, 0xF0,
  0x0F, 0xC0, 0x7F, 0xC0, 0x1F, 0x80, 0xFF, 0x00, 0x1F, 0x81, 0xFC, 0x00,
  0x3F, 0x03, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0xC0, 0x01,
  0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F,
  0x83, 0xF0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0xFC,
  0x1F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F,
  0xC0, 0x01, 0xF8, 0x3F, 0x80, 0x07, 0xE0, 0x7F, 0x00, 0x0F, 0xC0, 0xFE,
  0x00, 0x3F, 0x03, 0xFC, 0x00, 0xFE, 0x07, 0xFC, 0x03, 0xF8, 0x0F, 0xBE,
  0x1F, 0xE0, 0x1F, 0x7F, 0xFF, 0xC0, 0x3C, 0x7F, 0xFF, 0x00, 0xF8, 0x7F,
  0xF8, 0x01, 0xF0, 0x7F, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x1F, 0xC0, 0x30, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x80, 0xFF,
  0x03, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x81, 0xF0, 0x00, 0x7F, 0xF1, 0xF8,
  0x00, 0x7F, 0xFC, 0xFC, 0x00, 0xFF, 0xFF, 0x7E, 0x00, 0xFF, 0xFF, 0xBE,
  0x00, 0x7F, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x3F,
  0xC0, 0x3F, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x03,
  0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x7C, 0x07, 0xE0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xC0, 0x7E, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0x80,
  0x01, 0xF8, 0x07, 0xC0, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0xFE, 0x01, 0xF0,
  0x00, 0x7F, 0x00, 0xF8, 0x00, 0x7F, 0x80, 0x7C, 0x00, 0x3F, 0x80, 0x3F,
  0x00, 0x3F, 0xC0, 0x1F, 0x80, 0x3F, 0xE0, 0x0F, 0xE0, 0x3D, 0xF0, 0x03,
  0xF8, 0x7C, 0xF8, 0x01, 0xFF, 0xFC, 0xF8, 0x00, 0x7F, 0xFC, 0x7C, 0x00,
  0x1F, 0xFC, 0x3E, 0x00, 0x07, 0xFC, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x1F, 0xC0, 0xFC, 0x1F, 0x80, 0x3E, 0x1F,
  0xC0, 0x1F, 0x0F, 0xC0, 0x0F, 0x8F, 0xC0, 0x07, 0xCF, 0xC0, 0x03, 0xE7,
  0xE0, 0x03, 0xF3, 0xE0, 0x03, 0xF3, 0xF0, 0x03, 0xF9, 0xF8, 0x03, 0xF8,
  0xF8, 0x1F, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x60, 0xFF, 0x01, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x08, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x81, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x08, 0x3F, 0x80, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x1F, 0x00, 0x1F, 0xFF, 0x1F, 0x00, 0x7F,
  0xFF, 0x9F, 0x00, 0xFF, 0xFF, 0xBE, 0x00, 0xFE, 0x07, 0xFE, 0x01, 0xFC,
  0x03, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x03, 0xF0, 0x01, 0xFE, 0x07, 0xE0,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0xFC, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80,
  0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x01, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x03, 0xF0, 0x3E, 0x00, 0x07, 0xF0, 0x3E, 0x00, 0x07, 0xE0, 0x3E, 0x00,
  0x0F, 0xE0, 0x3E, 0x00, 0x0F, 0xE0, 0x3E, 0x00, 0x1F, 0xE0, 0x3E, 0x00,
  0x1F, 0xC0, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0x00, 0x7F, 0xC0, 0x3F, 0x80,
  0xF7, 0xC0, 0x1F, 0xC3, 0xEF, 0xC0, 0x1F, 0xFF, 0xEF, 0x80, 0x0F, 0xFF,
  0xCF, 0x80, 0x0F, 0xFF, 0x0F, 0x80, 0x03, 0xFE, 0x1F, 0x80, 0x00, 0x70,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x80, 0x00, 0xFC, 0x00, 0xC0, 0x01,
  0xF8, 0x00, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x7E,
  0x1F, 0xF8, 0x01, 0xF9, 0xFF, 0xF0, 0x07, 0xCF, 0xFF, 0xE0, 0x1F, 0x7F,
  0xFF, 0xC0, 0x7D, 0xE0, 0x7F, 0x03, 0xFF, 0x00, 0xFC, 0x0F, 0xF8, 0x03,
  0xF0, 0x3F, 0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC,
  0x1F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3E, 0x07,
  0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC1, 0xF8, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xF0, 0x7E,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00,
  0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x0C,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x10, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x80, 0xFC,
  0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0,
  0x1F, 0x80, 0x0F, 0x80, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0xFC, 0x1F, 0xC0, 0x01, 0xF0, 0x7F, 0x00, 0x03, 0xE0, 0xFC,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3E, 0x3F, 0x00,
  0x00, 0x7C, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xEF, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xDF, 0x80, 0x00, 0xFE, 0x1F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x03,
  0xE0, 0x7E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0xF8, 0x03, 0xF0, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x00,
  0x1F, 0x80, 0x3E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x03, 0xE0, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xC7, 0xFF, 0xC1, 0xFF, 0xF0,
  0x0F, 0x9F, 0xFF, 0x87, 0xFF, 0xE0, 0x1F, 0x7F, 0xFF, 0x9F, 0xFF, 0xE0,
  0x3F, 0xF0, 0x7F, 0x7C, 0x1F, 0xC0, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0x81,
  0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3E, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7C, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x3F,
  0x80, 0x0F, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x83, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0xFC, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x7E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x83, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x00, 0xF0, 0x1F, 0xC0, 0x07, 0xC1, 0xFF, 0xC0, 0x1F, 0x1F,
  0xFF, 0x80, 0x7C, 0xFF, 0xFE, 0x01, 0xF7, 0xFF, 0xFC, 0x0F, 0xFF, 0x07,
  0xF0, 0x3F, 0xF0, 0x0F, 0xC0, 0xFF, 0x80, 0x3F, 0x03, 0xFC, 0x00, 0xFC,
  0x0F, 0xE0, 0x03, 0xF0, 0x7F, 0x80, 0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x1F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3E,
  0x00, 0x07, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80,
  0x03, 0xF0, 0x7E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01,
  0xF8, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0x81, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xC0, 0x03,
  0xE1, 0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x3E,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xF8,
  0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xE0,
  0x07, 0xE0, 0x7E, 0x01, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x83, 0xFF, 0x00,
  0x03, 0xE1, 0xFF, 0xE0, 0x00, 0xF9, 0xFF, 0xFC, 0x00, 0x3E, 0x7F, 0xFF,
  0x00, 0x0F, 0xBC, 0x0F, 0xE0, 0x07, 0xFE, 0x01, 0xF8, 0x01, 0xFF, 0x00,
  0x7E, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x1F, 0xC0, 0x03, 0xF0, 0x07, 0xF0,
  0x00, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x3E, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x01, 0xF8,
  0x07, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x7E, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0,
  0x03, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF,
  0x80, 0x7F, 0x00, 0x3E, 0xF8, 0x7F, 0x80, 0x0F, 0xBF, 0xFF, 0xE0, 0x03,
  0xE7, 0xFF, 0xF0, 0x00, 0xF8, 0xFF, 0xF0, 0x00, 0x7E, 0x1F, 0xF8, 0x00,
  0x1F, 0x80, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0xE1, 0xF0, 0x07, 0xFF, 0xC7, 0xC0, 0x3F, 0xFF, 0x9F, 0x01,
  0xFF, 0xFE, 0xF8, 0x0F, 0xE0, 0x7F, 0xE0, 0x7F, 0x00, 0xFF, 0x83, 0xF8,
  0x01, 0xFE, 0x0F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F,
  0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xFC, 0x3E, 0x00,
  0x07, 0xE0, 0xF8, 0x00, 0x3F, 0x83, 0xE0, 0x00, 0xFE, 0x0F, 0x80, 0x07,
  0xF8, 0x3E, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0xFF, 0x03, 0xF0, 0x07, 0xFC,
  0x0F, 0xE0, 0x3D, 0xF0, 0x1F, 0xC3, 0xEF, 0xC0, 0x7F, 0xFF, 0x3E, 0x00,
  0xFF, 0xFC, 0xF8, 0x03, 0xFF, 0xC7, 0xE0, 0x03, 0xFE, 0x1F, 0x80, 0x01,
  0xC0, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0xF8, 0x7F, 0x80, 0x7C, 0x7F, 0xC0, 0x3E, 0x7F, 0xE0,
  0x1F, 0x7F, 0xF0, 0x0F, 0xBF, 0x10, 0x0F, 0xBC, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0x80, 0x78, 0x1F,
  0x80, 0x08, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x84, 0x00,
  0x0F, 0xC3, 0x00, 0x0F, 0xE1, 0xF0, 0x1F, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x82, 0x07, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x01, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x1F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E,
  0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0xFC, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0,
  0x7E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F,
  0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x83, 0xF0, 0x01, 0xFC, 0x0F, 0xC0,
  0x07, 0xF0, 0x3F, 0x00, 0x3F, 0xC0, 0xFC, 0x01, 0xFF, 0x03, 0xF0, 0x0F,
  0xFC, 0x0F, 0xE0, 0xFB, 0xE0, 0x1F, 0xFF, 0xCF, 0x80, 0x7F, 0xFE, 0x3E,
  0x00, 0xFF, 0xF0, 0xF8, 0x01, 0xFF, 0x83, 0xC0, 0x00, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x7E, 0x7C, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0xFC, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x1F,
  0x07, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xE0, 0x7E,
  0x00, 0x7C, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x80, 0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x3E, 0x03, 0xE0, 0x03,
  0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x0F,
  0x80, 0x03, 0xE1, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE3, 0xF0, 0x00,
  0x3E, 0x3E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xEF, 0x80, 0x07, 0xF0, 0x01, 0xFB, 0xE0, 0x03, 0xFC, 0x00, 0x7C,
  0xF8, 0x00, 0xFF, 0x00, 0x3F, 0x3E, 0x00, 0x7F, 0xC0, 0x0F, 0xCF, 0x80,
  0x1E, 0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0xBC, 0x01, 0xF8, 0xF8, 0x03, 0xCF,
  0x00, 0x7C, 0x3E, 0x01, 0xF3, 0xC0, 0x3F, 0x0F, 0x80, 0x7C, 0xF0, 0x0F,
  0x83, 0xE0, 0x1E, 0x3C, 0x07, 0xE0, 0xF8, 0x0F, 0x8F, 0x01, 0xF0, 0x3E,
  0x03, 0xC3, 0xC0, 0xFC, 0x0F, 0x81, 0xF0, 0xF0, 0x3F, 0x03, 0xE0, 0x7C,
  0x3C, 0x0F, 0x80, 0xF8, 0x3E, 0x0F, 0x07, 0xE0, 0x3E, 0x0F, 0x83, 0xC1,
  0xF0, 0x0F, 0x83, 0xC0, 0xF0, 0xFC, 0x03, 0xE1, 0xF0, 0x3C, 0x3E, 0x00,
  0xF8, 0x78, 0x0F, 0x0F, 0x80, 0x3E, 0x3E, 0x03, 0xC7, 0xE0, 0x0F, 0x8F,
  0x80, 0xF1, 0xF0, 0x03, 0xE7, 0xC0, 0x3C, 0xFC, 0x00, 0xF9, 0xF0, 0x0F,
  0x3E, 0x00, 0x3E, 0x78, 0x03, 0xCF, 0x80, 0x0F, 0xBE, 0x00, 0xF7, 0xC0,
  0x03, 0xEF, 0x00, 0x3D, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0x78, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0xF8, 0x03, 0xF8,
  0x00, 0x3E, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF0, 0x3F,
  0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x03, 0xE3,
  0xF0, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x01, 0xF0, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x3F, 0x00, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0xFC, 0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x7E,
  0x00, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x08, 0xFF, 0xC0, 0x00, 0xDF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xD8, 0x00, 0x3F, 0xF8, 0x80, 0x00, 0x7F, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Italic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 17, 48, 17, 1, -47 },
  { 103, 19, 17, 25, 7, -47 },
  { 144, 37, 47, 37, 1, -47 },
  { 362, 31, 54, 32, 1, -50 },
  { 572, 41, 49, 48, 4, -48 },
  { 824, 36, 49, 38, 1, -48 },
  { 1045, 9, 17, 14, 7, -47 },
  { 1065, 21, 57, 18, 2, -47 },
  { 1215, 21, 57, 18, -5, -47 },
  { 1365, 26, 27, 32, 7, -50 },
  { 1453, 28, 31, 34, 4, -39 },
  { 1562, 13, 17, 16, -3, -8 },
  { 1590, 16, 5, 19, 1, -20 },
  { 1600, 8, 9, 16, 1, -8 },
  { 1609, 31, 47, 23, -3, -47 },
  { 1792, 29, 49, 32, 3, -48 },
  { 1970, 18, 47, 32, 9, -47 },
  { 2076, 33, 48, 32, -1, -48 },
  { 2274, 30, 49, 32, 1, -48 },
  { 2458, 32, 47, 32, 0, -47 },
  { 2646, 31, 48, 32, 1, -47 },
  { 2832, 30, 49, 32, 3, -48 },
  { 3016, 30, 47, 32, 4, -47 },
  { 3193, 30, 49, 32, 2, -48 },
  { 3377, 29, 49, 32, 2, -48 },
  { 3555, 13, 37, 16, 1, -36 },
  { 3616, 17, 45, 16, -3, -36 },
  { 3712, 29, 31, 34, 4, -39 },
  { 3825, 28, 18, 34, 4, -32 },
  { 3888, 29, 31, 34, 4, -39 },
  { 4001, 23, 49, 25, 4, -48 },
  { 4142, 45, 53, 50, 3, -47 },
  { 4441, 34, 47, 33, -4, -47 },
  { 4641, 33, 47, 36, 2, -47 },
  { 4835, 34, 49, 34, 4, -48 },
  { 5044, 35, 47, 39, 2, -47 },
  { 5250, 31, 47, 30, 2, -47 },
  { 5433, 31, 47, 28, 2, -47 },
  { 5616, 36, 49, 40, 4, -48 },
  { 5837, 39, 47, 40, 2, -47 },
  { 6067, 26, 47, 20, -2, -47 },
  { 6220, 27, 60, 16, -10, -47 },
  { 6423, 37, 47, 33, 2, -47 },
  { 6641, 22, 47, 28, 2, -47 },
  { 6771, 49, 47, 51, 2, -47 },
  { 7059, 41, 47, 42, 2, -47 },
  { 7300, 36, 49, 42, 4, -48 },
  { 7521, 32, 47, 33, 2, -47 },
  { 7709, 36, 59, 42, 4, -48 },
  { 7975, 32, 47, 34, 2, -47 },
  { 8163, 32, 49, 30, 0, -48 },
  { 8359, 29, 47, 29, 6, -47 },
  { 8530, 37, 48, 40, 4, -47 },
  { 8752, 33, 47, 33, 6, -47 },
  { 8946, 50, 47, 52, 7, -47 },
  { 9240, 40, 47, 31, -4, -47 },
  { 9475, 30, 47, 30, 6, -47 },
  { 9652, 35, 47, 30, -1, -47 },
  { 9858, 25, 58, 19, -1, -47 },
  { 10040, 12, 47, 23, 7, -47 },
  { 10111, 25, 58, 19, -5, -47 },
  { 10293, 30, 28, 34, 2, -47 },
  { 10398, 25, 4, 24, -6, 6 },
  { 10411, 10, 11, 18, 10, -51 },
  { 10425, 30, 37, 34, 3, -36 },
  { 10564, 31, 51, 34, 1, -50 },
  { 10762, 25, 37, 27, 3, -36 },
  { 10878, 33, 51, 34, 3, -50 },
  { 11089, 25, 37, 30, 3, -36 },
  { 11205, 35, 66, 19, -8, -50 },
  { 11494, 32, 52, 34, 1, -36 },
  { 11702, 30, 50, 34, 1, -50 },
  { 11890, 16, 49, 15, 1, -49 },
  { 11988, 25, 65, 15, -8, -49 },
  { 12192, 31, 50, 29, 1, -50 },
  { 12386, 16, 50, 15, 1, -50 },
  { 12486, 47, 36, 51, 1, -36 },
  { 12698, 30, 36, 34, 1, -36 },
  { 12833, 28, 37, 33, 3, -36 },
  { 12963, 34, 52, 34, -2, -36 },
  { 13184, 30, 52, 34, 3, -36 },
  { 13379, 25, 36, 23, 1, -36 },
  { 13492, 25, 37, 26, 0, -36 },
  { 13608, 19, 44, 20, 3, -43 },
  { 13713, 30, 36, 34, 3, -35 },
  { 13848, 28, 35, 28, 3, -35 },
  { 13971, 42, 35, 43, 4, -35 },
  { 14155, 34, 35, 29, -3, -35 },
  { 14304, 37, 51, 28, -6, -35 },
  { 14540, 28, 35, 25, -2, -35 },
  { 14663, 25, 57, 23, 1, -47 },
  { 14842, 5, 66, 32, 14, -50 },
  { 14884, 25, 57, 23, -3, -47 },
  { 15063, 29, 9, 34, 4, -28 },
};

const GFXfont NotoSans_SemiCondensed_Italic66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic66pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC66PT7B_H_
