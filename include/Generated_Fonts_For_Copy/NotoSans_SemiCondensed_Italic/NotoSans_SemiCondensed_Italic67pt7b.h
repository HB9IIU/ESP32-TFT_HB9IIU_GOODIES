#ifndef _NOTOSANS_SEMICONDENSED_ITALIC67PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x1F, 0x83,
  0xF3, 0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xE0,
  0x7C, 0x3E, 0x07, 0xC7, 0xE0, 0x7C, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C,
  0x0F, 0x87, 0xC0, 0xF8, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0xF8, 0x0F, 0x0F,
  0x01, 0xE0, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0xF0, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00,
  0x3E, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x78, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x07, 0xF1, 0xC1, 0xE0, 0x1F, 0x87, 0x80, 0x80, 0x3E, 0x0F, 0x00, 0x00,
  0x7C, 0x1E, 0x00, 0x01, 0xF8, 0x3C, 0x00, 0x03, 0xE0, 0x70, 0x00, 0x07,
  0xC1, 0xE0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x1F, 0x87, 0x80, 0x00, 0x3F,
  0x0F, 0x00, 0x00, 0x3F, 0x1C, 0x00, 0x00, 0x7F, 0x78, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xEF, 0xF0, 0x00, 0x03, 0xC7, 0xE0, 0x00, 0x07, 0x87,
  0xE0, 0x00, 0x0F, 0x0F, 0xC0, 0x00, 0x1E, 0x1F, 0x80, 0x00, 0x38, 0x1F,
  0x00, 0x00, 0xF0, 0x3E, 0x00, 0x01, 0xE0, 0xFC, 0x00, 0x03, 0xC1, 0xF8,
  0x00, 0x07, 0x83, 0xE0, 0x40, 0x0E, 0x0F, 0xC0, 0xE0, 0x3C, 0x3F, 0x01,
  0xF8, 0x7B, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x0F,
  0x00, 0x0F, 0x80, 0x3C, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x07,
  0xC0, 0x1E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x03, 0xC0, 0x1E,
  0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x81, 0xF0,
  0x00, 0xF8, 0x07, 0xC1, 0xF0, 0x00, 0x78, 0x03, 0xE0, 0xF8, 0x00, 0x3C,
  0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x01, 0xF0, 0x78, 0x00, 0x0F, 0x00, 0xF8,
  0x7C, 0x3F, 0xC7, 0x80, 0x78, 0x7C, 0x3F, 0xF3, 0xC0, 0x7C, 0x3C, 0x3F,
  0xFD, 0xE0, 0x3C, 0x3E, 0x3F, 0xFE, 0xF8, 0x3E, 0x3E, 0x3F, 0x1F, 0xFC,
  0x3E, 0x1F, 0x1F, 0x07, 0xFF, 0xFF, 0x1F, 0x1F, 0x03, 0xEF, 0xFF, 0x1F,
  0x0F, 0x00, 0xF3, 0xFF, 0x0F, 0x8F, 0x80, 0x78, 0xFE, 0x0F, 0x87, 0xC0,
  0x7C, 0x08, 0x0F, 0x83, 0xC0, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x1F, 0x00,
  0x07, 0xC1, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0xF0, 0x07, 0xC0, 0x03, 0xE0,
  0x78, 0x03, 0xC0, 0x03, 0xE0, 0x7C, 0x01, 0xE0, 0x03, 0xE0, 0x3E, 0x01,
  0xF0, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x01,
  0xF0, 0x1E, 0x00, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x0F,
  0x00, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0xFF, 0x80, 0x3E,
  0x00, 0x07, 0xFF, 0x80, 0x3E, 0x00, 0x01, 0xFF, 0x80, 0x3E, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0x3E,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00,
  0x00, 0x3E, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x7E, 0x0F, 0xE3, 0xF0, 0x03, 0xE0, 0xFE, 0x1F, 0xC0, 0x3F, 0x0F, 0xE0,
  0x7E, 0x01, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0x87, 0xE0, 0x0F, 0xC0, 0xF8,
  0x3E, 0x00, 0x3F, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0xFC, 0x1F, 0x00, 0x07,
  0xE7, 0xE0, 0xF8, 0x00, 0x3F, 0xFE, 0x0F, 0xC0, 0x00, 0xFF, 0xE0, 0x7E,
  0x00, 0x07, 0xFF, 0x03, 0xF0, 0x00, 0x1F, 0xF0, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xE0, 0x00, 0x7F, 0xC0, 0x1F, 0x80,
  0x07, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFC, 0x1F, 0xF7, 0xE0,
  0x1F, 0xFF, 0xFE, 0x3F, 0x80, 0x7F, 0xFF, 0xE0, 0xFC, 0x01, 0xFF, 0xFC,
  0x07, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x9F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF0, 0xF8, 0x7C, 0x7E, 0x3E, 0x1F,
  0x0F, 0x87, 0x83, 0xC1, 0xE1, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x10, 0x03, 0xE0, 0x03, 0x80, 0x78, 0x00, 0x7C, 0x0F, 0x00,
  0x1F, 0xE1, 0xE0, 0x03, 0xFF, 0x3C, 0x00, 0x3F, 0xFF, 0x0F, 0xF0, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xF8, 0x7F,
  0x00, 0xF7, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x1F, 0x9E, 0x00, 0x07, 0xE3,
  0xE0, 0x01, 0xF8, 0x3C, 0x00, 0x7F, 0x07, 0xC0, 0x1F, 0xC0, 0xF8, 0x00,
  0xF0, 0x0F, 0x80, 0x0E, 0x01, 0xF0, 0x00, 0x80, 0x3F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x3F,
  0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3E, 0x01,
  0xF0, 0x0F, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xCF,
  0xFF, 0xE7, 0xFF, 0xF7, 0xFF, 0xF8, 0x1E, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7E, 0x38, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xEF,
  0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x01, 0xF8,
  0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x03, 0xE3, 0xF0, 0x00,
  0x3F, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E,
  0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xF3, 0xF0, 0x00,
  0x1F, 0x9F, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F,
  0x7E, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xFC,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC,
  0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xF0, 0x1F,
  0x80, 0x3F, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xFC, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFF,
  0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0x7C,
  0x3F, 0xDF, 0x9F, 0xF3, 0xF3, 0xF8, 0x7C, 0x3E, 0x1F, 0x87, 0x83, 0xF0,
  0x40, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xBF, 0xF8,
  0x00, 0xFC, 0x01, 0xFC, 0x00, 0x3C, 0x00, 0x7F, 0x00, 0x18, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0x80, 0x3F, 0x00,
  0x7F, 0x00, 0x38, 0x00, 0x7F, 0x00, 0x40, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x02, 0x00, 0x00, 0xFE, 0x07, 0x00, 0x07, 0xF8,
  0x0F, 0xE0, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0x7C,
  0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7C, 0xFC,
  0x00, 0x00, 0xFC, 0xF8, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x03, 0xF0, 0xF8,
  0x00, 0x03, 0xE1, 0xF8, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x0F, 0xC1, 0xF0,
  0x00, 0x1F, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x3E, 0x03, 0xF0,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0xF8, 0x03, 0xE0,
  0x01, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x0F, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xF0, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0xC0, 0x00, 0x3F, 0x80,
  0xF0, 0x00, 0xFF, 0x00, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xF9, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x1F, 0x1F, 0xFE, 0x00, 0xFC,
  0xFF, 0xFC, 0x03, 0xF7, 0xFF, 0xF8, 0x0F, 0xBF, 0xFF, 0xF0, 0x3F, 0xF0,
  0x1F, 0xC1, 0xFF, 0x00, 0x3F, 0x07, 0xF8, 0x00, 0x7E, 0x1F, 0xC0, 0x01,
  0xF8, 0x7F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E,
  0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x07, 0xE0, 0x7C, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x3F,
  0x80, 0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x00,
  0x7F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x01,
  0xF8, 0x0F, 0x80, 0x03, 0xF0, 0x1F, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x0F,
  0xC0, 0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xF8,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xF0, 0x7F, 0x00,
  0x07, 0xF3, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8,
  0x03, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x80, 0x07, 0xE0, 0x7E, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F,
  0x83, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xFC, 0x0F, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE,
  0x00, 0xFE, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00,
  0x0F, 0x83, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x03,
  0xF0, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFC,
  0x7E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x1F,
  0x80, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x3F, 0x87, 0xE0,
  0x01, 0xFE, 0x0F, 0xC0, 0x0F, 0xF8, 0x3F, 0x80, 0x7F, 0xC0, 0xFF, 0xDF,
  0xDF, 0x01, 0xFF, 0xFE, 0xFC, 0x03, 0xFF, 0xF3, 0xF0, 0x07, 0xFF, 0x8F,
  0x80, 0x07, 0xF8, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x20, 0x01, 0xFC, 0x00, 0xF8, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x20, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x83, 0xFC, 0x0F, 0xE0, 0x7E, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x01, 0xF8, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFC, 0x0F, 0xC0, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x07, 0xE0, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC3, 0xFE, 0xFF, 0xC7, 0x80, 0x3F, 0x84,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x03, 0xF8, 0x01, 0xF0,
  0x7C, 0x00, 0x7F, 0xFC, 0x07, 0xC3, 0xE0, 0x07, 0xFF, 0xF8, 0x1F, 0x0F,
  0x80, 0x3F, 0xFF, 0xC0, 0x7C, 0x7C, 0x01, 0xFC, 0x1F, 0x01, 0xF1, 0xF0,
  0x0F, 0xC0, 0x7C, 0x07, 0xCF, 0x80, 0x7E, 0x01, 0xE0, 0x1F, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF7, 0xC0, 0x3C,
  0x00, 0xF8, 0x07, 0xDF, 0x01, 0xF0, 0x03, 0xC0, 0x1F, 0x7C, 0x07, 0x80,
  0x1F, 0x00, 0x79, 0xE0, 0x3E, 0x00, 0x7C, 0x01, 0xEF, 0x80, 0xF8, 0x01,
  0xF0, 0x0F, 0xBE, 0x03, 0xC0, 0x07, 0x80, 0x3E, 0xF8, 0x0F, 0x00, 0x3E,
  0x00, 0xF3, 0xE0, 0x7C, 0x00, 0xF8, 0x07, 0xCF, 0x81, 0xF0, 0x03, 0xE0,
  0x1F, 0x3E, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0xF8, 0x1F, 0x00, 0x7C, 0x03,
  0xE3, 0xE0, 0x7C, 0x03, 0xF0, 0x0F, 0x0F, 0x81, 0xF0, 0x1F, 0xC0, 0x7C,
  0x3E, 0x03, 0xE0, 0xF7, 0x83, 0xE0, 0xF8, 0x0F, 0xE7, 0x9F, 0x3F, 0x03,
  0xE0, 0x3F, 0xFE, 0x7F, 0xFC, 0x0F, 0x80, 0x7F, 0xF0, 0xFF, 0xC0, 0x3E,
  0x00, 0xFF, 0x03, 0xFE, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFC, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x1F,
  0x8F, 0x80, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00,
  0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF8, 0x07, 0xC0,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x1F,
  0x00, 0x07, 0xE0, 0x07, 0xC0, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7E,
  0x00, 0x07, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0xF8,
  0x3F, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x1F, 0x00, 0x7F, 0xE0, 0x07, 0xC0, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x07, 0xF0, 0x0F, 0x80, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x0F, 0xE0, 0x0F,
  0xC0, 0x07, 0xF0, 0x03, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x03, 0xF0, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x0F, 0xC0, 0x01, 0xFC, 0x03, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x3F, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7F, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0xF8, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x03, 0xFC,
  0x07, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x70, 0x01, 0xFE, 0x00, 0x04,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0E, 0x00, 0x1F, 0xFE, 0x7F,
  0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xE0,
  0x3F, 0xF8, 0x00, 0x7C, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x03, 0xFC, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0x80,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7F, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0xF8, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xFC, 0x1F,
  0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0x00, 0x00, 0x7F,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x3E, 0x00, 0x03, 0xFC, 0x03, 0xE0, 0x00, 0x7F, 0x80, 0x7E,
  0x00, 0x0F, 0xF0, 0x07, 0xE0, 0x03, 0xFE, 0x00, 0x7E, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x02, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0x80, 0x0F, 0xF0, 0x00, 0x0C,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xC7, 0xF0, 0x00, 0x7F, 0xFE, 0x3F,
  0x00, 0x07, 0xFF, 0xE1, 0xF8, 0x00, 0x3F, 0xFF, 0x0F, 0xC0, 0x01, 0xFF,
  0xF8, 0x7E, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x7C, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x7F, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x7F, 0x00, 0x00, 0x7C, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x01, 0xFF,
  0xF3, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x0E, 0x3F, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0xFE, 0x00,
  0x07, 0xC0, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x3F, 0x80, 0x00,
  0x7E, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x7F,
  0x00, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x00, 0x7C, 0x1F, 0xC0, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x3F, 0x1F, 0xC0,
  0x00, 0x00, 0xF8, 0xFE, 0x00, 0x00, 0x03, 0xE7, 0xF0, 0x00, 0x00, 0x1F,
  0xBF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0x9F, 0x80, 0x00, 0x03, 0xFC, 0x7E, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x00, 0x3E, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0xFB, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x3E, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x0F, 0xBE,
  0x00, 0x00, 0xFD, 0xF0, 0x07, 0xEF, 0x80, 0x00, 0x3E, 0xFC, 0x01, 0xFB,
  0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x1F,
  0x3E, 0x00, 0x03, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF8, 0x03,
  0xF3, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0x1F, 0x80,
  0x3E, 0x1F, 0x00, 0x0F, 0xC7, 0xC0, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0,
  0x07, 0xE1, 0xF0, 0x01, 0xF0, 0xFC, 0x01, 0xF8, 0x7C, 0x00, 0x7C, 0x3F,
  0x00, 0x7E, 0x1F, 0x00, 0x3E, 0x0F, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x83,
  0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xC1, 0xF8, 0x03, 0xF0, 0x7C, 0x01, 0xF0,
  0x7E, 0x00, 0xFC, 0x1F, 0x00, 0xF8, 0x1F, 0x80, 0x3E, 0x07, 0xC0, 0x3E,
  0x07, 0xE0, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x07,
  0xC0, 0xFC, 0x01, 0xF8, 0x0F, 0x83, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xE1,
  0xF8, 0x0F, 0xC0, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x3E,
  0x3F, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x8F, 0x80, 0x7E, 0x00, 0xFC, 0x03,
  0xE7, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xF9, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x3E, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xBE, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x0F, 0xC0, 0x1F,
  0x00, 0x1F, 0xF0, 0x03, 0xF0, 0x07, 0xC0, 0x07, 0xF8, 0x00, 0xF8, 0x01,
  0xF0, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x1F, 0xC0, 0x00, 0x07, 0xC0, 0x1F, 0xE0, 0x00, 0x07, 0xE0, 0x0F,
  0xF0, 0x00, 0x03, 0xF0, 0x07, 0xF8, 0x00, 0x01, 0xF0, 0x03, 0xFE, 0x00,
  0x00, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x7E,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x00, 0x3E,
  0xF8, 0x00, 0x0F, 0x80, 0x3F, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0x3F, 0x00,
  0x07, 0xE0, 0x0F, 0x8F, 0x80, 0x03, 0xF0, 0x07, 0xC7, 0xC0, 0x01, 0xF0,
  0x03, 0xE3, 0xF0, 0x00, 0xF8, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x01, 0xF8,
  0x7C, 0x00, 0x7E, 0x00, 0xF8, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x1F, 0x80,
  0x1F, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x03, 0xF0, 0x0F, 0xC0,
  0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x7E, 0x00, 0xF8, 0x01, 0xF8, 0x3E, 0x00,
  0x7C, 0x00, 0xFC, 0x1F, 0x00, 0x7E, 0x00, 0x3E, 0x1F, 0x80, 0x3F, 0x00,
  0x1F, 0x0F, 0xC0, 0x1F, 0x00, 0x0F, 0xC7, 0xE0, 0x0F, 0x80, 0x03, 0xE3,
  0xE0, 0x07, 0xC0, 0x01, 0xF1, 0xF0, 0x07, 0xE0, 0x00, 0xFD, 0xF8, 0x03,
  0xF0, 0x00, 0x7E, 0xFC, 0x01, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x7E, 0x00, 0x01, 0xFF,
  0x80, 0x3F, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x7F, 0xC0, 0x0F,
  0x80, 0x00, 0x1F, 0xE0, 0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0x07, 0xE0, 0x00,
  0x07, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x01, 0xFC, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x07, 0xE3, 0xF8,
  0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x01,
  0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xE0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x7C, 0x07, 0xFE, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xF8, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x1F, 0x01, 0xF8, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x7E, 0x03, 0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x01, 0xFC, 0x07, 0xE0, 0x03,
  0xF8, 0x07, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0x07, 0xE3, 0xF8, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x01, 0xF9,
  0xFC, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x03, 0xFB,
  0xF0, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00,
  0x0F, 0xE7, 0xE0, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7F, 0x00,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x7F, 0xC0, 0x1F, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x3F, 0xF0, 0x01, 0xF0, 0x03, 0xFC,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x3E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x01,
  0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xE0, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x1F, 0xC0, 0x3E, 0x00, 0x1F, 0xC0, 0x3F, 0x00,
  0x1F, 0xE0, 0x1F, 0x80, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F,
  0xC0, 0x1F, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x03, 0xF0, 0x0F, 0x80, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0x80, 0x3E, 0x00, 0xFE, 0x00, 0x0C, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0xC0, 0x00, 0x3F, 0x80, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x1F, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0x1F, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x1F,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7C, 0x00,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0xF7,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x07, 0xF3, 0xF0, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x03, 0xF8, 0x7C,
  0x00, 0x01, 0xF8, 0x3E, 0x00, 0x01, 0xFC, 0x1F, 0x00, 0x00, 0xFC, 0x0F,
  0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x03, 0xF0,
  0x00, 0x7C, 0x01, 0xF8, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0xFC, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x03, 0xE0, 0x7E,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xC7,
  0xC0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0xFB,
  0xF0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00,
  0x7F, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x3E, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xF8, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x7E, 0x1F, 0x00, 0x07, 0xDE, 0x00, 0x0F, 0xC3,
  0xE0, 0x00, 0xFB, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x1F, 0x78, 0x00, 0x7E,
  0x0F, 0x80, 0x07, 0xCF, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0xF9, 0xE0, 0x03,
  0xF0, 0x3E, 0x00, 0x3E, 0x3C, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xC7, 0x80,
  0x0F, 0x80, 0xF8, 0x01, 0xF0, 0xF0, 0x03, 0xF0, 0x1F, 0x00, 0x3E, 0x1E,
  0x00, 0x7E, 0x03, 0xE0, 0x0F, 0xC3, 0xC0, 0x1F, 0x80, 0x7C, 0x01, 0xF0,
  0x78, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0xFC, 0x01, 0xF8, 0x0F,
  0x81, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x07, 0xE0,
  0x7C, 0x07, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0x80, 0xF8, 0x1F, 0x00, 0x1F,
  0x83, 0xF0, 0x1F, 0x07, 0xE0, 0x03, 0xF0, 0x7C, 0x03, 0xE0, 0xFC, 0x00,
  0x7E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x0F, 0x87, 0xE0,
  0x01, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x3E, 0x3F,
  0x00, 0x07, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x00, 0xFC, 0xF8, 0x00, 0xF8,
  0xF8, 0x00, 0x1F, 0x9F, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xF3, 0xE0, 0x03,
  0xE7, 0xC0, 0x00, 0x7E, 0xF8, 0x00, 0x7D, 0xF8, 0x00, 0x0F, 0x9F, 0x00,
  0x0F, 0xBE, 0x00, 0x01, 0xF7, 0xC0, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xDE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00,
  0x3E, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x00, 0x01, 0xF1, 0xF8, 0x00,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x00, 0x1F, 0xC1, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x07, 0xF1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x1F, 0x80,
  0x03, 0xF0, 0x3E, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x03,
  0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x03, 0xF0,
  0x01, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x3E, 0x0F, 0xC0, 0x00, 0xF8, 0x7E, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x0F,
  0x8F, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xBE,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x1E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xC0, 0x7C, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x78, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x0F,
  0x80, 0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x80,
  0x03, 0xE0, 0x7E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x00,
  0x7C, 0x3E, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F,
  0xBF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7C, 0x7F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x3F, 0x87,
  0xE1, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF0, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x7C, 0x00, 0xFF, 0xF0, 0xF0, 0x07, 0xFF,
  0xE3, 0xE0, 0x1F, 0xFF, 0xE7, 0xC0, 0x7F, 0xC7, 0xEF, 0x80, 0xFE, 0x03,
  0xFF, 0x03, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x07,
  0xF0, 0x7E, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xF8, 0x3F,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0xC1, 0xF0,
  0x00, 0x3F, 0x83, 0xE0, 0x00, 0xFE, 0x07, 0xC0, 0x01, 0xFC, 0x0F, 0xC0,
  0x07, 0xF8, 0x1F, 0x80, 0x1F, 0xF0, 0x3F, 0x00, 0x7F, 0xC0, 0x7F, 0x01,
  0xFF, 0x80, 0x7F, 0x0F, 0xDF, 0x00, 0xFF, 0xFF, 0x3E, 0x00, 0xFF, 0xFC,
  0x7C, 0x00, 0xFF, 0xF0, 0xF0, 0x00, 0xFF, 0x81, 0xE0, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x80,
  0x00, 0x7C, 0x1F, 0xF0, 0x01, 0xF8, 0xFF, 0xF0, 0x03, 0xF3, 0xFF, 0xF0,
  0x07, 0xEF, 0xFF, 0xF0, 0x0F, 0xBF, 0x1F, 0xE0, 0x1F, 0xF8, 0x0F, 0xC0,
  0x7F, 0xE0, 0x0F, 0xC0, 0xFF, 0x80, 0x1F, 0x81, 0xFE, 0x00, 0x3F, 0x03,
  0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x01, 0xF8, 0x3F,
  0x80, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0xFC, 0x3F, 0x80, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x1F,
  0x81, 0xFC, 0x00, 0x7F, 0x03, 0xFC, 0x01, 0xFC, 0x0F, 0xF8, 0x07, 0xF8,
  0x1F, 0x7C, 0x3F, 0xE0, 0x3E, 0x7F, 0xFF, 0x80, 0x78, 0xFF, 0xFE, 0x01,
  0xF0, 0xFF, 0xF8, 0x03, 0xE0, 0xFF, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xF8, 0xF8, 0x1F, 0xE0, 0x04, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x60, 0x7F, 0xC1, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x08, 0x07, 0xE0, 0x00, 0x7F, 0xC1, 0xF8, 0x00, 0x7F, 0xFC, 0x7C, 0x00,
  0x3F, 0xFF, 0x9F, 0x00, 0x1F, 0xFF, 0xEF, 0xC0, 0x0F, 0xF8, 0xFF, 0xF0,
  0x07, 0xF8, 0x0F, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x3F, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x03, 0xF8, 0x07, 0xE0, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3E, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x01, 0xFC, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0xF8, 0x00, 0x3F, 0x80, 0x3E, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x07,
  0xF8, 0x03, 0xF0, 0x03, 0xFE, 0x00, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0x80,
  0xF7, 0xC0, 0x07, 0xF0, 0xFD, 0xF0, 0x01, 0xFF, 0xFE, 0x7C, 0x00, 0x3F,
  0xFF, 0x1F, 0x00, 0x07, 0xFF, 0x87, 0x80, 0x00, 0xFF, 0x83, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0x0F, 0xE0,
  0x7F, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0xC7, 0xF0, 0x03,
  0xF1, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x8F, 0x80,
  0x0F, 0xE7, 0xE0, 0x07, 0xF1, 0xF8, 0x07, 0xF8, 0x7C, 0x1F, 0xFC, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x41, 0xFC, 0x00, 0x60,
  0x7F, 0xC0, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xC0, 0x07,
  0xFF, 0xC3, 0xC0, 0x07, 0xFF, 0xF3, 0xE0, 0x07, 0xFF, 0xF9, 0xF0, 0x07,
  0xFC, 0x7E, 0xF8, 0x07, 0xF8, 0x0F, 0xFC, 0x03, 0xF8, 0x03, 0xFC, 0x03,
  0xF8, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xE0,
  0x7F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xF8,
  0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x07, 0xF0, 0x1F, 0x00, 0x03,
  0xF8, 0x0F, 0x80, 0x03, 0xF8, 0x07, 0xC0, 0x03, 0xFC, 0x03, 0xF0, 0x01,
  0xFE, 0x01, 0xF8, 0x01, 0xFF, 0x00, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x01,
  0xEF, 0x80, 0x1F, 0xC3, 0xF7, 0xC0, 0x0F, 0xFF, 0xF7, 0xE0, 0x03, 0xFF,
  0xF3, 0xF0, 0x00, 0xFF, 0xF1, 0xF0, 0x00, 0x3F, 0xE0, 0xF8, 0x00, 0x03,
  0x80, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x02,
  0x00, 0x07, 0xF0, 0x01, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x80, 0x00, 0x7C, 0x1F, 0xF0, 0x00, 0xF8, 0xFF, 0xF0, 0x03,
  0xF3, 0xFF, 0xF0, 0x07, 0xCF, 0xFF, 0xF0, 0x0F, 0xBF, 0x9F, 0xE0, 0x1F,
  0xF8, 0x0F, 0xC0, 0x7F, 0xC0, 0x0F, 0xC0, 0xFF, 0x00, 0x1F, 0x81, 0xFE,
  0x00, 0x3F, 0x03, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xF8, 0x1F, 0xC0,
  0x01, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x1F, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x01,
  0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F,
  0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xFC,
  0x0F, 0x80, 0x01, 0xF0, 0x3F, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7C, 0x0F,
  0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7C,
  0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00,
  0x1E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0x01,
  0xF8, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F,
  0x80, 0x3F, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC,
  0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xE0, 0xFE, 0x00, 0x07, 0xC3,
  0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7C, 0x7E,
  0x00, 0x00, 0xF9, 0xF8, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0xFF, 0x3F, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF0, 0x07, 0xE0, 0x03,
  0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F,
  0x00, 0x1F, 0x80, 0x7C, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x80, 0x00, 0xF0,
  0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xF0, 0xFF, 0xF0, 0x3F, 0xFC, 0x01, 0xF1,
  0xFF, 0xF0, 0x7F, 0xFE, 0x01, 0xF3, 0xFF, 0xF8, 0xFF, 0xFE, 0x01, 0xF7,
  0xE7, 0xF9, 0xF8, 0xFF, 0x01, 0xFF, 0x81, 0xFB, 0xE0, 0x3F, 0x03, 0xFE,
  0x00, 0xFF, 0xC0, 0x3F, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x1F, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x3F, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x7E, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x7F, 0xC0, 0x07, 0xC3, 0xFF, 0xE0, 0x0F, 0x8F,
  0xFF, 0xC0, 0x1F, 0x3F, 0xFF, 0xC0, 0x3E, 0xFE, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0x81, 0xFF, 0x80, 0x7F, 0x03, 0xFE, 0x00, 0x7E, 0x07, 0xF8, 0x00,
  0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x0F,
  0xC0, 0xFE, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x7E,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x81, 0xF0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x03, 0xFE, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x07, 0xE0, 0x07, 0xE0, 0xFC,
  0x00, 0x3F, 0x1F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x1F, 0x3F, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x3F, 0x7E,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xEF,
  0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFC, 0xF8, 0x00,
  0x0F, 0xCF, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF8,
  0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xFC,
  0x3F, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x07, 0x81, 0xFF, 0x00, 0x01, 0xE0, 0xFF, 0xE0, 0x00, 0xF8, 0xFF,
  0xFC, 0x00, 0x3E, 0x7F, 0xFF, 0x80, 0x0F, 0xBF, 0x1F, 0xE0, 0x03, 0xFF,
  0x01, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0x00, 0x7F, 0xC0, 0x0F, 0xC0, 0x1F,
  0xE0, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x7F,
  0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0xFC, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0xE0, 0x1F, 0xE0,
  0x0F, 0xFE, 0x1F, 0xF0, 0x03, 0xE7, 0xFF, 0xF8, 0x00, 0xF9, 0xFF, 0xFC,
  0x00, 0x3E, 0x3F, 0xFE, 0x00, 0x1F, 0x87, 0xFE, 0x00, 0x07, 0xE0, 0x38,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x7C, 0x00, 0xFF, 0xF0, 0xF0, 0x07, 0xFF, 0xF3, 0xE0, 0x1F, 0xFF,
  0xE7, 0xC0, 0x7F, 0xC7, 0xEF, 0x80, 0xFE, 0x03, 0xFF, 0x03, 0xF8, 0x03,
  0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x07, 0xF0, 0x7E, 0x00, 0x0F,
  0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E,
  0x1F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xE0,
  0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0xC1, 0xF0, 0x00, 0x3F, 0x03, 0xE0,
  0x00, 0xFE, 0x07, 0xC0, 0x03, 0xFC, 0x0F, 0xC0, 0x07, 0xF8, 0x1F, 0x80,
  0x1F, 0xF0, 0x3F, 0x00, 0x7F, 0xC0, 0x7F, 0x01, 0xEF, 0x80, 0x7F, 0x0F,
  0xDF, 0x00, 0xFF, 0xFF, 0x7E, 0x00, 0xFF, 0xFC, 0xFC, 0x00, 0xFF, 0xF1,
  0xF0, 0x00, 0xFF, 0x83, 0xE0, 0x00, 0x38, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x78, 0x3F, 0xC0, 0x7C, 0x3F, 0xE0, 0x3E, 0x3F, 0xE0, 0x1F, 0x3F, 0xF0,
  0x0F, 0xBF, 0xF8, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFE, 0x07, 0xC0,
  0x7F, 0x00, 0x30, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x08, 0x00, 0x1F, 0x83, 0x00, 0x0F, 0xE0,
  0xF8, 0x0F, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFC, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x40, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x38, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x1F,
  0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x3F, 0x07, 0xC0,
  0x00, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x7E, 0x0F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x1F,
  0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xF8,
  0x00, 0x1F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x01, 0xF0, 0x7E, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF8,
  0x3F, 0x00, 0x1F, 0xE0, 0xFC, 0x00, 0xFF, 0x03, 0xF0, 0x07, 0xFC, 0x0F,
  0xC0, 0x3D, 0xF0, 0x3F, 0xC3, 0xE7, 0xC0, 0x7F, 0xFF, 0x9E, 0x01, 0xFF,
  0xFC, 0xF8, 0x03, 0xFF, 0xC3, 0xE0, 0x07, 0xFE, 0x0F, 0x80, 0x03, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x07,
  0xE7, 0xC0, 0x00, 0x7E, 0x7C, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0xFC, 0x7E,
  0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03,
  0xF0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x03,
  0xE0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x3E, 0x03,
  0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xE0, 0x7E, 0x00,
  0x3E, 0x0F, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x1F, 0x80, 0x03, 0xF1,
  0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x3E, 0x00,
  0x01, 0xF7, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFB, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x7C, 0x00, 0x3F, 0x80, 0x0F, 0xCF, 0x80, 0x0F, 0xF0, 0x01, 0xF9, 0xF0,
  0x01, 0xFE, 0x00, 0x3E, 0x3E, 0x00, 0x7F, 0xC0, 0x0F, 0xC7, 0xC0, 0x0F,
  0x78, 0x01, 0xF8, 0xFC, 0x03, 0xEF, 0x00, 0x7E, 0x1F, 0x80, 0x7D, 0xF0,
  0x0F, 0xC3, 0xF0, 0x0F, 0x3E, 0x01, 0xF0, 0x7E, 0x03, 0xE7, 0xC0, 0x7E,
  0x0F, 0xC0, 0x78, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x1F, 0x03, 0xF0, 0x3F,
  0x03, 0xE3, 0xE0, 0x7E, 0x07, 0xE0, 0xF8, 0x7C, 0x1F, 0x80, 0xFC, 0x1F,
  0x0F, 0x83, 0xF0, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x03, 0xF0, 0xF8, 0x3E,
  0x1F, 0x80, 0x7E, 0x1E, 0x07, 0xC3, 0xE0, 0x0F, 0xC7, 0xC0, 0xF8, 0xFC,
  0x01, 0xF8, 0xF8, 0x1F, 0x1F, 0x00, 0x3F, 0x3E, 0x03, 0xE3, 0xE0, 0x07,
  0xE7, 0xC0, 0x7C, 0xFC, 0x00, 0xFD, 0xF0, 0x0F, 0x9F, 0x00, 0x1F, 0xBE,
  0x01, 0xF7, 0xE0, 0x03, 0xE7, 0x80, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x07,
  0xDF, 0x00, 0x0F, 0xBE, 0x00, 0xFF, 0xC0, 0x01, 0xF7, 0x80, 0x1F, 0xF8,
  0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0x80, 0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x1F, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x01, 0xF0, 0x1F, 0x80, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x03, 0xE1, 0xF8, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0x80,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x1F,
  0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xF0,
  0x00, 0x7E, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x3F, 0x00,
  0x00, 0x7C, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00,
  0x1F, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x07, 0xC3, 0xF0,
  0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x00, 0x1F, 0x7E, 0x00, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0x03, 0xDF,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x09, 0xFF, 0xE0, 0x00,
  0xDF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xD0, 0x00, 0x1F, 0xF8, 0x80, 0x00,
  0x0E, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Italic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 17, 49, 17, 1, -48 },
  { 106, 20, 17, 25, 7, -48 },
  { 149, 38, 48, 38, 1, -48 },
  { 377, 31, 55, 33, 1, -51 },
  { 591, 41, 50, 49, 5, -49 },
  { 848, 37, 50, 39, 1, -49 },
  { 1080, 9, 17, 14, 7, -48 },
  { 1100, 21, 59, 19, 2, -48 },
  { 1255, 21, 59, 19, -5, -48 },
  { 1410, 27, 28, 32, 7, -51 },
  { 1505, 29, 32, 35, 4, -40 },
  { 1621, 13, 17, 16, -3, -8 },
  { 1649, 17, 6, 20, 1, -21 },
  { 1662, 8, 9, 16, 1, -8 },
  { 1671, 32, 48, 23, -3, -48 },
  { 1863, 29, 50, 33, 3, -49 },
  { 2045, 19, 48, 33, 9, -48 },
  { 2159, 33, 49, 33, -1, -49 },
  { 2362, 31, 50, 33, 1, -49 },
  { 2556, 32, 48, 33, 0, -48 },
  { 2748, 32, 49, 33, 1, -48 },
  { 2944, 30, 50, 33, 3, -49 },
  { 3132, 31, 48, 33, 4, -48 },
  { 3318, 31, 50, 33, 2, -49 },
  { 3512, 30, 50, 33, 2, -49 },
  { 3700, 13, 38, 16, 1, -37 },
  { 3762, 18, 46, 16, -3, -37 },
  { 3866, 29, 32, 35, 4, -40 },
  { 3982, 29, 19, 35, 4, -33 },
  { 4051, 29, 32, 35, 4, -40 },
  { 4167, 23, 50, 25, 4, -49 },
  { 4311, 46, 54, 50, 3, -48 },
  { 4622, 34, 48, 34, -4, -48 },
  { 4826, 34, 48, 36, 2, -48 },
  { 5030, 34, 50, 34, 4, -49 },
  { 5243, 36, 48, 40, 2, -48 },
  { 5459, 32, 48, 31, 2, -48 },
  { 5651, 32, 48, 29, 2, -48 },
  { 5843, 37, 50, 41, 4, -49 },
  { 6075, 39, 48, 41, 2, -48 },
  { 6309, 26, 48, 20, -2, -48 },
  { 6465, 28, 61, 17, -10, -48 },
  { 6679, 38, 48, 34, 2, -48 },
  { 6907, 22, 48, 29, 2, -48 },
  { 7039, 50, 48, 52, 2, -48 },
  { 7339, 41, 48, 43, 2, -48 },
  { 7585, 37, 50, 43, 4, -49 },
  { 7817, 32, 48, 34, 2, -48 },
  { 8009, 37, 60, 43, 4, -49 },
  { 8287, 33, 48, 35, 2, -48 },
  { 8485, 32, 50, 31, 0, -49 },
  { 8685, 29, 48, 30, 6, -48 },
  { 8859, 37, 49, 40, 4, -48 },
  { 9086, 33, 48, 33, 6, -48 },
  { 9284, 51, 48, 52, 7, -48 },
  { 9590, 41, 48, 31, -4, -48 },
  { 9836, 30, 48, 30, 6, -48 },
  { 10016, 35, 48, 31, -1, -48 },
  { 10226, 25, 59, 19, -1, -48 },
  { 10411, 12, 48, 23, 7, -48 },
  { 10483, 26, 59, 19, -5, -48 },
  { 10675, 30, 29, 34, 2, -48 },
  { 10784, 25, 4, 24, -6, 6 },
  { 10797, 10, 10, 18, 10, -51 },
  { 10810, 31, 38, 35, 3, -37 },
  { 10958, 31, 52, 35, 1, -51 },
  { 11160, 25, 38, 27, 3, -37 },
  { 11279, 34, 52, 35, 3, -51 },
  { 11500, 26, 38, 31, 3, -37 },
  { 11624, 35, 67, 19, -8, -51 },
  { 11918, 33, 53, 35, 1, -37 },
  { 12137, 31, 51, 35, 1, -51 },
  { 12335, 16, 49, 16, 1, -49 },
  { 12433, 26, 65, 16, -9, -49 },
  { 12645, 31, 51, 30, 1, -51 },
  { 12843, 17, 51, 16, 1, -51 },
  { 12952, 48, 37, 52, 1, -37 },
  { 13174, 31, 37, 35, 1, -37 },
  { 13318, 28, 37, 34, 3, -36 },
  { 13448, 34, 53, 35, -2, -37 },
  { 13674, 31, 53, 35, 3, -37 },
  { 13880, 25, 37, 24, 1, -37 },
  { 13996, 26, 38, 26, 0, -37 },
  { 14120, 19, 45, 20, 3, -44 },
  { 14227, 30, 37, 35, 3, -36 },
  { 14366, 28, 36, 28, 3, -36 },
  { 14492, 43, 36, 44, 4, -36 },
  { 14686, 34, 36, 29, -3, -36 },
  { 14839, 37, 52, 28, -6, -36 },
  { 15080, 28, 36, 26, -2, -36 },
  { 15206, 26, 59, 23, 1, -48 },
  { 15398, 4, 67, 32, 15, -51 },
  { 15432, 25, 59, 23, -3, -48 },
  { 15617, 29, 9, 35, 4, -28 },
};

const GFXfont NotoSans_SemiCondensed_Italic67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic67pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC67PT7B_H_
