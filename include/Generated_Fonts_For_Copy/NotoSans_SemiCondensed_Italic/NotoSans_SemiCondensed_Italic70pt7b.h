#ifndef _NOTOSANS_SEMICONDENSED_ITALIC70PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x1F, 0x80, 0x03, 0x80, 0x00, 0x1F, 0x83, 0xF8, 0xFC,
  0x1F, 0xC7, 0xE0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF0,
  0xFC, 0x0F, 0x87, 0xC0, 0xFC, 0x3E, 0x07, 0xE1, 0xF0, 0x3E, 0x1F, 0x01,
  0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x78, 0x3E, 0x03, 0xC1, 0xE0, 0x3E, 0x0F,
  0x01, 0xF0, 0x78, 0x0F, 0x07, 0xC0, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x3C,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0x80, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00,
  0xF0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFE, 0x38, 0x3C,
  0x01, 0xF8, 0x78, 0x0C, 0x03, 0xF0, 0x78, 0x00, 0x03, 0xF0, 0x78, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x03, 0xE0, 0x70, 0x00, 0x07, 0xE0, 0xF0, 0x00,
  0x07, 0xE0, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00,
  0x03, 0xF1, 0xE0, 0x00, 0x03, 0xF9, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xBF, 0xC0, 0x00, 0x07, 0x8F, 0xC0,
  0x00, 0x07, 0x8F, 0xE0, 0x00, 0x07, 0x87, 0xE0, 0x00, 0x0F, 0x07, 0xE0,
  0x00, 0x0F, 0x03, 0xE0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x0F, 0x07, 0xE0,
  0x00, 0x0F, 0x07, 0xE0, 0x00, 0x1E, 0x07, 0xE0, 0x00, 0x1E, 0x0F, 0xC0,
  0xC0, 0x1E, 0x1F, 0xC0, 0xF0, 0x1E, 0x3F, 0x80, 0xFF, 0xDF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF0, 0x07,
  0xFF, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xC0, 0x1F, 0x87, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x7C, 0x00,
  0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0x3F, 0x01, 0xF0, 0x03, 0xF0,
  0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x03,
  0xC0, 0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0x1F, 0x01,
  0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x00, 0x7C, 0x1F, 0x80,
  0x03, 0xE0, 0x0F, 0x03, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0xF8, 0x00, 0x0F,
  0x80, 0x7C, 0x3F, 0x01, 0xC1, 0xF0, 0x0F, 0x87, 0xC3, 0xFE, 0x3E, 0x03,
  0xE1, 0xF0, 0xFF, 0xE7, 0xC0, 0x7C, 0x3E, 0x3F, 0xFE, 0xF8, 0x1F, 0x0F,
  0x8F, 0xFF, 0xDF, 0x03, 0xE3, 0xE1, 0xF0, 0xFF, 0xF0, 0xF8, 0x7C, 0x7C,
  0x0F, 0xBF, 0xFE, 0x1F, 0x1F, 0x01, 0xF7, 0xFF, 0xC7, 0xC3, 0xE0, 0x3E,
  0x7F, 0xF0, 0xF8, 0x78, 0x07, 0xC7, 0xF8, 0x3E, 0x1F, 0x00, 0xF8, 0x38,
  0x0F, 0x83, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x78, 0x03, 0xE0, 0x00, 0x7C,
  0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x7C,
  0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x3C, 0x00, 0x3E, 0x01, 0xE0, 0x0F,
  0x80, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00,
  0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x3E, 0x00, 0xFC, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0x1F,
  0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x01, 0xF8, 0x00, 0x3E, 0x1F,
  0x80, 0x3E, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0xFF, 0xF8, 0x03,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x01, 0xFC, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x7F, 0x00, 0x00, 0x07,
  0xE7, 0xF8, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0x7E, 0x00, 0x3F, 0x07, 0xF8, 0xFC, 0x00, 0xFC, 0x3F, 0xC3,
  0xF8, 0x03, 0xE0, 0xFE, 0x07, 0xE0, 0x1F, 0x87, 0xF0, 0x1F, 0xC0, 0x7E,
  0x3F, 0x80, 0x3F, 0x03, 0xF0, 0xFC, 0x00, 0xFE, 0x0F, 0x87, 0xE0, 0x01,
  0xF8, 0x7E, 0x1F, 0x80, 0x07, 0xF3, 0xF0, 0x7E, 0x00, 0x0F, 0xFF, 0xC3,
  0xF0, 0x00, 0x1F, 0xFE, 0x0F, 0xC0, 0x00, 0x7F, 0xF0, 0x3F, 0x00, 0x00,
  0xFF, 0xC0, 0xFC, 0x00, 0x03, 0xFE, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0x1F, 0x80, 0x01, 0xFF, 0x80, 0x7F, 0x00, 0x1F,
  0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFE, 0x1F, 0xFB, 0xF8, 0x0F,
  0xFF, 0xFF, 0x8F, 0xE0, 0x1F, 0xFF, 0xFC, 0x1F, 0xC0, 0x3F, 0xFF, 0xC0,
  0x7F, 0x00, 0x3F, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0xC7, 0xE1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x20, 0x07, 0xC0, 0x07, 0x80, 0x78, 0x00, 0x7E, 0x07,
  0x80, 0x07, 0xF8, 0x78, 0x00, 0xFF, 0xE7, 0x80, 0x07, 0xFF, 0xF0, 0x3F,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xBC, 0x00, 0x01, 0xF3, 0xC0,
  0x00, 0x3E, 0x3E, 0x00, 0x0F, 0xE3, 0xE0, 0x01, 0xFC, 0x1F, 0x00, 0x3F,
  0x81, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x00, 0xF8, 0x00, 0xE0, 0x0F,
  0xC0, 0x04, 0x00, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03,
  0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF0, 0x3F, 0x7F, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x38, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF8,
  0x0F, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x1F,
  0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x1F, 0x8F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x01,
  0xFC, 0xFC, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xFC,
  0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x07, 0xFF,
  0xC0, 0xFF, 0xFC, 0x1F, 0xEF, 0xC7, 0xFC, 0xFC, 0xFF, 0x8F, 0xC7, 0xE1,
  0xF8, 0x7C, 0x1F, 0x83, 0x01, 0xF8, 0x20, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x78, 0x00, 0x7F, 0x00, 0x0C,
  0x00, 0x1F, 0xC0, 0x02, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xEF,
  0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x78, 0x00, 0x7F, 0x00, 0x20, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x80, 0x00, 0x1F, 0xC0, 0xC0, 0x00, 0x3F,
  0xC0, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0xCF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xBE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x03, 0xF0, 0xF8, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x01, 0xF0,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01,
  0xF0, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x20, 0x00, 0x07, 0xF8, 0x18, 0x00, 0x07, 0xF8, 0x0F, 0x80, 0x0F,
  0xF8, 0x07, 0xFC, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0x3E, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x20, 0x00, 0x1F,
  0x83, 0xFE, 0x00, 0x1F, 0x8F, 0xFF, 0x80, 0x1F, 0x3F, 0xFF, 0xC0, 0x3F,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xE0, 0x3F,
  0xE0, 0x07, 0xF0, 0x7F, 0xC0, 0x03, 0xF0, 0x7F, 0x80, 0x03, 0xF0, 0x7F,
  0x00, 0x03, 0xF0, 0x7F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x07, 0xE0, 0x7C, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x7F, 0xE3, 0xFE, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0xFC, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0x80, 0x0F,
  0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xE0, 0x3F,
  0x00, 0x07, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xE0, 0x7F,
  0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE1, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x80, 0x1F, 0xFD, 0xFF, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80,
  0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0x80, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xF8,
  0x3F, 0xC0, 0x7F, 0xF0, 0x3F, 0xF7, 0xF7, 0xE0, 0x7F, 0xFF, 0xDF, 0x80,
  0x7F, 0xFF, 0x3F, 0x00, 0x7F, 0xFC, 0x7E, 0x00, 0x3F, 0xE0, 0xF8, 0x00,
  0x04, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x10, 0x00, 0xFF, 0x00, 0x3F, 0xBF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x1F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x03,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3C,
  0x01, 0xFC, 0x18, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x03,
  0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0x07, 0xC0, 0x07, 0xFF, 0xF0, 0x1F, 0x0F,
  0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0x0F, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0x1F,
  0x00, 0x3F, 0x01, 0xF0, 0x1F, 0x1F, 0x00, 0x7E, 0x03, 0xE0, 0x1F, 0x1F,
  0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x3E, 0x01, 0xF8, 0x03, 0xE0, 0x1F, 0x3E,
  0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x7C,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x7C,
  0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0xF8,
  0x0F, 0x80, 0x0F, 0x80, 0x3E, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0xF8,
  0x0F, 0x80, 0x1F, 0x00, 0x7C, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0xF8,
  0x0F, 0x80, 0x3F, 0x00, 0x7C, 0xF8, 0x0F, 0x80, 0x3F, 0x00, 0xF8, 0xF8,
  0x0F, 0x80, 0x7F, 0x00, 0xF8, 0xF8, 0x0F, 0x80, 0x7F, 0x01, 0xF0, 0xF8,
  0x0F, 0x80, 0xFF, 0x03, 0xE0, 0xF8, 0x0F, 0xC1, 0xEF, 0x87, 0xE0, 0xF8,
  0x07, 0xFF, 0xCF, 0xFF, 0xC0, 0xF8, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0xF8,
  0x03, 0xFF, 0x07, 0xFF, 0x00, 0x7C, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00,
  0x0F, 0xDF, 0x00, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x7E, 0x7C, 0x00,
  0x00, 0x0F, 0xCF, 0x80, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x00,
  0x01, 0xF8, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x0F,
  0x80, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x3F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xFC, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x01,
  0xFB, 0xF8, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0x80, 0x07, 0xF8, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7F,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00,
  0xFE, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x1F, 0xF0, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x7F, 0xE0,
  0x03, 0xF0, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x01,
  0xFC, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x03, 0xF8, 0x0F, 0xC0,
  0x00, 0x7F, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x01, 0xFC, 0x0F,
  0xC0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00,
  0xFE, 0x07, 0xE0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0x00,
  0x07, 0xFC, 0x07, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x03,
  0xC0, 0x07, 0xFC, 0x00, 0x08, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x40, 0x01, 0xFF, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01,
  0xF8, 0x0F, 0xFF, 0x00, 0x07, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0x80, 0x07,
  0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x7E,
  0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x7F, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x1F,
  0xC1, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x00, 0xFE,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x00, 0x7F, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0xFE, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0x00, 0x01,
  0xFE, 0x00, 0xFC, 0x00, 0x1F, 0xF0, 0x07, 0xE0, 0x00, 0xFF, 0x80, 0x1F,
  0x80, 0x0F, 0xFC, 0x00, 0x7E, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x10, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x7E, 0x00, 0x3F, 0xE0, 0x00, 0x1C, 0x00, 0xFF, 0x80, 0x00, 0x08, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x10, 0xFC, 0x00, 0x0F, 0xFF, 0xC1, 0xF8, 0x00,
  0x1F, 0xFF, 0x83, 0xF0, 0x00, 0x7F, 0xFF, 0x0F, 0xE0, 0x00, 0xFF, 0xFE,
  0x1F, 0xC0, 0x01, 0xFF, 0xFC, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x01, 0xFE, 0x00, 0x03,
  0xF0, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x02, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x7E, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x03,
  0xF0, 0xFE, 0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x00, 0x1F, 0x8F, 0xE0,
  0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x00,
  0xFD, 0xFC, 0x00, 0x00, 0x03, 0xF7, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xEF, 0xE0, 0x00, 0x00, 0xFF, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x01, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xBF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFD, 0xF0, 0x01,
  0xF3, 0xE0, 0x00, 0x07, 0xDF, 0x80, 0x0F, 0x9F, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0xFC, 0xF8, 0x00, 0x03, 0xE7, 0xE0, 0x07, 0xE7, 0xC0, 0x00, 0x3F,
  0x3F, 0x00, 0x3F, 0x3E, 0x00, 0x01, 0xF3, 0xF0, 0x01, 0xF9, 0xF0, 0x00,
  0x1F, 0x9F, 0x80, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xFC, 0x00, 0xFC, 0x7C,
  0x00, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x3F,
  0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80,
  0x0F, 0x83, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x1F, 0x00, 0x3F, 0x07,
  0xE0, 0x07, 0xE0, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x3F, 0x07, 0xC0, 0x1F,
  0x83, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x81, 0xF0,
  0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x07, 0xE0,
  0x7C, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xF0, 0x01,
  0xF0, 0x1F, 0x83, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x1F, 0x00, 0xFC,
  0x00, 0xFC, 0x03, 0xE1, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x0F, 0x80,
  0x7E, 0x00, 0x3F, 0x00, 0xF8, 0xFC, 0x03, 0xF0, 0x01, 0xF0, 0x07, 0xC7,
  0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3E, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xF3, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xBF, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x7D, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0xE0,
  0x03, 0xF0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x1F,
  0xE0, 0x00, 0x03, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0x80, 0x1F, 0xF8, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x00, 0x00,
  0x7E, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0xFE, 0x00, 0x01, 0xF0,
  0x03, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0xC0, 0x0F,
  0x9F, 0x80, 0x01, 0xF8, 0x03, 0xF3, 0xF0, 0x00, 0x3E, 0x00, 0x7E, 0x3E,
  0x00, 0x0F, 0xC0, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0x01, 0xF0, 0xFC, 0x00,
  0x3F, 0x00, 0x3E, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xC1, 0xF0, 0x00, 0xF8,
  0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x01,
  0xF8, 0x03, 0xE0, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF0,
  0x1F, 0x80, 0x1F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x7C,
  0x00, 0xFC, 0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7C, 0x00, 0x3E, 0x0F, 0xC0, 0x1F, 0x80,
  0x07, 0xE1, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x00, 0x0F,
  0x8F, 0xC0, 0x0F, 0xC0, 0x01, 0xF9, 0xF8, 0x01, 0xF0, 0x00, 0x3F, 0x3F,
  0x00, 0x7E, 0x00, 0x07, 0xE7, 0xC0, 0x0F, 0xC0, 0x00, 0x7C, 0xF8, 0x01,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xC0,
  0x00, 0x1F, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0xE0, 0x07, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x3F, 0x80,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x03,
  0xF3, 0xF8, 0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x00,
  0xFE, 0xFC, 0x00, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x03, 0xF7, 0xF0,
  0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0xFC,
  0x00, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x00,
  0x1F, 0xC7, 0xE0, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x00, 0x7E, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F,
  0x81, 0xFF, 0xC0, 0x07, 0xE0, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x3F,
  0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x0F, 0xF8, 0x07, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00,
  0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x03, 0xF3,
  0xF8, 0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x03, 0xF7, 0xF0, 0x00,
  0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00, 0x3F,
  0xBF, 0x80, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x00, 0x7E, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0x81, 0xFF, 0xE0, 0x07, 0xE0, 0x07, 0xF8,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x07,
  0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3F,
  0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0x00, 0x1F, 0xE0, 0x1F, 0x80, 0x3F, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x0F, 0xC0, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x01, 0xFC, 0x07, 0xE0, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFC, 0x01, 0xF0, 0x03, 0xFC, 0x00,
  0x1C, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x02, 0x00, 0x00, 0x7F, 0x80, 0xE0, 0x00,
  0x3F, 0xC0, 0x3E, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x3F, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x01, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x1F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFE, 0x0F, 0xC0,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xF8,
  0x3F, 0x80, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x03, 0xE1, 0xFC, 0x00, 0x00,
  0x7C, 0x3F, 0x00, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x01, 0xF1, 0xF8, 0x00,
  0x00, 0x3E, 0x3F, 0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x00, 0x7D,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x01,
  0xFF, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x01, 0xF7, 0xC0, 0x01, 0xF8,
  0x3F, 0x00, 0x07, 0xDF, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x7C, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0xF9, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE7,
  0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x7C, 0x7C, 0x00, 0xFE, 0x03, 0xF0, 0x03, 0xE1, 0xF0, 0x03, 0xF0, 0x0F,
  0xC0, 0x0F, 0x87, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x1F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF0, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC1, 0xF0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x3E, 0x07, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0xF8,
  0x1F, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x03, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0xFC, 0x00,
  0x3F, 0x03, 0xE0, 0x1F, 0x03, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x7C, 0x1F,
  0x80, 0x03, 0xF0, 0x7C, 0x01, 0xF0, 0x7E, 0x00, 0x07, 0xC3, 0xF0, 0x07,
  0xC1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0xC0, 0x00, 0x7C, 0x3E,
  0x00, 0x7C, 0x3F, 0x00, 0x01, 0xF1, 0xF8, 0x01, 0xF1, 0xF8, 0x00, 0x07,
  0xC7, 0xC0, 0x07, 0xC7, 0xE0, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x1F, 0x00,
  0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xFC, 0x00, 0x01, 0xF3, 0xE0, 0x01, 0xF3,
  0xE0, 0x00, 0x07, 0xDF, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F, 0x7C, 0x00,
  0x1F, 0x7E, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0x3E, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x8F, 0x80, 0x00,
  0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0x80,
  0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x01, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF8, 0x3E,
  0x00, 0x07, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xE0, 0x3F,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0x3F, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x0F, 0x81, 0xFC, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07,
  0xCF, 0xE0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00,
  0x3E, 0x3E, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x01,
  0xF0, 0x0F, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x0F,
  0x80, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x7E,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3F, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x1F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x3F,
  0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0xF8,
  0x1F, 0x00, 0x1F, 0xFC, 0x1F, 0x00, 0x7F, 0xFE, 0x1F, 0x00, 0xFF, 0xFF,
  0x3F, 0x01, 0xFF, 0xFF, 0xBE, 0x03, 0xFE, 0x0F, 0xBE, 0x03, 0xF8, 0x03,
  0xFE, 0x07, 0xF0, 0x03, 0xFE, 0x0F, 0xE0, 0x01, 0xFE, 0x0F, 0xE0, 0x01,
  0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01,
  0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03,
  0xF0, 0xFE, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x7F,
  0xC0, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0x01, 0xEF, 0x80, 0x7F, 0xCF, 0xEF,
  0x80, 0x7F, 0xFF, 0xCF, 0x80, 0x3F, 0xFF, 0x8F, 0x80, 0x1F, 0xFE, 0x0F,
  0x80, 0x0F, 0xFC, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x1F, 0xC0, 0x00, 0xFC, 0x3F, 0xF8, 0x00, 0x7E, 0x3F, 0xFE, 0x00,
  0x7E, 0x7F, 0xFF, 0x80, 0x3F, 0x7F, 0xFF, 0xC0, 0x1F, 0xBE, 0x0F, 0xF0,
  0x0F, 0xBC, 0x03, 0xF8, 0x07, 0xFC, 0x00, 0xFC, 0x07, 0xFC, 0x00, 0x7E,
  0x03, 0xFC, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x07,
  0xE0, 0x7F, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x3F, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x3F, 0x80, 0xFF,
  0xC0, 0x3F, 0xC0, 0x7F, 0xFC, 0xFF, 0xC0, 0x3E, 0x7F, 0xFF, 0xC0, 0x1F,
  0x1F, 0xFF, 0xC0, 0x1F, 0x07, 0xFF, 0xC0, 0x0F, 0x81, 0xFF, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0xE0,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x38, 0x0F, 0xF8, 0x7E, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x1F, 0xFC,
  0x3F, 0x00, 0x0F, 0xFF, 0xC7, 0xE0, 0x03, 0xFF, 0xFC, 0xF8, 0x00, 0xFF,
  0xFF, 0xDF, 0x00, 0x3F, 0xE0, 0x7B, 0xE0, 0x07, 0xF0, 0x07, 0xFC, 0x01,
  0xFC, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00,
  0xFE, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0xC0,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0x80,
  0x03, 0xFC, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x0F,
  0xC0, 0x07, 0xFC, 0x01, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x3F, 0xF0,
  0x03, 0xF8, 0x0F, 0x7C, 0x00, 0x7F, 0xCF, 0xCF, 0x80, 0x0F, 0xFF, 0xF1,
  0xF0, 0x00, 0xFF, 0xFC, 0x3E, 0x00, 0x0F, 0xFF, 0x07, 0x80, 0x00, 0xFF,
  0xC1, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x07, 0xF8, 0x1F, 0xC1, 0xFE, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x0F,
  0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03,
  0xF3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE3, 0xF0,
  0x07, 0xFC, 0x7E, 0x0F, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x20, 0x7F, 0x80, 0x1C, 0x07,
  0xFC, 0x1F, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xDE, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x08, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x07, 0xC0, 0x01, 0xFF, 0xC1,
  0xF0, 0x01, 0xFF, 0xF8, 0x7C, 0x00, 0xFF, 0xFF, 0x3F, 0x00, 0x7F, 0xFF,
  0xEF, 0x80, 0x3F, 0xE0, 0x7B, 0xE0, 0x0F, 0xE0, 0x0F, 0xF8, 0x07, 0xF0,
  0x03, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x07, 0xF0, 0x1F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F,
  0xC0, 0xFE, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x7F, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x03, 0xF8, 0x0F, 0xC0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0xFC,
  0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x0F, 0xF0, 0x0F, 0xC0, 0x07, 0xFC, 0x03,
  0xF0, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xC0, 0xFB, 0xE0,
  0x07, 0xFC, 0xFC, 0xF8, 0x01, 0xFF, 0xFE, 0x7E, 0x00, 0x3F, 0xFF, 0x1F,
  0x80, 0x07, 0xFF, 0x87, 0xE0, 0x00, 0xFF, 0xC1, 0xF0, 0x00, 0x07, 0x80,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x02,
  0x00, 0x03, 0xF8, 0x00, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0x83, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x0F, 0xE0, 0x00, 0xFC, 0x3F, 0xF8, 0x00, 0xF8, 0xFF, 0xFC, 0x00, 0xF9,
  0xFF, 0xFE, 0x01, 0xFB, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0x01, 0xF7,
  0x80, 0x7F, 0x01, 0xFF, 0x00, 0x3F, 0x01, 0xFE, 0x00, 0x3F, 0x03, 0xFC,
  0x00, 0x3F, 0x03, 0xF8, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x3F, 0x07, 0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0xFC, 0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80,
  0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00,
  0x01, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x7C, 0x00,
  0x07, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x04, 0x00, 0x0F, 0x80, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x04, 0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x7F, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x3F,
  0x80, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x7C, 0x3F, 0x80, 0x00, 0x7E, 0x3F,
  0x80, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x0F, 0x9F,
  0x80, 0x00, 0x07, 0xDF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0x7E, 0x00, 0x00, 0xFF, 0x3F, 0x00, 0x00, 0xFF,
  0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F,
  0x81, 0xFC, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x07,
  0xE0, 0x1F, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x00,
  0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x03, 0xF8,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0xF8,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3E, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0x0F,
  0x8F, 0xFF, 0x81, 0xFF, 0xF8, 0x03, 0xE7, 0xFF, 0xF0, 0xFF, 0xFE, 0x01,
  0xFB, 0xFF, 0xFC, 0x7F, 0xFF, 0xC0, 0x7D, 0xF8, 0x3F, 0xBF, 0x07, 0xF0,
  0x1F, 0x78, 0x07, 0xFF, 0x00, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x1F, 0xF0,
  0x00, 0xF8, 0x7F, 0xF8, 0x00, 0xF8, 0xFF, 0xFC, 0x01, 0xF9, 0xFF, 0xFE,
  0x01, 0xFB, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0x01, 0xF7, 0x80, 0x7F,
  0x01, 0xFF, 0x00, 0x3F, 0x03, 0xFE, 0x00, 0x3F, 0x03, 0xFC, 0x00, 0x3F,
  0x03, 0xFC, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x3F, 0x07, 0xF8, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC,
  0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8,
  0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF8,
  0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0,
  0x7F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xE0,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xF8, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0x01, 0xFC, 0x00, 0xFE, 0x0F, 0xE0,
  0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x03,
  0xF8, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8,
  0x1F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x9F, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x01, 0xFC, 0x00,
  0x01, 0xF0, 0x7F, 0xF0, 0x00, 0x1F, 0x0F, 0xFF, 0x80, 0x01, 0xF3, 0xFF,
  0xFC, 0x00, 0x3F, 0x7F, 0xFF, 0xC0, 0x03, 0xE7, 0xC1, 0xFE, 0x00, 0x3E,
  0xF0, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x07, 0xE0,
  0x07, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x3F, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x03,
  0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xFC, 0x03, 0xFC, 0x00,
  0xFD, 0xF9, 0xFF, 0x80, 0x0F, 0xDF, 0xFF, 0xF0, 0x00, 0xFC, 0xFF, 0xFE,
  0x00, 0x0F, 0x87, 0xFF, 0xC0, 0x01, 0xF8, 0x3F, 0xF0, 0x00, 0x1F, 0x80,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0x00, 0x1F, 0xFC, 0x1F, 0x00,
  0x7F, 0xFE, 0x1F, 0x00, 0xFF, 0xFF, 0x3F, 0x01, 0xFF, 0xFF, 0xBE, 0x03,
  0xFE, 0x0F, 0xBE, 0x03, 0xF8, 0x03, 0xFE, 0x07, 0xF0, 0x03, 0xFE, 0x0F,
  0xE0, 0x01, 0xFC, 0x0F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F,
  0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x01, 0xF8, 0x7F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0xC0, 0xFC,
  0x00, 0x7F, 0xC0, 0xFC, 0x00, 0x7F, 0xC0, 0xFE, 0x00, 0xFF, 0xC0, 0xFF,
  0x03, 0xEF, 0x80, 0x7F, 0xCF, 0xDF, 0x80, 0x7F, 0xFF, 0xDF, 0x80, 0x3F,
  0xFF, 0x1F, 0x80, 0x1F, 0xFE, 0x1F, 0x80, 0x0F, 0xFC, 0x3F, 0x00, 0x01,
  0xE0, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0xC0, 0x3E,
  0x1F, 0xF0, 0x0F, 0x8F, 0xFC, 0x03, 0xE7, 0xFE, 0x01, 0xF3, 0xFF, 0x80,
  0x7C, 0xFE, 0x60, 0x1F, 0x7C, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xF0, 0x0F, 0x01, 0xFC, 0x00, 0x20, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x04, 0x00, 0x0F, 0xE0, 0xE0,
  0x03, 0xFC, 0x1F, 0xC1, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0xF1, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF1, 0x80, 0x7F, 0xF8, 0x07, 0xFF,
  0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x03, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3E, 0x07, 0xE0, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x01,
  0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01,
  0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x7F, 0xC0, 0xFC, 0x00, 0x7F,
  0x80, 0xFC, 0x00, 0xFF, 0x80, 0xFE, 0x03, 0xEF, 0x80, 0x7F, 0x9F, 0xCF,
  0x80, 0x7F, 0xFF, 0x9F, 0x80, 0x7F, 0xFF, 0x1F, 0x00, 0x3F, 0xFE, 0x1F,
  0x00, 0x0F, 0xF8, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x80,
  0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x7E, 0x01,
  0xF0, 0x03, 0xF0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0,
  0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7E,
  0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x3E, 0x1F, 0x80, 0x01, 0xF1, 0xF8, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x7C,
  0xFC, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0xFB, 0xF0,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7F, 0x80,
  0x0F, 0xEF, 0xC0, 0x07, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0xE0, 0x03,
  0xF3, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0xF8, 0x01, 0xF8,
  0xFC, 0x00, 0xF7, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xBE, 0x00, 0xFC, 0x3F,
  0x00, 0x7D, 0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xCF, 0x80, 0x7E, 0x0F, 0xC0,
  0x3E, 0x7C, 0x03, 0xF0, 0x7E, 0x03, 0xE3, 0xE0, 0x3F, 0x03, 0xF0, 0x1F,
  0x1F, 0x01, 0xF8, 0x1F, 0x80, 0xF8, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0x87,
  0xC0, 0xFC, 0x07, 0xE0, 0x7C, 0x3E, 0x07, 0xC0, 0x3F, 0x07, 0xC1, 0xF0,
  0x7E, 0x01, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0x0F, 0xC3, 0xE0, 0x7C, 0x3F,
  0x00, 0x3E, 0x1F, 0x03, 0xE1, 0xF8, 0x01, 0xF1, 0xF0, 0x1F, 0x0F, 0x80,
  0x0F, 0x8F, 0x80, 0xF8, 0xFC, 0x00, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x03,
  0xE7, 0xC0, 0x3E, 0x7E, 0x00, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x00, 0xFB,
  0xE0, 0x0F, 0x9F, 0x00, 0x07, 0xDF, 0x00, 0x7D, 0xF8, 0x00, 0x3E, 0xF0,
  0x03, 0xEF, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xFC, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x3F, 0x80, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xBE, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00,
  0x7E, 0x0F, 0x80, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0xFC, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x0F, 0xE0, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x03, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0x07, 0xC1,
  0xF8, 0x00, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x43, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x02, 0x7F, 0xFC, 0x00, 0x0D, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xB8, 0x00, 0xFF, 0xFE, 0x60, 0x00, 0x7F, 0xF8, 0x80, 0x00,
  0x0F, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_Italic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 18, 51, 18, 1, -50 },
  { 116, 21, 18, 26, 7, -50 },
  { 164, 39, 50, 39, 1, -50 },
  { 408, 32, 57, 34, 2, -53 },
  { 636, 43, 52, 51, 5, -51 },
  { 916, 38, 52, 41, 1, -51 },
  { 1163, 10, 18, 15, 7, -50 },
  { 1186, 23, 61, 19, 2, -50 },
  { 1362, 22, 61, 19, -5, -50 },
  { 1530, 28, 29, 34, 7, -53 },
  { 1632, 30, 33, 36, 4, -41 },
  { 1756, 13, 17, 17, -3, -8 },
  { 1784, 17, 6, 21, 2, -22 },
  { 1797, 8, 9, 17, 1, -8 },
  { 1806, 33, 50, 24, -3, -50 },
  { 2013, 31, 52, 34, 3, -51 },
  { 2215, 20, 50, 34, 9, -50 },
  { 2340, 34, 51, 34, -1, -51 },
  { 2557, 32, 52, 34, 1, -51 },
  { 2765, 33, 50, 34, 0, -50 },
  { 2972, 33, 51, 34, 1, -50 },
  { 3183, 32, 52, 34, 3, -51 },
  { 3391, 32, 50, 34, 4, -50 },
  { 3591, 32, 52, 34, 2, -51 },
  { 3799, 31, 52, 34, 2, -51 },
  { 4001, 14, 39, 17, 1, -38 },
  { 4070, 18, 47, 17, -3, -38 },
  { 4176, 31, 33, 36, 4, -42 },
  { 4304, 30, 19, 36, 4, -34 },
  { 4376, 31, 33, 36, 4, -42 },
  { 4504, 25, 52, 26, 4, -51 },
  { 4667, 48, 56, 53, 3, -50 },
  { 5003, 35, 50, 35, -4, -50 },
  { 5222, 35, 50, 38, 2, -50 },
  { 5441, 36, 52, 36, 4, -51 },
  { 5675, 38, 50, 42, 2, -50 },
  { 5913, 33, 50, 32, 2, -50 },
  { 6120, 33, 50, 30, 2, -50 },
  { 6327, 39, 52, 43, 4, -51 },
  { 6581, 41, 50, 43, 2, -50 },
  { 6838, 27, 50, 21, -2, -50 },
  { 7007, 29, 63, 17, -11, -50 },
  { 7236, 39, 50, 35, 2, -50 },
  { 7480, 24, 50, 30, 2, -50 },
  { 7630, 53, 50, 54, 2, -50 },
  { 7962, 43, 50, 45, 2, -50 },
  { 8231, 39, 52, 45, 4, -51 },
  { 8485, 34, 50, 35, 2, -50 },
  { 8698, 39, 63, 45, 4, -51 },
  { 9006, 34, 50, 36, 2, -50 },
  { 9219, 34, 52, 32, 0, -51 },
  { 9440, 31, 50, 31, 6, -50 },
  { 9634, 39, 51, 42, 4, -50 },
  { 9883, 35, 50, 35, 6, -50 },
  { 10102, 54, 50, 55, 7, -50 },
  { 10440, 42, 50, 33, -4, -50 },
  { 10703, 32, 50, 32, 6, -50 },
  { 10903, 37, 50, 32, -1, -50 },
  { 11135, 26, 61, 20, -1, -50 },
  { 11334, 13, 50, 25, 7, -50 },
  { 11416, 26, 61, 20, -5, -50 },
  { 11615, 32, 30, 36, 2, -50 },
  { 11735, 26, 5, 25, -6, 6 },
  { 11752, 11, 12, 19, 10, -54 },
  { 11769, 32, 39, 36, 3, -38 },
  { 11925, 33, 54, 36, 1, -53 },
  { 12148, 26, 39, 28, 3, -38 },
  { 12275, 35, 54, 36, 3, -53 },
  { 12512, 27, 39, 32, 3, -38 },
  { 12644, 36, 71, 20, -8, -54 },
  { 12964, 34, 55, 37, 1, -38 },
  { 13198, 32, 53, 36, 1, -53 },
  { 13410, 17, 52, 16, 1, -52 },
  { 13521, 27, 69, 16, -9, -52 },
  { 13754, 33, 53, 31, 1, -53 },
  { 13973, 17, 53, 16, 1, -53 },
  { 14086, 50, 38, 55, 1, -38 },
  { 14324, 32, 38, 36, 1, -38 },
  { 14476, 30, 39, 35, 3, -38 },
  { 14623, 36, 55, 36, -2, -38 },
  { 14871, 32, 55, 36, 3, -38 },
  { 15091, 26, 38, 25, 1, -38 },
  { 15215, 27, 39, 27, 0, -38 },
  { 15347, 20, 47, 21, 3, -46 },
  { 15465, 32, 39, 36, 3, -38 },
  { 15621, 29, 38, 29, 4, -38 },
  { 15759, 45, 38, 46, 4, -38 },
  { 15973, 35, 38, 30, -3, -38 },
  { 16140, 40, 55, 29, -7, -38 },
  { 16415, 30, 38, 27, -2, -38 },
  { 16558, 27, 61, 24, 1, -50 },
  { 16764, 5, 70, 34, 15, -53 },
  { 16808, 26, 61, 24, -3, -50 },
  { 17007, 31, 9, 36, 4, -29 },
};

const GFXfont NotoSans_SemiCondensed_Italic70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic70pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC70PT7B_H_
