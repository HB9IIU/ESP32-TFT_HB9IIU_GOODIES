#ifndef _NOTOSANS_SEMICONDENSED_ITALIC51PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0,
  0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x06,
  0x00, 0x00, 0x3E, 0x1E, 0x78, 0x7C, 0xF0, 0xF9, 0xE1, 0xE3, 0xC3, 0xCF,
  0x07, 0x9E, 0x0E, 0x3C, 0x3C, 0x70, 0x78, 0xE0, 0xF1, 0xC1, 0xC3, 0x83,
  0x8E, 0x07, 0x00, 0x00, 0x07, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0F,
  0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x07, 0x80, 0x01, 0xE0, 0x70,
  0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03,
  0x80, 0xE0, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xF0, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x3C, 0x00, 0x0F, 0x03, 0x80, 0x00,
  0xE0, 0x38, 0x00, 0x0E, 0x07, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x1E, 0x07,
  0x00, 0x01, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x80, 0x78, 0x1C, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x70, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x38, 0x00,
  0x0E, 0x07, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xF7, 0x3E,
  0x07, 0xC7, 0x04, 0x07, 0x87, 0x00, 0x07, 0x87, 0x00, 0x07, 0x0E, 0x00,
  0x0F, 0x0E, 0x00, 0x0F, 0x0E, 0x00, 0x07, 0x8E, 0x00, 0x07, 0xCC, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3B, 0xF0, 0x00, 0x39, 0xF0,
  0x00, 0x38, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0x70, 0xF0,
  0x00, 0x70, 0xF0, 0x00, 0x71, 0xF0, 0xC0, 0xE3, 0xE0, 0xF8, 0xEF, 0xC0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3C, 0x07,
  0xFC, 0x00, 0x78, 0x0F, 0x3E, 0x00, 0xF0, 0x1E, 0x1E, 0x00, 0xF0, 0x1C,
  0x1E, 0x01, 0xE0, 0x3C, 0x0E, 0x03, 0xC0, 0x3C, 0x0E, 0x03, 0xC0, 0x38,
  0x1E, 0x07, 0x80, 0x78, 0x1E, 0x07, 0x00, 0x78, 0x1E, 0x0F, 0x00, 0x70,
  0x1C, 0x1E, 0x00, 0x70, 0x1C, 0x1C, 0x00, 0x70, 0x1C, 0x3C, 0x00, 0x70,
  0x3C, 0x78, 0x00, 0xF0, 0x38, 0x70, 0xFC, 0xF0, 0x78, 0xF3, 0xFE, 0x70,
  0x79, 0xE7, 0xFE, 0x70, 0xF1, 0xC7, 0x8F, 0x79, 0xE3, 0xCF, 0x0F, 0x7F,
  0xE7, 0x8E, 0x07, 0x3F, 0xC7, 0x1E, 0x07, 0x0F, 0x0F, 0x1C, 0x07, 0x00,
  0x1E, 0x1C, 0x0F, 0x00, 0x1C, 0x3C, 0x0F, 0x00, 0x3C, 0x3C, 0x0F, 0x00,
  0x78, 0x38, 0x0F, 0x00, 0x70, 0x38, 0x0E, 0x00, 0xF0, 0x38, 0x1E, 0x01,
  0xE0, 0x38, 0x1E, 0x01, 0xC0, 0x38, 0x1C, 0x03, 0xC0, 0x38, 0x3C, 0x07,
  0x80, 0x38, 0x38, 0x07, 0x00, 0x3C, 0x78, 0x0F, 0x00, 0x3F, 0xF0, 0x1E,
  0x00, 0x1F, 0xE0, 0x3C, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x0F, 0x03, 0xE0, 0x01, 0xE0, 0x1E, 0x00,
  0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x3E, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0,
  0x7C, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x1F, 0x3F, 0x00,
  0x00, 0xF7, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0x0F, 0x9F, 0x01,
  0xE1, 0xF0, 0xF0, 0x1E, 0x3E, 0x0F, 0x83, 0xC7, 0xC0, 0x78, 0x3C, 0x78,
  0x07, 0xC7, 0x8F, 0x80, 0x3E, 0xF8, 0xF0, 0x03, 0xEF, 0x0F, 0x00, 0x1F,
  0xF0, 0xF0, 0x01, 0xFE, 0x0F, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0xF8, 0x0F,
  0x80, 0x1F, 0xC0, 0xFC, 0x07, 0xFE, 0x07, 0xE1, 0xFF, 0xE0, 0x7F, 0xFF,
  0x9F, 0x03, 0xFF, 0xE0, 0xF8, 0x0F, 0xF8, 0x0F, 0x80, 0x08, 0x00, 0x00,
  0x3E, 0x7C, 0xF1, 0xE3, 0xCF, 0x1E, 0x3C, 0x78, 0xE1, 0xC3, 0x8E, 0x00,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x30, 0x1C, 0x01, 0xE1, 0xE0, 0x0F, 0xCE, 0x00, 0xFF, 0xF0, 0x18,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0x80, 0x03, 0xDC,
  0x00, 0x3E, 0xF0, 0x03, 0xE3, 0x80, 0x3E, 0x1E, 0x03, 0xE0, 0xF0, 0x07,
  0x03, 0xC0, 0x10, 0x1E, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x07, 0x87, 0xC3, 0xE3, 0xE1, 0xF0, 0xF0, 0xF8, 0x78, 0x3C,
  0x3C, 0x1C, 0x1E, 0x0E, 0x00, 0x7F, 0xFB, 0xFF, 0xBF, 0xFD, 0xFF, 0xE0,
  0x79, 0xFF, 0xFF, 0xFB, 0xE2, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xC0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0x0F, 0xC0, 0x7C, 0x0F, 0x81,
  0xF0, 0x0F, 0x03, 0xC0, 0x1E, 0x0F, 0x80, 0x3C, 0x1E, 0x00, 0x7C, 0x7C,
  0x00, 0xF8, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xC7, 0xC0, 0x07, 0x8F, 0x00,
  0x0F, 0x1E, 0x00, 0x1E, 0x7C, 0x00, 0x3C, 0xF8, 0x00, 0x79, 0xE0, 0x01,
  0xF3, 0xC0, 0x03, 0xE7, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x3E, 0x00, 0x1E,
  0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF1, 0xF0, 0x01, 0xE3, 0xE0, 0x07, 0xC7,
  0xC0, 0x0F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x1E, 0x01, 0xF0, 0x3C,
  0x03, 0xC0, 0x7C, 0x0F, 0x80, 0x7E, 0x7E, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x7C, 0x07, 0xF0,
  0x3F, 0x81, 0xFE, 0x1F, 0xF8, 0xFD, 0xEF, 0xEF, 0xBE, 0x3C, 0xF0, 0xF1,
  0x87, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x0F, 0x81, 0xF8, 0x07, 0x00, 0x7C, 0x01, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xF0, 0x3F, 0x01, 0xC0,
  0x1F, 0x01, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x80, 0x01, 0xF0, 0xC0, 0x03, 0xE0, 0xFC, 0x1F,
  0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xDE, 0x00, 0x07, 0x9E, 0x00, 0x07, 0xBE, 0x00, 0x0F, 0x3C, 0x00, 0x1E,
  0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x7C, 0x00, 0x78, 0x78, 0x00, 0xF0,
  0x78, 0x01, 0xE0, 0x78, 0x03, 0xE0, 0x78, 0x03, 0xC0, 0xF8, 0x07, 0x80,
  0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x3C, 0x01,
  0xF0, 0x78, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0x0F, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x80, 0x03,
  0xE0, 0xC0, 0x07, 0xE0, 0xF8, 0x3F, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x87, 0xC0, 0x1F, 0x3F, 0xE0, 0x3D, 0xFF, 0xE0, 0x7F, 0xFF, 0xE1, 0xFE,
  0x07, 0xC3, 0xF8, 0x07, 0x87, 0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00,
  0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0xF8, 0xF0, 0x01, 0xF3, 0xE0, 0x03,
  0xC7, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x3E, 0x1E, 0x00, 0x78,
  0x3E, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0x7E, 0x3F, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x1F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x1F, 0x03,
  0xC0, 0x1F, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x0F, 0x03,
  0xC0, 0x1F, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x7C, 0x01,
  0xF0, 0xF8, 0x01, 0xFB, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xE7, 0xE0, 0x1F, 0x83, 0xE0, 0x3E,
  0x01, 0xF0, 0x3C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x78, 0x00, 0x78, 0x78,
  0x00, 0x78, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0xF8,
  0x00, 0xF8, 0x78, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F,
  0x07, 0xC0, 0xF8, 0x07, 0x81, 0xE0, 0x0F, 0x87, 0xC0, 0x0F, 0x0F, 0x00,
  0x1E, 0x1E, 0x00, 0x3C, 0x7C, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x01,
  0xE3, 0xC0, 0x07, 0xC7, 0x80, 0x0F, 0x8F, 0x00, 0x1F, 0x1E, 0x00, 0x7E,
  0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xF0, 0x7E, 0x1F, 0xE0, 0xFF, 0xFB, 0xC0,
  0xFF, 0xEF, 0x80, 0xFF, 0x1E, 0x00, 0x30, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xC1, 0xFC,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x81, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x83, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0,
  0x60, 0x00, 0x00, 0x38, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xE0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01,
  0xC0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x83,
  0xFF, 0xF0, 0xFF, 0xFE, 0x3C, 0x0F, 0x84, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x60, 0x07, 0x87, 0x80, 0x7F,
  0xE0, 0x71, 0xE0, 0x1F, 0xFE, 0x0E, 0x3C, 0x0F, 0xEF, 0x81, 0xC7, 0x01,
  0xE0, 0xF0, 0x39, 0xE0, 0x78, 0x1E, 0x07, 0x38, 0x1E, 0x03, 0x80, 0xEF,
  0x03, 0x80, 0x70, 0x1D, 0xE0, 0xF0, 0x1E, 0x07, 0xB8, 0x1C, 0x03, 0xC0,
  0xF7, 0x07, 0x80, 0x70, 0x1F, 0xE0, 0xF0, 0x1E, 0x03, 0xBC, 0x1E, 0x03,
  0xC0, 0xF7, 0x83, 0x80, 0x78, 0x1E, 0xF0, 0x70, 0x1E, 0x03, 0x9E, 0x0E,
  0x03, 0xC0, 0xF3, 0xC1, 0xE0, 0xF8, 0x3C, 0x78, 0x3C, 0x3B, 0x87, 0x8F,
  0x07, 0xFE, 0x7F, 0xE1, 0xE0, 0x7F, 0xCF, 0xF8, 0x1C, 0x07, 0xE0, 0xFC,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x10, 0x00, 0x1F, 0x80, 0x0E, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x3C, 0x00,
  0x03, 0xCF, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x3C,
  0x00, 0x0F, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0xF0,
  0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x1F, 0x03, 0xC0, 0x07, 0x80, 0xF8, 0x03,
  0xE0, 0x3E, 0x00, 0xF0, 0x0F, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xF0, 0x01, 0xE0, 0x78, 0x00,
  0x78, 0x3E, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x87, 0xC0, 0x01, 0xE1, 0xE0,
  0x00, 0x78, 0xF8, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xC1, 0xFE, 0x01, 0xE0, 0x0F, 0xC0, 0x78,
  0x01, 0xF0, 0x1E, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x03, 0xE0, 0x03, 0xC0,
  0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x7C, 0x1F, 0x00, 0x1E, 0x07, 0xC0, 0x0F,
  0x81, 0xE0, 0x07, 0xC0, 0x78, 0x07, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3C, 0x03, 0xF0, 0x0F,
  0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0x7C,
  0x1E, 0x00, 0x1F, 0x07, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xE0, 0xF8, 0x00,
  0xF8, 0x3C, 0x00, 0x3E, 0x0F, 0x00, 0x1F, 0x87, 0xC0, 0x0F, 0xC1, 0xF0,
  0x07, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFE, 0x03, 0x80, 0x7E, 0x00, 0x40, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x20, 0x0F, 0xF9, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0x0F, 0xF8, 0x01, 0xE0, 0x0F,
  0xC0, 0x1E, 0x00, 0x7E, 0x01, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x03,
  0xE0, 0x01, 0xF0, 0x3C, 0x00, 0x1F, 0x03, 0xC0, 0x01, 0xF0, 0x7C, 0x00,
  0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xF0,
  0x78, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E,
  0x1F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x83, 0xC0, 0x01, 0xF0, 0x3C, 0x00, 0x3E,
  0x03, 0xC0, 0x07, 0xE0, 0x7C, 0x01, 0xFC, 0x07, 0xC0, 0x7F, 0x80, 0x7F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0xFE, 0x03, 0xE0, 0x1F, 0x80, 0x06, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF8, 0x01, 0xFF, 0xCF, 0x80, 0x1F, 0xF8, 0xF8, 0x01, 0xFF,
  0x8F, 0x80, 0x3F, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8,
  0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x0F, 0x80, 0x01,
  0xF0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x1E, 0x07,
  0xE0, 0x03, 0xE0, 0x3F, 0x00, 0x3E, 0x01, 0xFF, 0x3F, 0xC0, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x78, 0x07, 0xC0, 0x00, 0xF0,
  0x0F, 0x80, 0x03, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x07,
  0x80, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x7C,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x78, 0x03, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0x78, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xE0, 0x00,
  0x78, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C,
  0x03, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0xC0,
  0x3E, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x78, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x02, 0x1F, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xF8,
  0x07, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1E,
  0x00, 0xF8, 0x00, 0xF0, 0x0F, 0x80, 0x07, 0x80, 0xF8, 0x00, 0x7C, 0x0F,
  0x80, 0x03, 0xE0, 0xF8, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0xF0, 0xFC, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x1E,
  0x7C, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x9E, 0x00, 0x00, 0xF8, 0xF8, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x1E, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x1E,
  0x07, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x07,
  0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF8, 0x03, 0xC0, 0x07, 0xC0, 0x1E,
  0x00, 0x1E, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xE7,
  0xFF, 0xFB, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xE0,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0xF7, 0x80,
  0x01, 0xFE, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x03, 0xDE, 0x00, 0x0F, 0x78,
  0x07, 0xBC, 0x00, 0x3D, 0xF0, 0x0F, 0x78, 0x00, 0x7B, 0xE0, 0x3E, 0xF0,
  0x01, 0xE7, 0x80, 0x79, 0xE0, 0x07, 0xCF, 0x00, 0xF1, 0xC0, 0x0F, 0x1E,
  0x01, 0xE3, 0x80, 0x3E, 0x7C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x8F,
  0x01, 0xF1, 0xE0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x0F, 0x8F,
  0x80, 0x78, 0x78, 0x1E, 0x1F, 0x00, 0xF0, 0xF0, 0x78, 0x3C, 0x03, 0xE1,
  0xE0, 0xF0, 0x78, 0x07, 0x83, 0xC3, 0xC0, 0xF0, 0x0F, 0x07, 0x87, 0x83,
  0xE0, 0x1E, 0x07, 0x1E, 0x07, 0xC0, 0x7C, 0x0E, 0x3C, 0x0F, 0x00, 0xF0,
  0x1E, 0xF0, 0x1E, 0x01, 0xE0, 0x3D, 0xE0, 0x3C, 0x03, 0xC0, 0x7F, 0x80,
  0xF8, 0x07, 0x80, 0xFF, 0x01, 0xF0, 0x1F, 0x01, 0xFC, 0x03, 0xC0, 0x3C,
  0x03, 0xF8, 0x07, 0x80, 0x78, 0x07, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0xC0,
  0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x1F, 0x01, 0xFC, 0x00, 0x1E,
  0x01, 0xFC, 0x00, 0x1E, 0x01, 0xFC, 0x00, 0x1E, 0x01, 0xFE, 0x00, 0x1E,
  0x03, 0xDE, 0x00, 0x3E, 0x03, 0xDE, 0x00, 0x3C, 0x03, 0xDE, 0x00, 0x3C,
  0x03, 0xCF, 0x00, 0x3C, 0x03, 0xCF, 0x00, 0x7C, 0x07, 0xCF, 0x00, 0x7C,
  0x07, 0x8F, 0x80, 0x78, 0x07, 0x87, 0x80, 0x78, 0x07, 0x87, 0x80, 0x78,
  0x07, 0x87, 0xC0, 0xF8, 0x0F, 0x83, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0xF0,
  0x0F, 0x03, 0xC0, 0xF0, 0x0F, 0x01, 0xE0, 0xF0, 0x0F, 0x01, 0xE1, 0xF0,
  0x1F, 0x01, 0xE1, 0xE0, 0x1E, 0x01, 0xF1, 0xE0, 0x1E, 0x00, 0xF1, 0xE0,
  0x1E, 0x00, 0xF1, 0xE0, 0x3E, 0x00, 0xFB, 0xE0, 0x3C, 0x00, 0x7B, 0xC0,
  0x3C, 0x00, 0x7B, 0xC0, 0x3C, 0x00, 0x7B, 0xC0, 0x3C, 0x00, 0x3F, 0xC0,
  0x7C, 0x00, 0x3F, 0x80, 0x78, 0x00, 0x3F, 0x80, 0x78, 0x00, 0x3F, 0x80,
  0x78, 0x00, 0x1F, 0x80, 0x78, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x03,
  0xE0, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF1, 0xF8, 0x00, 0x1F, 0x1F,
  0x00, 0x01, 0xF1, 0xE0, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0xF3, 0xE0, 0x00,
  0x0F, 0x7C, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x0F, 0x7C, 0x00, 0x01, 0xF7,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E,
  0xF8, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x87, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x3E,
  0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3E,
  0x3F, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x7C, 0x07, 0x80, 0x3E, 0x07,
  0xC0, 0x0F, 0x03, 0xE0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0,
  0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x7C,
  0x0F, 0x00, 0x7E, 0x0F, 0x80, 0x7E, 0x07, 0xC0, 0xFE, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFC, 0x0F, 0xC0,
  0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x0F, 0x80,
  0x01, 0xF1, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x0F,
  0x3E, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0xF7, 0xC0,
  0x00, 0x0F, 0x7C, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1E, 0xF8,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xCF, 0x80, 0x00,
  0x7C, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x87,
  0x80, 0x01, 0xF0, 0x7C, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00,
  0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3E, 0x3F, 0xE0,
  0x1E, 0x01, 0xF8, 0x0F, 0x00, 0x7C, 0x07, 0x80, 0x3E, 0x07, 0xC0, 0x0F,
  0x03, 0xE0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0xF8, 0x01,
  0xF0, 0x7C, 0x00, 0xF8, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x7C, 0x0F, 0x00,
  0x7C, 0x0F, 0x80, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x1F, 0x00, 0x3C,
  0x0F, 0x80, 0x1E, 0x03, 0xC0, 0x0F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07,
  0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0,
  0xF8, 0x01, 0xE0, 0x78, 0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x1E, 0x00, 0x1E,
  0x1F, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xF8, 0x1E, 0x03, 0xF0, 0x02, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x80, 0x03, 0xE0, 0xE0, 0x07, 0xE0, 0xFE, 0x7F, 0xC0, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x1E,
  0x07, 0xC0, 0x00, 0xF0, 0x3E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x7C, 0x0F,
  0x00, 0x03, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF0, 0x3E, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1E,
  0x07, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x7C, 0x0F,
  0x00, 0x03, 0xC0, 0xF8, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF0, 0x3C, 0x00,
  0x0F, 0x81, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x1E,
  0x07, 0xC0, 0x00, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x78, 0x0F,
  0x80, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x01, 0xE0, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0x7F, 0xDF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xBC, 0x00, 0x07, 0x9E, 0x00, 0x07, 0xCF, 0x00, 0x03,
  0xC7, 0x80, 0x03, 0xE3, 0xC0, 0x01, 0xE1, 0xE0, 0x01, 0xF0, 0xF8, 0x00,
  0xF8, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x07, 0x80,
  0x3E, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x1F, 0x00, 0x78,
  0x0F, 0x80, 0x3C, 0x07, 0x80, 0x1E, 0x07, 0xC0, 0x0F, 0x03, 0xC0, 0x07,
  0x83, 0xE0, 0x03, 0xC1, 0xE0, 0x01, 0xE1, 0xF0, 0x00, 0xF0, 0xF0, 0x00,
  0x78, 0xF8, 0x00, 0x3E, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xBC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x00, 0xF8, 0x00, 0x7B,
  0xC0, 0x03, 0xF0, 0x01, 0xF7, 0x80, 0x07, 0xE0, 0x03, 0xCF, 0x00, 0x1F,
  0xC0, 0x0F, 0x9E, 0x00, 0x3F, 0x80, 0x1F, 0x3C, 0x00, 0xFF, 0x00, 0x3C,
  0x78, 0x01, 0xFE, 0x00, 0xF8, 0xF0, 0x03, 0xBC, 0x01, 0xE1, 0xE0, 0x0F,
  0x78, 0x07, 0xC3, 0xC0, 0x1E, 0xF0, 0x0F, 0x07, 0xC0, 0x79, 0xE0, 0x1E,
  0x0F, 0x80, 0xF3, 0xC0, 0x7C, 0x1F, 0x03, 0xC7, 0x80, 0xF0, 0x3E, 0x07,
  0x8F, 0x03, 0xE0, 0x7C, 0x1E, 0x1E, 0x07, 0x80, 0xF8, 0x3C, 0x3C, 0x1F,
  0x01, 0xF0, 0x78, 0x78, 0x3C, 0x03, 0xE1, 0xE0, 0xF0, 0x78, 0x07, 0xC3,
  0xC1, 0xE1, 0xF0, 0x0F, 0x8F, 0x03, 0xC3, 0xC0, 0x1F, 0x1E, 0x07, 0x8F,
  0x80, 0x3E, 0x78, 0x0F, 0x1E, 0x00, 0x7C, 0xF0, 0x1E, 0x3C, 0x00, 0x79,
  0xC0, 0x3C, 0xF0, 0x00, 0xF7, 0x80, 0x39, 0xE0, 0x01, 0xEF, 0x00, 0x77,
  0xC0, 0x03, 0xBC, 0x00, 0xEF, 0x00, 0x07, 0x78, 0x01, 0xDE, 0x00, 0x0E,
  0xE0, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x01, 0xE0,
  0x0F, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0x81,
  0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x1E, 0x3E,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xE0, 0x0F, 0x00, 0x0F, 0x80,
  0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3C, 0x01, 0xF0, 0x00,
  0x78, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFB,
  0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0x87, 0x80, 0x1F, 0x0F, 0x00, 0x7C, 0x1E,
  0x00, 0xF0, 0x3C, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x78, 0x1F, 0x00, 0xF0,
  0x7C, 0x01, 0xE0, 0xF0, 0x03, 0xC3, 0xE0, 0x07, 0x8F, 0x80, 0x07, 0x9E,
  0x00, 0x0F, 0x7C, 0x00, 0x1E, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0xF0, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x38, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x38, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0xF7, 0x80, 0x01, 0xE3, 0xC0, 0x01, 0xE3,
  0xC0, 0x03, 0xC1, 0xE0, 0x03, 0xC1, 0xE0, 0x07, 0x80, 0xE0, 0x07, 0x80,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x1E, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x1C, 0x78, 0x00, 0x1E, 0xF8, 0x00,
  0x0F, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xF8,
  0x7C, 0x3C, 0x3C, 0x1E, 0x0E, 0x0F, 0x07, 0x00, 0x3E, 0x00, 0x00, 0xFF,
  0x0F, 0x01, 0xFF, 0x8E, 0x03, 0xFF, 0xDE, 0x07, 0xE1, 0xDE, 0x0F, 0x80,
  0xFE, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00,
  0x7C, 0x3C, 0x00, 0x7C, 0x7C, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00,
  0x78, 0x78, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF0, 0xF8, 0x01,
  0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x03, 0xE0, 0xF8, 0x07,
  0xE0, 0xF8, 0x0F, 0xE0, 0xF8, 0x1F, 0xE0, 0x7C, 0x3D, 0xE0, 0x7F, 0xF9,
  0xC0, 0x3F, 0xF1, 0xC0, 0x1F, 0xC3, 0xC0, 0x02, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x07, 0xC7,
  0xF8, 0x07, 0x9F, 0xFC, 0x07, 0xBF, 0xFC, 0x07, 0xF8, 0x3E, 0x07, 0xF0,
  0x3E, 0x0F, 0xE0, 0x1E, 0x0F, 0xC0, 0x1E, 0x0F, 0x80, 0x1F, 0x0F, 0x80,
  0x1F, 0x0F, 0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x1E, 0x00,
  0x1E, 0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x7C, 0x00,
  0xF8, 0x7E, 0x01, 0xF0, 0x7E, 0x03, 0xE0, 0x7F, 0x8F, 0xE0, 0xF3, 0xFF,
  0xC0, 0xF3, 0xFF, 0x80, 0xE1, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x1F,
  0x80, 0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x7E, 0x04, 0x1F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x10, 0x7E, 0x0E, 0x07, 0xFF, 0xC0,
  0x7F, 0xF8, 0x07, 0xFE, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0xFF,
  0x1E, 0x00, 0xFF, 0xE7, 0x80, 0x7F, 0xFD, 0xE0, 0x1F, 0x87, 0xF8, 0x0F,
  0x80, 0xFE, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0xF8, 0x01, 0xF0,
  0x3E, 0x00, 0x7C, 0x0F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0x81, 0xE0, 0x01,
  0xE0, 0x78, 0x00, 0x78, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x03, 0xE0,
  0x03, 0xC0, 0xF8, 0x01, 0xF0, 0x3C, 0x00, 0x7C, 0x0F, 0x00, 0x3F, 0x03,
  0xC0, 0x0F, 0x80, 0xF8, 0x07, 0xE0, 0x3E, 0x03, 0xF8, 0x0F, 0x81, 0xFE,
  0x01, 0xF0, 0xF7, 0x80, 0x7F, 0xF9, 0xC0, 0x0F, 0xFC, 0xF0, 0x01, 0xFC,
  0x3C, 0x00, 0x08, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x01, 0xFF,
  0xE0, 0x3F, 0xFE, 0x07, 0xC1, 0xF0, 0xF8, 0x0F, 0x1F, 0x00, 0xF1, 0xE0,
  0x0F, 0x3E, 0x01, 0xF3, 0xC0, 0x1E, 0x7C, 0x03, 0xE7, 0x80, 0xFC, 0x79,
  0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x10, 0x7E, 0x07, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x00, 0xFF, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE1, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x04, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x06, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xF8, 0xF0, 0x0F, 0xFE, 0x38, 0x07, 0xFF, 0xDE,
  0x01, 0xF8, 0x7F, 0x80, 0xF8, 0x0F, 0xE0, 0x7C, 0x01, 0xF0, 0x1F, 0x00,
  0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF0, 0x01, 0xF0, 0x7C,
  0x00, 0x78, 0x1F, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x83, 0xE0, 0x03, 0xE0,
  0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3C, 0x0F, 0x80, 0x1F, 0x03, 0xC0, 0x07,
  0xC0, 0xF0, 0x03, 0xF0, 0x3C, 0x00, 0xF8, 0x0F, 0x80, 0x7E, 0x03, 0xE0,
  0x3F, 0x80, 0xF8, 0x1F, 0xE0, 0x1F, 0x0F, 0xF8, 0x07, 0xFF, 0xBC, 0x00,
  0xFF, 0xCF, 0x00, 0x1F, 0xC3, 0xC0, 0x00, 0x81, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7C, 0x03, 0x00, 0x3E, 0x00, 0xFE, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x3C, 0x7F, 0x80, 0xF3,
  0xFF, 0x81, 0xEF, 0xFF, 0x83, 0xFC, 0x1F, 0x07, 0xF0, 0x3E, 0x1F, 0xC0,
  0x3C, 0x3F, 0x00, 0x78, 0x7C, 0x00, 0xF0, 0xF8, 0x03, 0xE1, 0xE0, 0x07,
  0xC7, 0xC0, 0x0F, 0x0F, 0x80, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0xF8,
  0x78, 0x01, 0xE1, 0xF0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F,
  0x00, 0x3E, 0x3E, 0x00, 0x78, 0x7C, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0,
  0x07, 0xC3, 0xC0, 0x0F, 0x8F, 0x80, 0x1E, 0x1F, 0x00, 0x3C, 0x3C, 0x00,
  0x78, 0x00, 0x00, 0x40, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x78, 0x07,
  0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C,
  0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x27, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x01, 0x07, 0xC0,
  0x3E, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x07, 0x81, 0xF0, 0x07, 0x83,
  0xE0, 0x0F, 0x87, 0xC0, 0x0F, 0x0F, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x1E,
  0x00, 0x0F, 0x3E, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xBC, 0x00, 0x3F, 0x3E, 0x00, 0x3E, 0x3E,
  0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x0F,
  0x00, 0x78, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0xC0, 0xF8, 0x07,
  0xC0, 0xF8, 0x03, 0xC0, 0xF0, 0x03, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0,
  0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80,
  0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03,
  0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07,
  0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x78,
  0xFF, 0x83, 0xFE, 0x07, 0x9F, 0xF8, 0x7F, 0xE0, 0x7B, 0xFF, 0xCF, 0xFF,
  0x07, 0xF8, 0x7D, 0xE1, 0xF0, 0x7E, 0x03, 0xF8, 0x0F, 0x0F, 0xE0, 0x3F,
  0x00, 0xF0, 0xFC, 0x03, 0xF0, 0x0F, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0xF8,
  0x03, 0xE0, 0x0F, 0x0F, 0x00, 0x3C, 0x00, 0xF1, 0xF0, 0x07, 0xC0, 0x1F,
  0x1F, 0x00, 0x7C, 0x01, 0xE1, 0xE0, 0x07, 0x80, 0x1E, 0x1E, 0x00, 0x78,
  0x01, 0xE1, 0xE0, 0x07, 0x80, 0x1E, 0x3E, 0x00, 0xF8, 0x03, 0xE3, 0xC0,
  0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x00, 0x3C,
  0x7C, 0x00, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x00, 0x7C, 0x78, 0x01, 0xE0,
  0x07, 0x87, 0x80, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE0, 0x07, 0x8F, 0x80,
  0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE0, 0x0F, 0x8F, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x03, 0xF0, 0x0F, 0x1F, 0xF0, 0x1E, 0x7F, 0xF0, 0x3D, 0xFF, 0xF0,
  0x7F, 0x83, 0xE0, 0xFE, 0x07, 0xC3, 0xF8, 0x07, 0x87, 0xE0, 0x0F, 0x0F,
  0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xE1, 0xF0,
  0x03, 0xC3, 0xC0, 0x0F, 0x87, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00,
  0x78, 0x7C, 0x00, 0xF0, 0xF0, 0x03, 0xE1, 0xE0, 0x07, 0xC7, 0xC0, 0x0F,
  0x8F, 0x80, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0xF8, 0xF8, 0x01, 0xF1,
  0xF0, 0x03, 0xC3, 0xE0, 0x07, 0x87, 0x80, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xC1, 0xF8, 0x3E,
  0x03, 0xE1, 0xF0, 0x07, 0x87, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF0, 0x01,
  0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x78, 0x00, 0x7D, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xBE, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x03, 0xEF, 0x00,
  0x0F, 0x3C, 0x00, 0x7C, 0xF0, 0x01, 0xF3, 0xE0, 0x0F, 0x87, 0x80, 0x3C,
  0x1F, 0x01, 0xF0, 0x7E, 0x1F, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x0E, 0x1F, 0xE0, 0x03, 0xCF, 0xFE,
  0x00, 0x7B, 0xFF, 0xC0, 0x0F, 0xF0, 0x7C, 0x01, 0xFC, 0x0F, 0x80, 0x7F,
  0x00, 0xF0, 0x0F, 0xC0, 0x1E, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x7C,
  0x07, 0x80, 0x0F, 0x01, 0xF0, 0x01, 0xE0, 0x3E, 0x00, 0x3C, 0x07, 0x80,
  0x07, 0x80, 0xF0, 0x01, 0xF0, 0x1E, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0,
  0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x3E, 0x03, 0xC0, 0x07, 0xC0, 0x78, 0x01,
  0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xE0, 0x0F,
  0xF1, 0xFC, 0x03, 0xEF, 0xFF, 0x00, 0x79, 0xFF, 0xC0, 0x0F, 0x1F, 0xE0,
  0x01, 0xE0, 0x20, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x01, 0x00, 0xFF, 0x8E, 0x01,
  0xFF, 0x8E, 0x03, 0xFF, 0xDE, 0x07, 0xE1, 0xFE, 0x0F, 0x80, 0xFE, 0x1F,
  0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3C,
  0x00, 0x7C, 0x7C, 0x00, 0x78, 0x7C, 0x00, 0x78, 0x78, 0x00, 0x78, 0xF8,
  0x00, 0xF8, 0xF8, 0x00, 0xF0, 0xF8, 0x00, 0xF0, 0xF8, 0x01, 0xF0, 0xF0,
  0x01, 0xF0, 0xF0, 0x03, 0xF0, 0xF0, 0x03, 0xE0, 0xF8, 0x07, 0xE0, 0xF8,
  0x0F, 0xE0, 0xF8, 0x1F, 0xE0, 0x7C, 0x3F, 0xE0, 0x7F, 0xFB, 0xC0, 0x3F,
  0xF3, 0xC0, 0x1F, 0xC3, 0xC0, 0x02, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0xF1, 0xFC, 0x1E, 0x7F,
  0x03, 0xDF, 0xE0, 0x7F, 0xC4, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0xF8, 0x0C,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC4, 0x00, 0xF8, 0xF0, 0x7F, 0x1F,
  0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xE0, 0x1F, 0xFF,
  0x7F, 0xFD, 0xFF, 0xF8, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x10, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F,
  0x80, 0x10, 0x00, 0x0F, 0x80, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78,
  0x78, 0x01, 0xF1, 0xF0, 0x03, 0xC3, 0xE0, 0x07, 0x87, 0x80, 0x0F, 0x0F,
  0x00, 0x3E, 0x1E, 0x00, 0x7C, 0x7C, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0,
  0x03, 0xC3, 0xC0, 0x0F, 0x87, 0x80, 0x1E, 0x1F, 0x00, 0x3C, 0x3C, 0x00,
  0x78, 0x78, 0x01, 0xF0, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F,
  0x0F, 0x80, 0x7E, 0x1F, 0x01, 0xFC, 0x3E, 0x07, 0xF8, 0x3E, 0x3F, 0xE0,
  0x7F, 0xFB, 0xC0, 0xFF, 0xE7, 0x80, 0x7F, 0x0F, 0x00, 0x30, 0x00, 0x00,
  0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xBC, 0x00, 0x79, 0xE0, 0x07, 0xCF, 0x00,
  0x3C, 0x78, 0x03, 0xE3, 0xC0, 0x1E, 0x1E, 0x01, 0xF0, 0xF0, 0x0F, 0x07,
  0xC0, 0x78, 0x3E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x83, 0xC0, 0x3C, 0x1E,
  0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E,
  0x78, 0x00, 0xF3, 0xC0, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x07, 0xE0, 0x0F, 0xF8, 0x03, 0xF0, 0x0F, 0xBC, 0x01, 0xF8, 0x07, 0x9E,
  0x01, 0xFC, 0x03, 0xCF, 0x00, 0xFE, 0x03, 0xE7, 0x80, 0xFF, 0x01, 0xE3,
  0xC0, 0x77, 0x81, 0xF1, 0xE0, 0x7B, 0xC0, 0xF0, 0xF0, 0x3D, 0xE0, 0xF8,
  0x78, 0x1C, 0xF0, 0x78, 0x3C, 0x1E, 0x78, 0x3C, 0x1E, 0x0E, 0x3C, 0x3C,
  0x0F, 0x0F, 0x1E, 0x1E, 0x07, 0x87, 0x0F, 0x1F, 0x03, 0xC7, 0x87, 0x8F,
  0x01, 0xE3, 0xC3, 0xC7, 0x80, 0xF3, 0xC1, 0xE7, 0x80, 0x79, 0xE0, 0xF3,
  0xC0, 0x3C, 0xE0, 0x7B, 0xC0, 0x1E, 0xF0, 0x3D, 0xE0, 0x0F, 0x70, 0x1E,
  0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x78, 0x07, 0xC0, 0x1E, 0x01,
  0xE0, 0x07, 0xC0, 0xF8, 0x00, 0xF0, 0x7C, 0x00, 0x3C, 0x1E, 0x00, 0x0F,
  0x8F, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7D,
  0xE0, 0x00, 0x3E, 0x78, 0x00, 0x0F, 0x1F, 0x00, 0x07, 0x83, 0xC0, 0x03,
  0xE0, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x78, 0x07, 0x80, 0x3E, 0x01, 0xE0,
  0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x07,
  0x80, 0x07, 0x80, 0x3C, 0x00, 0x7C, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x3E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x78, 0x0F, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x07, 0xC0, 0x00,
  0xF0, 0x3C, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE1,
  0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x01, 0xC7, 0x80,
  0x00, 0x0E, 0x78, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0x9F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x10, 0xFF, 0xFF, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x1F, 0x80, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFE,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x78, 0x00, 0x00,
  0x3F, 0xC0, 0x05, 0xFF, 0xC0, 0x3F, 0xFF, 0xE3, 0xFC, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFA, 0x00, 0x3F, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_Italic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 13, 37, 13, 1, -36 },
  { 62, 15, 13, 19, 5, -36 },
  { 87, 28, 36, 29, 1, -36 },
  { 213, 24, 42, 25, 1, -39 },
  { 339, 32, 38, 37, 3, -37 },
  { 491, 28, 38, 30, 1, -37 },
  { 624, 7, 13, 11, 5, -36 },
  { 636, 16, 45, 14, 2, -37 },
  { 726, 16, 45, 14, -4, -37 },
  { 816, 21, 21, 25, 5, -39 },
  { 872, 22, 24, 27, 3, -30 },
  { 938, 9, 13, 12, -2, -6 },
  { 953, 13, 4, 15, 1, -16 },
  { 960, 6, 7, 12, 1, -6 },
  { 966, 24, 36, 18, -2, -36 },
  { 1074, 23, 38, 25, 2, -37 },
  { 1184, 14, 36, 25, 7, -36 },
  { 1247, 25, 37, 25, -1, -37 },
  { 1363, 24, 38, 25, 0, -37 },
  { 1477, 24, 37, 25, 0, -37 },
  { 1588, 24, 37, 25, 1, -36 },
  { 1699, 23, 38, 25, 2, -37 },
  { 1809, 23, 36, 25, 3, -36 },
  { 1913, 24, 38, 25, 1, -37 },
  { 2027, 23, 38, 25, 1, -37 },
  { 2137, 10, 29, 12, 1, -28 },
  { 2174, 14, 35, 12, -3, -28 },
  { 2236, 22, 24, 27, 3, -30 },
  { 2302, 22, 14, 27, 3, -25 },
  { 2341, 22, 24, 27, 3, -30 },
  { 2407, 18, 38, 19, 3, -37 },
  { 2493, 35, 41, 38, 2, -37 },
  { 2673, 26, 36, 26, -3, -36 },
  { 2790, 26, 36, 27, 1, -36 },
  { 2907, 26, 38, 26, 3, -37 },
  { 3031, 28, 36, 30, 1, -36 },
  { 3157, 25, 36, 23, 1, -36 },
  { 3270, 25, 36, 22, 1, -36 },
  { 3383, 28, 38, 31, 3, -37 },
  { 3516, 31, 36, 31, 1, -36 },
  { 3656, 21, 36, 15, -2, -36 },
  { 3751, 21, 46, 13, -8, -36 },
  { 3872, 29, 36, 26, 1, -36 },
  { 4003, 18, 36, 22, 1, -36 },
  { 4084, 39, 36, 39, 1, -36 },
  { 4260, 32, 36, 32, 1, -36 },
  { 4404, 28, 38, 33, 3, -37 },
  { 4537, 25, 36, 26, 1, -36 },
  { 4650, 28, 46, 33, 3, -37 },
  { 4811, 25, 36, 26, 1, -36 },
  { 4924, 24, 38, 23, 0, -37 },
  { 5038, 23, 36, 23, 4, -36 },
  { 5142, 29, 37, 31, 3, -36 },
  { 5277, 25, 36, 25, 5, -36 },
  { 5390, 39, 36, 40, 5, -36 },
  { 5566, 31, 36, 24, -3, -36 },
  { 5706, 23, 36, 23, 5, -36 },
  { 5810, 27, 36, 23, -1, -36 },
  { 5932, 20, 45, 15, -1, -37 },
  { 6045, 9, 36, 18, 5, -36 },
  { 6086, 20, 45, 15, -4, -37 },
  { 6199, 24, 22, 26, 1, -37 },
  { 6265, 20, 4, 18, -5, 4 },
  { 6275, 8, 8, 14, 7, -39 },
  { 6283, 24, 29, 26, 2, -28 },
  { 6370, 24, 40, 27, 1, -39 },
  { 6490, 19, 29, 21, 2, -28 },
  { 6559, 26, 40, 27, 2, -39 },
  { 6689, 20, 29, 23, 2, -28 },
  { 6762, 27, 51, 15, -6, -39 },
  { 6935, 26, 40, 27, 0, -28 },
  { 7065, 23, 39, 26, 1, -39 },
  { 7178, 12, 38, 12, 1, -38 },
  { 7235, 19, 50, 12, -6, -38 },
  { 7354, 24, 39, 23, 1, -39 },
  { 7471, 12, 39, 12, 1, -39 },
  { 7530, 36, 28, 40, 1, -28 },
  { 7656, 23, 28, 26, 1, -28 },
  { 7737, 22, 28, 26, 2, -28 },
  { 7814, 27, 40, 27, -2, -28 },
  { 7949, 24, 40, 27, 2, -28 },
  { 8069, 19, 28, 18, 1, -28 },
  { 8136, 19, 29, 20, 0, -28 },
  { 8205, 15, 35, 15, 2, -34 },
  { 8271, 23, 28, 26, 2, -27 },
  { 8352, 21, 27, 21, 3, -27 },
  { 8423, 33, 27, 34, 3, -27 },
  { 8535, 26, 27, 22, -2, -27 },
  { 8623, 29, 39, 21, -5, -27 },
  { 8765, 21, 27, 20, -1, -27 },
  { 8836, 19, 44, 17, 1, -36 },
  { 8941, 4, 51, 25, 11, -39 },
  { 8967, 19, 44, 17, -2, -36 },
  { 9072, 22, 6, 27, 3, -21 },
};

const GFXfont NotoSans_SemiCondensed_Italic51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic51pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC51PT7B_H_
