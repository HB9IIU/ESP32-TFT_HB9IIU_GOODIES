#ifndef _NOTOSANS_SEMICONDENSED_ITALIC27PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x38, 0x60, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0xE1, 0x83,
  0x06, 0x00, 0x00, 0x61, 0xE1, 0x80, 0x67, 0x66, 0xE6, 0xC6, 0xC4, 0xCC,
  0x8C, 0x03, 0x18, 0x06, 0x30, 0x08, 0x60, 0x31, 0x80, 0x63, 0x0F, 0xFF,
  0xDF, 0xFF, 0x06, 0x30, 0x0C, 0x60, 0x30, 0x80, 0x63, 0x00, 0xC6, 0x0F,
  0xFF, 0x86, 0x30, 0x0C, 0x60, 0x18, 0xC0, 0x61, 0x00, 0xC6, 0x01, 0x8C,
  0x00, 0x01, 0x80, 0x18, 0x01, 0x80, 0xFE, 0x1F, 0xF3, 0xB1, 0x33, 0x03,
  0x30, 0x32, 0x03, 0xA0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x4C, 0x04, 0xC0,
  0xCC, 0x0C, 0xCC, 0xB8, 0xFF, 0x03, 0xC0, 0x18, 0x01, 0x80, 0x10, 0x00,
  0x08, 0x01, 0x1F, 0x03, 0x1D, 0x83, 0x0C, 0x61, 0x84, 0x31, 0x86, 0x11,
  0x83, 0x18, 0xC1, 0x8C, 0xC0, 0xC6, 0xCE, 0x66, 0x6F, 0xB3, 0x6C, 0x7F,
  0x66, 0x32, 0x36, 0x18, 0x33, 0x08, 0x31, 0x8C, 0x18, 0xC6, 0x18, 0x63,
  0x18, 0x33, 0x0C, 0x1F, 0x8C, 0x07, 0x80, 0x00, 0x80, 0x07, 0xE0, 0x1C,
  0xC0, 0x71, 0xC0, 0xC3, 0x81, 0x86, 0x03, 0x1C, 0x07, 0x70, 0x07, 0xC0,
  0x0E, 0x00, 0x7C, 0x01, 0xDC, 0x37, 0x1C, 0xCC, 0x19, 0x98, 0x3E, 0x70,
  0x3C, 0x60, 0x70, 0xC1, 0xE1, 0xFF, 0xE1, 0xF8, 0xE0, 0x6F, 0xED, 0xA0,
  0x03, 0x06, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x70, 0x60, 0x60, 0xE0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0x60, 0x60, 0x06,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0E, 0x07, 0x03, 0x81, 0x80, 0xC0,
  0x60, 0x30, 0x38, 0x18, 0x0C, 0x0E, 0x06, 0x07, 0x03, 0x03, 0x03, 0x83,
  0x80, 0x04, 0x00, 0xC0, 0x18, 0x62, 0x0F, 0x40, 0x7F, 0xC3, 0xF9, 0xF0,
  0x76, 0x1C, 0x61, 0x0C, 0x01, 0x00, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x3F, 0xF8, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x39, 0x9C, 0xC6, 0x63, 0x00, 0xFF, 0xF0, 0x7F, 0x60, 0x00, 0x38, 0x03,
  0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x00, 0x01, 0x00, 0x7E, 0x0E, 0xE1, 0xC7, 0x38, 0x33,
  0x03, 0x30, 0x37, 0x03, 0x60, 0x36, 0x07, 0x60, 0x7E, 0x06, 0xE0, 0x6C,
  0x0E, 0xC0, 0xEC, 0x0C, 0xE1, 0xC6, 0x38, 0x7F, 0x03, 0xE0, 0x07, 0x0F,
  0x3F, 0xF6, 0x66, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x1C, 0x1C, 0x18, 0x18,
  0x18, 0x38, 0x38, 0x30, 0x30, 0x00, 0x80, 0x3F, 0x87, 0xFC, 0x10, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03,
  0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x3F, 0xF9,
  0xFF, 0xC0, 0x01, 0x80, 0x7F, 0x87, 0xDC, 0x10, 0x70, 0x01, 0x80, 0x1C,
  0x00, 0xE0, 0x06, 0x00, 0xE0, 0x7E, 0x03, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0xE4, 0x0E, 0x3F, 0xF0, 0xFE, 0x00, 0x00,
  0x38, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x1B, 0x01, 0xB8, 0x19, 0x81, 0xCC,
  0x0C, 0x60, 0xC3, 0x0C, 0x38, 0xC1, 0x8E, 0x0C, 0x7F, 0xFF, 0xFF, 0xC0,
  0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x0F, 0xF0, 0xFF, 0x18, 0x01, 0x80,
  0x18, 0x03, 0x80, 0x30, 0x03, 0xF0, 0x3F, 0x82, 0x1C, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x83, 0x8F, 0xF8, 0xFE, 0x00, 0x00,
  0x20, 0x3F, 0x07, 0x90, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x77,
  0x86, 0xFC, 0x70, 0xE6, 0x06, 0xE0, 0x6E, 0x06, 0xE0, 0x6E, 0x0E, 0xE0,
  0xC6, 0x1C, 0x7F, 0x83, 0xF0, 0x7F, 0xF7, 0xFF, 0x00, 0x60, 0x0E, 0x00,
  0xC0, 0x18, 0x01, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C,
  0x01, 0x80, 0x38, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0xFE, 0x1E, 0xF1, 0x83, 0x18, 0x33, 0x83, 0x18, 0x31, 0x86, 0x1D, 0xC0,
  0xF8, 0x1F, 0x83, 0x9C, 0x60, 0xCE, 0x0E, 0xC0, 0xEC, 0x0E, 0xC0, 0xCE,
  0x1C, 0x7F, 0x83, 0xF0, 0x01, 0x00, 0xFC, 0x1F, 0xE3, 0x86, 0x30, 0x77,
  0x07, 0x60, 0x76, 0x07, 0x60, 0x77, 0x0E, 0x71, 0xE3, 0xF6, 0x1E, 0xE0,
  0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x70, 0xFE, 0x0F, 0xC0, 0x08, 0x71,
  0xC6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x63, 0xCE, 0x00, 0x04, 0x1C,
  0x38, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x86, 0x1C, 0x30,
  0x61, 0x82, 0x00, 0x00, 0x20, 0x1C, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x30,
  0x07, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x30, 0x02, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x80, 0x1C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x18, 0x0F, 0x0F, 0x87, 0x83, 0xC0, 0x60, 0x08,
  0x00, 0x04, 0x1F, 0xE3, 0xBC, 0x87, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0x03,
  0x03, 0x80, 0xC0, 0x60, 0x30, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x0F,
  0x01, 0x80, 0x00, 0xFE, 0x00, 0x78, 0xF0, 0x18, 0x07, 0x06, 0x00, 0x61,
  0x80, 0x0C, 0x60, 0xF8, 0xCC, 0x7F, 0x1B, 0x1C, 0x63, 0x63, 0x08, 0x68,
  0xC3, 0x0F, 0x18, 0x63, 0x63, 0x0C, 0x6C, 0x63, 0x0D, 0x8C, 0x63, 0x31,
  0xF7, 0xC6, 0x1C, 0x70, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1E,
  0x1C, 0x00, 0xFF, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x36, 0x00,
  0xD8, 0x06, 0x60, 0x19, 0x80, 0xC6, 0x03, 0x18, 0x18, 0x60, 0x61, 0x83,
  0xFF, 0x0F, 0xFC, 0x70, 0x71, 0x81, 0xCE, 0x03, 0x30, 0x0D, 0xC0, 0x3E,
  0x00, 0xC0, 0x0F, 0xF0, 0xFF, 0xC7, 0x0E, 0x30, 0x31, 0x81, 0x8C, 0x0C,
  0xE0, 0xE6, 0x0E, 0x3F, 0xE1, 0xFE, 0x1C, 0x18, 0xE0, 0xE6, 0x03, 0x30,
  0x19, 0x81, 0xDC, 0x0E, 0xE0, 0xE7, 0xFE, 0x3F, 0xC0, 0x00, 0xC0, 0x3F,
  0xC3, 0xFE, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xE0,
  0x07, 0x82, 0x1F, 0xF0, 0x7F, 0x80, 0x0F, 0xE0, 0x7F, 0xE1, 0xC3, 0x86,
  0x07, 0x18, 0x0C, 0x60, 0x33, 0x80, 0xCC, 0x03, 0x30, 0x0C, 0xC0, 0x37,
  0x01, 0xDC, 0x07, 0x60, 0x19, 0x80, 0xE6, 0x07, 0x38, 0x3C, 0xE1, 0xE3,
  0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0xFF, 0x86, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0xE0, 0x06, 0x00, 0x3F, 0xC1, 0xFE, 0x1C, 0x00, 0xE0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F,
  0xF8, 0xFF, 0x87, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00,
  0x30, 0x01, 0xFE, 0x1F, 0xF0, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C,
  0x00, 0xE0, 0x06, 0x00, 0x30, 0x00, 0x00, 0x60, 0x1F, 0xF0, 0xFF, 0xC7,
  0x01, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C,
  0x0F, 0xB0, 0x7E, 0xC0, 0x3B, 0x00, 0xCC, 0x03, 0x30, 0x0C, 0xE0, 0x71,
  0xC1, 0xC7, 0xFE, 0x07, 0xF8, 0x0C, 0x07, 0x1C, 0x06, 0x1C, 0x06, 0x18,
  0x06, 0x18, 0x0E, 0x18, 0x0C, 0x38, 0x0C, 0x30, 0x0C, 0x3F, 0xFC, 0x3F,
  0xFC, 0x30, 0x18, 0x70, 0x18, 0x60, 0x18, 0x60, 0x38, 0x60, 0x38, 0xE0,
  0x30, 0xE0, 0x30, 0xC0, 0x30, 0xC0, 0x70, 0x0F, 0xE0, 0x60, 0x0C, 0x01,
  0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00,
  0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x0F, 0x83, 0xF8, 0x00, 0x00, 0x60,
  0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0xE0, 0x38, 0x3F, 0x07, 0x80, 0x0C, 0x0E, 0x38, 0x30, 0x70,
  0xE0, 0xC3, 0x81, 0x8E, 0x03, 0x38, 0x0E, 0xE0, 0x1B, 0x80, 0x36, 0x00,
  0x7E, 0x01, 0xEC, 0x03, 0x9C, 0x06, 0x38, 0x0C, 0x30, 0x18, 0x70, 0x70,
  0xE0, 0xE0, 0xC1, 0x81, 0xC3, 0x03, 0x80, 0x0C, 0x0E, 0x07, 0x03, 0x01,
  0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x1C, 0x0E, 0x06, 0x03, 0x01, 0x81,
  0xC0, 0xE0, 0x7F, 0xFF, 0xE0, 0x0E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x01,
  0xF1, 0xE0, 0x1E, 0x1E, 0x03, 0x61, 0xB0, 0x36, 0x3B, 0x06, 0xE3, 0x30,
  0x6C, 0x33, 0x0C, 0xC3, 0x30, 0xCC, 0x73, 0x19, 0xC6, 0x31, 0x9C, 0x63,
  0x31, 0x86, 0x37, 0x18, 0x63, 0x61, 0x8E, 0x3E, 0x38, 0xC1, 0xC3, 0x8C,
  0x1C, 0x30, 0xC1, 0x83, 0x00, 0x0E, 0x03, 0x1E, 0x03, 0x1E, 0x03, 0x1E,
  0x07, 0x1B, 0x06, 0x1B, 0x06, 0x33, 0x06, 0x33, 0x86, 0x31, 0x8E, 0x31,
  0x8C, 0x71, 0xCC, 0x60, 0xCC, 0x60, 0xCC, 0x60, 0xDC, 0x60, 0x78, 0xE0,
  0x78, 0xC0, 0x78, 0xC0, 0x78, 0xC0, 0x38, 0x00, 0x80, 0x0F, 0xE0, 0x3F,
  0xE0, 0xE0, 0xE3, 0x80, 0xCE, 0x01, 0x9C, 0x03, 0xB0, 0x07, 0xE0, 0x0F,
  0x80, 0x1B, 0x00, 0x36, 0x00, 0x6C, 0x01, 0xD8, 0x03, 0xB0, 0x0E, 0x60,
  0x1C, 0xE0, 0x71, 0xE1, 0xC1, 0xFF, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0xFF,
  0x87, 0x0E, 0x30, 0x71, 0x83, 0x8C, 0x1C, 0xE0, 0xE6, 0x06, 0x30, 0x71,
  0xFF, 0x1F, 0xF0, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0,
  0x06, 0x00, 0x30, 0x00, 0x00, 0x80, 0x0F, 0xE0, 0x3F, 0xE0, 0xE0, 0xE3,
  0x80, 0xCE, 0x01, 0x9C, 0x03, 0xB0, 0x07, 0xE0, 0x0F, 0x80, 0x1B, 0x00,
  0x36, 0x00, 0x6C, 0x01, 0xD8, 0x03, 0xB0, 0x06, 0x60, 0x1C, 0xE0, 0x71,
  0xE1, 0xC1, 0xFF, 0x01, 0xFC, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x60, 0x00, 0xE0, 0x0F, 0xE0, 0xFF, 0x87, 0x0E, 0x30, 0x71, 0x83, 0x8C,
  0x1C, 0xE0, 0xE6, 0x06, 0x30, 0xF1, 0xFF, 0x1F, 0xC0, 0xE7, 0x06, 0x18,
  0x30, 0xC1, 0x87, 0x1C, 0x18, 0xE0, 0xC6, 0x07, 0x30, 0x38, 0x00, 0xC0,
  0x3F, 0xC3, 0xFC, 0x38, 0x21, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1C,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE4, 0x0E, 0x3F, 0xE1, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01,
  0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x00,
  0x38, 0x0E, 0x70, 0x18, 0xC0, 0x31, 0x80, 0x63, 0x01, 0xCE, 0x03, 0x18,
  0x06, 0x30, 0x0C, 0x60, 0x39, 0xC0, 0x73, 0x80, 0xC6, 0x01, 0x8C, 0x03,
  0x18, 0x0E, 0x30, 0x18, 0x60, 0x70, 0xE0, 0xC0, 0xFF, 0x80, 0xFC, 0x00,
  0xE0, 0x1D, 0x80, 0xE6, 0x03, 0x18, 0x1C, 0x60, 0x61, 0x81, 0x86, 0x0C,
  0x18, 0x30, 0x61, 0xC1, 0x86, 0x06, 0x38, 0x18, 0xC0, 0x77, 0x01, 0xD8,
  0x07, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x00, 0xC0, 0x60,
  0x3C, 0x0E, 0x07, 0xC0, 0xE0, 0x6C, 0x1E, 0x0E, 0xC1, 0xE0, 0xCC, 0x36,
  0x0C, 0xC3, 0x61, 0x8C, 0x76, 0x18, 0xC6, 0x63, 0x8C, 0x66, 0x30, 0xCC,
  0x67, 0x0C, 0xC6, 0x60, 0xD8, 0x66, 0x0D, 0x86, 0xC0, 0xD8, 0x6C, 0x0F,
  0x06, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x00, 0x0E, 0x07,
  0x0E, 0x0E, 0x06, 0x1C, 0x06, 0x18, 0x07, 0x30, 0x03, 0x70, 0x03, 0x60,
  0x03, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0xC0, 0x06, 0xC0, 0x0E, 0xC0,
  0x1C, 0xE0, 0x18, 0xE0, 0x30, 0x60, 0x70, 0x60, 0x60, 0x70, 0xC0, 0x70,
  0xE0, 0x3B, 0x03, 0x98, 0x38, 0xC1, 0x87, 0x1C, 0x18, 0xC0, 0xCC, 0x06,
  0xE0, 0x36, 0x01, 0xF0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00,
  0x70, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x0F, 0xC3, 0xE0, 0xC0, 0x30,
  0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x3E, 0x0F, 0x80,
  0xC6, 0x31, 0x8E, 0x31, 0x8C, 0x63, 0x18, 0xE3, 0x18, 0xC6, 0x31, 0x8E,
  0x07, 0xC1, 0xF0, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0xC0,
  0x30, 0x0C, 0x3F, 0x0F, 0x80, 0x06, 0x00, 0x70, 0x0F, 0x00, 0xD8, 0x19,
  0x81, 0x8C, 0x30, 0xC3, 0x0C, 0x60, 0x66, 0x06, 0xC0, 0x30, 0xFF, 0xFF,
  0xF0, 0xEE, 0x63, 0x10, 0x07, 0x08, 0x7D, 0x87, 0x3C, 0x70, 0xE7, 0x07,
  0x30, 0x39, 0x81, 0x9C, 0x0C, 0xE0, 0x66, 0x07, 0x30, 0x31, 0x83, 0x8E,
  0x3C, 0x3F, 0x61, 0xF3, 0x00, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x33, 0x83, 0xBE, 0x1B, 0x38, 0xE1, 0xC7, 0x06, 0x70,
  0x33, 0x81, 0x98, 0x1C, 0xC0, 0xE6, 0x06, 0x70, 0x73, 0x83, 0x1C, 0x38,
  0xFF, 0x8C, 0xF8, 0x00, 0x03, 0x83, 0xF1, 0xC4, 0xE0, 0x70, 0x18, 0x06,
  0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x80, 0xE0, 0x1F, 0xC3, 0xF0, 0x00,
  0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x73, 0x87,
  0xEC, 0x1C, 0xF0, 0xE1, 0xC7, 0x07, 0x18, 0x1C, 0x60, 0x63, 0x81, 0x8E,
  0x0E, 0x30, 0x38, 0xC0, 0xC3, 0x07, 0x0E, 0x3C, 0x1F, 0xB0, 0x7C, 0xC0,
  0x07, 0x81, 0xF8, 0x73, 0x98, 0x77, 0x0E, 0xC1, 0x98, 0xF7, 0xF8, 0xF0,
  0x18, 0x03, 0x00, 0x70, 0x0E, 0x08, 0xFF, 0x0F, 0xC0, 0x00, 0x18, 0x01,
  0xF0, 0x0E, 0x40, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x03, 0xFC, 0x03,
  0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x03, 0x84, 0x3F,
  0x60, 0xE7, 0x87, 0x0E, 0x38, 0x38, 0xC0, 0xE3, 0x03, 0x1C, 0x0C, 0x70,
  0x71, 0x81, 0xC6, 0x06, 0x18, 0x38, 0x71, 0xE0, 0xFD, 0x83, 0xEE, 0x00,
  0x30, 0x00, 0xC0, 0x07, 0x08, 0x18, 0x3B, 0xE0, 0xFF, 0x00, 0x06, 0x00,
  0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x33, 0x03, 0xFE, 0x1B,
  0x38, 0xE1, 0xC7, 0x0E, 0x70, 0x73, 0x83, 0x18, 0x18, 0xC0, 0xC6, 0x0E,
  0x70, 0x63, 0x83, 0x18, 0x18, 0xC0, 0xCE, 0x0E, 0x00, 0x06, 0x1C, 0x38,
  0x00, 0x00, 0x07, 0x0C, 0x18, 0x30, 0xE1, 0xC3, 0x06, 0x0C, 0x38, 0x60,
  0xC1, 0x87, 0x00, 0x00, 0xC0, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0x60, 0xF0, 0x3C, 0x00,
  0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x23,
  0x8E, 0x18, 0x60, 0xC6, 0x06, 0x60, 0x76, 0x03, 0x70, 0x1F, 0x80, 0xEC,
  0x06, 0x60, 0x73, 0x83, 0x0C, 0x18, 0x70, 0xC3, 0x8E, 0x0C, 0x00, 0x06,
  0x0C, 0x38, 0x60, 0xC1, 0x83, 0x0E, 0x18, 0x30, 0x61, 0xC3, 0x86, 0x0C,
  0x18, 0x70, 0xC1, 0x83, 0x0E, 0x00, 0x00, 0xE0, 0xC1, 0xBF, 0x3E, 0x1B,
  0x76, 0x71, 0xC3, 0xC7, 0x1C, 0x38, 0x73, 0x83, 0x07, 0x38, 0x30, 0x63,
  0x07, 0x06, 0x30, 0x70, 0x63, 0x06, 0x0E, 0x70, 0x60, 0xE7, 0x06, 0x0C,
  0x60, 0xE0, 0xC6, 0x0E, 0x0C, 0xE0, 0xC1, 0xC0, 0x18, 0xE0, 0xDF, 0x87,
  0xDE, 0x38, 0x71, 0xC3, 0x9C, 0x1C, 0xE0, 0xC6, 0x06, 0x30, 0x31, 0x83,
  0x9C, 0x1C, 0xE0, 0xC6, 0x06, 0x30, 0x73, 0x83, 0x80, 0x07, 0x00, 0xFC,
  0x1C, 0xE3, 0x06, 0x70, 0x76, 0x07, 0x60, 0x7E, 0x06, 0xC0, 0x6C, 0x06,
  0xC0, 0xEE, 0x0C, 0xE1, 0xC7, 0xF8, 0x3F, 0x00, 0x00, 0x70, 0x33, 0xE0,
  0xD9, 0xC3, 0x87, 0x0E, 0x0C, 0x70, 0x31, 0xC0, 0xC6, 0x07, 0x18, 0x1C,
  0x60, 0x63, 0x83, 0x8E, 0x0C, 0x38, 0x70, 0xFF, 0x83, 0x7C, 0x1C, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x07, 0x08, 0x7D,
  0x87, 0x3C, 0x70, 0xE7, 0x07, 0x30, 0x39, 0x81, 0x9C, 0x0C, 0xE0, 0xE6,
  0x07, 0x30, 0x31, 0x83, 0x8E, 0x3C, 0x3F, 0x61, 0xF7, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x00, 0x00, 0xE3, 0x78, 0x6D,
  0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x38,
  0x06, 0x00, 0xC0, 0x38, 0x00, 0x07, 0x07, 0xF3, 0x8C, 0xC0, 0x30, 0x0C,
  0x03, 0xC0, 0x78, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x83, 0xBF, 0xCF, 0xE0,
  0x0C, 0x18, 0x18, 0x38, 0xFF, 0x30, 0x30, 0x30, 0x70, 0x70, 0x60, 0x60,
  0x60, 0xE0, 0xE0, 0xE0, 0xF8, 0x78, 0x38, 0x33, 0x03, 0x30, 0x33, 0x07,
  0x70, 0x66, 0x06, 0x60, 0x66, 0x0E, 0x60, 0xEE, 0x0C, 0xE1, 0xCE, 0x3C,
  0xFE, 0xC7, 0xC8, 0xE0, 0x76, 0x0E, 0x60, 0xC6, 0x1C, 0x61, 0x86, 0x38,
  0x63, 0x06, 0x70, 0x66, 0x06, 0xE0, 0x6C, 0x07, 0xC0, 0x78, 0x07, 0x80,
  0xC3, 0x83, 0xE1, 0xC1, 0xB0, 0xA1, 0xD8, 0xD0, 0xCC, 0x6C, 0xE6, 0x66,
  0x63, 0x33, 0x31, 0xB1, 0xB0, 0xD8, 0xD8, 0x68, 0x7C, 0x3C, 0x3C, 0x1E,
  0x1E, 0x0E, 0x0E, 0x07, 0x07, 0x00, 0x1C, 0x3C, 0x31, 0xC0, 0xC6, 0x01,
  0xB0, 0x07, 0xC0, 0x1E, 0x00, 0x30, 0x01, 0xC0, 0x0D, 0x80, 0x76, 0x01,
  0x98, 0x0C, 0x30, 0x70, 0xC3, 0x83, 0x80, 0x0E, 0x07, 0x06, 0x0E, 0x06,
  0x0C, 0x06, 0x1C, 0x06, 0x18, 0x06, 0x38, 0x06, 0x30, 0x06, 0x70, 0x06,
  0x60, 0x06, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0xBC, 0x00, 0xF8, 0x00, 0x0F,
  0xF1, 0x06, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0C,
  0x01, 0x80, 0x38, 0x07, 0x00, 0x7F, 0x8F, 0xF8, 0x01, 0xE0, 0x78, 0x0C,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x81, 0xE0, 0x30,
  0x0F, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x78, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0x03, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80,
  0x38, 0x07, 0x07, 0xC3, 0x80, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0x60,
  0x38, 0x3C, 0x0E, 0x00, 0xFC, 0x3F, 0xFE, 0x1F, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_Italic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 7, 19, 7, 0, -19 },
  { 18, 8, 7, 10, 3, -19 },
  { 25, 15, 19, 15, 1, -19 },
  { 61, 12, 23, 13, 1, -21 },
  { 96, 17, 20, 20, 2, -20 },
  { 139, 15, 20, 16, 0, -20 },
  { 177, 3, 7, 6, 3, -19 },
  { 180, 8, 23, 8, 1, -19 },
  { 203, 9, 23, 8, -2, -19 },
  { 229, 11, 12, 13, 3, -21 },
  { 246, 11, 13, 14, 2, -16 },
  { 264, 5, 7, 6, -1, -3 },
  { 269, 6, 2, 8, 1, -8 },
  { 271, 4, 3, 6, 0, -3 },
  { 273, 13, 19, 9, -1, -19 },
  { 304, 12, 20, 13, 1, -20 },
  { 334, 8, 19, 13, 3, -19 },
  { 353, 13, 20, 13, 0, -20 },
  { 386, 13, 20, 13, 0, -20 },
  { 419, 13, 19, 13, 0, -19 },
  { 450, 12, 19, 13, 1, -19 },
  { 479, 12, 20, 13, 1, -20 },
  { 509, 12, 19, 13, 2, -19 },
  { 538, 12, 20, 13, 1, -20 },
  { 568, 12, 20, 13, 1, -20 },
  { 598, 6, 15, 6, 0, -15 },
  { 610, 7, 19, 6, -1, -15 },
  { 627, 11, 13, 14, 2, -16 },
  { 645, 11, 7, 14, 2, -13 },
  { 655, 11, 13, 14, 2, -16 },
  { 673, 10, 20, 10, 1, -20 },
  { 698, 19, 21, 20, 1, -19 },
  { 748, 14, 19, 14, -2, -19 },
  { 782, 13, 19, 15, 1, -19 },
  { 813, 13, 20, 14, 2, -20 },
  { 846, 14, 19, 16, 1, -19 },
  { 880, 13, 19, 12, 1, -19 },
  { 911, 13, 19, 12, 1, -19 },
  { 942, 14, 20, 16, 2, -20 },
  { 977, 16, 19, 16, 1, -19 },
  { 1015, 11, 19, 8, -1, -19 },
  { 1042, 11, 24, 7, -4, -19 },
  { 1075, 15, 19, 14, 1, -19 },
  { 1111, 9, 19, 12, 1, -19 },
  { 1133, 20, 19, 21, 1, -19 },
  { 1181, 16, 19, 17, 1, -19 },
  { 1219, 15, 20, 17, 2, -20 },
  { 1257, 13, 19, 14, 1, -19 },
  { 1288, 15, 25, 17, 2, -20 },
  { 1335, 13, 19, 14, 1, -19 },
  { 1366, 13, 20, 12, 0, -20 },
  { 1399, 12, 19, 12, 2, -19 },
  { 1428, 15, 19, 16, 2, -19 },
  { 1464, 14, 19, 13, 2, -19 },
  { 1498, 20, 19, 21, 3, -19 },
  { 1546, 16, 19, 13, -1, -19 },
  { 1584, 13, 19, 12, 2, -19 },
  { 1615, 15, 19, 12, -1, -19 },
  { 1651, 10, 23, 8, 0, -19 },
  { 1680, 5, 19, 9, 3, -19 },
  { 1692, 10, 23, 8, -2, -19 },
  { 1721, 12, 11, 14, 1, -19 },
  { 1738, 10, 2, 10, -2, 2 },
  { 1741, 4, 5, 7, 4, -21 },
  { 1744, 13, 15, 14, 1, -15 },
  { 1769, 13, 21, 14, 0, -21 },
  { 1804, 10, 15, 11, 1, -15 },
  { 1823, 14, 21, 14, 1, -21 },
  { 1860, 11, 15, 12, 1, -15 },
  { 1881, 14, 27, 8, -3, -21 },
  { 1929, 14, 21, 14, 0, -15 },
  { 1966, 13, 21, 14, 0, -21 },
  { 2001, 7, 20, 6, 0, -20 },
  { 2019, 10, 26, 6, -3, -20 },
  { 2052, 13, 21, 12, 0, -21 },
  { 2087, 7, 21, 6, 0, -21 },
  { 2106, 20, 15, 21, 0, -15 },
  { 2144, 13, 15, 14, 0, -15 },
  { 2169, 12, 15, 14, 1, -15 },
  { 2192, 14, 21, 14, -1, -15 },
  { 2229, 13, 21, 14, 1, -15 },
  { 2264, 11, 15, 10, 0, -15 },
  { 2285, 10, 15, 11, 0, -15 },
  { 2304, 8, 18, 8, 1, -18 },
  { 2322, 12, 14, 14, 1, -14 },
  { 2343, 12, 14, 11, 1, -14 },
  { 2364, 17, 14, 18, 2, -14 },
  { 2394, 14, 14, 12, -1, -14 },
  { 2419, 16, 20, 11, -3, -14 },
  { 2459, 12, 14, 10, -1, -14 },
  { 2480, 11, 23, 9, 0, -19 },
  { 2512, 2, 27, 13, 6, -21 },
  { 2519, 10, 23, 9, -1, -19 },
  { 2548, 11, 3, 14, 2, -11 },
};

const GFXfont NotoSans_SemiCondensed_Italic27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic27pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC27PT7B_H_
