#ifndef _NOTOSANS_SEMICONDENSED_ITALIC24PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x31, 0xC7, 0x18, 0x61, 0x86, 0x30, 0xC3, 0x0C, 0x00, 0x06,
  0x38, 0xE0, 0xEF, 0x9B, 0x36, 0x68, 0x93, 0x00, 0x03, 0x18, 0x0C, 0x40,
  0x23, 0x01, 0x8C, 0x06, 0x20, 0xFF, 0xF0, 0x46, 0x03, 0x18, 0x0C, 0x40,
  0x23, 0x07, 0xFF, 0x3F, 0xFC, 0x11, 0x80, 0x46, 0x03, 0x10, 0x0C, 0xC0,
  0x23, 0x00, 0x03, 0x00, 0x60, 0x3F, 0x9F, 0xE3, 0x20, 0x4C, 0x09, 0x01,
  0xA0, 0x3C, 0x01, 0xE0, 0x3E, 0x04, 0xC0, 0x98, 0x13, 0x26, 0xC7, 0xF8,
  0x7C, 0x02, 0x00, 0xC0, 0x00, 0x3C, 0x1C, 0xC8, 0x31, 0x18, 0xC6, 0x23,
  0x0C, 0x46, 0x11, 0x98, 0x23, 0x62, 0x44, 0xDE, 0xDB, 0x65, 0xEC, 0x8C,
  0x1B, 0x10, 0x66, 0x21, 0x88, 0xC3, 0x11, 0x8C, 0x22, 0x30, 0x6C, 0x60,
  0xF0, 0x07, 0xC0, 0x77, 0x03, 0x18, 0x18, 0xC0, 0xC6, 0x06, 0x60, 0x36,
  0x00, 0xE0, 0x1E, 0x01, 0xD8, 0xD8, 0xE6, 0xC3, 0x6E, 0x1F, 0x60, 0x71,
  0x87, 0x8F, 0xFE, 0x3E, 0x30, 0xFB, 0x69, 0x00, 0x06, 0x18, 0x60, 0xC3,
  0x06, 0x18, 0x30, 0x61, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x02, 0x06, 0x00, 0x06, 0x06, 0x06, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x60, 0xC0,
  0x06, 0x01, 0x84, 0x43, 0xD0, 0x1F, 0xC7, 0x03, 0x61, 0xC8, 0x23, 0x00,
  0x80, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x41, 0xFF, 0xC1, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x00, 0x39, 0x9C, 0xC4, 0x60, 0xFF, 0xC0, 0x7F,
  0x80, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30,
  0x06, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0,
  0x00, 0x0F, 0x83, 0xB8, 0xE3, 0x18, 0x67, 0x0E, 0xC1, 0xD8, 0x33, 0x06,
  0xC0, 0xD8, 0x1B, 0x03, 0x60, 0xCC, 0x19, 0x87, 0x30, 0xC3, 0xF0, 0x3C,
  0x00, 0x0E, 0x3D, 0xF7, 0x64, 0xC1, 0x86, 0x0C, 0x18, 0x30, 0x61, 0x83,
  0x06, 0x0C, 0x38, 0x60, 0x0F, 0xC3, 0xDC, 0x21, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x38, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x07, 0xFE, 0xFF, 0x80, 0x0F, 0xC3, 0xDC, 0x41, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x30, 0x7C, 0x0F, 0x00, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xA0,
  0x67, 0xFC, 0xFE, 0x00, 0x00, 0x60, 0x1C, 0x07, 0x81, 0xB0, 0x36, 0x0D,
  0x83, 0x30, 0xC6, 0x30, 0xC6, 0x31, 0x86, 0x7F, 0xFF, 0xFE, 0x03, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x0F, 0xF0, 0xFE, 0x0C, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x1A, 0x03, 0xF8, 0x11, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x81, 0x8F, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xE4, 0x70, 0x0C, 0x03,
  0x00, 0xE0, 0x19, 0xC3, 0xFC, 0x71, 0x9C, 0x1B, 0x03, 0x60, 0x6C, 0x19,
  0x83, 0x38, 0xE3, 0xF8, 0x3E, 0x00, 0x7F, 0xFF, 0xF0, 0x1C, 0x06, 0x03,
  0x00, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x1C, 0x06,
  0x03, 0x00, 0xC0, 0x00, 0x0F, 0xC3, 0x98, 0xC1, 0x98, 0x33, 0x06, 0x61,
  0x86, 0x60, 0x78, 0x1F, 0x0E, 0x63, 0x86, 0x60, 0xCC, 0x19, 0x83, 0x30,
  0x67, 0xF8, 0x7E, 0x00, 0x0F, 0x8F, 0x73, 0x0D, 0x83, 0x60, 0xD8, 0x36,
  0x0D, 0x87, 0x73, 0xCF, 0xB1, 0xD8, 0x06, 0x01, 0x80, 0xC0, 0x63, 0xF8,
  0xF8, 0x00, 0x19, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x19, 0xCE, 0x00, 0x0C,
  0x70, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x0C, 0x61, 0x8C, 0x30, 0x00,
  0x60, 0x3C, 0x1E, 0x0F, 0x07, 0x81, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x00, 0x80, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0xF0, 0x78, 0x3C,
  0x1E, 0x03, 0x00, 0x00, 0x3F, 0x3B, 0xC0, 0x60, 0x30, 0x18, 0x18, 0x1C,
  0x1C, 0x18, 0x18, 0x0C, 0x04, 0x04, 0x00, 0x01, 0x81, 0xC0, 0xE0, 0x00,
  0x01, 0xFC, 0x03, 0x87, 0x03, 0x00, 0xC3, 0x00, 0x63, 0x04, 0x11, 0x0F,
  0x8D, 0x8C, 0xC6, 0x8C, 0x63, 0xC4, 0x31, 0x66, 0x11, 0xB3, 0x18, 0xD9,
  0x8C, 0x4C, 0xCA, 0x66, 0x3D, 0xE3, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x1E, 0x70, 0x03, 0xF0, 0x00, 0x00, 0xC0, 0x1E, 0x01, 0xE0, 0x36, 0x03,
  0x60, 0x66, 0x06, 0x60, 0xC6, 0x0C, 0x61, 0x86, 0x1F, 0xE3, 0xFE, 0x30,
  0x67, 0x06, 0x60, 0x3E, 0x03, 0xC0, 0x30, 0x1F, 0xC1, 0xFE, 0x18, 0x73,
  0x83, 0x30, 0x33, 0x06, 0x30, 0xE3, 0xFC, 0x7F, 0x86, 0x0C, 0x60, 0xC6,
  0x0E, 0x60, 0xEC, 0x0C, 0xC1, 0xCF, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0x7F,
  0x87, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0xF0, 0x1F,
  0x80, 0x1F, 0xC0, 0xFF, 0x06, 0x1C, 0x70, 0x63, 0x03, 0x18, 0x1C, 0xC0,
  0xE6, 0x07, 0x60, 0x33, 0x01, 0x98, 0x0C, 0xC0, 0xE6, 0x06, 0x60, 0x63,
  0x0F, 0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x60, 0x1C, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0xFC, 0x7F, 0x8C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80,
  0x30, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x60, 0x1C, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x7F, 0x8F, 0xF1, 0x80, 0x30, 0x06, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x00, 0x03, 0xFC, 0x3F, 0xE1, 0xC0, 0x0E, 0x00,
  0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x61, 0xFB, 0x87, 0xCE, 0x03,
  0x38, 0x0C, 0x60, 0x31, 0x81, 0x87, 0x06, 0x0F, 0xF8, 0x1F, 0xC0, 0x18,
  0x0C, 0x60, 0x61, 0x81, 0x8E, 0x06, 0x30, 0x18, 0xC0, 0x63, 0x03, 0x0F,
  0xFC, 0x7F, 0xF1, 0x80, 0xC6, 0x03, 0x18, 0x18, 0x60, 0x63, 0x01, 0x8C,
  0x06, 0x30, 0x38, 0xC0, 0xC0, 0x0F, 0xC1, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80,
  0xE0, 0xFC, 0x00, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x03, 0x80, 0xC2, 0x70, 0xF8, 0x10, 0x00, 0x18, 0x38, 0xC3, 0x86, 0x38,
  0x71, 0x83, 0x18, 0x19, 0x80, 0xD8, 0x07, 0xC0, 0x7E, 0x03, 0xB0, 0x19,
  0xC0, 0xC6, 0x06, 0x30, 0x61, 0xC3, 0x06, 0x18, 0x30, 0xC1, 0xC0, 0x18,
  0x18, 0x18, 0x38, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0x60,
  0xC0, 0xC0, 0xFF, 0xFE, 0x1C, 0x03, 0xC7, 0x00, 0xE1, 0x40, 0x78, 0xD0,
  0x1E, 0x36, 0x0D, 0x8D, 0x83, 0x63, 0x61, 0xB0, 0xD8, 0x6C, 0x66, 0x33,
  0x19, 0x8C, 0xC6, 0x66, 0x61, 0x99, 0x98, 0x66, 0xC6, 0x30, 0xB1, 0x8C,
  0x38, 0x63, 0x0C, 0x30, 0xC3, 0x0C, 0x00, 0x1C, 0x0E, 0x38, 0x18, 0x70,
  0x31, 0xB0, 0x63, 0x60, 0xC6, 0xC3, 0x0C, 0x86, 0x19, 0x8C, 0x63, 0x18,
  0xC6, 0x71, 0x86, 0xC3, 0x0D, 0x86, 0x1B, 0x18, 0x1E, 0x30, 0x38, 0x60,
  0x70, 0xC0, 0xE0, 0x07, 0xF0, 0x3D, 0xE1, 0xC1, 0x8E, 0x06, 0x30, 0x1D,
  0xC0, 0x36, 0x01, 0xD8, 0x07, 0x60, 0x1B, 0x80, 0x6E, 0x01, 0xB8, 0x0E,
  0xE0, 0x31, 0x81, 0xC7, 0x0E, 0x0F, 0xF0, 0x1F, 0x80, 0x1F, 0xC3, 0xFC,
  0x61, 0x9C, 0x33, 0x06, 0x60, 0xCC, 0x19, 0x86, 0x67, 0xCF, 0xE1, 0x80,
  0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x00, 0x07, 0xF0, 0x3D,
  0xE1, 0xC1, 0x8E, 0x06, 0x30, 0x1D, 0xC0, 0x36, 0x01, 0xD8, 0x07, 0x60,
  0x1F, 0x80, 0x6E, 0x01, 0xB8, 0x0E, 0xE0, 0x31, 0x81, 0xC7, 0x0E, 0x0F,
  0xF0, 0x1F, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x1F, 0xC3,
  0xFC, 0x61, 0x9C, 0x33, 0x06, 0x60, 0xCC, 0x19, 0x86, 0x7F, 0x8F, 0xC1,
  0x8C, 0x31, 0x86, 0x31, 0x87, 0x30, 0x66, 0x0C, 0xC1, 0xC0, 0x0F, 0xF1,
  0xFE, 0x18, 0x03, 0x80, 0x30, 0x03, 0x80, 0x18, 0x01, 0xE0, 0x0F, 0x00,
  0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x18, 0x83, 0x8F, 0xF0, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x00,
  0x18, 0x0C, 0x60, 0x63, 0x81, 0x8C, 0x06, 0x30, 0x18, 0xC0, 0x63, 0x03,
  0x1C, 0x0C, 0x60, 0x31, 0x80, 0xC6, 0x03, 0x18, 0x18, 0xE0, 0x61, 0x81,
  0x86, 0x0C, 0x1F, 0xF0, 0x3F, 0x00, 0xC0, 0x7C, 0x06, 0xC0, 0x6C, 0x0C,
  0xE0, 0xC6, 0x18, 0x61, 0x86, 0x30, 0x63, 0x06, 0x60, 0x66, 0x06, 0xC0,
  0x6C, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x00, 0xC0, 0xE0, 0xF8, 0x1C,
  0x1B, 0x07, 0x87, 0x60, 0xF0, 0xCC, 0x16, 0x19, 0x86, 0xC6, 0x10, 0xD8,
  0xC2, 0x33, 0x30, 0x46, 0x66, 0x0D, 0x8C, 0xC1, 0xB1, 0xB0, 0x3C, 0x36,
  0x05, 0x87, 0x80, 0xA0, 0xF0, 0x1C, 0x1C, 0x03, 0x83, 0x80, 0x60, 0x70,
  0x00, 0x0C, 0x1C, 0x30, 0x60, 0xC3, 0x01, 0x9C, 0x06, 0x60, 0x1B, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x00, 0x1E, 0x00, 0xD8, 0x03, 0x60, 0x18, 0xC0,
  0xC3, 0x07, 0x0C, 0x18, 0x30, 0xC0, 0xE0, 0xC0, 0xFC, 0x19, 0x86, 0x30,
  0xC6, 0x30, 0xCE, 0x19, 0x81, 0xE0, 0x3C, 0x07, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x0C,
  0x00, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x0F, 0xF8, 0xFF, 0xC0, 0x0F,
  0x86, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x1F, 0x0F, 0x00, 0x8C,
  0xCC, 0xCC, 0xC4, 0x66, 0x66, 0x66, 0x23, 0x30, 0x07, 0x84, 0xC0, 0x60,
  0x30, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20,
  0x30, 0x18, 0x0C, 0x06, 0x02, 0x0F, 0x0F, 0x80, 0x04, 0x01, 0xC0, 0x28,
  0x0D, 0x83, 0x30, 0x63, 0x18, 0x63, 0x04, 0xC0, 0xD8, 0x0C, 0xFF, 0xFF,
  0xC0, 0xE6, 0x30, 0x0F, 0x63, 0xEC, 0xC3, 0xB0, 0x66, 0x0D, 0xC1, 0xB0,
  0x36, 0x0E, 0xC1, 0x98, 0x73, 0x0E, 0x7E, 0xC7, 0x90, 0x0C, 0x00, 0xC0,
  0x0C, 0x01, 0xC0, 0x18, 0x01, 0xBC, 0x1F, 0xE1, 0xC6, 0x38, 0x73, 0x87,
  0x30, 0x63, 0x06, 0x30, 0x66, 0x06, 0x60, 0xC7, 0x1C, 0x7B, 0x8C, 0xF0,
  0x0F, 0x8F, 0xCC, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x0E, 0xC7, 0xE0, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0xF6,
  0x3F, 0x63, 0x0E, 0x60, 0xC6, 0x0C, 0xE0, 0xCC, 0x0C, 0xC1, 0x8C, 0x18,
  0xC3, 0x8C, 0x38, 0xFD, 0x87, 0x90, 0x0F, 0x0F, 0xCC, 0x6C, 0x36, 0x1E,
  0x3B, 0xF9, 0x80, 0xC0, 0x60, 0x30, 0x0E, 0xE3, 0xE0, 0x00, 0xF8, 0x0E,
  0x80, 0x60, 0x03, 0x00, 0x18, 0x03, 0xF0, 0x3F, 0x80, 0x60, 0x03, 0x00,
  0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x03, 0xC0, 0x1C, 0x00,
  0x07, 0xB1, 0xFB, 0x18, 0x73, 0x06, 0x30, 0x67, 0x06, 0x60, 0x66, 0x0E,
  0x60, 0xC6, 0x1C, 0x61, 0xC7, 0xEC, 0x3D, 0x80, 0x18, 0x01, 0x80, 0x38,
  0x83, 0x0F, 0xE0, 0x38, 0x00, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80,
  0x37, 0x87, 0xF8, 0xE3, 0x38, 0x66, 0x0C, 0xC1, 0x98, 0x33, 0x0E, 0xC1,
  0x98, 0x33, 0x06, 0x60, 0xDC, 0x30, 0x0C, 0x30, 0xC0, 0x00, 0x61, 0x86,
  0x30, 0xC3, 0x0C, 0x31, 0x86, 0x18, 0x63, 0x80, 0x01, 0x80, 0xC0, 0x60,
  0x00, 0x00, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x81, 0xC3, 0xC1, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x87, 0x18, 0xC1, 0x98, 0x33,
  0x03, 0x70, 0x3E, 0x03, 0xE0, 0x36, 0x06, 0x30, 0x63, 0x06, 0x30, 0x61,
  0x8E, 0x18, 0x0C, 0x30, 0xC7, 0x18, 0x61, 0x86, 0x30, 0xC3, 0x0C, 0x31,
  0x86, 0x18, 0x63, 0x80, 0x1B, 0xC7, 0x87, 0xFB, 0xE1, 0xC7, 0x1C, 0xE1,
  0xC3, 0x30, 0x61, 0x8C, 0x18, 0x63, 0x0C, 0x18, 0xC3, 0x06, 0x60, 0xC1,
  0x98, 0x30, 0xC6, 0x0C, 0x31, 0x86, 0x0C, 0xE1, 0x83, 0x00, 0x1B, 0xC3,
  0xFC, 0x71, 0x9C, 0x33, 0x86, 0x60, 0xCC, 0x19, 0x87, 0x60, 0xCC, 0x19,
  0x83, 0x30, 0x6E, 0x18, 0x0F, 0x0F, 0xE3, 0x0D, 0x83, 0x60, 0xF0, 0x3C,
  0x0F, 0x03, 0xC1, 0xF0, 0x6C, 0x39, 0xFC, 0x3E, 0x00, 0x0D, 0xE0, 0x7F,
  0x83, 0x8C, 0x38, 0x71, 0xC3, 0x8C, 0x18, 0x60, 0xC3, 0x06, 0x30, 0x31,
  0x83, 0x0E, 0x38, 0x7B, 0x83, 0x78, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x00, 0x0F, 0x63, 0xEC, 0xC3, 0xB0, 0x66, 0x0D, 0xC1,
  0xB0, 0x36, 0x0E, 0xC1, 0x98, 0x73, 0x0E, 0x7E, 0xC7, 0xB0, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x00, 0x1B, 0x8F, 0xC7, 0x07, 0x03,
  0x81, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x00, 0x1F, 0x9F,
  0xCC, 0x06, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x81, 0xDF, 0xCF,
  0xC0, 0x18, 0x30, 0xC3, 0xFF, 0xE6, 0x18, 0x30, 0x60, 0xC1, 0x86, 0x0C,
  0x18, 0x3A, 0x3C, 0x30, 0x66, 0x0C, 0xC3, 0x30, 0x66, 0x0C, 0xC1, 0x98,
  0x37, 0x0C, 0xC1, 0x98, 0x73, 0x0E, 0x7E, 0xC7, 0x90, 0xC0, 0xF0, 0x7C,
  0x19, 0x0E, 0x63, 0x19, 0xC6, 0x61, 0xB8, 0x6C, 0x1B, 0x07, 0x81, 0xE0,
  0x70, 0x00, 0xC1, 0x87, 0xC3, 0x86, 0xC3, 0x86, 0xC6, 0x8C, 0xC6, 0x8C,
  0x44, 0x98, 0x4C, 0x98, 0x48, 0x98, 0x58, 0xB0, 0x58, 0xB0, 0x70, 0xE0,
  0x70, 0xE0, 0x60, 0xC0, 0x18, 0x31, 0x86, 0x0C, 0xC0, 0xDC, 0x0D, 0x80,
  0x70, 0x06, 0x00, 0xF0, 0x1F, 0x01, 0xB0, 0x31, 0x86, 0x18, 0xE1, 0xC0,
  0x18, 0x18, 0xC1, 0xC3, 0x0C, 0x18, 0xE0, 0xC6, 0x06, 0x70, 0x33, 0x01,
  0x98, 0x0D, 0x80, 0x6C, 0x03, 0xC0, 0x1E, 0x00, 0x60, 0x07, 0x00, 0x30,
  0x03, 0x80, 0x18, 0x07, 0x80, 0x38, 0x00, 0x1F, 0xC7, 0xF0, 0x1C, 0x06,
  0x03, 0x01, 0x80, 0xE0, 0x30, 0x18, 0x0C, 0x03, 0x01, 0xFC, 0xFF, 0x00,
  0x03, 0xC1, 0xE0, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x1E,
  0x0E, 0x00, 0xC0, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xE0, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x07, 0x00,
  0xC0, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x80, 0xE1, 0xC0, 0xC0,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x1E, 0x0C, 0x00, 0x78, 0x3F, 0xFE,
  0x0F, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Italic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 17, 6, 0, -17 },
  { 14, 7, 6, 9, 3, -17 },
  { 20, 14, 17, 14, 0, -17 },
  { 50, 11, 19, 12, 1, -18 },
  { 77, 15, 17, 18, 2, -17 },
  { 109, 13, 17, 14, 0, -17 },
  { 137, 3, 6, 5, 3, -17 },
  { 140, 7, 21, 7, 1, -17 },
  { 159, 8, 21, 7, -2, -17 },
  { 180, 10, 10, 12, 2, -18 },
  { 193, 11, 11, 12, 1, -14 },
  { 209, 5, 6, 6, -1, -3 },
  { 213, 5, 2, 7, 1, -7 },
  { 215, 3, 3, 6, 0, -3 },
  { 217, 11, 17, 8, -1, -17 },
  { 241, 11, 17, 12, 1, -17 },
  { 265, 7, 17, 12, 3, -17 },
  { 280, 11, 17, 12, 0, -17 },
  { 304, 11, 17, 12, 0, -17 },
  { 328, 11, 17, 12, 0, -17 },
  { 352, 12, 17, 12, 0, -17 },
  { 378, 11, 17, 12, 1, -17 },
  { 402, 10, 17, 12, 2, -17 },
  { 424, 11, 17, 12, 1, -17 },
  { 448, 10, 17, 12, 1, -17 },
  { 470, 5, 13, 6, 0, -13 },
  { 479, 6, 16, 6, -1, -13 },
  { 491, 11, 11, 12, 1, -14 },
  { 507, 10, 7, 12, 2, -12 },
  { 516, 11, 11, 12, 1, -14 },
  { 532, 9, 17, 9, 1, -17 },
  { 552, 17, 19, 18, 1, -17 },
  { 593, 12, 17, 12, -1, -17 },
  { 619, 12, 17, 13, 1, -17 },
  { 645, 13, 17, 12, 1, -17 },
  { 673, 13, 17, 14, 1, -17 },
  { 701, 11, 17, 11, 1, -17 },
  { 725, 11, 17, 10, 1, -17 },
  { 749, 14, 17, 15, 1, -17 },
  { 779, 14, 17, 15, 1, -17 },
  { 809, 10, 17, 7, -1, -17 },
  { 831, 10, 22, 6, -4, -17 },
  { 859, 13, 17, 12, 1, -17 },
  { 887, 8, 17, 10, 1, -17 },
  { 904, 18, 17, 18, 1, -17 },
  { 943, 15, 17, 15, 1, -17 },
  { 975, 14, 17, 15, 1, -17 },
  { 1005, 11, 17, 12, 1, -17 },
  { 1029, 14, 21, 15, 1, -17 },
  { 1066, 11, 17, 12, 1, -17 },
  { 1090, 12, 17, 11, 0, -17 },
  { 1116, 11, 17, 11, 2, -17 },
  { 1140, 14, 17, 14, 1, -17 },
  { 1170, 12, 17, 12, 2, -17 },
  { 1196, 19, 17, 19, 2, -17 },
  { 1237, 14, 17, 11, -1, -17 },
  { 1267, 11, 17, 11, 2, -17 },
  { 1291, 13, 17, 11, -1, -17 },
  { 1319, 9, 21, 7, 0, -17 },
  { 1343, 4, 17, 8, 3, -17 },
  { 1352, 9, 21, 7, -2, -17 },
  { 1376, 11, 10, 12, 1, -17 },
  { 1390, 9, 2, 9, -2, 2 },
  { 1393, 4, 3, 6, 3, -18 },
  { 1395, 11, 13, 12, 1, -13 },
  { 1413, 12, 18, 12, 0, -18 },
  { 1440, 9, 13, 10, 1, -13 },
  { 1455, 12, 18, 13, 1, -18 },
  { 1482, 9, 13, 11, 1, -13 },
  { 1497, 13, 24, 7, -3, -18 },
  { 1536, 12, 19, 13, 0, -13 },
  { 1565, 11, 18, 12, 0, -18 },
  { 1590, 6, 18, 6, 0, -18 },
  { 1604, 9, 24, 6, -3, -18 },
  { 1631, 12, 18, 11, 0, -18 },
  { 1658, 6, 18, 6, 0, -18 },
  { 1672, 18, 13, 19, 0, -13 },
  { 1702, 11, 13, 12, 0, -13 },
  { 1720, 10, 13, 12, 1, -13 },
  { 1737, 13, 19, 12, -1, -13 },
  { 1768, 11, 19, 13, 1, -13 },
  { 1795, 9, 13, 8, 0, -13 },
  { 1810, 9, 13, 9, 0, -13 },
  { 1825, 7, 16, 7, 1, -16 },
  { 1839, 11, 13, 12, 1, -13 },
  { 1857, 10, 13, 10, 1, -13 },
  { 1874, 16, 13, 16, 1, -13 },
  { 1900, 12, 13, 10, -1, -13 },
  { 1920, 13, 19, 10, -2, -13 },
  { 1951, 10, 13, 9, -1, -13 },
  { 1968, 10, 21, 8, 0, -17 },
  { 1995, 2, 24, 12, 5, -18 },
  { 2001, 9, 21, 8, -1, -17 },
  { 2025, 11, 3, 12, 1, -10 },
};

const GFXfont NotoSans_SemiCondensed_Italic24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic24pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC24PT7B_H_
