#ifndef _NOTOSANS_SEMICONDENSED_ITALIC61PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x03,
  0x00, 0x00, 0x1F, 0x07, 0xC7, 0xC1, 0xF3, 0xF0, 0xFC, 0xF8, 0x3F, 0x3E,
  0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0xF0, 0x3C, 0x3C, 0x0F, 0x1F, 0x07,
  0xC7, 0x81, 0xF1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x01, 0xC3,
  0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x0F,
  0x80, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1F, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xEF, 0x3E, 0x01, 0xF8, 0xE0, 0x60,
  0x3E, 0x0E, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x3E, 0x1E, 0x00, 0x03, 0xC1,
  0xC0, 0x00, 0x3C, 0x1C, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x3E, 0x3C, 0x00,
  0x03, 0xE3, 0xC0, 0x00, 0x3F, 0x38, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xF7, 0xF0, 0x00,
  0x0F, 0x3F, 0x00, 0x00, 0xE1, 0xF0, 0x00, 0x0E, 0x1F, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xC1, 0xF0, 0x00, 0x1C, 0x1F, 0x00,
  0x01, 0xC1, 0xF0, 0x80, 0x3C, 0x3E, 0x0F, 0x03, 0xC7, 0xE0, 0xFF, 0x3F,
  0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x0F, 0xFC, 0x00,
  0x0F, 0x80, 0x7F, 0xF0, 0x00, 0x3C, 0x03, 0xFF, 0xE0, 0x01, 0xF0, 0x0F,
  0x87, 0x80, 0x07, 0x80, 0x7C, 0x1E, 0x00, 0x3C, 0x01, 0xE0, 0x7C, 0x01,
  0xF0, 0x0F, 0x81, 0xF0, 0x07, 0x80, 0x3C, 0x07, 0xC0, 0x3C, 0x00, 0xF0,
  0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x3C,
  0x00, 0x78, 0x07, 0x81, 0xF0, 0x01, 0xE0, 0x1E, 0x07, 0x80, 0x0F, 0x80,
  0x78, 0x3C, 0x00, 0x3E, 0x03, 0xE1, 0xF0, 0x00, 0xF0, 0x0F, 0x07, 0x80,
  0x03, 0xC0, 0x3C, 0x3C, 0x0E, 0x0F, 0x01, 0xF1, 0xF1, 0xFF, 0x3C, 0x07,
  0x87, 0x8F, 0xFE, 0xF0, 0x3E, 0x3C, 0x7F, 0xFB, 0xE0, 0xF1, 0xF1, 0xF1,
  0xF7, 0x87, 0xC7, 0x8F, 0x87, 0xDF, 0xFE, 0x3C, 0x7C, 0x0F, 0x7F, 0xF1,
  0xF1, 0xE0, 0x3C, 0xFF, 0x87, 0x87, 0x80, 0xF1, 0xF8, 0x3C, 0x3C, 0x03,
  0xC0, 0x01, 0xF0, 0xF0, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x3C, 0x00, 0x3E,
  0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x78, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x1E,
  0x00, 0x3E, 0x07, 0x80, 0x78, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x07, 0x80,
  0x78, 0x0F, 0x00, 0x3E, 0x01, 0xE0, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0xF0,
  0x07, 0x80, 0x1E, 0x07, 0x80, 0x3E, 0x00, 0x78, 0x3E, 0x01, 0xF0, 0x01,
  0xE0, 0xF0, 0x07, 0x80, 0x07, 0xCF, 0xC0, 0x3E, 0x00, 0x0F, 0xFE, 0x01,
  0xF0, 0x00, 0x3F, 0xF0, 0x0F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x7E, 0x00,
  0x01, 0xF0, 0x7E, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x1F, 0x07, 0xE7, 0xE0, 0x0F, 0x87, 0xE1, 0xF8,
  0x0F, 0x87, 0xE0, 0x7C, 0x07, 0xC7, 0xE0, 0x3F, 0x07, 0xC3, 0xE0, 0x0F,
  0x83, 0xE3, 0xE0, 0x07, 0xE3, 0xE1, 0xF0, 0x01, 0xF9, 0xF1, 0xF8, 0x00,
  0xFD, 0xF0, 0xF8, 0x00, 0x3F, 0xF0, 0x7C, 0x00, 0x0F, 0xF8, 0x3E, 0x00,
  0x07, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xFC, 0x07, 0xE0,
  0x01, 0xFF, 0x01, 0xF8, 0x03, 0xFF, 0x80, 0xFE, 0x03, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF9, 0xF0, 0x1F, 0xFF, 0xF0, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0x00,
  0xFF, 0xE0, 0x1F, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x3E, 0x7D, 0xFB, 0xF7,
  0xCF, 0x9F, 0x3C, 0x79, 0xF3, 0xE7, 0x8F, 0x1E, 0x38, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x80, 0x7C, 0x00, 0xF0, 0x3C, 0x00, 0x7E,
  0x1E, 0x00, 0x3F, 0xCF, 0x00, 0x3F, 0xFF, 0x00, 0x63, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xF9, 0xFE, 0x03, 0xFC, 0x00,
  0x03, 0xEF, 0x00, 0x03, 0xE7, 0x80, 0x03, 0xF1, 0xE0, 0x03, 0xF0, 0xF0,
  0x03, 0xF0, 0x7C, 0x01, 0xF0, 0x1E, 0x00, 0x78, 0x0F, 0x80, 0x18, 0x07,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x07, 0xE0,
  0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x01, 0xE0, 0x3E, 0x03,
  0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB,
  0xFF, 0xEF, 0xFF, 0xC0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0x3F, 0x80, 0x7E, 0x07, 0xE0, 0x3F,
  0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x07, 0xE0, 0x07, 0xC3, 0xF0, 0x01, 0xF0,
  0xFC, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x1F, 0x80, 0x07, 0xC7, 0xC0, 0x01,
  0xF3, 0xF0, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80,
  0x01, 0xF7, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xDF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x0F,
  0xBE, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x7C, 0xF8, 0x00,
  0x1F, 0x3E, 0x00, 0x0F, 0xCF, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF8,
  0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x03, 0xE0,
  0xF8, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x07, 0xC0, 0x7F, 0x01, 0xF8, 0x3F,
  0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x0F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xBE, 0x7F,
  0xBE, 0x7F, 0x1F, 0x1F, 0x0F, 0x8F, 0x0F, 0xC2, 0x07, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xCF, 0xF8, 0x01,
  0xF8, 0x07, 0xE0, 0x03, 0x80, 0x0F, 0xC0, 0x04, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x7C, 0x01, 0xFC, 0x01,
  0x80, 0x07, 0xE0, 0x08, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x40, 0x00, 0x1F, 0x83, 0x80, 0x01, 0xF8, 0x1F, 0x80,
  0x3F, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xBE, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x01,
  0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x7C,
  0x00, 0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x08, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x40, 0x00, 0x3F, 0x03, 0x00, 0x03, 0xF0, 0x1F, 0x00,
  0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0x0C, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC3, 0xFE, 0x00, 0xF8, 0xFF,
  0xE0, 0x1F, 0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xC0, 0xFC, 0x1F,
  0xE0, 0x0F, 0xC3, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x1F, 0xC0, 0x03,
  0xE3, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0,
  0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x3F,
  0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x3F, 0x0F, 0xC0,
  0x07, 0xC0, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x1F, 0x80,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x03, 0xF0, 0x3F,
  0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01,
  0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x03,
  0xE0, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC3,
  0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xE1,
  0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0,
  0x7C, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80,
  0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F,
  0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xE0, 0xFE,
  0x00, 0x7E, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xE3, 0xF8, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x03, 0xF0,
  0x3E, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00,
  0x0F, 0x8F, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x07, 0xE3, 0xE0, 0x00,
  0xFC, 0x7C, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE1, 0xF0, 0x01, 0xFC, 0x3F,
  0x00, 0x7F, 0x87, 0xF0, 0x1F, 0xF0, 0x7F, 0xDF, 0xFC, 0x0F, 0xFF, 0xEF,
  0x80, 0xFF, 0xF9, 0xF0, 0x07, 0xFE, 0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x06,
  0x01, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xE0, 0x3F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x07, 0x00, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F,
  0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0x81, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x1F, 0xC7, 0xF8, 0x38, 0x07, 0xF0, 0x80, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x07, 0x80,
  0x07, 0xC0, 0x07, 0x83, 0xE0, 0x07, 0xFF, 0x81, 0xE0, 0xF0, 0x07, 0xFF,
  0xE0, 0x78, 0x7C, 0x03, 0xFF, 0xF8, 0x1F, 0x1E, 0x01, 0xF8, 0x3E, 0x07,
  0xCF, 0x80, 0xF8, 0x0F, 0x01, 0xF3, 0xC0, 0x7C, 0x03, 0xC0, 0x7D, 0xF0,
  0x1E, 0x01, 0xF0, 0x1E, 0x78, 0x0F, 0x80, 0x7C, 0x07, 0x9E, 0x03, 0xC0,
  0x1E, 0x01, 0xE7, 0x81, 0xF0, 0x07, 0x80, 0x7B, 0xE0, 0x78, 0x03, 0xE0,
  0x1E, 0xF0, 0x1E, 0x00, 0xF8, 0x07, 0xBC, 0x0F, 0x80, 0x3C, 0x03, 0xCF,
  0x03, 0xC0, 0x0F, 0x00, 0xF3, 0xC0, 0xF0, 0x07, 0xC0, 0x3C, 0xF0, 0x3C,
  0x01, 0xF0, 0x1E, 0x3C, 0x0F, 0x00, 0xF8, 0x07, 0x8F, 0x03, 0xC0, 0x3E,
  0x03, 0xC3, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0xF0, 0x3E, 0x0F, 0xF0, 0xF8,
  0x3C, 0x07, 0xC7, 0xBE, 0x7C, 0x0F, 0x01, 0xFF, 0xCF, 0xFF, 0x03, 0xC0,
  0x3F, 0xE1, 0xFF, 0x80, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x40, 0x00, 0x0F, 0xE0,
  0x00, 0x70, 0x00, 0x01, 0xFF, 0xC3, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x01, 0xF8, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0x1F, 0x01, 0xE0, 0x00, 0x7E, 0x03, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x01,
  0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7E, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x1F,
  0x3F, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80,
  0x1F, 0x00, 0x7F, 0x80, 0x3E, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x01,
  0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xFC, 0x07, 0xC0, 0x01, 0xF8, 0x1F,
  0x80, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x3F, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0x80,
  0x07, 0xE0, 0x1F, 0x00, 0x7F, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xC0, 0xFF,
  0xC0, 0x0F, 0x80, 0x1F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F,
  0x80, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C,
  0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xF8, 0x1F, 0x00, 0x1F, 0xE0, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xBF, 0x80, 0x1F, 0xE0, 0x07, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x01, 0x00, 0x1F, 0xF0, 0x1E, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07,
  0xC0, 0x7F, 0xE0, 0x03, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xFC, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xFC,
  0x0F, 0x80, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F,
  0x83, 0xE0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x03,
  0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00,
  0xFC, 0x1F, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x1F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0x07, 0xE0, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7C, 0x00,
  0x03, 0xF0, 0x3E, 0x00, 0x03, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x0F, 0x80,
  0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xFC, 0x07, 0xC0, 0x01, 0xFC, 0x03, 0xE0,
  0x03, 0xFC, 0x01, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xBF, 0xF0, 0x07, 0xFC, 0x00,
  0xF8, 0x07, 0xF8, 0x00, 0x08, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0xE3, 0xF0, 0x00, 0xFF, 0xF1, 0xF0,
  0x00, 0xFF, 0xF8, 0xF8, 0x00, 0x7F, 0xFC, 0x7C, 0x00, 0x3F, 0xFE, 0x3E,
  0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x3E, 0x03, 0xF8, 0x00, 0x1F,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x7F, 0xC0, 0x3F, 0x80, 0x1F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x1F, 0x80, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x1F,
  0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0xF8,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x1F, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00,
  0xF8, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x3E, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x20, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x1F, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x1F,
  0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x7C, 0x03,
  0xF0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xE0,
  0x7F, 0x00, 0x00, 0xF8, 0x3F, 0x80, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x0F,
  0x87, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00,
  0x7C, 0xFC, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x07, 0xDF, 0x80, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x07, 0xF0, 0xF8, 0x00, 0x01, 0xF8, 0x3E,
  0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x01,
  0xF8, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x01, 0xF8, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x7D, 0xF0, 0x07, 0xFE, 0x00, 0x01,
  0xF7, 0xC0, 0x1E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0xF9, 0xE0, 0x00, 0x3E,
  0xF8, 0x03, 0xE7, 0x80, 0x01, 0xF3, 0xE0, 0x0F, 0x9E, 0x00, 0x07, 0xCF,
  0x80, 0x3E, 0x78, 0x00, 0x3E, 0x7E, 0x00, 0xF9, 0xE0, 0x00, 0xF9, 0xF0,
  0x07, 0xC7, 0xC0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00,
  0x7C, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xF0, 0x0F,
  0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8,
  0x3C, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF0, 0x0F, 0x83, 0xE0, 0x0F, 0x83,
  0xC0, 0x7C, 0x1F, 0x80, 0x7C, 0x0F, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x3C,
  0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xE1,
  0xF0, 0x3F, 0x00, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x03, 0xE0, 0x3E, 0x3E,
  0x03, 0xE0, 0x0F, 0x80, 0xF8, 0xF8, 0x0F, 0x80, 0x3E, 0x03, 0xE7, 0xC0,
  0x3E, 0x00, 0xF8, 0x07, 0x9F, 0x01, 0xF8, 0x03, 0xE0, 0x1E, 0xF8, 0x07,
  0xC0, 0x1F, 0x00, 0x7B, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xFF, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0xE0, 0x0F, 0xC0,
  0x3E, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xFC, 0x00, 0xF8, 0x03,
  0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3E,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x3F, 0x80, 0x00, 0x3E, 0x01, 0xFC, 0x00, 0x01, 0xF0,
  0x0F, 0xF0, 0x00, 0x0F, 0x80, 0x7F, 0x80, 0x00, 0xF8, 0x07, 0xFC, 0x00,
  0x07, 0xC0, 0x3F, 0xF0, 0x00, 0x3E, 0x01, 0xFF, 0x80, 0x01, 0xF0, 0x0F,
  0xFC, 0x00, 0x0F, 0x80, 0x79, 0xF0, 0x00, 0xF8, 0x07, 0xCF, 0x80, 0x07,
  0xC0, 0x3E, 0x7C, 0x00, 0x3E, 0x01, 0xF3, 0xE0, 0x01, 0xF0, 0x0F, 0x8F,
  0x80, 0x1F, 0x80, 0x78, 0x7C, 0x00, 0xF8, 0x07, 0xC3, 0xE0, 0x07, 0xC0,
  0x3E, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x0F, 0x83, 0xE0,
  0x1F, 0x00, 0xF8, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3E,
  0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x1F,
  0x00, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x3E, 0x00,
  0x7C, 0x3E, 0x01, 0xF0, 0x03, 0xE1, 0xF0, 0x0F, 0x80, 0x1F, 0x1F, 0x00,
  0xF8, 0x00, 0xF8, 0xF8, 0x07, 0xC0, 0x03, 0xE7, 0xC0, 0x3E, 0x00, 0x1F,
  0x3E, 0x01, 0xF0, 0x00, 0xF9, 0xE0, 0x0F, 0x80, 0x03, 0xFF, 0x00, 0xF8,
  0x00, 0x1F, 0xF8, 0x07, 0xC0, 0x00, 0xFF, 0xC0, 0x3E, 0x00, 0x03, 0xFE,
  0x01, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0x00, 0x00, 0xFF, 0x00, 0xF8, 0x00,
  0x07, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0xC0, 0x3E, 0x00, 0x00, 0xFE, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFE,
  0xFF, 0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x7E, 0x07, 0xF0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0xF8, 0xF8,
  0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x1F, 0x7E,
  0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x01,
  0xF9, 0xF0, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7C, 0x07, 0xF8, 0x03, 0xE0, 0x0F,
  0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xC0,
  0x7C, 0x00, 0x3E, 0x07, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x3F, 0x07, 0xE0, 0x01,
  0xF8, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0xC0,
  0x7C, 0x00, 0xFE, 0x07, 0xE0, 0x1F, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0xC0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7E,
  0x07, 0xF0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00,
  0x7C, 0xFC, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00,
  0x0F, 0xBF, 0x00, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0x7C, 0x00,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x07, 0xEF, 0x80,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x01, 0xF9, 0xF0,
  0x00, 0x01, 0xF8, 0xF8, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x7C, 0x07, 0xF8, 0x03, 0xE0, 0x0F, 0xE0,
  0x3F, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x7C,
  0x00, 0x3E, 0x07, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8,
  0x3E, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0xC0, 0x7C,
  0x01, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x7C, 0x00,
  0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0xFC,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0xFC, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xE0,
  0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xE0, 0xFC,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xE1, 0xF0, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x78,
  0x07, 0xF0, 0x00, 0x80, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x40, 0x00, 0x3F, 0x03, 0x80, 0x07, 0xF8, 0x1F,
  0x80, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x0F,
  0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x03, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x0F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0xFC, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01,
  0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0xFC, 0x0F, 0x80,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xE0, 0x3E,
  0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x01, 0xF9, 0xF0,
  0x00, 0x03, 0xF3, 0xE0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x1F, 0x8F, 0x80,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x07, 0xE0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0x7C, 0x07, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0x1F, 0x80, 0x0F,
  0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0xF8, 0x03, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x80,
  0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF7,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xEF, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0x9F,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0xF0, 0x00, 0x7C, 0x7C,
  0x00, 0x1F, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xE1, 0xF0,
  0x00, 0xF7, 0x80, 0x07, 0xC3, 0xE0, 0x03, 0xEF, 0x00, 0x1F, 0x87, 0xC0,
  0x07, 0xDE, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x3C, 0x00, 0xFC, 0x1F, 0x00,
  0x3E, 0x78, 0x01, 0xF0, 0x3E, 0x00, 0x78, 0xF0, 0x07, 0xE0, 0x7C, 0x01,
  0xF1, 0xE0, 0x0F, 0x80, 0xF8, 0x03, 0xC3, 0xC0, 0x1F, 0x01, 0xF0, 0x0F,
  0x87, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x7C,
  0x1E, 0x03, 0xF0, 0x0F, 0x80, 0xF8, 0x3C, 0x07, 0xC0, 0x1F, 0x01, 0xE0,
  0x78, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x01,
  0xE0, 0x7C, 0x00, 0xF8, 0x3E, 0x03, 0xC1, 0xF0, 0x00, 0xF0, 0x7C, 0x07,
  0x83, 0xE0, 0x01, 0xE1, 0xF0, 0x0F, 0x0F, 0xC0, 0x03, 0xC3, 0xE0, 0x1E,
  0x1F, 0x00, 0x07, 0x87, 0x80, 0x3E, 0x3E, 0x00, 0x0F, 0x1F, 0x00, 0x7C,
  0xF8, 0x00, 0x1E, 0x3C, 0x00, 0xF9, 0xF0, 0x00, 0x3C, 0xF8, 0x01, 0xF7,
  0xC0, 0x00, 0x79, 0xF0, 0x03, 0xCF, 0x80, 0x00, 0xF3, 0xC0, 0x07, 0x9F,
  0x00, 0x01, 0xEF, 0x80, 0x0F, 0x7C, 0x00, 0x03, 0xDE, 0x00, 0x1E, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x07, 0xC3, 0xF0, 0x00,
  0x00, 0x3E, 0x3E, 0x00, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00, 0x3E, 0xFC,
  0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x0F, 0xC1, 0xF0,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x03, 0xF0,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x3E, 0x7C, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0xFC, 0x7C, 0x00, 0x0F,
  0xC7, 0xE0, 0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xF0, 0x3E,
  0x00, 0x7E, 0x03, 0xE0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x0F,
  0x80, 0x1F, 0x01, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0xF0, 0x7E, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x9F,
  0x80, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xBF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xF8, 0x0F, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x3C, 0x07, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x01,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x1F, 0x1E, 0x00,
  0x03, 0xC3, 0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x07, 0xC0,
  0xF8, 0x00, 0xF0, 0x0F, 0x00, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x01,
  0xF0, 0x03, 0xE0, 0x3C, 0x00, 0x3C, 0x0F, 0x80, 0x07, 0xC1, 0xE0, 0x00,
  0xF8, 0x7C, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1E, 0x78,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0xFC, 0x7E, 0x1F, 0x0F, 0xC3, 0xE0,
  0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xC0, 0x00, 0x1F, 0xE0, 0x78, 0x01, 0xFF,
  0x87, 0x80, 0x3F, 0xFE, 0x3C, 0x03, 0xFF, 0xFB, 0xE0, 0x3F, 0xC3, 0xDF,
  0x01, 0xF8, 0x0F, 0xF8, 0x1F, 0x80, 0x3F, 0x81, 0xF8, 0x00, 0xFC, 0x0F,
  0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF8, 0x7E, 0x00,
  0x0F, 0x83, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x3F,
  0x0F, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF0, 0x7E, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x7F,
  0x03, 0xE0, 0x07, 0xF0, 0x1F, 0x00, 0x7F, 0x80, 0xFC, 0x07, 0xFC, 0x07,
  0xF0, 0x7B, 0xE0, 0x1F, 0xFF, 0x9E, 0x00, 0xFF, 0xF8, 0xF0, 0x03, 0xFF,
  0x87, 0x80, 0x0F, 0xF8, 0x3C, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x07, 0xF0, 0x01,
  0xF1, 0xFF, 0x80, 0x3F, 0x3F, 0xFC, 0x03, 0xE7, 0xFF, 0xE0, 0x3E, 0xF8,
  0x7E, 0x03, 0xFE, 0x03, 0xF0, 0x3F, 0xC0, 0x3F, 0x07, 0xF8, 0x01, 0xF0,
  0x7F, 0x00, 0x1F, 0x07, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x07, 0xE0,
  0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F,
  0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x03, 0xF1, 0xF0,
  0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x07,
  0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x3F,
  0x00, 0x1F, 0x87, 0xF0, 0x03, 0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xFC, 0x0F,
  0xE0, 0x79, 0xFF, 0xFC, 0x07, 0x9F, 0xFF, 0x80, 0xF8, 0xFF, 0xF0, 0x0F,
  0x07, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFC, 0x1C, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x20, 0x3F, 0x80, 0xE0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x03, 0xFC, 0x1F, 0x00, 0x1F, 0xFC, 0x7C, 0x00,
  0x7F, 0xFC, 0xF8, 0x01, 0xFF, 0xFD, 0xF0, 0x07, 0xF8, 0x7B, 0xE0, 0x1F,
  0xC0, 0x3F, 0xC0, 0x3F, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x3F, 0x00,
  0x07, 0xC0, 0x7E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x03, 0xF0, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3E,
  0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xF0,
  0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x80, 0x3E, 0x00, 0xFF, 0x00,
  0x7E, 0x03, 0xFE, 0x00, 0xFE, 0x0F, 0x7C, 0x00, 0xFF, 0xFC, 0xF0, 0x01,
  0xFF, 0xF1, 0xE0, 0x01, 0xFF, 0xC3, 0xC0, 0x01, 0xFF, 0x07, 0x80, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xF8, 0x3F, 0x07, 0xF0, 0x1F, 0x07, 0xE0,
  0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x00,
  0x3F, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0xFE, 0x3E, 0x03, 0xFC, 0x7E, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x7F, 0xC0,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x10, 0x3F, 0x80, 0x70, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x1E, 0x00, 0x3F,
  0xF8, 0x78, 0x00, 0xFF, 0xF8, 0xF0, 0x03, 0xFF, 0xFB, 0xE0, 0x0F, 0xF0,
  0xF7, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7E, 0x00, 0xFE, 0x01, 0xF8, 0x00,
  0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E,
  0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x7C, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x1F,
  0x80, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x7F, 0x00, 0x7C,
  0x01, 0xFE, 0x00, 0xFC, 0x07, 0xFC, 0x01, 0xFC, 0x1E, 0xF8, 0x01, 0xFF,
  0xFB, 0xE0, 0x03, 0xFF, 0xE7, 0xC0, 0x03, 0xFF, 0x8F, 0x80, 0x03, 0xFE,
  0x1F, 0x00, 0x00, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x01, 0x80, 0x03, 0xF0,
  0x03, 0xC0, 0x1F, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x07,
  0xF0, 0x01, 0xF1, 0xFF, 0xC0, 0x1E, 0x3F, 0xFC, 0x03, 0xE7, 0xFF, 0xE0,
  0x3E, 0xF8, 0x7E, 0x03, 0xFE, 0x03, 0xF0, 0x3F, 0xC0, 0x3F, 0x07, 0xF8,
  0x01, 0xF0, 0x7F, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3E,
  0x07, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xE0, 0xF8,
  0x00, 0x7E, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x1F, 0x80, 0x07,
  0xC1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0xF8, 0x1F,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x01,
  0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07,
  0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0xFC, 0x00,
  0x3E, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF8, 0x07,
  0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x01, 0xF0, 0x07, 0xE0, 0x3F,
  0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x03, 0xE0, 0x3F,
  0x00, 0x3E, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x7C, 0x1F, 0x80, 0x07,
  0xC3, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0xF8, 0xF8,
  0x00, 0x0F, 0x9F, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFE, 0xF8, 0x00, 0x1F, 0xCF,
  0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xE0, 0x7E, 0x00,
  0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x3F, 0x00, 0x3E, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0xF8,
  0x07, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x00, 0x01, 0xE0, 0xFF, 0x00, 0x7F, 0x00, 0x1E, 0x1F, 0xF8, 0x1F,
  0xFC, 0x01, 0xE7, 0xFF, 0xC3, 0xFF, 0xE0, 0x3E, 0x7F, 0xFC, 0x7F, 0xFE,
  0x03, 0xEF, 0x8F, 0xCF, 0x87, 0xE0, 0x3F, 0xE0, 0x7F, 0xE0, 0x3F, 0x03,
  0xF8, 0x03, 0xFC, 0x03, 0xF0, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0xE0, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC1,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC1, 0xF0,
  0x00, 0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x83, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x7C,
  0x00, 0x7E, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0xFF, 0x80, 0x1E, 0x1F, 0xFC, 0x03,
  0xE7, 0xFF, 0xE0, 0x3E, 0xFF, 0xFE, 0x03, 0xEF, 0xCF, 0xF0, 0x3F, 0xE0,
  0x3F, 0x03, 0xFC, 0x03, 0xF0, 0x7F, 0x80, 0x3F, 0x07, 0xF0, 0x03, 0xF0,
  0x7F, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0,
  0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x7E,
  0x1F, 0x80, 0x07, 0xC1, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0xC1, 0xF0,
  0x00, 0xFC, 0x1F, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x0F,
  0x83, 0xE0, 0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF0, 0x7E,
  0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x3F, 0x07, 0xC0, 0x03,
  0xF0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x03, 0xFC, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x3F,
  0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC7, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x7C,
  0xFC, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF7, 0xE0, 0x00,
  0x7D, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0xFD, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xEF,
  0xC0, 0x01, 0xF3, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x3F, 0x1F, 0x00, 0x1F,
  0x87, 0xE0, 0x07, 0xC1, 0xF8, 0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0xE0, 0x00, 0x78, 0x7F, 0xE0, 0x00,
  0xF1, 0xFF, 0xE0, 0x03, 0xE7, 0xFF, 0xE0, 0x07, 0xDF, 0x0F, 0xC0, 0x0F,
  0xF8, 0x0F, 0xC0, 0x1F, 0xE0, 0x1F, 0x80, 0x3F, 0x80, 0x1F, 0x00, 0xFE,
  0x00, 0x3E, 0x01, 0xFC, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0xF8, 0x07, 0xE0,
  0x01, 0xF0, 0x1F, 0x80, 0x03, 0xE0, 0x3F, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7E, 0x07, 0xC0, 0x00,
  0xFC, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x0F,
  0xC0, 0x7C, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0xFC,
  0x07, 0xE0, 0x01, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x80, 0x1F, 0x80,
  0x7F, 0x80, 0x7F, 0x00, 0xFF, 0x81, 0xFC, 0x01, 0xF7, 0xFF, 0xF0, 0x03,
  0xEF, 0xFF, 0xC0, 0x0F, 0x8F, 0xFF, 0x00, 0x1F, 0x0F, 0xF8, 0x00, 0x3E,
  0x03, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x78, 0x01, 0xFF,
  0x87, 0x80, 0x3F, 0xFE, 0x3C, 0x03, 0xFF, 0xFB, 0xE0, 0x3F, 0xC3, 0xDF,
  0x01, 0xF8, 0x0F, 0xF8, 0x1F, 0x80, 0x3F, 0x81, 0xF8, 0x00, 0xFC, 0x0F,
  0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF0, 0x7E, 0x00,
  0x0F, 0x83, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x3F,
  0x0F, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F,
  0x00, 0x07, 0xE0, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF0, 0x7E, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x7F,
  0x07, 0xE0, 0x07, 0xF0, 0x1F, 0x00, 0x7F, 0x80, 0xFC, 0x07, 0xFC, 0x07,
  0xF0, 0x7B, 0xE0, 0x1F, 0xFF, 0xBE, 0x00, 0xFF, 0xF9, 0xF0, 0x03, 0xFF,
  0x8F, 0x80, 0x0F, 0xF8, 0x7C, 0x00, 0x0C, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xE0, 0xFE, 0x03, 0xC3, 0xF8, 0x07, 0x9F, 0xF0, 0x1F, 0x3F, 0xE0,
  0x3E, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F,
  0x03, 0xC1, 0xF8, 0x01, 0x83, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x84, 0x00, 0x3F, 0x0F, 0x00, 0xFE, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC1, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x80,
  0x7F, 0xC0, 0x02, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0x7C,
  0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x1F, 0x00,
  0x0F, 0x87, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3,
  0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x1F, 0x80, 0x07, 0xC3, 0xE0, 0x00,
  0xF8, 0x7C, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xC3, 0xF0, 0x00, 0xF8, 0x7C,
  0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x1F,
  0x0F, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x87, 0xC0,
  0x07, 0xE0, 0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x3F, 0x83, 0xE0, 0x0F, 0xF0,
  0x7C, 0x03, 0xFE, 0x0F, 0xC1, 0xF7, 0x81, 0xFF, 0xFC, 0xF0, 0x1F, 0xFF,
  0x1E, 0x03, 0xFF, 0xC7, 0xC0, 0x1F, 0xE0, 0xF8, 0x00, 0x60, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF3, 0xE0, 0x00,
  0x7C, 0xFC, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xC1, 0xF0,
  0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x1F, 0x01,
  0xF0, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C,
  0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x03, 0xE0, 0x03, 0xC1,
  0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03,
  0xE7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00,
  0x03, 0xEF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xF8, 0x00, 0xFB, 0xE0, 0x07,
  0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0xE0, 0x07, 0xCF, 0x80, 0x3F, 0xC0, 0x1F,
  0x9F, 0x00, 0x7F, 0x80, 0x3E, 0x3E, 0x01, 0xFF, 0x00, 0x7C, 0x7C, 0x03,
  0xDE, 0x01, 0xF0, 0xF8, 0x07, 0xBC, 0x03, 0xE1, 0xF0, 0x1E, 0x78, 0x0F,
  0xC3, 0xE0, 0x3C, 0xF0, 0x1F, 0x07, 0xC0, 0xF9, 0xE0, 0x3E, 0x0F, 0x81,
  0xE3, 0xC0, 0xF8, 0x1F, 0x07, 0xC7, 0x81, 0xF0, 0x3E, 0x0F, 0x0F, 0x07,
  0xC0, 0x7C, 0x3E, 0x1E, 0x0F, 0x80, 0xF8, 0x78, 0x3C, 0x3F, 0x01, 0xF0,
  0xF0, 0x78, 0x7C, 0x03, 0xE3, 0xE0, 0xF0, 0xF8, 0x07, 0xC7, 0x81, 0xE3,
  0xE0, 0x0F, 0x9F, 0x03, 0xC7, 0xC0, 0x1F, 0x3C, 0x07, 0x9F, 0x00, 0x3E,
  0xF8, 0x0F, 0x3E, 0x00, 0x7D, 0xE0, 0x1E, 0x78, 0x00, 0xFB, 0xC0, 0x3D,
  0xF0, 0x01, 0xFF, 0x80, 0x7B, 0xE0, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x03,
  0xE0, 0x0F, 0x80, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x00, 0xF8, 0x07, 0xE0,
  0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x1F, 0x07, 0xE0, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xF7, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xE0,
  0x1F, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x07, 0xE0, 0x03,
  0xE0, 0x1F, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x1F, 0x80, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0xFC, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x1F, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x03, 0xCF,
  0x80, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x01,
  0xEF, 0x80, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x20, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x0B, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x4F, 0xF8, 0x00, 0x17, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFA, 0x00, 0x0F, 0xF8, 0x80, 0x00, 0x00, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Italic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 15, 45, 15, 1, -44 },
  { 86, 18, 16, 23, 6, -44 },
  { 122, 34, 44, 34, 1, -44 },
  { 309, 28, 50, 30, 1, -46 },
  { 484, 38, 45, 44, 4, -44 },
  { 698, 33, 45, 36, 1, -44 },
  { 884, 7, 16, 13, 7, -44 },
  { 898, 19, 54, 17, 2, -44 },
  { 1027, 20, 54, 17, -5, -44 },
  { 1162, 25, 26, 29, 6, -47 },
  { 1244, 26, 29, 32, 4, -36 },
  { 1339, 12, 15, 14, -3, -7 },
  { 1362, 15, 5, 18, 1, -19 },
  { 1372, 7, 8, 14, 1, -7 },
  { 1379, 29, 44, 21, -3, -44 },
  { 1539, 26, 45, 30, 3, -44 },
  { 1686, 17, 44, 30, 8, -44 },
  { 1780, 30, 44, 30, -1, -44 },
  { 1945, 29, 45, 30, 0, -44 },
  { 2109, 29, 44, 30, 0, -44 },
  { 2269, 29, 45, 30, 1, -44 },
  { 2433, 27, 45, 30, 3, -44 },
  { 2585, 27, 44, 30, 4, -44 },
  { 2734, 28, 45, 30, 2, -44 },
  { 2892, 27, 45, 30, 2, -44 },
  { 3044, 12, 34, 14, 1, -33 },
  { 3095, 16, 41, 14, -3, -33 },
  { 3177, 26, 29, 32, 4, -36 },
  { 3272, 26, 17, 32, 4, -30 },
  { 3328, 26, 29, 32, 4, -36 },
  { 3423, 22, 45, 23, 3, -44 },
  { 3547, 42, 49, 46, 3, -44 },
  { 3805, 31, 44, 31, -4, -44 },
  { 3976, 31, 44, 33, 2, -44 },
  { 4147, 31, 45, 31, 4, -44 },
  { 4322, 33, 44, 36, 2, -44 },
  { 4504, 29, 44, 28, 2, -44 },
  { 4664, 29, 44, 26, 2, -44 },
  { 4824, 33, 45, 37, 4, -44 },
  { 5010, 36, 44, 37, 2, -44 },
  { 5208, 24, 44, 18, -2, -44 },
  { 5340, 25, 56, 15, -9, -44 },
  { 5515, 34, 44, 31, 2, -44 },
  { 5702, 20, 44, 26, 2, -44 },
  { 5812, 46, 44, 47, 2, -44 },
  { 6065, 37, 44, 39, 2, -44 },
  { 6269, 33, 45, 39, 4, -44 },
  { 6455, 29, 44, 31, 2, -44 },
  { 6615, 33, 54, 39, 4, -44 },
  { 6838, 29, 44, 31, 2, -44 },
  { 6998, 29, 45, 28, 0, -44 },
  { 7162, 27, 44, 27, 5, -44 },
  { 7311, 34, 45, 37, 4, -44 },
  { 7503, 31, 44, 30, 5, -44 },
  { 7674, 47, 44, 48, 6, -44 },
  { 7933, 36, 44, 29, -3, -44 },
  { 8131, 28, 44, 28, 5, -44 },
  { 8285, 32, 44, 28, -1, -44 },
  { 8461, 23, 54, 18, -1, -44 },
  { 8617, 11, 44, 21, 6, -44 },
  { 8678, 23, 54, 18, -4, -44 },
  { 8834, 27, 26, 31, 2, -44 },
  { 8922, 23, 4, 22, -5, 5 },
  { 8934, 9, 10, 16, 9, -47 },
  { 8946, 29, 34, 31, 2, -33 },
  { 9070, 28, 47, 32, 1, -46 },
  { 9235, 24, 34, 25, 2, -33 },
  { 9337, 31, 47, 32, 2, -46 },
  { 9520, 24, 34, 28, 2, -33 },
  { 9622, 32, 62, 17, -7, -47 },
  { 9870, 31, 48, 32, 0, -33 },
  { 10056, 28, 46, 32, 1, -46 },
  { 10217, 15, 45, 14, 1, -45 },
  { 10302, 24, 60, 14, -8, -45 },
  { 10482, 28, 46, 27, 1, -46 },
  { 10643, 15, 46, 14, 1, -46 },
  { 10730, 44, 33, 48, 1, -33 },
  { 10912, 28, 33, 32, 1, -33 },
  { 11028, 26, 34, 31, 2, -33 },
  { 11139, 31, 47, 32, -2, -33 },
  { 11322, 29, 48, 32, 2, -33 },
  { 11496, 23, 33, 22, 1, -33 },
  { 11591, 23, 34, 24, 0, -33 },
  { 11689, 17, 41, 18, 3, -40 },
  { 11777, 27, 34, 32, 3, -33 },
  { 11892, 26, 33, 26, 3, -33 },
  { 12000, 39, 33, 40, 4, -33 },
  { 12161, 30, 33, 26, -2, -33 },
  { 12285, 35, 48, 26, -6, -33 },
  { 12495, 25, 33, 24, -1, -33 },
  { 12599, 23, 54, 21, 1, -44 },
  { 12755, 5, 61, 29, 13, -46 },
  { 12794, 23, 54, 21, -3, -44 },
  { 12950, 26, 9, 32, 4, -26 },
};

const GFXfont NotoSans_SemiCondensed_Italic61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic61pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC61PT7B_H_
