#ifndef _NOTOSANS_SEMICONDENSED_ITALIC56PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x07, 0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x20,
  0x00, 0x3E, 0x1F, 0x3E, 0x1F, 0x3C, 0x1F, 0x7C, 0x1E, 0x7C, 0x1E, 0x7C,
  0x3E, 0x78, 0x3E, 0x78, 0x3C, 0x78, 0x3C, 0x70, 0x3C, 0xF0, 0x38, 0xF0,
  0x38, 0xF0, 0x78, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x0E,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0xF0, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0x80, 0x1C, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x38, 0x0F, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x80, 0x3C, 0x07, 0x00, 0x00, 0x70, 0x1E,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x07, 0x01, 0xE0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0x0E, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7E, 0x73,
  0xE0, 0x3E, 0x1C, 0x10, 0x0F, 0x0E, 0x00, 0x07, 0xC3, 0x80, 0x01, 0xE0,
  0xE0, 0x00, 0x78, 0x38, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0xC7, 0x00, 0x01,
  0xF1, 0xC0, 0x00, 0x7E, 0x70, 0x00, 0x0F, 0xDC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xCF, 0xC0, 0x00, 0x71, 0xF0, 0x00,
  0x1C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xE0, 0xF0,
  0x00, 0x38, 0x7C, 0x00, 0x0E, 0x1F, 0x0C, 0x07, 0x8F, 0x83, 0xC1, 0xCF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xE0, 0x1F, 0xF0, 0x00, 0x78, 0x07,
  0xFF, 0x00, 0x0F, 0x01, 0xF1, 0xE0, 0x03, 0xC0, 0x3C, 0x1E, 0x00, 0xF0,
  0x0F, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x01,
  0xE0, 0x0F, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x3C, 0x0F, 0x00, 0x38, 0x07,
  0x83, 0xE0, 0x0F, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x3C, 0x1E, 0x00, 0x3C,
  0x07, 0x87, 0xC0, 0x07, 0x80, 0xF0, 0xF0, 0x00, 0xF0, 0x3C, 0x3C, 0x0C,
  0x1E, 0x07, 0x8F, 0x8F, 0xE3, 0xC0, 0xF1, 0xE3, 0xFE, 0x78, 0x3C, 0x78,
  0xFF, 0xEF, 0x07, 0x9F, 0x3E, 0x3D, 0xF1, 0xE3, 0xCF, 0x87, 0x9F, 0xF8,
  0xF1, 0xE0, 0x7B, 0xFE, 0x3E, 0x3C, 0x0F, 0x3F, 0x87, 0x8F, 0x01, 0xE0,
  0xC1, 0xE1, 0xE0, 0x38, 0x00, 0x7C, 0x38, 0x0F, 0x00, 0x0F, 0x0F, 0x01,
  0xE0, 0x03, 0xC1, 0xE0, 0x3C, 0x00, 0xF8, 0x3C, 0x07, 0x80, 0x1E, 0x07,
  0x80, 0xF0, 0x07, 0x80, 0xF0, 0x1C, 0x01, 0xF0, 0x1C, 0x07, 0x80, 0x3C,
  0x03, 0x80, 0xF0, 0x0F, 0x00, 0x70, 0x3C, 0x03, 0xE0, 0x0E, 0x07, 0x80,
  0x78, 0x01, 0xE1, 0xE0, 0x1E, 0x00, 0x3C, 0x7C, 0x03, 0xC0, 0x07, 0xFF,
  0x00, 0xF0, 0x00, 0x7F, 0xC0, 0x3C, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF0, 0x0F, 0x80,
  0x03, 0xC0, 0x3E, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0xF0, 0x1F, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E,
  0x3E, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7E, 0xF8, 0x03, 0xC3, 0xF3, 0xF0, 0x1F, 0x1F, 0x07, 0xC0, 0x78,
  0xF8, 0x0F, 0x83, 0xE7, 0xC0, 0x3E, 0x0F, 0x1F, 0x00, 0x7C, 0x7C, 0x78,
  0x01, 0xFB, 0xE3, 0xE0, 0x03, 0xEF, 0x8F, 0x80, 0x0F, 0xFC, 0x3E, 0x00,
  0x1F, 0xE0, 0xF8, 0x00, 0x3F, 0x83, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x07,
  0xF0, 0x3F, 0x00, 0x3F, 0xE0, 0x7E, 0x03, 0xFF, 0x81, 0xFF, 0xFF, 0xBF,
  0x03, 0xFF, 0xFC, 0x7C, 0x07, 0xFF, 0xC0, 0xF8, 0x0F, 0xFE, 0x03, 0xF0,
  0x07, 0x00, 0x00, 0x00, 0x3E, 0x7C, 0xF9, 0xE7, 0xCF, 0x9E, 0x3C, 0x78,
  0xF1, 0xC7, 0x8F, 0x1C, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x01, 0x00, 0xF0, 0x06, 0x03, 0xC0, 0x3E, 0x0E, 0x00, 0xFE, 0x38, 0x03,
  0xFE, 0xE0, 0x13, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x07,
  0xE0, 0x70, 0x3F, 0xC0, 0x01, 0xE7, 0x00, 0x0F, 0x9E, 0x00, 0x7C, 0x78,
  0x07, 0xE0, 0xF0, 0x0F, 0x03, 0xC0, 0x1C, 0x0F, 0x80, 0x20, 0x3E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC3, 0xF0, 0xF8, 0x3E, 0x1F,
  0x07, 0xC3, 0xE0, 0xF8, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x00, 0x7F,
  0xFD, 0xFF, 0xE7, 0xFF, 0xBF, 0xFE, 0x18, 0xFB, 0xFF, 0xFF, 0xDF, 0xBE,
  0x30, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xC1, 0xF8, 0x0F,
  0xC0, 0x7C, 0x07, 0xC0, 0x1F, 0x07, 0xE0, 0x0F, 0x83, 0xE0, 0x07, 0xC3,
  0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C,
  0x7C, 0x00, 0x3E, 0x3C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07,
  0xCF, 0x80, 0x03, 0xE7, 0x80, 0x01, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x00,
  0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1E, 0x3C, 0x00,
  0x1F, 0x1E, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x07, 0xC7, 0xC0,
  0x03, 0xE3, 0xE0, 0x01, 0xF0, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0xF8, 0x3E,
  0x00, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0xFC, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0xFE, 0x01, 0xFE,
  0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xFE, 0x7F, 0x3C, 0xFE, 0x7C, 0x78, 0x7C,
  0x30, 0x7C, 0x20, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x7E, 0x00, 0x70, 0x03,
  0xE0, 0x02, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xE0, 0x1F, 0x80, 0x30, 0x01, 0xF0,
  0x04, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x40, 0x00,
  0x7E, 0x0F, 0x00, 0x3F, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xBC, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x3E, 0x00,
  0x07, 0xC7, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x87,
  0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x07, 0xC0, 0x07,
  0xC0, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x00, 0x78,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0x80,
  0x0F, 0x01, 0xF0, 0x01, 0xE0, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x10, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0x3F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x08, 0x00, 0x1F, 0x83, 0x80, 0x1F, 0xC0, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x1F, 0xC0, 0x1E, 0x3F, 0xF0, 0x1F,
  0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xF8, 0x1F, 0x83, 0xF8, 0x07, 0xE3,
  0xF8, 0x01, 0xF1, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0x7C, 0x7C, 0x00, 0x3E,
  0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x00, 0x07, 0xC7, 0x80, 0x03,
  0xE3, 0xC0, 0x01, 0xE1, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00,
  0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x80, 0x7C, 0x07, 0xE0, 0x7E, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xF7,
  0xFC, 0x01, 0xF0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x1E, 0x03,
  0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x01, 0xF0, 0x03,
  0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x0F,
  0x80, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0xBF, 0x80, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFE,
  0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x0F, 0x80,
  0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00,
  0x7C, 0x1E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x0F,
  0x00, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xF0, 0x1F,
  0x80, 0x7F, 0xDF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x05, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xF0, 0x3E,
  0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x0F,
  0x1F, 0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x3E, 0x00, 0x0F,
  0x3E, 0x00, 0x0F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F,
  0x3E, 0x00, 0x3F, 0x3E, 0x00, 0x7F, 0x1F, 0x00, 0xFF, 0x1F, 0x81, 0xFE,
  0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xBE, 0x07, 0xFF, 0x3E, 0x01, 0xFC, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x80, 0x3F, 0x80, 0xFF, 0xFF, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x7C, 0x1F, 0x83, 0xF0, 0xFE, 0x1F, 0xC1, 0xF0, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x0F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3E, 0x03, 0x00, 0x00, 0x08, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE1, 0xC0, 0x3E, 0x10, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x01, 0xF0, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0xFF, 0x00, 0xF0, 0xF0, 0x07, 0xFF, 0x81,
  0xE1, 0xE0, 0x1F, 0xFF, 0x03, 0xC7, 0x80, 0x7C, 0x1E, 0x07, 0x8F, 0x01,
  0xF0, 0x3C, 0x0F, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x78, 0x1F, 0x01, 0xE0,
  0x3C, 0xF0, 0x3C, 0x03, 0xC0, 0x7B, 0xC0, 0xF0, 0x07, 0x80, 0xF7, 0x81,
  0xE0, 0x1E, 0x01, 0xCF, 0x03, 0xC0, 0x3C, 0x07, 0x9E, 0x0F, 0x00, 0x78,
  0x0F, 0x3C, 0x1E, 0x01, 0xF0, 0x1E, 0x70, 0x3C, 0x03, 0xC0, 0x39, 0xE0,
  0x78, 0x07, 0x80, 0xF3, 0xC0, 0xF0, 0x1F, 0x01, 0xE7, 0x81, 0xE0, 0x3E,
  0x07, 0x8F, 0x03, 0xC0, 0xFC, 0x1F, 0x1E, 0x07, 0xC3, 0xB8, 0x3C, 0x3C,
  0x0F, 0xFF, 0x7F, 0xF0, 0x3C, 0x0F, 0xFC, 0xFF, 0xC0, 0x78, 0x0F, 0xF0,
  0xFF, 0x00, 0xF0, 0x07, 0x80, 0xF8, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x10, 0x00,
  0x07, 0xE0, 0x01, 0xE0, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1E, 0x7C,
  0x00, 0x03, 0xE3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0xC3, 0xC0, 0x00,
  0x78, 0x3C, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x1F, 0x03,
  0xC0, 0x01, 0xF0, 0x3C, 0x00, 0x3E, 0x03, 0xC0, 0x03, 0xE0, 0x3E, 0x00,
  0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x1E, 0x0F, 0xC0,
  0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x1F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x1F,
  0x3F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0x80, 0xFF, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xC0, 0x07, 0xE0, 0x3E,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x78, 0x00,
  0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8,
  0x0F, 0x80, 0x0F, 0x80, 0x78, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0xC0, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xE0, 0x07, 0xC0, 0x3F, 0x80, 0x3E, 0x00, 0x7E, 0x01, 0xF0, 0x01, 0xF0,
  0x0F, 0x80, 0x07, 0xC0, 0x78, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3E,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x3F, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0xFC,
  0x0F, 0x00, 0x1F, 0xC0, 0xF8, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x30, 0x07, 0xF0, 0x00, 0x80,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x01, 0x80,
  0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x50, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F,
  0x81, 0xFF, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0x7E, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0,
  0x01, 0xF0, 0x1F, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0xF8, 0x1E, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3F, 0x03,
  0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x00, 0x07, 0xE0, 0x3E,
  0x00, 0x1F, 0x80, 0x7C, 0x00, 0xFE, 0x00, 0xF0, 0x03, 0xF8, 0x03, 0xE0,
  0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x08, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F, 0x80,
  0x7F, 0x00, 0x02, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0x8F, 0x80, 0x0F,
  0xFE, 0x1F, 0x00, 0x3F, 0xFC, 0x7E, 0x00, 0x7F, 0xF8, 0xF8, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF0,
  0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x7C, 0x01, 0xFC, 0x00, 0xF8, 0x03,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x78, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00,
  0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x01, 0xE0, 0x0F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x03, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x78, 0x00, 0x7E, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x00,
  0xF8, 0x03, 0xE0, 0x00, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0xC0, 0x01,
  0xF0, 0x1F, 0x80, 0x01, 0xF0, 0x3F, 0x00, 0x01, 0xE0, 0x7E, 0x00, 0x03,
  0xE0, 0xFC, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x03, 0xC7, 0xE0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x07,
  0xDF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xF7, 0xC0, 0x00, 0x0F, 0xE7, 0xC0, 0x00, 0x0F,
  0xC7, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1E,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xFE, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x07,
  0xBC, 0x01, 0xEF, 0x00, 0x01, 0xFF, 0x80, 0x3D, 0xE0, 0x00, 0x7D, 0xF0,
  0x07, 0xBE, 0x00, 0x0F, 0xBC, 0x01, 0xF7, 0xC0, 0x03, 0xE7, 0x80, 0x3E,
  0x78, 0x00, 0x79, 0xF0, 0x07, 0xCF, 0x00, 0x1F, 0x3E, 0x00, 0xF1, 0xE0,
  0x03, 0xC7, 0xC0, 0x1E, 0x3C, 0x00, 0xF8, 0xF0, 0x07, 0xC7, 0x80, 0x1E,
  0x3E, 0x00, 0xF8, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1E, 0x00, 0xF0, 0xF8,
  0x03, 0xC3, 0xC0, 0x3E, 0x1F, 0x00, 0x78, 0x78, 0x07, 0x83, 0xC0, 0x1F,
  0x0F, 0x81, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x3C, 0x1F, 0x00, 0x78, 0x1E,
  0x0F, 0x83, 0xE0, 0x0F, 0x03, 0xC1, 0xE0, 0x7C, 0x03, 0xE0, 0x78, 0x7C,
  0x0F, 0x00, 0x7C, 0x0F, 0x0F, 0x03, 0xE0, 0x0F, 0x81, 0xE3, 0xE0, 0x7C,
  0x01, 0xE0, 0x3C, 0x78, 0x0F, 0x80, 0x3C, 0x07, 0x9F, 0x01, 0xE0, 0x0F,
  0x80, 0xF3, 0xC0, 0x7C, 0x01, 0xF0, 0x1E, 0xF8, 0x0F, 0x80, 0x3E, 0x03,
  0xFE, 0x01, 0xF0, 0x07, 0x80, 0x7F, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0xF0,
  0x07, 0x80, 0x3E, 0x00, 0xFE, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0xF0, 0x03, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x07,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x0F, 0xC0,
  0x00, 0x7C, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x7F, 0x00, 0x01, 0xF0, 0x0F,
  0xF0, 0x00, 0x3C, 0x01, 0xFE, 0x00, 0x0F, 0x80, 0x7F, 0xC0, 0x01, 0xF0,
  0x0F, 0xF8, 0x00, 0x3E, 0x01, 0xEF, 0x80, 0x07, 0x80, 0x3D, 0xF0, 0x00,
  0xF0, 0x07, 0x9E, 0x00, 0x3E, 0x01, 0xF3, 0xE0, 0x07, 0xC0, 0x3E, 0x7C,
  0x00, 0xF8, 0x07, 0x87, 0x80, 0x1E, 0x00, 0xF0, 0xF0, 0x03, 0xC0, 0x1E,
  0x1F, 0x00, 0xF8, 0x07, 0xC1, 0xE0, 0x1F, 0x00, 0xF8, 0x3C, 0x03, 0xE0,
  0x1F, 0x07, 0xC0, 0x78, 0x03, 0xC0, 0xF8, 0x1F, 0x00, 0x78, 0x0F, 0x03,
  0xE0, 0x1F, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x3E, 0x0F, 0x00, 0x78, 0x03,
  0xC1, 0xE0, 0x0F, 0x00, 0x78, 0x7C, 0x03, 0xE0, 0x0F, 0x8F, 0x80, 0x7C,
  0x01, 0xF1, 0xF0, 0x0F, 0x80, 0x1E, 0x3C, 0x01, 0xE0, 0x03, 0xE7, 0x80,
  0x3C, 0x00, 0x7D, 0xF0, 0x0F, 0x80, 0x07, 0xBE, 0x01, 0xF0, 0x00, 0xFF,
  0xC0, 0x3E, 0x00, 0x1F, 0xF0, 0x07, 0x80, 0x01, 0xFE, 0x00, 0xF0, 0x00,
  0x3F, 0xC0, 0x3E, 0x00, 0x07, 0xF8, 0x07, 0xC0, 0x00, 0xFF, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x1E, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x0F,
  0x80, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF1, 0xF8,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7D, 0xF0, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0xFC,
  0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xF8, 0x3F,
  0xE0, 0x0F, 0x80, 0x7E, 0x00, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x3F, 0x01,
  0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x3E, 0x00,
  0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0,
  0x3C, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0xFC, 0x07, 0xC0,
  0x1F, 0x80, 0x7C, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x7E, 0x0F, 0x80, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x01, 0xF1, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x07, 0xCF, 0xC0, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xF7,
  0xC0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x3E, 0x3F,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xFC, 0x03, 0xFC,
  0x07, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0xF8, 0x1F, 0xE0, 0x0F, 0x80, 0x7E, 0x00, 0xF0, 0x03, 0xE0, 0x1F, 0x00,
  0x3F, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0,
  0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x03, 0xE0,
  0x03, 0xE0, 0x3C, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0xFC,
  0x07, 0xC0, 0x3F, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0xF0, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x1F,
  0x01, 0xF0, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x3C, 0x00, 0x7C, 0x07,
  0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00,
  0x3F, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xF8,
  0x07, 0x80, 0xFE, 0x00, 0x20, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x60, 0x00, 0xFC, 0x0F, 0x00, 0x7F, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E,
  0x03, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x78, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8,
  0x0F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF0,
  0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xC0,
  0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x50, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3E, 0xF8,
  0x00, 0x07, 0xEF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00,
  0xF8, 0xF8, 0x00, 0x1F, 0x87, 0x80, 0x01, 0xF0, 0x78, 0x00, 0x3F, 0x07,
  0x80, 0x03, 0xE0, 0x78, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00,
  0x7C, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0,
  0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xC0, 0xF8, 0x00, 0x3C, 0x0F, 0x80,
  0x03, 0xC1, 0xF0, 0x00, 0x3C, 0x1F, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x3C,
  0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0x80,
  0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xFB, 0xC0,
  0x00, 0xF8, 0x00, 0x3E, 0x78, 0x00, 0x3F, 0x00, 0x07, 0xCF, 0x00, 0x07,
  0xE0, 0x00, 0xF9, 0xE0, 0x01, 0xFE, 0x00, 0x3E, 0x3C, 0x00, 0x3F, 0xC0,
  0x07, 0xC7, 0x80, 0x0F, 0x78, 0x01, 0xF0, 0xF0, 0x01, 0xEF, 0x00, 0x3E,
  0x1E, 0x00, 0x7D, 0xE0, 0x0F, 0x83, 0xC0, 0x0F, 0x3C, 0x01, 0xF0, 0x78,
  0x01, 0xE7, 0x80, 0x3E, 0x0F, 0x00, 0x78, 0xF0, 0x0F, 0x81, 0xE0, 0x0F,
  0x1E, 0x01, 0xF0, 0x3C, 0x03, 0xE3, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x78,
  0x0F, 0x80, 0xF0, 0x1F, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC1, 0xE0, 0x7C,
  0x03, 0xC0, 0x78, 0x3C, 0x0F, 0x80, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0x0F,
  0x03, 0xC0, 0xF0, 0x7C, 0x01, 0xE0, 0xF8, 0x1E, 0x1F, 0x00, 0x3E, 0x1E,
  0x03, 0xC3, 0xE0, 0x07, 0xC7, 0xC0, 0x78, 0x78, 0x00, 0xF8, 0xF0, 0x0F,
  0x1F, 0x00, 0x1F, 0x3E, 0x01, 0xE3, 0xC0, 0x03, 0xE7, 0x80, 0x3C, 0xF8,
  0x00, 0x7C, 0xF0, 0x07, 0x9F, 0x00, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x01,
  0xE7, 0x80, 0x1E, 0xF8, 0x00, 0x3D, 0xF0, 0x03, 0xDE, 0x00, 0x07, 0xBC,
  0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x0F, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x1F,
  0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x1E,
  0x1F, 0x00, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00,
  0x7D, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00,
  0xF8, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xCF, 0x00,
  0x07, 0xC7, 0xC0, 0x07, 0xE3, 0xE0, 0x03, 0xE1, 0xF0, 0x03, 0xE0, 0x78,
  0x01, 0xF0, 0x3C, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xF8, 0x07,
  0xC0, 0xF8, 0x01, 0xE0, 0x7C, 0x00, 0xF0, 0x7C, 0x00, 0x78, 0x7C, 0x00,
  0x3E, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0x9F, 0x00, 0x03, 0xDF, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x00, 0xF0, 0x3C, 0x0F, 0x83, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0x07,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x0F, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x7C, 0x1F, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xDF,
  0x00, 0x01, 0xE7, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0xF0,
  0x78, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x07, 0xC0, 0x3C,
  0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x0F,
  0x80, 0x07, 0x87, 0x80, 0x03, 0xC7, 0xC0, 0x01, 0xF3, 0xC0, 0x00, 0x7B,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0xF0,
  0x3C, 0x0E, 0x07, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xF0, 0xF0, 0x0F,
  0xFE, 0x3C, 0x07, 0xFF, 0xCF, 0x03, 0xFD, 0xF7, 0x81, 0xF8, 0x1F, 0xE0,
  0xFC, 0x03, 0xF8, 0x3E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xC0, 0x07,
  0xC3, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x1F, 0x00,
  0x07, 0xC7, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1E,
  0x00, 0x0F, 0x8F, 0x80, 0x03, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C,
  0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x07, 0xE0, 0xF8, 0x03,
  0xF8, 0x1F, 0x01, 0xFE, 0x07, 0xC0, 0xF7, 0x81, 0xFF, 0xFB, 0xE0, 0x3F,
  0xFC, 0xF0, 0x07, 0xFE, 0x3C, 0x00, 0xFF, 0x0F, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xE0, 0x20, 0x00, 0xF8, 0x7F, 0x00, 0x3E, 0x7F,
  0xF0, 0x0F, 0x3F, 0xFC, 0x03, 0xDF, 0xFF, 0x81, 0xFF, 0x03, 0xE0, 0x7F,
  0x80, 0xFC, 0x1F, 0xC0, 0x1F, 0x07, 0xE0, 0x07, 0xC3, 0xF8, 0x01, 0xF0,
  0xFC, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01,
  0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x87, 0xC0,
  0x03, 0xE1, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F,
  0x80, 0x07, 0xC3, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x7C,
  0x1F, 0xC0, 0x3F, 0x07, 0xF8, 0x1F, 0x81, 0xEF, 0xBF, 0xC0, 0xFB, 0xFF,
  0xE0, 0x3C, 0x7F, 0xF0, 0x0F, 0x0F, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x03, 0x80, 0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0x03, 0xF0, 0x08, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x60, 0x7F, 0x9F,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x1A, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x60, 0x3C, 0x00, 0x1F,
  0xE3, 0xE0, 0x03, 0xFF, 0x9F, 0x00, 0x3F, 0xFE, 0xF8, 0x03, 0xFD, 0xF7,
  0x80, 0x3F, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x00, 0x3F, 0x01,
  0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0xC0,
  0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF0, 0x1F, 0x00, 0x07,
  0x80, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x03,
  0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0xC0,
  0x07, 0xE0, 0x3E, 0x00, 0x3F, 0x01, 0xF0, 0x03, 0xF0, 0x0F, 0x80, 0x3F,
  0x80, 0x3E, 0x03, 0xFC, 0x01, 0xF0, 0x3F, 0xE0, 0x0F, 0xF7, 0xDE, 0x00,
  0x3F, 0xFC, 0xF0, 0x01, 0xFF, 0xC7, 0x80, 0x03, 0xFC, 0x3C, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x7F, 0xFE, 0x03, 0xF9, 0xFC, 0x1F, 0x81, 0xF0, 0xFC, 0x07, 0xC3, 0xE0,
  0x0F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x3E,
  0x7C, 0x03, 0xF9, 0xF0, 0x3F, 0xC7, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFE, 0x03, 0xFF, 0x80, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x0C, 0x0F, 0xF1, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7E, 0x18, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0x0F, 0x00, 0x3F, 0xF8, 0xF0,
  0x07, 0xFF, 0xCF, 0x00, 0xFF, 0x7D, 0xE0, 0x1F, 0x81, 0xFE, 0x03, 0xF0,
  0x0F, 0xE0, 0x3E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0x7C,
  0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC1, 0xF0,
  0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E,
  0x00, 0x3F, 0x03, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x7F, 0x03, 0xE0, 0x07,
  0xE0, 0x3E, 0x00, 0xFE, 0x03, 0xF0, 0x1F, 0xE0, 0x1F, 0x03, 0xFE, 0x01,
  0xFE, 0xFB, 0xE0, 0x0F, 0xFF, 0x3C, 0x00, 0xFF, 0xE7, 0xC0, 0x03, 0xFC,
  0x7C, 0x00, 0x04, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x80, 0x03, 0xE0, 0x0E, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x02, 0x00, 0x1F, 0x0F, 0xF0, 0x0F, 0x9F, 0xFC, 0x07, 0x9F,
  0xFF, 0x03, 0xDF, 0xFF, 0x83, 0xFE, 0x07, 0xC1, 0xFE, 0x03, 0xE0, 0xFE,
  0x00, 0xF0, 0x7E, 0x00, 0x78, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0x3E, 0x1F,
  0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0x87, 0xC0, 0x03, 0xC3,
  0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x78, 0x00, 0x78,
  0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F,
  0x87, 0x80, 0x07, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01,
  0xF0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x7C, 0x00, 0x7C, 0x3E, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x03,
  0xC0, 0x7E, 0x01, 0xF0, 0x3F, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x07, 0xC0,
  0x07, 0x83, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x7C,
  0x00, 0x0F, 0x3E, 0x00, 0x03, 0xDF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xF7, 0xC0, 0x01, 0xF9, 0xF0, 0x00,
  0xFC, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xC0, 0x7C,
  0x00, 0xF0, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xE0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F,
  0x80, 0x1F, 0x80, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x40,
  0x03, 0xC3, 0xFC, 0x07, 0xFC, 0x03, 0xC7, 0xFE, 0x0F, 0xFE, 0x03, 0xCF,
  0xFF, 0x1F, 0xFE, 0x03, 0xDF, 0xFF, 0x3F, 0xFF, 0x07, 0xFC, 0x1F, 0x78,
  0x1F, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x0F,
  0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x00, 0x1E,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x1F, 0x00,
  0x1E, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x00,
  0x3C, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x3E,
  0x00, 0x3C, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x3E, 0x00, 0x7C,
  0x00, 0x78, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0x78, 0x00, 0xF8,
  0x7C, 0x00, 0x78, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x78, 0x00,
  0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xF0, 0x01,
  0xF0, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0xF0, 0xFF,
  0x80, 0x3C, 0x7F, 0xF0, 0x0F, 0x3F, 0xFE, 0x07, 0xDF, 0xFF, 0x81, 0xFF,
  0x03, 0xE0, 0x7F, 0x80, 0xFC, 0x1F, 0xC0, 0x1F, 0x07, 0xE0, 0x07, 0x83,
  0xF0, 0x03, 0xE0, 0xFC, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F,
  0x83, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00,
  0x1F, 0x07, 0xC0, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x3E,
  0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0,
  0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x01,
  0xF0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07,
  0xE0, 0x7E, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F,
  0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0xF8,
  0x00, 0x1E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7C,
  0x01, 0xF0, 0x7E, 0x07, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x03, 0xC1, 0xFC, 0x00, 0x1E, 0x3F, 0xF8, 0x00, 0xF3, 0xFF, 0xC0, 0x07,
  0xBE, 0xFF, 0x00, 0x7F, 0xC0, 0xF8, 0x03, 0xFC, 0x07, 0xE0, 0x1F, 0xC0,
  0x1F, 0x00, 0xFC, 0x00, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x7E, 0x00, 0x3E,
  0x03, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x0F,
  0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1E, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00,
  0x0F, 0x80, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x3E,
  0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x0F,
  0xC0, 0x0F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xFC, 0x0F, 0xC0, 0x1E, 0xFB,
  0xFC, 0x00, 0xF7, 0xFF, 0xC0, 0x0F, 0x9F, 0xFC, 0x00, 0x7C, 0x7F, 0xC0,
  0x03, 0xE0, 0x30, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0F, 0xF0, 0xF0, 0x0F, 0xFE, 0x3C, 0x07, 0xFF,
  0xCF, 0x03, 0xFD, 0xF7, 0x81, 0xF8, 0x1F, 0xE0, 0xFC, 0x03, 0xF8, 0x3E,
  0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xC0, 0x07, 0xC3, 0xF0, 0x01, 0xF0,
  0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0x87, 0xC0, 0x03,
  0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80,
  0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x3F, 0x0F,
  0x80, 0x1F, 0xC3, 0xE0, 0x07, 0xE0, 0xF8, 0x03, 0xF8, 0x3F, 0x01, 0xFE,
  0x07, 0xC0, 0xFF, 0x81, 0xFE, 0xFB, 0xE0, 0x3F, 0xFC, 0xF0, 0x0F, 0xFE,
  0x7C, 0x00, 0xFE, 0x1F, 0x00, 0x04, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x60, 0x1E, 0x1F, 0xC0, 0xF1, 0xFC, 0x07, 0x9F, 0xE0, 0x3D, 0xFF,
  0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x07, 0xFF, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0x3F, 0x07, 0xE0,
  0x18, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC4, 0x00, 0x7E, 0x30, 0x07, 0xE1, 0xF9, 0xFF, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x60, 0x00, 0x01, 0xE0, 0x03,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF9,
  0x83, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x80, 0x00, 0x07, 0xC0, 0x07,
  0xC1, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0x78, 0x3E, 0x00, 0x3E, 0x0F, 0x80,
  0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3C, 0x1F,
  0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0x78,
  0x3E, 0x00, 0x1E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00,
  0xF8, 0x3C, 0x00, 0x3C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0,
  0x01, 0xF0, 0x7C, 0x00, 0xFC, 0x1E, 0x00, 0x3E, 0x07, 0x80, 0x1F, 0x83,
  0xE0, 0x0F, 0xE0, 0xF8, 0x07, 0xF8, 0x1F, 0x03, 0xFC, 0x07, 0xF7, 0xEF,
  0x01, 0xFF, 0xF3, 0xC0, 0x3F, 0xF8, 0xF0, 0x07, 0xF8, 0x3C, 0x00, 0x10,
  0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0,
  0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x1E, 0x3E, 0x00, 0x7C, 0x7C, 0x00,
  0xF0, 0x78, 0x03, 0xE0, 0xF0, 0x07, 0x81, 0xE0, 0x1F, 0x03, 0xC0, 0x3C,
  0x07, 0x80, 0xF8, 0x0F, 0x01, 0xE0, 0x1E, 0x07, 0xC0, 0x3E, 0x0F, 0x00,
  0x7C, 0x3E, 0x00, 0xF8, 0x78, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xC0, 0x03,
  0xCF, 0x80, 0x07, 0x9E, 0x00, 0x0F, 0x7C, 0x00, 0x1E, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0x80, 0x1E, 0xF8, 0x03, 0xF8, 0x03, 0xEF, 0x80, 0x3F, 0x80, 0x3E, 0xF8,
  0x07, 0xF8, 0x07, 0xCF, 0x80, 0x7F, 0x80, 0x7C, 0xF8, 0x07, 0x78, 0x0F,
  0x8F, 0x80, 0xF7, 0x80, 0xF8, 0xF8, 0x0F, 0x78, 0x0F, 0x0F, 0x81, 0xE7,
  0x81, 0xF0, 0xF8, 0x1E, 0x78, 0x1F, 0x07, 0x83, 0xC7, 0x83, 0xE0, 0x78,
  0x3C, 0x78, 0x3E, 0x07, 0x83, 0xC7, 0x83, 0xC0, 0x78, 0x78, 0x78, 0x7C,
  0x07, 0x87, 0x87, 0x87, 0x80, 0x78, 0xF0, 0x78, 0xF8, 0x07, 0x8F, 0x07,
  0x8F, 0x00, 0x79, 0xE0, 0x79, 0xF0, 0x07, 0x9E, 0x07, 0x9F, 0x00, 0x7B,
  0xE0, 0x79, 0xE0, 0x07, 0xBC, 0x07, 0xBE, 0x00, 0x7B, 0xC0, 0x7B, 0xC0,
  0x07, 0xF8, 0x07, 0xBC, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x07, 0xF0, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x03, 0xF0,
  0x1F, 0x00, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0xF8, 0x00, 0xF8,
  0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x78, 0x3E, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x7C, 0xF8, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xBC, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x3E,
  0x00, 0x07, 0xC1, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x01,
  0xF0, 0x0F, 0x80, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x00,
  0x7C, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0xF8,
  0x00, 0x78, 0x03, 0xE0, 0x00, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x0F, 0x07, 0xC0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x3C, 0x3E, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03,
  0xCF, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE,
  0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F,
  0xC0, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xBF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xF6, 0x00, 0x3F, 0xF2,
  0x00, 0x07, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Italic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 14, 41, 14, 1, -40 },
  { 73, 16, 14, 21, 6, -40 },
  { 101, 31, 40, 32, 1, -40 },
  { 256, 26, 46, 28, 1, -43 },
  { 406, 35, 42, 41, 4, -41 },
  { 590, 30, 42, 33, 1, -41 },
  { 748, 7, 14, 12, 6, -40 },
  { 761, 18, 49, 16, 2, -40 },
  { 872, 18, 49, 16, -4, -40 },
  { 983, 22, 24, 27, 6, -43 },
  { 1049, 25, 27, 29, 3, -33 },
  { 1134, 10, 13, 13, -2, -6 },
  { 1151, 14, 4, 16, 1, -17 },
  { 1158, 7, 8, 13, 1, -7 },
  { 1165, 27, 40, 19, -3, -40 },
  { 1300, 25, 42, 28, 2, -41 },
  { 1432, 16, 40, 28, 7, -40 },
  { 1512, 28, 41, 28, -1, -41 },
  { 1656, 27, 42, 28, 0, -41 },
  { 1798, 27, 40, 28, 0, -40 },
  { 1933, 26, 41, 28, 1, -40 },
  { 2067, 25, 42, 28, 3, -41 },
  { 2199, 25, 40, 28, 4, -40 },
  { 2324, 27, 42, 28, 1, -41 },
  { 2466, 24, 42, 28, 2, -41 },
  { 2592, 11, 32, 13, 1, -31 },
  { 2636, 15, 38, 13, -3, -31 },
  { 2708, 25, 26, 29, 3, -33 },
  { 2790, 23, 15, 29, 4, -27 },
  { 2834, 25, 26, 29, 3, -33 },
  { 2916, 20, 42, 21, 3, -41 },
  { 3021, 39, 45, 42, 2, -40 },
  { 3241, 28, 40, 28, -3, -40 },
  { 3381, 29, 40, 30, 1, -40 },
  { 3526, 29, 42, 29, 3, -41 },
  { 3679, 31, 40, 33, 1, -40 },
  { 3834, 27, 40, 26, 1, -40 },
  { 3969, 27, 40, 24, 1, -40 },
  { 4104, 31, 42, 34, 3, -41 },
  { 4267, 33, 40, 34, 2, -40 },
  { 4432, 22, 40, 17, -2, -40 },
  { 4542, 24, 51, 14, -9, -40 },
  { 4695, 32, 40, 28, 1, -40 },
  { 4855, 19, 40, 24, 1, -40 },
  { 4950, 43, 40, 43, 1, -40 },
  { 5165, 35, 40, 36, 1, -40 },
  { 5340, 31, 42, 36, 3, -41 },
  { 5503, 28, 40, 28, 1, -40 },
  { 5643, 31, 51, 36, 3, -41 },
  { 5841, 28, 40, 29, 1, -40 },
  { 5981, 27, 42, 26, 0, -41 },
  { 6123, 25, 40, 25, 5, -40 },
  { 6248, 32, 41, 34, 3, -40 },
  { 6412, 28, 40, 28, 5, -40 },
  { 6552, 43, 40, 44, 6, -40 },
  { 6767, 34, 40, 26, -3, -40 },
  { 6937, 25, 40, 25, 5, -40 },
  { 7062, 29, 40, 26, -1, -40 },
  { 7207, 21, 49, 16, -1, -40 },
  { 7336, 10, 40, 20, 6, -40 },
  { 7386, 21, 49, 16, -4, -40 },
  { 7515, 25, 24, 28, 2, -40 },
  { 7590, 21, 4, 20, -5, 5 },
  { 7601, 9, 9, 15, 8, -43 },
  { 7612, 26, 32, 29, 2, -31 },
  { 7716, 26, 44, 29, 1, -43 },
  { 7859, 21, 32, 23, 2, -31 },
  { 7943, 29, 44, 29, 2, -43 },
  { 8103, 22, 32, 26, 2, -31 },
  { 8191, 30, 56, 16, -7, -43 },
  { 8401, 28, 44, 29, 0, -31 },
  { 8555, 25, 43, 29, 1, -43 },
  { 8690, 13, 41, 13, 1, -41 },
  { 8757, 21, 54, 13, -7, -41 },
  { 8899, 26, 43, 25, 1, -43 },
  { 9039, 14, 43, 13, 1, -43 },
  { 9115, 40, 31, 44, 1, -31 },
  { 9270, 26, 31, 29, 1, -31 },
  { 9371, 24, 31, 28, 2, -30 },
  { 9464, 29, 44, 29, -2, -31 },
  { 9624, 26, 44, 29, 2, -31 },
  { 9767, 21, 31, 20, 1, -31 },
  { 9849, 21, 32, 22, 0, -31 },
  { 9933, 15, 38, 17, 3, -37 },
  { 10005, 26, 31, 29, 2, -30 },
  { 10106, 23, 30, 23, 3, -30 },
  { 10193, 36, 30, 37, 3, -30 },
  { 10328, 28, 30, 24, -2, -30 },
  { 10433, 31, 43, 24, -5, -30 },
  { 10600, 23, 30, 22, -1, -30 },
  { 10687, 21, 49, 19, 1, -40 },
  { 10816, 4, 56, 27, 12, -43 },
  { 10844, 21, 49, 19, -3, -40 },
  { 10973, 25, 7, 29, 3, -23 },
};

const GFXfont NotoSans_SemiCondensed_Italic56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic56pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC56PT7B_H_
