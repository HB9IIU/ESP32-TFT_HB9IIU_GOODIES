#ifndef _NOTOSANS_SEMICONDENSED_ITALIC20PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC6, 0x23, 0x18, 0xC4, 0x23, 0x00, 0x0E, 0x60, 0x6D, 0x2C,
  0xB2, 0x98, 0x06, 0x60, 0x44, 0x04, 0xC0, 0xCC, 0x3F, 0xF0, 0x88, 0x19,
  0x81, 0x90, 0x7F, 0xCF, 0xFC, 0x32, 0x02, 0x20, 0x26, 0x06, 0x60, 0x02,
  0x00, 0x81, 0xFC, 0xCA, 0x34, 0x0D, 0x03, 0xC0, 0x78, 0x0F, 0x02, 0xC0,
  0x90, 0x2C, 0xEF, 0x1F, 0x01, 0x00, 0x40, 0x3C, 0x33, 0x23, 0x11, 0x10,
  0x89, 0x8C, 0xD8, 0x64, 0x9B, 0x2F, 0x6E, 0xD3, 0x04, 0x98, 0x6C, 0xC6,
  0x44, 0x22, 0x23, 0x1B, 0x30, 0x70, 0x02, 0x01, 0xF0, 0x62, 0x0C, 0x41,
  0x98, 0x36, 0x03, 0x80, 0xE0, 0x36, 0x6C, 0xCD, 0x0F, 0x61, 0xCC, 0x18,
  0xCF, 0x1F, 0x30, 0x6B, 0x68, 0x0C, 0x63, 0x08, 0x61, 0x0C, 0x30, 0xC2,
  0x08, 0x20, 0x82, 0x0C, 0x30, 0x40, 0x0C, 0x08, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x08, 0x30, 0x60, 0x83, 0x0C, 0x10, 0xE0, 0x0C, 0x08, 0xC8,
  0x7F, 0x19, 0x28, 0x4C, 0x44, 0x08, 0x04, 0x02, 0x01, 0x0F, 0xFF, 0xFC,
  0x20, 0x10, 0x08, 0x04, 0x00, 0x36, 0x64, 0x80, 0xF8, 0xFC, 0x01, 0xC0,
  0x60, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x01,
  0x80, 0x60, 0x30, 0x00, 0x04, 0x0F, 0x8C, 0xC4, 0x36, 0x1B, 0x0F, 0x07,
  0x82, 0xC3, 0x61, 0xB0, 0xD8, 0x4C, 0x66, 0x61, 0xE0, 0x1B, 0xF7, 0x23,
  0x18, 0xC6, 0x23, 0x18, 0xC6, 0x60, 0x3F, 0x84, 0x60, 0x0C, 0x02, 0x01,
  0x80, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xFF, 0x3F, 0xC0,
  0x3F, 0x84, 0x60, 0x0C, 0x02, 0x01, 0x80, 0xC1, 0xC0, 0x1C, 0x03, 0x00,
  0x40, 0x10, 0x0C, 0xC6, 0x3F, 0x00, 0x01, 0xC0, 0xE0, 0x78, 0x16, 0x0D,
  0x86, 0x43, 0x30, 0x8C, 0x43, 0x3F, 0xEF, 0xF8, 0x18, 0x06, 0x01, 0x80,
  0x0F, 0xC6, 0x01, 0x80, 0x40, 0x30, 0x0F, 0x83, 0xF0, 0x0C, 0x01, 0x80,
  0x60, 0x10, 0x0C, 0xC6, 0x3F, 0x00, 0x0F, 0x8C, 0x0C, 0x04, 0x06, 0x02,
  0xF3, 0xDD, 0x86, 0xC3, 0x61, 0xB0, 0xD8, 0xCE, 0xE3, 0xE0, 0x7F, 0x80,
  0xC0, 0x40, 0x60, 0x60, 0x30, 0x30, 0x18, 0x18, 0x08, 0x0C, 0x04, 0x06,
  0x06, 0x00, 0x04, 0x0F, 0x8C, 0x64, 0x32, 0x19, 0x18, 0xD8, 0x38, 0x76,
  0x63, 0x20, 0xD0, 0x68, 0x26, 0x31, 0xF0, 0x3F, 0x33, 0x61, 0x41, 0x41,
  0xC3, 0x43, 0x7F, 0x3B, 0x02, 0x06, 0x0C, 0x9C, 0xF0, 0x33, 0x30, 0x00,
  0x00, 0x0E, 0xC0, 0x18, 0xC6, 0x00, 0x00, 0x00, 0x01, 0x98, 0xCC, 0x40,
  0x00, 0x81, 0xC3, 0x87, 0x0E, 0x07, 0x00, 0xF0, 0x1E, 0x01, 0x80, 0x40,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x1C, 0x38, 0xF0, 0xC0, 0x40, 0x00, 0x7E, 0x8C, 0x18, 0x30, 0x61,
  0x86, 0x18, 0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x07, 0xE0, 0x70, 0x63,
  0x00, 0x88, 0x02, 0x67, 0xCD, 0x33, 0x3C, 0x8C, 0xE2, 0x22, 0x98, 0x8A,
  0x66, 0x69, 0xBB, 0x23, 0xB8, 0xC0, 0x01, 0x80, 0x03, 0xB8, 0x03, 0xC0,
  0x01, 0x80, 0xE0, 0x28, 0x1A, 0x04, 0x83, 0x20, 0x88, 0x62, 0x1F, 0xCF,
  0xF2, 0x0D, 0x83, 0x40, 0xF0, 0x30, 0x3F, 0x8C, 0x63, 0x0C, 0x83, 0x21,
  0x98, 0xE7, 0xE1, 0x8C, 0x41, 0xB0, 0x6C, 0x1B, 0x0C, 0xCF, 0x3F, 0x00,
  0x0F, 0xC6, 0x13, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x01, 0x80, 0x73, 0x0F, 0xC0, 0x3F, 0x0C, 0x73, 0x0C, 0x83, 0x20,
  0x58, 0x16, 0x0D, 0x83, 0x40, 0xF0, 0x6C, 0x1B, 0x0C, 0xFE, 0x3E, 0x00,
  0x3F, 0x98, 0x0C, 0x04, 0x02, 0x03, 0x01, 0xF8, 0xC0, 0x40, 0x60, 0x30,
  0x18, 0x0F, 0xC7, 0xE0, 0x3F, 0x98, 0x0C, 0x04, 0x02, 0x03, 0x01, 0xF8,
  0xFC, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x00, 0x0F, 0xE3, 0x84, 0xC0,
  0x30, 0x06, 0x00, 0xC0, 0x30, 0xF6, 0x1E, 0xC0, 0xD8, 0x1B, 0x02, 0x30,
  0xC7, 0x18, 0x7F, 0x00, 0x30, 0x66, 0x0C, 0xC1, 0x90, 0x32, 0x04, 0xC1,
  0x9F, 0xF3, 0x06, 0x40, 0xD8, 0x13, 0x06, 0x60, 0xCC, 0x19, 0x02, 0x00,
  0x1F, 0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x18, 0x10, 0x30,
  0x30, 0xF8, 0x03, 0x03, 0x03, 0x02, 0x02, 0x06, 0x06, 0x06, 0x04, 0x0C,
  0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0xF0, 0xE0, 0x30, 0xE6, 0x30, 0xCC,
  0x13, 0x82, 0x60, 0xD8, 0x1E, 0x03, 0xE0, 0x4C, 0x18, 0x83, 0x18, 0x63,
  0x0C, 0x21, 0x06, 0x00, 0x30, 0xC3, 0x08, 0x21, 0x86, 0x18, 0x43, 0x0C,
  0x30, 0xFF, 0xF0, 0x1C, 0x07, 0x1C, 0x0E, 0x14, 0x0E, 0x14, 0x1E, 0x14,
  0x16, 0x34, 0x34, 0x36, 0x2C, 0x36, 0x6C, 0x26, 0x4C, 0x66, 0xCC, 0x67,
  0x88, 0x63, 0x98, 0x43, 0x18, 0xC2, 0x18, 0x1C, 0x18, 0xE0, 0xC5, 0x04,
  0x2C, 0x61, 0x63, 0x19, 0x18, 0xC8, 0xC6, 0x64, 0x23, 0x63, 0x0B, 0x18,
  0x78, 0xC3, 0x84, 0x0C, 0x60, 0x60, 0x02, 0x01, 0xF8, 0x63, 0x98, 0x36,
  0x06, 0xC0, 0xD8, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0x60, 0x66, 0x18,
  0xE7, 0x0F, 0x80, 0x3F, 0x18, 0xCC, 0x64, 0x12, 0x1B, 0x0D, 0x8C, 0xFC,
  0x40, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x00, 0x02, 0x01, 0xF8, 0x63, 0x98,
  0x36, 0x06, 0xC0, 0xD8, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0x60, 0x66,
  0x18, 0xE7, 0x0F, 0x80, 0x30, 0x03, 0x00, 0x70, 0x3F, 0x18, 0xCC, 0x64,
  0x12, 0x1B, 0x0D, 0x9C, 0xFC, 0x4C, 0x63, 0x31, 0x98, 0xCC, 0x24, 0x18,
  0x1F, 0xCE, 0x23, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0xCE, 0x3F, 0x00, 0xFF, 0x8C, 0x06, 0x02, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x00, 0x30, 0x66,
  0x0C, 0xC1, 0x90, 0x36, 0x04, 0xC1, 0x98, 0x32, 0x06, 0x40, 0x98, 0x13,
  0x06, 0x60, 0xC6, 0x70, 0xFC, 0x00, 0xC1, 0xF0, 0x6C, 0x13, 0x0C, 0xC2,
  0x31, 0x8C, 0x43, 0x30, 0xC8, 0x36, 0x05, 0x01, 0xC0, 0x60, 0x18, 0x00,
  0xC3, 0x87, 0x87, 0x0F, 0x0E, 0x36, 0x3C, 0x6C, 0x58, 0x99, 0xB3, 0x32,
  0x64, 0x6C, 0xD8, 0xD1, 0xB1, 0xA3, 0xC3, 0xC7, 0x87, 0x0E, 0x0E, 0x1C,
  0x18, 0x30, 0x00, 0x18, 0x30, 0x86, 0x0C, 0xC0, 0xD8, 0x05, 0x80, 0x70,
  0x06, 0x00, 0xE0, 0x0F, 0x01, 0xB0, 0x33, 0x02, 0x10, 0x61, 0x8C, 0x18,
  0xC3, 0xE1, 0xB1, 0x88, 0x84, 0xC3, 0xC1, 0xE0, 0xE0, 0x20, 0x30, 0x18,
  0x0C, 0x04, 0x06, 0x00, 0x1F, 0xC8, 0x30, 0x18, 0x0C, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x18, 0x0C, 0x06, 0x01, 0x80, 0xFF, 0x3F, 0x80, 0x1E, 0x30,
  0x40, 0x83, 0x06, 0x0C, 0x10, 0x20, 0xC1, 0x82, 0x04, 0x18, 0x30, 0x60,
  0xF0, 0xCC, 0xC4, 0x44, 0x66, 0x66, 0x22, 0x23, 0x1E, 0x0C, 0x18, 0x20,
  0x41, 0x83, 0x04, 0x08, 0x30, 0x60, 0xC1, 0x02, 0x0C, 0x18, 0xF0, 0x08,
  0x0E, 0x0D, 0x04, 0xC6, 0x22, 0x13, 0x0D, 0x03, 0xFF, 0xC8, 0x80, 0x1C,
  0x9F, 0xD8, 0xE8, 0x2C, 0x36, 0x1B, 0x0D, 0x86, 0xC6, 0x65, 0x1D, 0x80,
  0x18, 0x06, 0x01, 0x80, 0x40, 0x13, 0x0F, 0xE3, 0x8C, 0xC3, 0x30, 0xC8,
  0x26, 0x19, 0x86, 0x61, 0x1C, 0xCD, 0xE0, 0x1E, 0x7D, 0x82, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x89, 0xF0, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x1D, 0x8F,
  0xE6, 0x39, 0x04, 0xC3, 0x30, 0xCC, 0x33, 0x0C, 0xC6, 0x32, 0x87, 0x60,
  0x1E, 0x3E, 0x63, 0x42, 0xC6, 0xFC, 0xC0, 0x80, 0xC0, 0xC4, 0x7C, 0x03,
  0xC0, 0x80, 0x60, 0x18, 0x0F, 0x87, 0xC0, 0xC0, 0x30, 0x0C, 0x02, 0x00,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x0E, 0x03, 0x00,
  0x0E, 0x47, 0xF3, 0x1C, 0x86, 0x61, 0x98, 0x66, 0x19, 0x8E, 0x63, 0x19,
  0xC3, 0xB0, 0x0C, 0x02, 0x01, 0x8F, 0xC1, 0xE0, 0x18, 0x0C, 0x06, 0x02,
  0x01, 0x79, 0xFC, 0xE2, 0x61, 0x31, 0x90, 0xD8, 0x6C, 0x36, 0x12, 0x1B,
  0x0C, 0x08, 0xC4, 0x01, 0x18, 0xC6, 0x21, 0x18, 0xC6, 0x23, 0x00, 0x01,
  0x03, 0x02, 0x00, 0x02, 0x06, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x0C, 0x0C,
  0x08, 0x18, 0x18, 0x18, 0x10, 0xF0, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x40,
  0x11, 0xCC, 0x63, 0x30, 0xD8, 0x2C, 0x0F, 0x07, 0xC1, 0x90, 0x66, 0x11,
  0x8C, 0x30, 0x18, 0xC6, 0x21, 0x18, 0xC6, 0x21, 0x18, 0xC6, 0x23, 0x00,
  0x17, 0x1C, 0x7F, 0x7C, 0xE7, 0x19, 0x8C, 0x33, 0x18, 0x44, 0x31, 0x98,
  0x43, 0x30, 0x86, 0x63, 0x0C, 0x86, 0x13, 0x0C, 0x60, 0x17, 0x9F, 0xCE,
  0x26, 0x13, 0x1B, 0x0D, 0x86, 0xC3, 0x61, 0x21, 0xB0, 0xC0, 0x1E, 0x3F,
  0x63, 0x41, 0xC1, 0xC3, 0xC3, 0xC3, 0xC6, 0xCE, 0x7C, 0x09, 0x83, 0xF8,
  0x71, 0x8C, 0x31, 0x86, 0x20, 0x8C, 0x31, 0x86, 0x30, 0x87, 0x31, 0xBC,
  0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0x1C, 0x9F, 0xD8, 0xE8, 0x6C,
  0x36, 0x1B, 0x0D, 0x86, 0xC6, 0x67, 0x1D, 0x80, 0xC0, 0x40, 0x20, 0x30,
  0x18, 0x17, 0x3E, 0x38, 0x30, 0x30, 0x20, 0x60, 0x60, 0x60, 0x40, 0xC0,
  0x1F, 0x3E, 0x60, 0x60, 0x30, 0x38, 0x0C, 0x06, 0x04, 0x8C, 0xF8, 0x30,
  0x87, 0xFE, 0x61, 0x84, 0x10, 0xC3, 0x0C, 0x30, 0xF0, 0x61, 0xB0, 0xD8,
  0x4C, 0x24, 0x36, 0x1B, 0x0D, 0x84, 0xC6, 0x67, 0x3D, 0x80, 0xC3, 0xC3,
  0xC6, 0xC6, 0xC4, 0xCC, 0x48, 0x58, 0x50, 0x70, 0x60, 0xC6, 0x1E, 0x30,
  0xB1, 0x8D, 0x9E, 0x6C, 0xB6, 0x6D, 0xB3, 0x4D, 0x1E, 0x78, 0xE3, 0x87,
  0x1C, 0x38, 0xC0, 0x10, 0xC6, 0x61, 0x98, 0x2C, 0x0E, 0x03, 0x00, 0xE0,
  0x78, 0x32, 0x18, 0xCC, 0x30, 0x18, 0x23, 0x0C, 0x61, 0x0C, 0x60, 0x88,
  0x13, 0x02, 0x40, 0x58, 0x0A, 0x01, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30,
  0x3C, 0x07, 0x00, 0x3F, 0x3F, 0x06, 0x0C, 0x08, 0x18, 0x30, 0x60, 0x60,
  0xC0, 0xFC, 0x07, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x30, 0xE0, 0x30,
  0x30, 0x30, 0x20, 0x20, 0x60, 0x68, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1C, 0x06, 0x04, 0x04, 0x0C, 0x0C, 0x0C, 0x0C, 0x03, 0x0C, 0x18, 0x18,
  0x10, 0x10, 0x30, 0x30, 0xE0, 0xF8, 0xC7, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_Italic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 14, 5, 0, -14 },
  { 10, 6, 5, 7, 2, -14 },
  { 14, 12, 14, 11, 0, -14 },
  { 35, 10, 16, 10, 0, -15 },
  { 55, 13, 14, 15, 1, -14 },
  { 78, 11, 15, 12, 0, -15 },
  { 99, 3, 5, 4, 2, -14 },
  { 101, 6, 17, 6, 1, -14 },
  { 114, 7, 17, 6, -2, -14 },
  { 129, 8, 8, 10, 2, -15 },
  { 137, 9, 10, 10, 1, -12 },
  { 149, 4, 5, 5, -1, -2 },
  { 152, 5, 1, 6, 0, -6 },
  { 153, 3, 2, 5, 0, -2 },
  { 154, 10, 14, 7, -1, -14 },
  { 172, 9, 15, 10, 1, -15 },
  { 189, 5, 14, 10, 3, -14 },
  { 198, 10, 14, 10, 0, -14 },
  { 216, 10, 14, 10, 0, -14 },
  { 234, 10, 14, 10, 0, -14 },
  { 252, 10, 14, 10, 0, -14 },
  { 270, 9, 14, 10, 1, -14 },
  { 286, 9, 14, 10, 1, -14 },
  { 302, 9, 15, 10, 1, -15 },
  { 319, 8, 14, 10, 1, -14 },
  { 333, 4, 11, 5, 0, -11 },
  { 339, 5, 14, 5, -1, -11 },
  { 348, 9, 10, 10, 1, -12 },
  { 360, 9, 6, 10, 1, -10 },
  { 367, 9, 10, 10, 1, -12 },
  { 379, 7, 14, 8, 1, -14 },
  { 392, 14, 16, 15, 1, -14 },
  { 420, 10, 14, 10, -1, -14 },
  { 438, 10, 14, 11, 1, -14 },
  { 456, 10, 14, 10, 1, -14 },
  { 474, 10, 14, 12, 1, -14 },
  { 492, 9, 14, 9, 1, -14 },
  { 508, 9, 14, 9, 1, -14 },
  { 524, 11, 14, 12, 1, -14 },
  { 544, 11, 14, 12, 1, -14 },
  { 564, 8, 14, 6, -1, -14 },
  { 578, 8, 18, 5, -3, -14 },
  { 596, 11, 14, 10, 1, -14 },
  { 616, 6, 14, 9, 1, -14 },
  { 627, 16, 14, 15, 0, -14 },
  { 655, 13, 14, 13, 0, -14 },
  { 678, 11, 15, 13, 1, -15 },
  { 699, 9, 14, 10, 1, -14 },
  { 715, 11, 18, 13, 1, -15 },
  { 740, 9, 14, 10, 1, -14 },
  { 756, 10, 14, 9, 0, -14 },
  { 774, 9, 14, 9, 2, -14 },
  { 790, 11, 14, 12, 1, -14 },
  { 810, 10, 14, 10, 2, -14 },
  { 828, 15, 14, 16, 2, -14 },
  { 855, 12, 14, 9, -1, -14 },
  { 876, 9, 14, 9, 2, -14 },
  { 892, 10, 14, 9, 0, -14 },
  { 910, 7, 17, 6, 0, -14 },
  { 925, 4, 14, 7, 2, -14 },
  { 932, 7, 17, 6, -1, -14 },
  { 947, 9, 8, 10, 1, -14 },
  { 956, 8, 1, 7, -2, 2 },
  { 957, 3, 3, 5, 3, -15 },
  { 959, 9, 11, 10, 1, -11 },
  { 972, 10, 15, 10, 0, -15 },
  { 991, 7, 11, 8, 1, -11 },
  { 1001, 10, 15, 10, 1, -15 },
  { 1020, 8, 11, 9, 1, -11 },
  { 1031, 10, 20, 6, -2, -15 },
  { 1056, 10, 16, 10, 0, -11 },
  { 1076, 9, 15, 10, 0, -15 },
  { 1093, 5, 15, 5, 0, -15 },
  { 1103, 8, 20, 5, -3, -15 },
  { 1123, 10, 15, 9, 0, -15 },
  { 1142, 5, 15, 5, 0, -15 },
  { 1152, 15, 11, 16, 0, -11 },
  { 1173, 9, 11, 10, 0, -11 },
  { 1186, 8, 11, 10, 1, -11 },
  { 1197, 11, 16, 10, -1, -11 },
  { 1219, 9, 16, 10, 1, -11 },
  { 1237, 8, 11, 7, 0, -11 },
  { 1248, 8, 11, 8, 0, -11 },
  { 1259, 6, 13, 6, 1, -13 },
  { 1269, 9, 11, 10, 1, -11 },
  { 1282, 8, 11, 8, 1, -11 },
  { 1293, 13, 11, 13, 1, -11 },
  { 1311, 10, 11, 9, -1, -11 },
  { 1325, 11, 16, 8, -2, -11 },
  { 1347, 8, 11, 8, 0, -11 },
  { 1358, 8, 17, 7, 0, -14 },
  { 1375, 2, 20, 10, 4, -15 },
  { 1380, 8, 17, 7, -1, -14 },
  { 1397, 9, 2, 10, 1, -8 },
};

const GFXfont NotoSans_SemiCondensed_Italic20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic20pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC20PT7B_H_
