#ifndef _NOTOSANS_SEMICONDENSED_ITALIC72PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0x3F, 0x83,
  0xF9, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x7E, 0x3F,
  0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x7C, 0x07, 0xC3, 0xE0, 0x3E,
  0x1F, 0x01, 0xF0, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0,
  0x3E, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x07, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xE3,
  0xC1, 0xE0, 0x0F, 0xC1, 0xE0, 0x30, 0x0F, 0xE0, 0xF0, 0x00, 0x07, 0xE0,
  0xF8, 0x00, 0x03, 0xF0, 0x78, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0xF8,
  0x1E, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x1F,
  0x87, 0x80, 0x00, 0x0F, 0xC3, 0xC0, 0x00, 0x07, 0xF1, 0xE0, 0x00, 0x01,
  0xFE, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x01, 0xE7, 0xF0, 0x00, 0x01, 0xE1, 0xFC, 0x00, 0x00, 0xF0, 0xFE,
  0x00, 0x00, 0x78, 0x3F, 0x00, 0x00, 0x3C, 0x1F, 0x80, 0x00, 0x1E, 0x0F,
  0xC0, 0x00, 0x1E, 0x07, 0xE0, 0x00, 0x0F, 0x03, 0xF0, 0x00, 0x07, 0x81,
  0xF8, 0x00, 0x03, 0xC1, 0xF8, 0x10, 0x03, 0xE0, 0xFC, 0x0C, 0x01, 0xE1,
  0xFC, 0x07, 0xC0, 0xF1, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x40, 0x07, 0xFE, 0x00, 0x00, 0x7C, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x7F,
  0x7F, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0xF8, 0x00, 0x3F, 0x00, 0x3E, 0x07,
  0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0xF0,
  0x01, 0xF8, 0x01, 0xF0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x3C, 0x00,
  0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x7E, 0x00,
  0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x07,
  0xC0, 0x1F, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0,
  0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0xC0, 0x7C, 0x03,
  0xE0, 0xF8, 0x3F, 0xC3, 0xE0, 0x1F, 0x0F, 0x87, 0xFF, 0x1F, 0x01, 0xF8,
  0xFC, 0x7F, 0xFC, 0xF8, 0x0F, 0x87, 0xC7, 0xFF, 0xF7, 0xC0, 0xF8, 0x7C,
  0x3F, 0x1F, 0xBF, 0x0F, 0xC7, 0xE3, 0xE0, 0x7C, 0xFD, 0xFC, 0x3E, 0x3F,
  0x03, 0xE7, 0xFF, 0xE3, 0xE1, 0xF0, 0x0F, 0x9F, 0xFE, 0x3F, 0x0F, 0x80,
  0x7C, 0x7F, 0xC1, 0xF0, 0xF8, 0x03, 0xE1, 0xFC, 0x1F, 0x07, 0xC0, 0x1F,
  0x00, 0x01, 0xF8, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x0F, 0x80,
  0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0xF8, 0x03, 0xE0, 0x00,
  0x7C, 0x07, 0xC0, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x00, 0x7E,
  0x03, 0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x3E,
  0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x7C,
  0x00, 0x7C, 0x00, 0x0F, 0x87, 0xE0, 0x07, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x7E, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x07, 0xF0, 0x00, 0x00, 0x7E, 0x1F, 0xE0, 0x00, 0x00, 0xFC, 0x7F, 0x80,
  0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xCF, 0xC0, 0x07, 0xE0, 0xFF, 0x1F, 0xC0,
  0x0F, 0xC3, 0xF8, 0x1F, 0xC0, 0x3F, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x1F,
  0x80, 0x3F, 0x81, 0xF8, 0x7F, 0x00, 0x3F, 0x03, 0xF0, 0xFC, 0x00, 0x7F,
  0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x87, 0xE0, 0x00, 0xFE, 0x7E, 0x0F,
  0xC0, 0x00, 0xFF, 0xF8, 0x3F, 0x00, 0x01, 0xFF, 0xF0, 0x7E, 0x00, 0x01,
  0xFF, 0xC0, 0xFC, 0x00, 0x01, 0xFF, 0x01, 0xF8, 0x00, 0x03, 0xFC, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x07, 0xE0, 0x00,
  0x7F, 0xF0, 0x0F, 0xE0, 0x01, 0xFF, 0xE0, 0x1F, 0xE0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xCF, 0xE0, 0x3F, 0xFF, 0xFF, 0x1F, 0xC0, 0x3F, 0xFF,
  0xF8, 0x1F, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0x80, 0x1F, 0xFF, 0x00, 0x3F,
  0x80, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3E, 0x1F, 0x0F, 0x87, 0x87, 0xC3, 0xE1, 0xF0,
  0xF0, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x06, 0x00, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xF8, 0x3E, 0x00, 0x1F,
  0xF1, 0xE0, 0x01, 0xFF, 0xEF, 0x00, 0x07, 0xFF, 0xF8, 0x7F, 0x83, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xBF,
  0xF8, 0x03, 0xFE, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0x3F, 0x1E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x3F, 0x87, 0xC0, 0x03, 0xF8,
  0x1F, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x78, 0x07, 0xE0, 0x01, 0xC0, 0x1F,
  0x00, 0x04, 0x00, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07,
  0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F,
  0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF8, 0x04,
  0x1F, 0x9F, 0xCF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x7E, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xC3, 0xFC,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7E,
  0x01, 0xFC, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E,
  0x07, 0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F,
  0x1F, 0x80, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0xFE,
  0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0,
  0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0xFF, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xF7, 0xE3, 0xFE, 0x7F, 0x3F, 0xE3,
  0xF0, 0xFC, 0x1F, 0x83, 0xC0, 0xFC, 0x1C, 0x0F, 0xE0, 0x40, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xE1, 0xFF,
  0x80, 0x07, 0xE0, 0x07, 0xF8, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x0C, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x01,
  0xF0, 0x01, 0xFE, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x20, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x08,
  0x00, 0x00, 0xFE, 0x06, 0x00, 0x00, 0xFF, 0x03, 0xE0, 0x01, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F,
  0x81, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01,
  0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x00,
  0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE1, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x20, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x02, 0x00, 0x00, 0x3F,
  0x80, 0xE0, 0x00, 0x3F, 0xE0, 0x3E, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x06, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x07, 0xFE, 0x00, 0x3F,
  0x1F, 0xFF, 0x00, 0x3F, 0x3F, 0xFF, 0x80, 0x7F, 0x7F, 0xFF, 0xC0, 0x7E,
  0xFF, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xE0, 0x7F, 0xE0, 0x0F, 0xE0, 0x7F,
  0x80, 0x07, 0xF0, 0xFF, 0x00, 0x03, 0xF0, 0xFF, 0x00, 0x03, 0xF0, 0xFE,
  0x00, 0x03, 0xF0, 0xFE, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFC, 0x01, 0xFE,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F,
  0xC0, 0x7F, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x0F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC,
  0x7F, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xF0, 0x3F,
  0x80, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x3F, 0x0F,
  0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xE3, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0xFE,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x1F, 0xC0,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x7F, 0x1F, 0xC0,
  0x00, 0x7F, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xFE, 0x0F, 0xC0,
  0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xFE, 0x0F, 0xF0, 0x07, 0xFE, 0x07, 0xF8,
  0x3F, 0x7E, 0x07, 0xFF, 0xFE, 0xFC, 0x03, 0xFF, 0xFC, 0xFC, 0x01, 0xFF,
  0xF8, 0xFC, 0x00, 0xFF, 0xF1, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x0F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xE0, 0x0E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0x0F, 0xFC, 0x3C, 0x00,
  0xFE, 0x18, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0xC0, 0x00, 0xF8, 0x0F,
  0x80, 0x03, 0xFF, 0x80, 0x3E, 0x07, 0xE0, 0x03, 0xFF, 0xF8, 0x0F, 0x81,
  0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xF0, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7C,
  0x3E, 0x00, 0xFE, 0x03, 0xE0, 0x1F, 0x1F, 0x00, 0x7E, 0x01, 0xF0, 0x07,
  0xC7, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF3, 0xF0, 0x0F, 0x80, 0x1F, 0x00,
  0x7C, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x1E, 0x3E, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0x8F, 0x80, 0xFC, 0x00, 0xF8, 0x03, 0xE7, 0xC0, 0x3E, 0x00, 0x3E,
  0x00, 0xF9, 0xF0, 0x0F, 0x80, 0x1F, 0x80, 0x3E, 0x7C, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0x9F, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0xCF, 0x80, 0x7C, 0x00,
  0x7C, 0x01, 0xF3, 0xE0, 0x1F, 0x00, 0x3F, 0x00, 0x7C, 0xF8, 0x0F, 0x80,
  0x0F, 0x80, 0x1F, 0x3E, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0x8F, 0x80, 0xF8,
  0x01, 0xF8, 0x03, 0xE3, 0xE0, 0x3E, 0x00, 0x7E, 0x01, 0xF0, 0xF8, 0x0F,
  0xC0, 0x3F, 0x80, 0x7C, 0x3E, 0x03, 0xF0, 0x1F, 0xE0, 0x3E, 0x0F, 0x80,
  0x7C, 0x0F, 0x78, 0x1F, 0x03, 0xE0, 0x1F, 0x87, 0xDF, 0x1F, 0xC0, 0xF8,
  0x07, 0xFF, 0xE7, 0xFF, 0xE0, 0x3E, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x07,
  0xC0, 0x1F, 0xF8, 0x3F, 0xF8, 0x01, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x00, 0xFC,
  0xF8, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x00,
  0x1F, 0x8F, 0x80, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00, 0x3F, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0xF8, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x7F, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0xC0,
  0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x03, 0xF7,
  0xF0, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x03, 0xFE, 0x00, 0x7E, 0x00,
  0x0F, 0xF0, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F,
  0x80, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x03, 0xFC,
  0x03, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0xC0,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0xFC,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x03, 0xF8,
  0x1F, 0x80, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x7F, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x7E, 0x00, 0x07, 0xFC, 0x07, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC7, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0x80, 0x0F, 0xF8, 0x00, 0x04, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x10, 0x00, 0x7F, 0xE0, 0x07, 0x80, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x00,
  0xFE, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xF0,
  0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x7E, 0x00,
  0x03, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0xE0,
  0x07, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xC1, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7C,
  0x00, 0x7F, 0xE0, 0x00, 0x0C, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xF8, 0x7E,
  0x00, 0x07, 0xFF, 0xF0, 0x7E, 0x00, 0x07, 0xFF, 0xF0, 0x7E, 0x00, 0x07,
  0xFF, 0xF0, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0xFE, 0x00, 0x00, 0x07, 0xE0,
  0xFE, 0x00, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0xFE, 0x00,
  0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x0F,
  0xC0, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x7F, 0x80, 0x00, 0x1F, 0x80,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x08, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x80, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x7E, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x3F,
  0xC0, 0x00, 0x01, 0xF8, 0x3F, 0xC0, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00,
  0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x00, 0x0F, 0xDF, 0xE0,
  0x00, 0x00, 0x07, 0xEF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x9F, 0x80, 0x00, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x00, 0x7F, 0x87, 0xF0,
  0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x07, 0xF0,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x1F,
  0x7C, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x01, 0xF7, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xDF, 0x00, 0x00, 0x1F,
  0xBF, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0xFD, 0xF8, 0x00,
  0x03, 0xF7, 0xE0, 0x03, 0xE7, 0xE0, 0x00, 0x0F, 0x9F, 0x80, 0x0F, 0x9F,
  0x80, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xF1, 0xF8, 0x01,
  0xF9, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xE0, 0x00, 0x3E, 0x3F,
  0x00, 0x1F, 0x8F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x07,
  0xC3, 0xF0, 0x03, 0xF0, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xE0,
  0x00, 0xF8, 0x7F, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0xF8,
  0x3F, 0x00, 0x1F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80,
  0x1F, 0x83, 0xF0, 0x03, 0xE0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83,
  0xF8, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xC0, 0x7C, 0x03,
  0xF0, 0x3F, 0x00, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x07,
  0xC0, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x03, 0xF0, 0x1F, 0x80, 0x0F,
  0xC0, 0x7C, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x01, 0xF0, 0x7E, 0x01, 0xF8,
  0x01, 0xF8, 0x07, 0xC1, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x8F, 0xC0,
  0x3F, 0x80, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF9,
  0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE7, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xBF, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0xFC, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0xE0,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x07, 0xE0, 0x03,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x80,
  0x0F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xE0, 0x03,
  0xEF, 0x80, 0x00, 0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF0, 0x01, 0xFB,
  0xF0, 0x00, 0x1F, 0x80, 0x0F, 0xDF, 0x80, 0x00, 0xFC, 0x00, 0x7C, 0x7E,
  0x00, 0x07, 0xE0, 0x03, 0xE3, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x1F, 0x80,
  0x03, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x00,
  0xFC, 0x00, 0x7C, 0x1F, 0x80, 0x07, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0x7E,
  0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x80,
  0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF8,
  0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x00, 0x7C, 0x00,
  0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x83, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xE0, 0x00, 0xFC, 0x7E,
  0x00, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x1F, 0x80,
  0x0F, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xE7, 0xC0, 0x07,
  0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x3F,
  0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00,
  0x01, 0xF8, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x7E, 0x00,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x07,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFE, 0x01, 0xFF, 0x00, 0x1F,
  0x80, 0x0F, 0xF0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x0F, 0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x3F,
  0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x3F, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x1F, 0x80, 0x0F, 0xF8, 0x07, 0xF0, 0x07, 0xFE, 0x00, 0xFC, 0x1F,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x3F, 0xF8, 0x00, 0x3F,
  0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x00, 0x7E, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFE,
  0x01, 0xFF, 0x80, 0x1F, 0x80, 0x0F, 0xF0, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0xFF,
  0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0x80, 0x1F, 0xF0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x01, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x0F,
  0xC0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x03, 0xF8,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00,
  0xFE, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F,
  0xF0, 0x03, 0xE0, 0x07, 0xF8, 0x00, 0x08, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x08, 0x00, 0x00, 0xFE,
  0x00, 0xC0, 0x00, 0x7F, 0xC0, 0x3F, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x1F,
  0xC0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0x1F, 0xC7, 0xE0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x87, 0xE0,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01,
  0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x03, 0xF8, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x3F, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xF8,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFD,
  0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF3, 0xE0, 0x01, 0xFC, 0x1F, 0x80,
  0x03, 0xE7, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xCF, 0x80, 0x07, 0xE0,
  0x7E, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x3E, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0xFE, 0x01, 0xF0, 0x03, 0xF0,
  0xF8, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xF0, 0x07, 0xC0,
  0x0F, 0x83, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x3F, 0x07, 0xC0, 0x1F, 0x80,
  0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x7E, 0x00, 0x3E, 0x01, 0xF8, 0x1F, 0x00,
  0xFC, 0x00, 0x7C, 0x03, 0xE0, 0x3E, 0x03, 0xF8, 0x00, 0xF8, 0x0F, 0xC0,
  0x7C, 0x07, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x03, 0xF0,
  0x7E, 0x01, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x03, 0xE0, 0x7E, 0x00,
  0x0F, 0xC1, 0xF0, 0x07, 0xC1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x0F, 0x83,
  0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x07, 0xE0, 0x00, 0x7E, 0x3F, 0x00,
  0x3E, 0x1F, 0x80, 0x00, 0xFC, 0x7C, 0x00, 0x7C, 0x3F, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0xF8, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x01, 0xF1, 0xF8, 0x00,
  0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xCF,
  0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x3E, 0xFC, 0x00,
  0x1F, 0x3E, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x1F, 0x80, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xBF,
  0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0,
  0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x07, 0xF0,
  0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x03, 0xF8,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x01,
  0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x03, 0xE1, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x3F, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0xF8, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x01,
  0xF0, 0x1F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0xC0, 0x00,
  0x1F, 0x87, 0xC0, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x03, 0xF3, 0xE0, 0x00,
  0x00, 0xFB, 0xF0, 0x00, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFC,
  0x1F, 0xC3, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0,
  0xF8, 0x0F, 0x80, 0x00, 0x07, 0xF8, 0x0F, 0x80, 0x0F, 0xFF, 0x07, 0xC0,
  0x0F, 0xFF, 0xC3, 0xE0, 0x0F, 0xFF, 0xF3, 0xF0, 0x0F, 0xFF, 0xF9, 0xF0,
  0x0F, 0xF0, 0x3E, 0xF8, 0x0F, 0xF0, 0x0F, 0xFC, 0x0F, 0xF0, 0x03, 0xFE,
  0x07, 0xF0, 0x01, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x3F, 0x0F, 0xE0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x0F, 0xE1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xF0, 0x7E, 0x00,
  0x03, 0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x0F, 0xC0,
  0x01, 0xFE, 0x07, 0xE0, 0x00, 0xFF, 0x03, 0xF0, 0x00, 0xFF, 0x81, 0xFC,
  0x00, 0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0x80, 0xFB, 0xE0, 0x1F,
  0xFB, 0xF9, 0xF0, 0x07, 0xFF, 0xF8, 0xF8, 0x03, 0xFF, 0xF8, 0xFC, 0x00,
  0xFF, 0xF8, 0x7C, 0x00, 0x1F, 0xF0, 0x3E, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x0F, 0xF0,
  0x00, 0x3F, 0x0F, 0xFF, 0x00, 0x0F, 0xC7, 0xFF, 0xE0, 0x03, 0xF3, 0xFF,
  0xFC, 0x00, 0xF9, 0xFF, 0xFF, 0x00, 0x7E, 0xFC, 0x1F, 0xE0, 0x1F, 0xFC,
  0x03, 0xF8, 0x07, 0xFE, 0x00, 0x7E, 0x01, 0xFF, 0x00, 0x1F, 0x80, 0xFF,
  0x80, 0x07, 0xE0, 0x3F, 0xC0, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x3F, 0x83, 0xF0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7F, 0x00,
  0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x0F,
  0xF0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x1F, 0xE0,
  0x3F, 0xE0, 0x0F, 0xF0, 0x1F, 0xFC, 0x07, 0xF8, 0x07, 0xEF, 0xEF, 0xFC,
  0x01, 0xF3, 0xFF, 0xFF, 0x00, 0x7C, 0x7F, 0xFF, 0x00, 0x1F, 0x0F, 0xFF,
  0x80, 0x0F, 0x81, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x03, 0xFE, 0x03, 0x80, 0xFF, 0x00, 0x10, 0x3F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x04, 0x0F, 0xF0, 0x03, 0x00, 0xFF, 0xC7, 0xE0, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x1F, 0x80, 0x00, 0xFF, 0xF0, 0xFC,
  0x00, 0x0F, 0xFF, 0xC7, 0xE0, 0x01, 0xFF, 0xFF, 0x3E, 0x00, 0x1F, 0xFF,
  0xFB, 0xF0, 0x00, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xF0, 0x0F, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x01, 0xFC, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x3F, 0x00, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x03, 0xF0, 0x00,
  0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x03,
  0xF8, 0x0F, 0xBE, 0x00, 0x1F, 0xFB, 0xFB, 0xF0, 0x00, 0x7F, 0xFF, 0x9F,
  0x80, 0x03, 0xFF, 0xF8, 0xF8, 0x00, 0x0F, 0xFF, 0x87, 0xC0, 0x00, 0x3F,
  0xF0, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0x3F,
  0x0F, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x1F, 0xC0, 0x03, 0xF1, 0xF8,
  0x00, 0x3F, 0x3F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFE, 0x3F, 0x00, 0x1F,
  0xC7, 0xF0, 0x07, 0xFC, 0x7E, 0x03, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x02, 0x07, 0xF8, 0x01, 0xE0, 0x3F, 0xF0, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x18, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x20, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x03, 0xE0, 0x00, 0xFF, 0xF0, 0x7C, 0x00, 0x3F,
  0xFF, 0x0F, 0x80, 0x1F, 0xFF, 0xF3, 0xF0, 0x07, 0xFF, 0xFE, 0x7C, 0x00,
  0xFF, 0x03, 0xEF, 0x80, 0x3F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF0, 0x03, 0xFE,
  0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x03, 0xF8, 0x1F, 0xC0,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x1F,
  0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x01,
  0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x01, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x0F, 0xF0, 0x1F,
  0x80, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x7E, 0x00, 0x0F, 0xF0,
  0x0F, 0xC0, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0x80, 0x3F,
  0xF0, 0x03, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xEF, 0xEF, 0xC0, 0x07, 0xFF,
  0xF9, 0xF8, 0x00, 0xFF, 0xFE, 0x3F, 0x00, 0x0F, 0xFF, 0x8F, 0xC0, 0x00,
  0xFF, 0xC1, 0xF8, 0x00, 0x03, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x80, 0x00, 0x7F, 0x00, 0x18,
  0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x0F, 0xF0, 0x00, 0x7E, 0x1F, 0xFE, 0x00, 0x3F, 0x1F, 0xFF,
  0x80, 0x1F, 0x9F, 0xFF, 0xE0, 0x0F, 0x9F, 0xFF, 0xF0, 0x0F, 0xDF, 0x83,
  0xFC, 0x07, 0xFF, 0x00, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0x01, 0xFF, 0x00,
  0x1F, 0x80, 0xFF, 0x00, 0x0F, 0xC0, 0xFF, 0x00, 0x07, 0xE0, 0x7F, 0x00,
  0x03, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0xC0,
  0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x3F, 0x81, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x83, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x0F, 0xE0,
  0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x07, 0xE0, 0x3F,
  0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0xFC,
  0x7F, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0x01, 0xF7, 0xF8, 0x00, 0x00, 0x7D, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFE, 0xFE, 0x00,
  0x00, 0xFF, 0x1F, 0x80, 0x00, 0x7F, 0x87, 0xE0, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x03, 0xF0,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0x0F, 0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x0F, 0xF0, 0x01, 0xFF, 0x00,
  0x0F, 0x83, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xF8, 0x7F, 0xFC, 0x0F, 0xFF,
  0xC0, 0x0F, 0x8F, 0xFF, 0xE1, 0xFF, 0xFE, 0x00, 0xF9, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE0, 0x1F, 0xBE, 0x0F, 0xE7, 0xE0, 0xFF, 0x01, 0xFF, 0xC0, 0x7F,
  0xF8, 0x07, 0xF0, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0x01, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xF0, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x3F, 0x80, 0x03, 0xF0, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xF8, 0x00,
  0x7C, 0x1F, 0xFE, 0x00, 0x3E, 0x1F, 0xFF, 0x80, 0x1F, 0x1F, 0xFF, 0xE0,
  0x1F, 0x9F, 0xFF, 0xF0, 0x0F, 0xDF, 0x83, 0xFC, 0x07, 0xFF, 0x00, 0xFE,
  0x03, 0xFF, 0x00, 0x7F, 0x01, 0xFF, 0x00, 0x1F, 0x81, 0xFF, 0x00, 0x0F,
  0xC0, 0xFF, 0x00, 0x07, 0xE0, 0x7F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x03,
  0xF8, 0x3F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFC, 0x0F, 0xE0, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x1F, 0x81, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x07, 0xF0, 0x3F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x1F, 0xC0,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7F, 0x03, 0xF0,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF0, 0x3F,
  0x80, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFE, 0x07,
  0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFC, 0x1F,
  0xC0, 0x01, 0xF8, 0x7F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0x7F, 0x7E, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x03, 0xF7, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x3F, 0xBF, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F,
  0x8F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF0,
  0x3F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x00,
  0xFF, 0xDF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1F, 0x01, 0xFE, 0x00, 0x00, 0xF8, 0x3F, 0xFC, 0x00, 0x07, 0xC3, 0xFF,
  0xF0, 0x00, 0x3E, 0x3F, 0xFF, 0xC0, 0x01, 0xF3, 0xFF, 0xFE, 0x00, 0x1F,
  0xBF, 0x07, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xC0, 0x07, 0xFE, 0x00, 0x7E,
  0x00, 0x3F, 0xE0, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x00, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x03,
  0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xE0,
  0x03, 0xF7, 0xF7, 0xFE, 0x00, 0x1F, 0xBF, 0xFF, 0xF0, 0x00, 0xFC, 0xFF,
  0xFF, 0x00, 0x07, 0xE3, 0xFF, 0xE0, 0x00, 0x7E, 0x0F, 0xFE, 0x00, 0x03,
  0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x0F, 0x80, 0x0F,
  0xFF, 0x07, 0xC0, 0x0F, 0xFF, 0xC3, 0xE0, 0x0F, 0xFF, 0xF3, 0xF0, 0x0F,
  0xFF, 0xF9, 0xF0, 0x0F, 0xF0, 0x3E, 0xF8, 0x0F, 0xF0, 0x0F, 0xFC, 0x0F,
  0xF0, 0x03, 0xFE, 0x07, 0xF0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x03,
  0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8,
  0x7F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x1F,
  0xC3, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07,
  0xF0, 0x7E, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x03, 0xFC, 0x1F, 0x80, 0x01,
  0xFC, 0x0F, 0xC0, 0x01, 0xFE, 0x07, 0xE0, 0x00, 0xFF, 0x03, 0xF0, 0x00,
  0xFF, 0x81, 0xFC, 0x00, 0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0x80,
  0xFF, 0xE0, 0x1F, 0xFB, 0xFB, 0xF0, 0x07, 0xFF, 0xF9, 0xF8, 0x03, 0xFF,
  0xF8, 0xFC, 0x00, 0xFF, 0xF8, 0xFC, 0x00, 0x3F, 0xF0, 0x7E, 0x00, 0x03,
  0xC0, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x0F,
  0xE0, 0x1F, 0x07, 0xFC, 0x03, 0xE1, 0xFF, 0x00, 0x7C, 0x7F, 0xE0, 0x0F,
  0x9F, 0xFC, 0x03, 0xF7, 0xFB, 0x80, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0x3C, 0x07, 0xF0, 0x00, 0xC0, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xE0, 0x80, 0x00, 0xFE, 0x0F, 0x00, 0x3F, 0xC0, 0xFF, 0x1F, 0xFC, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE7, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x3C, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0,
  0xFE, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x03, 0xF8, 0x1F, 0x80,
  0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xC0, 0x01, 0xFE, 0x07, 0xE0,
  0x00, 0xFF, 0x03, 0xF0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0xFE,
  0x00, 0xFF, 0xC0, 0x7F, 0x81, 0xFF, 0xE0, 0x1F, 0xF7, 0xFB, 0xF0, 0x0F,
  0xFF, 0xF9, 0xF0, 0x03, 0xFF, 0xF8, 0xF8, 0x00, 0xFF, 0xF0, 0x7C, 0x00,
  0x3F, 0xF0, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x07, 0xF3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFE, 0x3F, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7E, 0x07, 0xC0, 0x03,
  0xF8, 0x1F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x7F, 0x01, 0xF8, 0x01, 0xF8,
  0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x01,
  0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0x7E,
  0x07, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x0F, 0x83,
  0xF0, 0x00, 0x3E, 0x1F, 0xC0, 0x00, 0xF8, 0x7E, 0x00, 0x03, 0xE1, 0xF8,
  0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0xF9, 0xF8, 0x00,
  0x03, 0xE7, 0xE0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFB, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xCF, 0xC0, 0x07,
  0xFE, 0x00, 0x7F, 0x3F, 0x00, 0x1E, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFB,
  0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xEF, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x3E,
  0x00, 0xFC, 0x3F, 0x00, 0x7C, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF3, 0xE0,
  0x1F, 0x83, 0xF0, 0x0F, 0x8F, 0x80, 0xFE, 0x07, 0xC0, 0x3E, 0x3E, 0x03,
  0xF0, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC3, 0xE0, 0x7E,
  0x01, 0xF0, 0x3E, 0x0F, 0x81, 0xF8, 0x07, 0xC0, 0xF8, 0x3E, 0x0F, 0xC0,
  0x1F, 0x07, 0xE0, 0xF8, 0x3F, 0x00, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x01,
  0xF0, 0x7C, 0x0F, 0x87, 0xE0, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x80, 0x1F,
  0x0F, 0x80, 0xF8, 0xFC, 0x00, 0x7C, 0x7C, 0x03, 0xE3, 0xF0, 0x01, 0xF1,
  0xF0, 0x0F, 0x9F, 0x80, 0x07, 0xCF, 0xC0, 0x3E, 0x7E, 0x00, 0x1F, 0x3E,
  0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x03, 0xEF, 0xC0, 0x01, 0xF7, 0xC0,
  0x0F, 0xBF, 0x00, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x7F, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x00, 0x7C,
  0x3F, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x1F, 0x80,
  0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x00,
  0x7C, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x02, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0x1F, 0xFE, 0x00, 0x03, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0xC0, 0x00, 0xFF, 0xF8, 0x80, 0x00, 0x1F, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Italic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 18, 52, 18, 1, -51 },
  { 118, 21, 18, 27, 8, -51 },
  { 166, 41, 51, 41, 1, -51 },
  { 428, 33, 59, 35, 2, -55 },
  { 672, 45, 53, 52, 5, -52 },
  { 971, 39, 53, 42, 1, -52 },
  { 1230, 9, 18, 15, 8, -51 },
  { 1251, 23, 63, 20, 2, -52 },
  { 1433, 22, 63, 20, -5, -52 },
  { 1607, 29, 30, 35, 7, -55 },
  { 1716, 31, 35, 37, 4, -43 },
  { 1852, 14, 17, 17, -3, -8 },
  { 1882, 17, 6, 21, 2, -22 },
  { 1895, 9, 10, 17, 1, -9 },
  { 1907, 34, 51, 25, -3, -51 },
  { 2124, 32, 53, 35, 3, -52 },
  { 2336, 21, 51, 35, 9, -51 },
  { 2470, 35, 52, 35, -1, -52 },
  { 2698, 33, 53, 35, 1, -52 },
  { 2917, 34, 52, 35, 0, -52 },
  { 3138, 34, 52, 35, 1, -51 },
  { 3359, 32, 53, 35, 4, -52 },
  { 3571, 32, 51, 35, 5, -51 },
  { 3775, 33, 53, 35, 2, -52 },
  { 3994, 32, 53, 35, 2, -52 },
  { 4206, 14, 40, 17, 1, -39 },
  { 4276, 20, 48, 17, -4, -39 },
  { 4396, 32, 34, 37, 4, -43 },
  { 4532, 30, 20, 37, 5, -35 },
  { 4607, 32, 34, 37, 4, -43 },
  { 4743, 25, 53, 27, 4, -52 },
  { 4909, 50, 58, 54, 3, -52 },
  { 5272, 36, 51, 36, -4, -51 },
  { 5502, 36, 51, 39, 2, -51 },
  { 5732, 37, 53, 37, 4, -52 },
  { 5978, 39, 51, 43, 2, -51 },
  { 6227, 34, 51, 33, 2, -51 },
  { 6444, 34, 51, 31, 2, -51 },
  { 6661, 40, 53, 44, 4, -52 },
  { 6926, 43, 51, 44, 2, -51 },
  { 7201, 28, 51, 22, -2, -51 },
  { 7380, 30, 65, 18, -11, -51 },
  { 7624, 41, 51, 36, 2, -51 },
  { 7886, 24, 51, 31, 2, -51 },
  { 8039, 54, 51, 55, 2, -51 },
  { 8384, 45, 51, 46, 2, -51 },
  { 8671, 40, 53, 46, 4, -52 },
  { 8936, 35, 51, 37, 2, -51 },
  { 9160, 40, 64, 46, 4, -52 },
  { 9480, 35, 51, 37, 2, -51 },
  { 9704, 35, 53, 33, 0, -52 },
  { 9936, 32, 51, 32, 6, -51 },
  { 10140, 41, 52, 43, 4, -51 },
  { 10407, 36, 51, 36, 6, -51 },
  { 10637, 55, 51, 56, 7, -51 },
  { 10988, 43, 51, 34, -4, -51 },
  { 11263, 33, 51, 33, 6, -51 },
  { 11474, 39, 51, 33, -2, -51 },
  { 11723, 27, 63, 21, -1, -52 },
  { 11936, 12, 51, 25, 8, -51 },
  { 12013, 27, 63, 21, -5, -52 },
  { 12226, 33, 31, 37, 2, -52 },
  { 12354, 27, 5, 26, -6, 6 },
  { 12371, 11, 11, 19, 11, -55 },
  { 12387, 33, 40, 37, 3, -39 },
  { 12552, 34, 56, 37, 1, -55 },
  { 12790, 27, 40, 29, 3, -39 },
  { 12925, 37, 56, 38, 3, -55 },
  { 13184, 28, 40, 33, 3, -39 },
  { 13324, 37, 72, 21, -8, -55 },
  { 13657, 35, 56, 38, 1, -39 },
  { 13902, 33, 55, 37, 1, -55 },
  { 14129, 17, 53, 17, 1, -53 },
  { 14242, 27, 70, 17, -9, -53 },
  { 14479, 34, 55, 32, 1, -55 },
  { 14713, 18, 55, 17, 1, -55 },
  { 14837, 52, 39, 56, 1, -39 },
  { 15091, 33, 39, 37, 1, -39 },
  { 15252, 31, 40, 36, 3, -39 },
  { 15407, 37, 56, 37, -2, -39 },
  { 15666, 33, 56, 38, 3, -39 },
  { 15897, 27, 39, 25, 1, -39 },
  { 16029, 28, 40, 28, 0, -39 },
  { 16169, 21, 48, 21, 3, -47 },
  { 16295, 33, 40, 37, 3, -39 },
  { 16460, 30, 39, 30, 4, -39 },
  { 16607, 46, 39, 47, 4, -39 },
  { 16832, 36, 39, 31, -3, -39 },
  { 17008, 41, 56, 30, -7, -39 },
  { 17295, 30, 39, 28, -2, -39 },
  { 17442, 28, 62, 25, 1, -51 },
  { 17659, 5, 72, 35, 16, -55 },
  { 17704, 27, 62, 25, -3, -51 },
  { 17914, 32, 9, 37, 4, -30 },
};

const GFXfont NotoSans_SemiCondensed_Italic72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic72pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC72PT7B_H_
