#ifndef _NOTOSANS_SEMICONDENSED_ITALIC21PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x61, 0x86, 0x10, 0xC3, 0x0C, 0x20, 0x86, 0x00, 0x43, 0x8E,
  0x00, 0x6D, 0xB4, 0xF2, 0xC8, 0x02, 0x20, 0x66, 0x04, 0x40, 0x44, 0x3F,
  0xF3, 0xFF, 0x08, 0x80, 0x88, 0x19, 0x87, 0xFE, 0xFF, 0xE3, 0x30, 0x22,
  0x02, 0x20, 0x66, 0x00, 0x01, 0x00, 0x80, 0xFC, 0x6B, 0x32, 0x0D, 0x83,
  0x40, 0x70, 0x0E, 0x01, 0xC0, 0xD8, 0x26, 0x09, 0x3F, 0xC7, 0xC0, 0x60,
  0x10, 0x00, 0x3C, 0x19, 0x21, 0x99, 0x18, 0x88, 0x84, 0x4C, 0x62, 0xC3,
  0x35, 0xE9, 0x69, 0x76, 0xC8, 0x24, 0x43, 0x22, 0x11, 0x11, 0x19, 0x98,
  0x49, 0x83, 0x80, 0x07, 0x80, 0xCC, 0x18, 0xC1, 0x8C, 0x19, 0x80, 0xB0,
  0x0E, 0x01, 0xC0, 0x36, 0x36, 0x36, 0x43, 0x6C, 0x1C, 0xC1, 0x86, 0x7C,
  0x3C, 0x60, 0x6D, 0x2C, 0x0C, 0x61, 0x0C, 0x21, 0x84, 0x30, 0xC3, 0x08,
  0x20, 0x82, 0x08, 0x30, 0xC1, 0x00, 0x0C, 0x08, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x10, 0x60, 0xC1, 0x06, 0x18, 0x31, 0xC0, 0x0C, 0x06,
  0x32, 0x1F, 0x31, 0xF9, 0xC1, 0x90, 0x8C, 0x04, 0x00, 0x0C, 0x06, 0x03,
  0x01, 0x8F, 0xF8, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x00, 0x36, 0x64, 0xC0,
  0xFC, 0x5F, 0x80, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x40,
  0x30, 0x08, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x00, 0x0F, 0x0D,
  0xCC, 0x6C, 0x36, 0x1B, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xB0, 0xD8, 0x6C,
  0x67, 0x61, 0xE0, 0x1C, 0xE7, 0xB6, 0x18, 0x43, 0x0C, 0x30, 0xC2, 0x18,
  0x61, 0x86, 0x00, 0x0F, 0x86, 0x71, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x3F, 0xCF, 0xF0, 0x0F, 0x86,
  0x70, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x70, 0x78, 0x03, 0x00, 0x60, 0x18,
  0x06, 0x03, 0x31, 0xCF, 0xE0, 0x00, 0xC0, 0x70, 0x3C, 0x1A, 0x05, 0x82,
  0x61, 0x98, 0xC4, 0x61, 0x10, 0xCF, 0xFF, 0xFF, 0x02, 0x01, 0x80, 0x60,
  0x0F, 0xC7, 0xF1, 0x80, 0x60, 0x10, 0x0C, 0x03, 0xF0, 0x8E, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x03, 0x31, 0xCF, 0xE0, 0x07, 0x8E, 0x46, 0x06, 0x06,
  0x03, 0x01, 0x7D, 0xC6, 0xC1, 0x60, 0xB0, 0x58, 0x6C, 0x33, 0x31, 0xF0,
  0x7F, 0xDF, 0xF0, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x30, 0x0C, 0x06,
  0x01, 0x80, 0xC0, 0x30, 0x18, 0x0C, 0x00, 0x1F, 0x1C, 0xCC, 0x64, 0x13,
  0x19, 0x98, 0x78, 0x78, 0x66, 0x61, 0xA0, 0xD0, 0x6C, 0x37, 0x31, 0xF0,
  0x1F, 0x19, 0x98, 0x6C, 0x34, 0x1A, 0x0D, 0x06, 0xC7, 0x7D, 0x01, 0x80,
  0xC0, 0xC0, 0x64, 0xE3, 0xE0, 0x39, 0x80, 0x00, 0x00, 0x00, 0x47, 0x38,
  0x1C, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC6, 0x18, 0xC2, 0x00, 0x00,
  0x80, 0xC1, 0xE3, 0x87, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x80, 0xC0, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C,
  0x1E, 0x38, 0x70, 0x60, 0x00, 0x7E, 0x66, 0x03, 0x03, 0x06, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0x60, 0x00, 0x40, 0xE0, 0xC0, 0x03, 0xF0, 0x38, 0xE1,
  0x80, 0xCC, 0x01, 0x63, 0xE5, 0x19, 0x94, 0xC4, 0x72, 0x11, 0xC8, 0xC6,
  0x63, 0x39, 0x98, 0xA3, 0xFE, 0xC6, 0x63, 0x00, 0x06, 0x00, 0x0E, 0x70,
  0x0F, 0x00, 0x01, 0x80, 0xE0, 0x38, 0x1B, 0x06, 0xC3, 0x30, 0xCC, 0x63,
  0x18, 0xCF, 0xF3, 0x0D, 0x83, 0x60, 0xF0, 0x1C, 0x04, 0x1F, 0x8F, 0xF3,
  0x0C, 0xC3, 0x30, 0xC8, 0x37, 0xF9, 0xFC, 0x61, 0x98, 0x6C, 0x1B, 0x06,
  0xC3, 0xBF, 0xCF, 0xC0, 0x07, 0xE3, 0xC8, 0x60, 0x18, 0x06, 0x00, 0xC0,
  0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x06, 0x00, 0xE6, 0x0F,
  0xC0, 0x1F, 0x07, 0xF8, 0xC3, 0x18, 0x33, 0x06, 0x40, 0xD8, 0x1B, 0x03,
  0x60, 0x6C, 0x1B, 0x03, 0x60, 0xCC, 0x39, 0xFC, 0x3F, 0x00, 0x1F, 0xCF,
  0xE3, 0x00, 0xC0, 0x30, 0x08, 0x07, 0xF1, 0xFC, 0x60, 0x18, 0x0C, 0x03,
  0x00, 0xC0, 0x3F, 0x8F, 0xC0, 0x1F, 0xCF, 0xE3, 0x00, 0xC0, 0x30, 0x08,
  0x06, 0x01, 0xFC, 0x7E, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x00,
  0x07, 0xF1, 0xE6, 0x18, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x3E,
  0xC3, 0xEC, 0x04, 0xC0, 0xCC, 0x0C, 0x60, 0xC7, 0x18, 0x3F, 0x80, 0x18,
  0x33, 0x03, 0x30, 0x23, 0x06, 0x30, 0x62, 0x06, 0x7F, 0xE7, 0xFC, 0x60,
  0xC6, 0x0C, 0x40, 0xCC, 0x0C, 0xC0, 0x8C, 0x18, 0x81, 0x80, 0x1F, 0x83,
  0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x01, 0x83, 0xF0, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x78, 0x38,
  0x00, 0x18, 0x66, 0x18, 0xC6, 0x19, 0x83, 0x60, 0x5C, 0x1B, 0x03, 0xE0,
  0x6C, 0x0C, 0xC3, 0x18, 0x63, 0x0C, 0x31, 0x86, 0x20, 0xC0, 0x18, 0x60,
  0xC1, 0x83, 0x04, 0x18, 0x30, 0x60, 0x83, 0x06, 0x0C, 0x1F, 0xFF, 0x00,
  0x18, 0x0E, 0x70, 0x1C, 0xE0, 0x79, 0xE0, 0xF2, 0xC3, 0x45, 0x87, 0x9B,
  0x1B, 0x36, 0x26, 0x6C, 0xCC, 0x89, 0x13, 0x16, 0x66, 0x28, 0xCC, 0x71,
  0x98, 0xC3, 0x21, 0x8C, 0x00, 0x18, 0x19, 0xC0, 0x8E, 0x0C, 0x78, 0x62,
  0xC3, 0x12, 0x11, 0x99, 0x8C, 0xCC, 0x62, 0x62, 0x1B, 0x30, 0xD1, 0x87,
  0x8C, 0x1C, 0x60, 0xE2, 0x07, 0x00, 0x07, 0xC1, 0xCE, 0x38, 0x63, 0x03,
  0x60, 0x36, 0x03, 0x60, 0x3C, 0x03, 0xC0, 0x2C, 0x06, 0xC0, 0x6C, 0x0C,
  0x61, 0xC7, 0x38, 0x3F, 0x00, 0x1F, 0x0F, 0xE3, 0x0C, 0xC3, 0x30, 0xC8,
  0x36, 0x19, 0x9C, 0x7E, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x00,
  0x07, 0xC1, 0xCE, 0x38, 0x63, 0x03, 0x60, 0x36, 0x03, 0x60, 0x3C, 0x03,
  0xC0, 0x2C, 0x06, 0xC0, 0x6C, 0x0C, 0x60, 0xC7, 0x38, 0x3F, 0x00, 0x60,
  0x03, 0x00, 0x38, 0x01, 0x80, 0x1F, 0x0F, 0xE3, 0x0C, 0xC3, 0x30, 0xC8,
  0x36, 0x19, 0xFC, 0x7C, 0x19, 0x8C, 0x63, 0x18, 0xC3, 0x30, 0xC8, 0x30,
  0x0F, 0xC7, 0x73, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x33, 0xCF, 0xC0, 0xFF, 0xFF, 0xC6, 0x03, 0x01,
  0x80, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x00,
  0x30, 0x33, 0x03, 0x30, 0x23, 0x06, 0x20, 0x66, 0x06, 0x60, 0x66, 0x04,
  0x60, 0xC4, 0x0C, 0xC0, 0xCC, 0x08, 0xC1, 0x87, 0x70, 0x3E, 0x00, 0xC0,
  0xF0, 0x3C, 0x1B, 0x06, 0xC3, 0x30, 0xCC, 0x63, 0x18, 0xCC, 0x13, 0x05,
  0x81, 0x60, 0x70, 0x1C, 0x06, 0x00, 0xC1, 0x83, 0xC1, 0x83, 0xC3, 0x86,
  0xC2, 0x86, 0xC6, 0x8C, 0xC4, 0x8C, 0xCC, 0x88, 0xCC, 0x98, 0xC8, 0x98,
  0xD8, 0xB0, 0xD0, 0xB0, 0xF0, 0xA0, 0xE0, 0xE0, 0xE0, 0xC0, 0xE0, 0xC0,
  0x18, 0x38, 0x61, 0x03, 0x18, 0x19, 0x80, 0x58, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x0F, 0x00, 0x78, 0x06, 0x40, 0x63, 0x03, 0x18, 0x30, 0xC3, 0x03,
  0x00, 0xC1, 0xE0, 0xB0, 0xC8, 0xC6, 0x63, 0x61, 0xA0, 0xF0, 0x30, 0x18,
  0x08, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x1F, 0xE3, 0xF8, 0x03, 0x00, 0xC0,
  0x30, 0x06, 0x01, 0x80, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x01,
  0xFE, 0x3F, 0xC0, 0x1F, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x30, 0x20,
  0x20, 0x60, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0xC0, 0xF0, 0xCC, 0x44, 0x46,
  0x66, 0x62, 0x22, 0x33, 0x30, 0x1E, 0x0C, 0x18, 0x30, 0x40, 0x83, 0x06,
  0x0C, 0x10, 0x20, 0xC1, 0x83, 0x04, 0x18, 0x31, 0xE0, 0x0C, 0x0E, 0x05,
  0x06, 0xC2, 0x23, 0x19, 0x05, 0x83, 0x81, 0x80, 0xFF, 0xCC, 0x80, 0x1E,
  0xCC, 0xE6, 0x19, 0x06, 0xC1, 0xB0, 0x4C, 0x33, 0x0C, 0xC7, 0x33, 0x87,
  0xA0, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x05, 0xE3, 0xCC, 0xE3, 0x30,
  0xCC, 0x32, 0x0D, 0x83, 0x61, 0x98, 0x67, 0x33, 0x78, 0x1F, 0x31, 0x60,
  0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE4, 0x7C, 0x00, 0x60, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x7D, 0x0C, 0xE3, 0x0C, 0x41, 0x98, 0x33, 0x04, 0x61,
  0x8C, 0x31, 0x8E, 0x33, 0x83, 0xD0, 0x1F, 0x33, 0x63, 0xC3, 0xCE, 0xF8,
  0xC0, 0xC0, 0xC0, 0xE6, 0x7C, 0x01, 0xE0, 0x68, 0x08, 0x03, 0x00, 0x60,
  0x3F, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30,
  0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x70, 0x0E, 0x00, 0x0F, 0x63,
  0x38, 0xC3, 0x10, 0x66, 0x0C, 0xC1, 0x18, 0x63, 0x0C, 0x63, 0x8C, 0xE0,
  0xF4, 0x01, 0x80, 0x30, 0x0C, 0x3B, 0x87, 0xE0, 0x0C, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x05, 0xE3, 0xCC, 0xE3, 0x30, 0xCC, 0x32, 0x09, 0x86, 0x61,
  0x98, 0x64, 0x13, 0x0C, 0x18, 0xC0, 0x11, 0x18, 0xC6, 0x31, 0x18, 0xC6,
  0x23, 0x00, 0x03, 0x03, 0x00, 0x01, 0x02, 0x06, 0x06, 0x06, 0x06, 0x04,
  0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x18, 0xB0, 0xE0, 0x0C, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x04, 0x73, 0x18, 0xCC, 0x36, 0x0B, 0x03, 0xC1,
  0x98, 0x66, 0x19, 0x84, 0x33, 0x0C, 0x0C, 0x61, 0x86, 0x18, 0x43, 0x0C,
  0x30, 0xC2, 0x18, 0x61, 0x84, 0x30, 0x17, 0x9E, 0x71, 0xCC, 0xC3, 0x09,
  0x86, 0x33, 0x08, 0x64, 0x30, 0xD8, 0x61, 0xB0, 0xC2, 0x61, 0x0C, 0x86,
  0x1B, 0x0C, 0x30, 0x01, 0x05, 0xF3, 0xCC, 0xE3, 0x30, 0xCC, 0x36, 0x19,
  0x86, 0x61, 0x98, 0x64, 0x1B, 0x0C, 0x1F, 0x19, 0x98, 0x68, 0x3C, 0x1E,
  0x0F, 0x05, 0x86, 0xC3, 0x77, 0x1F, 0x00, 0x0B, 0xC3, 0xCC, 0x71, 0x8C,
  0x31, 0x86, 0x20, 0xCC, 0x19, 0x86, 0x30, 0xC7, 0x31, 0xBC, 0x30, 0x06,
  0x00, 0xC0, 0x10, 0x06, 0x00, 0x1E, 0xCC, 0xE6, 0x19, 0x06, 0xC1, 0xB0,
  0x4C, 0x33, 0x0C, 0xC7, 0x33, 0x87, 0xA0, 0x18, 0x06, 0x01, 0x80, 0x40,
  0x30, 0x17, 0x3C, 0x38, 0x30, 0x30, 0x20, 0x60, 0x60, 0x60, 0x40, 0xC0,
  0x3F, 0x31, 0x60, 0x60, 0x38, 0x1C, 0x0E, 0x06, 0x06, 0x8C, 0xFC, 0x10,
  0xC3, 0x3F, 0x61, 0x86, 0x18, 0x43, 0x0C, 0x30, 0xD3, 0xC0, 0x20, 0xB0,
  0xD8, 0x6C, 0x34, 0x16, 0x1B, 0x0D, 0x86, 0xC7, 0x65, 0x1C, 0x80, 0xC1,
  0xE1, 0xB0, 0x98, 0xCC, 0x42, 0x61, 0x20, 0xB0, 0x50, 0x38, 0x18, 0x00,
  0xC3, 0x0F, 0x1C, 0x6C, 0x51, 0x33, 0x4C, 0xC9, 0x33, 0x65, 0x8D, 0x16,
  0x34, 0x50, 0xF1, 0xC3, 0x86, 0x0E, 0x18, 0x00, 0x18, 0xE3, 0x30, 0x26,
  0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xD0, 0x33, 0x0C, 0x63, 0x86, 0x00,
  0x18, 0x31, 0x86, 0x18, 0x40, 0x8C, 0x08, 0x80, 0x98, 0x09, 0x00, 0xB0,
  0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0xB0, 0x0E, 0x00,
  0x3F, 0x03, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0x60, 0x60, 0xC0, 0xFC, 0x03,
  0x06, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x70, 0xE0, 0x30, 0x30, 0x30,
  0x30, 0x20, 0x60, 0x20, 0x38, 0xFF, 0xFF, 0xF8, 0x0C, 0x1E, 0x06, 0x06,
  0x04, 0x04, 0x0C, 0x0C, 0x06, 0x07, 0x0C, 0x18, 0x18, 0x18, 0x10, 0x30,
  0x30, 0xE0, 0x70, 0xFF, 0xE1, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Italic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 15, 5, 0, -15 },
  { 13, 6, 5, 8, 2, -15 },
  { 17, 12, 15, 12, 0, -15 },
  { 40, 10, 17, 10, 0, -16 },
  { 62, 13, 15, 15, 1, -15 },
  { 87, 12, 15, 12, 0, -15 },
  { 110, 3, 5, 4, 2, -15 },
  { 112, 6, 18, 6, 1, -15 },
  { 126, 7, 18, 6, -2, -15 },
  { 142, 9, 9, 10, 2, -16 },
  { 153, 9, 10, 11, 1, -12 },
  { 165, 4, 5, 5, -1, -2 },
  { 168, 6, 1, 6, 0, -6 },
  { 169, 3, 3, 5, 0, -3 },
  { 171, 10, 15, 7, -1, -15 },
  { 190, 9, 15, 10, 1, -15 },
  { 207, 6, 15, 10, 3, -15 },
  { 219, 10, 15, 10, 0, -15 },
  { 238, 10, 15, 10, 0, -15 },
  { 257, 10, 15, 10, 0, -15 },
  { 276, 10, 15, 10, 0, -15 },
  { 295, 9, 15, 10, 1, -15 },
  { 312, 10, 15, 10, 1, -15 },
  { 331, 9, 15, 10, 1, -15 },
  { 348, 9, 15, 10, 1, -15 },
  { 365, 5, 11, 5, 0, -11 },
  { 372, 6, 14, 5, -1, -11 },
  { 383, 9, 10, 11, 1, -13 },
  { 395, 9, 5, 11, 1, -10 },
  { 401, 9, 10, 11, 1, -13 },
  { 413, 8, 15, 8, 1, -15 },
  { 428, 14, 17, 16, 1, -15 },
  { 458, 10, 15, 11, -1, -15 },
  { 477, 10, 15, 11, 1, -15 },
  { 496, 11, 15, 11, 1, -15 },
  { 517, 11, 15, 12, 1, -15 },
  { 538, 10, 15, 10, 1, -15 },
  { 557, 10, 15, 9, 1, -15 },
  { 576, 12, 15, 13, 1, -15 },
  { 599, 12, 15, 13, 1, -15 },
  { 622, 9, 15, 6, -1, -15 },
  { 639, 9, 19, 5, -3, -15 },
  { 661, 11, 15, 11, 1, -15 },
  { 682, 7, 15, 9, 1, -15 },
  { 696, 15, 15, 16, 1, -15 },
  { 725, 13, 15, 13, 1, -15 },
  { 750, 12, 15, 13, 1, -15 },
  { 773, 10, 15, 11, 1, -15 },
  { 792, 12, 19, 13, 1, -15 },
  { 821, 10, 15, 11, 1, -15 },
  { 840, 10, 15, 10, 0, -15 },
  { 859, 9, 15, 9, 2, -15 },
  { 876, 12, 15, 13, 1, -15 },
  { 899, 10, 15, 10, 2, -15 },
  { 918, 16, 15, 16, 2, -15 },
  { 948, 13, 15, 10, -1, -15 },
  { 973, 9, 15, 10, 2, -15 },
  { 990, 11, 15, 10, 0, -15 },
  { 1011, 8, 18, 6, 0, -15 },
  { 1029, 4, 15, 7, 2, -15 },
  { 1037, 7, 18, 6, -1, -15 },
  { 1053, 9, 9, 11, 1, -15 },
  { 1064, 8, 1, 8, -2, 2 },
  { 1065, 3, 3, 6, 3, -16 },
  { 1067, 10, 11, 11, 1, -11 },
  { 1081, 10, 16, 11, 0, -16 },
  { 1101, 8, 11, 8, 1, -11 },
  { 1112, 11, 16, 11, 1, -16 },
  { 1134, 8, 11, 10, 1, -11 },
  { 1145, 11, 21, 6, -2, -16 },
  { 1174, 11, 16, 11, 0, -11 },
  { 1196, 10, 16, 11, 0, -16 },
  { 1216, 5, 15, 5, 0, -15 },
  { 1226, 8, 20, 5, -3, -15 },
  { 1246, 10, 16, 9, 0, -16 },
  { 1266, 6, 16, 5, 0, -16 },
  { 1278, 15, 11, 16, 0, -11 },
  { 1299, 10, 12, 11, 0, -12 },
  { 1314, 9, 11, 11, 1, -11 },
  { 1327, 11, 16, 11, -1, -11 },
  { 1349, 10, 16, 11, 1, -11 },
  { 1369, 8, 11, 7, 0, -11 },
  { 1380, 8, 11, 8, 0, -11 },
  { 1391, 6, 14, 6, 1, -14 },
  { 1402, 9, 11, 11, 1, -11 },
  { 1415, 9, 11, 9, 1, -11 },
  { 1428, 14, 11, 14, 1, -11 },
  { 1448, 11, 11, 9, -1, -11 },
  { 1464, 12, 16, 9, -2, -11 },
  { 1488, 8, 11, 8, 0, -11 },
  { 1499, 8, 18, 7, 0, -15 },
  { 1517, 1, 21, 10, 5, -16 },
  { 1520, 8, 18, 7, -1, -15 },
  { 1538, 9, 3, 11, 1, -9 },
};

const GFXfont NotoSans_SemiCondensed_Italic21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic21pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC21PT7B_H_
