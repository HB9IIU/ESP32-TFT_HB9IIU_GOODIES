#ifndef _NOTOSANS_SEMICONDENSED_ITALIC33PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x18,
  0x38, 0x38, 0x38, 0x30, 0x30, 0x70, 0x00, 0x00, 0x00, 0x60, 0xE0, 0xE0,
  0xE0, 0x39, 0xCC, 0x77, 0x1D, 0xC6, 0x71, 0x98, 0xE6, 0x39, 0x8C, 0xC3,
  0x00, 0x00, 0xC3, 0x80, 0x30, 0xC0, 0x1C, 0x30, 0x06, 0x1C, 0x01, 0x86,
  0x00, 0x61, 0x80, 0x30, 0x60, 0xFF, 0xFF, 0x3F, 0xFF, 0xC1, 0xC3, 0x00,
  0x61, 0xC0, 0x18, 0x60, 0x0E, 0x18, 0x03, 0x0E, 0x00, 0xC3, 0x03, 0xFF,
  0xFC, 0xFF, 0xFF, 0x06, 0x18, 0x01, 0x86, 0x00, 0xE1, 0x80, 0x30, 0xE0,
  0x0C, 0x30, 0x07, 0x0C, 0x01, 0x87, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x1F, 0xE0, 0xFF, 0xE3, 0xD9, 0x87, 0x30, 0x0C, 0x60, 0x18, 0x80,
  0x33, 0x00, 0x76, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0xFC, 0x01,
  0xBC, 0x03, 0x38, 0x06, 0x70, 0x18, 0xE0, 0x33, 0x8C, 0x6F, 0x1F, 0xFC,
  0x3F, 0xE0, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x0F, 0x00,
  0x60, 0xFC, 0x07, 0x0E, 0x60, 0x30, 0x63, 0x83, 0x07, 0x1C, 0x38, 0x30,
  0xE1, 0x81, 0x87, 0x18, 0x0C, 0x31, 0xC0, 0xE1, 0x8C, 0x07, 0x0C, 0xC0,
  0x30, 0xCE, 0x7D, 0xC6, 0x67, 0xE6, 0x67, 0x73, 0xBF, 0x73, 0x1C, 0xE3,
  0x30, 0xE0, 0x39, 0x87, 0x03, 0x8C, 0x30, 0x18, 0xE1, 0x81, 0xC7, 0x0C,
  0x1C, 0x38, 0xE0, 0xC1, 0xC6, 0x0E, 0x0E, 0x70, 0xE0, 0x3F, 0x0E, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0x79, 0xC0, 0x18, 0x70, 0x0E, 0x0C,
  0x03, 0x83, 0x00, 0xE1, 0xC0, 0x38, 0xE0, 0x0E, 0x78, 0x01, 0xFC, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x4E, 0x70, 0xE7, 0x1C, 0x3B, 0x83,
  0x8C, 0xE0, 0x77, 0x30, 0x1F, 0x8C, 0x03, 0xC3, 0x00, 0xF0, 0xE0, 0x7C,
  0x3C, 0x3F, 0x87, 0xFC, 0xE0, 0xFE, 0x1C, 0x77, 0xEE, 0xEC, 0xCC, 0xC0,
  0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x38,
  0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x38, 0x03, 0x00, 0x01, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0C, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0,
  0x30, 0x0E, 0x03, 0x80, 0x60, 0x18, 0x0F, 0x00, 0x01, 0x80, 0x06, 0x00,
  0x38, 0x10, 0xE0, 0x73, 0x03, 0xFC, 0xF0, 0xFF, 0xC1, 0xCF, 0x0D, 0x80,
  0x66, 0x07, 0x9C, 0x0C, 0x30, 0x10, 0xE0, 0x02, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x1C, 0xE3, 0x8C, 0x71, 0x8E, 0x30, 0xFF, 0xFE, 0x7F, 0xF0, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x07, 0xF0, 0x1F, 0xF0, 0x70, 0xE1, 0xE0, 0xE3, 0x81, 0xC7, 0x03,
  0x9C, 0x07, 0x38, 0x0E, 0x60, 0x1D, 0xC0, 0x3B, 0x80, 0x77, 0x01, 0xCE,
  0x03, 0x98, 0x07, 0x70, 0x0E, 0xE0, 0x39, 0xC0, 0x73, 0x80, 0xE3, 0x03,
  0x87, 0x0F, 0x0F, 0x3C, 0x0F, 0xF0, 0x0F, 0xC0, 0x01, 0xC0, 0xE0, 0xF8,
  0x7E, 0x7B, 0xBC, 0xC6, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x00, 0xF8, 0x03, 0xFC, 0x0F, 0xFE, 0x06, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF, 0xF8, 0xFF, 0xF8,
  0xFF, 0xF8, 0x00, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x04, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xF8,
  0x07, 0xE0, 0x07, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x80, 0x38, 0xE0, 0xF0, 0xFF, 0xE0,
  0x7F, 0xC0, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x6E, 0x00, 0xEE, 0x01, 0xCC, 0x03, 0x9C, 0x03, 0x1C, 0x07, 0x1C,
  0x0E, 0x18, 0x1C, 0x18, 0x38, 0x38, 0x30, 0x38, 0x70, 0x38, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x70, 0x00, 0xE0, 0x01,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xFF, 0x81, 0xFF,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0xC8, 0x07, 0x18, 0x3C, 0x3F, 0xF0, 0x7F, 0xC0, 0x00,
  0x7C, 0x07, 0xF0, 0x7F, 0xC3, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x0E,
  0x00, 0x70, 0x01, 0xCF, 0x06, 0xFE, 0x3F, 0xFC, 0xF0, 0x73, 0xC0, 0xEE,
  0x03, 0xB8, 0x0E, 0xC0, 0x3B, 0x00, 0xCC, 0x07, 0x38, 0x1C, 0xE0, 0xE3,
  0xC7, 0x87, 0xFC, 0x0F, 0xC0, 0x3F, 0xFE, 0x7F, 0xFD, 0xFF, 0xF8, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x01, 0xF0, 0x0F, 0xF8, 0x3E, 0xF8, 0x70, 0x71, 0xC0, 0xE3,
  0x81, 0xC7, 0x03, 0x8E, 0x07, 0x0E, 0x1C, 0x1C, 0x70, 0x1F, 0xC0, 0x1E,
  0x00, 0xFE, 0x07, 0x9E, 0x1E, 0x1E, 0x38, 0x1C, 0xE0, 0x39, 0xC0, 0x73,
  0x80, 0xE7, 0x01, 0xCE, 0x03, 0x9E, 0x1E, 0x1F, 0xF8, 0x1F, 0xE0, 0x01,
  0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0xE0, 0xE1, 0xC0, 0xC7, 0x01, 0xCE, 0x03,
  0x98, 0x07, 0x70, 0x0E, 0xE0, 0x38, 0xC0, 0x71, 0xC1, 0xE3, 0xC7, 0xC3,
  0xFB, 0x83, 0xE6, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x07,
  0x00, 0x1E, 0x10, 0x78, 0x3F, 0xE0, 0x7F, 0x00, 0x0E, 0x3C, 0x78, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x38, 0xF0, 0xE0,
  0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x38, 0x1C, 0x1C, 0x0E, 0x06, 0x07, 0x07,
  0x00, 0x00, 0x04, 0x00, 0x30, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x00, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x80, 0x03, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1C, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x0E, 0x00, 0x20,
  0x00, 0x0F, 0x87, 0xFC, 0x7F, 0xE2, 0x0E, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x0E, 0x01, 0xC0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x03,
  0x00, 0x30, 0x04, 0x00, 0x00, 0x00, 0x00, 0x60, 0x0F, 0x00, 0xF0, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xE7, 0xE0, 0x1E, 0x01,
  0xC0, 0x70, 0x01, 0xC1, 0xC0, 0x01, 0x83, 0x00, 0x03, 0x8C, 0x0F, 0xE3,
  0x38, 0x7F, 0x86, 0x61, 0xC3, 0x0D, 0xC3, 0x0E, 0x1B, 0x0E, 0x1C, 0x36,
  0x18, 0x30, 0x6C, 0x70, 0x61, 0xD8, 0xC1, 0xC3, 0x71, 0x83, 0x86, 0xE3,
  0x0E, 0x1D, 0xC7, 0x1C, 0x73, 0x8F, 0xEF, 0xC3, 0x0F, 0x9F, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x07,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0xC0, 0x03, 0x60, 0x03, 0xB0, 0x01, 0x98, 0x01, 0xCC,
  0x00, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x70, 0xE0, 0x38, 0x70, 0x38,
  0x38, 0x1F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x0E, 0x03, 0x87, 0x00, 0xC7,
  0x00, 0x63, 0x80, 0x3B, 0x80, 0x1D, 0xC0, 0x0F, 0xC0, 0x07, 0x07, 0xE0,
  0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x1C, 0x30,
  0x0E, 0x38, 0x0E, 0x1C, 0x07, 0x0E, 0x07, 0x07, 0xFF, 0x07, 0xFE, 0x03,
  0xFF, 0x81, 0xC0, 0xE0, 0xE0, 0x38, 0x60, 0x1C, 0x70, 0x0E, 0x38, 0x07,
  0x1C, 0x03, 0x8E, 0x03, 0x86, 0x03, 0xC7, 0x0F, 0xC3, 0xFF, 0xC1, 0xFF,
  0x80, 0x00, 0x7E, 0x00, 0xFF, 0xC1, 0xFF, 0xC1, 0xE0, 0x21, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xE1, 0x80,
  0xFF, 0xC0, 0x1F, 0xE0, 0x07, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x38,
  0x3C, 0x0E, 0x07, 0x83, 0x80, 0xE0, 0xC0, 0x3C, 0x70, 0x07, 0x1C, 0x01,
  0xC7, 0x00, 0x71, 0xC0, 0x1C, 0xE0, 0x07, 0x38, 0x03, 0x8E, 0x00, 0xE3,
  0x80, 0x38, 0xC0, 0x1E, 0x70, 0x07, 0x1C, 0x03, 0xC7, 0x00, 0xE1, 0xC0,
  0x78, 0x60, 0x7C, 0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFF,
  0x07, 0xFE, 0x0F, 0xFE, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF0,
  0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF,
  0x07, 0xFE, 0x0F, 0xFE, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF0, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x7F, 0xF0, 0x7F, 0xFC, 0x3E, 0x02, 0x1E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x02, 0xE0, 0x3F, 0x38, 0x1F, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07,
  0x38, 0x01, 0x8E, 0x00, 0xE3, 0xC0, 0x38, 0x70, 0x0E, 0x1F, 0x07, 0x83,
  0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0x00, 0x60, 0xC0, 0x1C, 0x38, 0x03, 0x87,
  0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x01, 0x83, 0x00, 0x70, 0xE0, 0x0E, 0x1C,
  0x01, 0xC3, 0x80, 0x30, 0x7F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0x70,
  0x07, 0x0E, 0x00, 0xC1, 0xC0, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0,
  0x1C, 0x38, 0x03, 0x06, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00,
  0x70, 0x07, 0xF8, 0x3F, 0xC0, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x1C, 0x00, 0x70, 0x27, 0x80, 0xFE, 0x03, 0xF0, 0x00, 0x07, 0x01, 0xE0,
  0xC0, 0x78, 0x38, 0x1E, 0x07, 0x07, 0x80, 0xE0, 0xE0, 0x1C, 0x38, 0x03,
  0x0E, 0x00, 0xE3, 0x80, 0x1C, 0xE0, 0x03, 0xBC, 0x00, 0x7F, 0x00, 0x1D,
  0xC0, 0x03, 0xFC, 0x00, 0x7B, 0x80, 0x0E, 0x38, 0x01, 0x87, 0x00, 0x70,
  0xE0, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x38, 0x06, 0x03, 0x81, 0xC0,
  0x70, 0x38, 0x0E, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x0F, 0x83, 0xC0, 0x07, 0xC3, 0xE0, 0x07,
  0xC1, 0xF0, 0x03, 0xE0, 0xD8, 0x03, 0xF0, 0x6C, 0x01, 0xF8, 0x36, 0x01,
  0xD8, 0x3B, 0x00, 0xDC, 0x1D, 0xC0, 0xEE, 0x0E, 0xE0, 0x67, 0x06, 0x70,
  0x73, 0x87, 0x38, 0x31, 0x83, 0x9C, 0x39, 0xC1, 0xC6, 0x18, 0xE0, 0xE3,
  0x1C, 0x70, 0x61, 0x8C, 0x38, 0x70, 0xCE, 0x18, 0x38, 0x66, 0x1C, 0x1C,
  0x37, 0x0E, 0x0C, 0x1F, 0x07, 0x06, 0x0F, 0x83, 0x87, 0x07, 0x83, 0x83,
  0x83, 0xC1, 0xC1, 0xC1, 0xC0, 0xE0, 0x07, 0x00, 0x30, 0x70, 0x07, 0x0F,
  0x80, 0x70, 0xF8, 0x07, 0x0F, 0x80, 0x70, 0xD8, 0x06, 0x0D, 0xC0, 0xE1,
  0xDC, 0x0E, 0x1C, 0xC0, 0xE1, 0xCE, 0x0C, 0x18, 0xE1, 0xC3, 0x86, 0x1C,
  0x38, 0x71, 0xC3, 0x87, 0x1C, 0x38, 0x71, 0x83, 0x03, 0x38, 0x70, 0x3B,
  0x87, 0x03, 0xB8, 0x70, 0x1B, 0x86, 0x01, 0xF0, 0x60, 0x1F, 0x0E, 0x00,
  0xF0, 0xE0, 0x0F, 0x0E, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F,
  0xF8, 0x3C, 0x0E, 0x1E, 0x03, 0xC7, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07,
  0x70, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x01, 0xCE, 0x00,
  0x73, 0xC0, 0x38, 0x70, 0x1E, 0x1F, 0x1F, 0x03, 0xFF, 0x80, 0x3F, 0x80,
  0x07, 0xC0, 0x07, 0xFC, 0x0F, 0xFE, 0x0E, 0x0E, 0x0E, 0x07, 0x0E, 0x07,
  0x0C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x0E, 0x1C, 0x0E, 0x38, 0x3C,
  0x3F, 0xFC, 0x3F, 0xF0, 0x3F, 0xC0, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3C, 0x0E, 0x1E, 0x03, 0xC7,
  0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07, 0x70, 0x01, 0xDC, 0x00, 0x77, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3B, 0x80, 0x0E,
  0xE0, 0x03, 0xB8, 0x01, 0xCE, 0x00, 0x73, 0xC0, 0x38, 0x70, 0x1E, 0x1F,
  0x1F, 0x03, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x07, 0xFC,
  0x0F, 0xFE, 0x0E, 0x0F, 0x0E, 0x07, 0x0E, 0x07, 0x0C, 0x07, 0x1C, 0x07,
  0x1C, 0x07, 0x1C, 0x0E, 0x1C, 0x1E, 0x38, 0x7C, 0x3F, 0xF8, 0x3F, 0xE0,
  0x38, 0xE0, 0x30, 0xE0, 0x70, 0x60, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70,
  0x60, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x1C, 0x00, 0xFC, 0x03, 0xFF,
  0x07, 0xFE, 0x0F, 0x02, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x80, 0x78, 0xE1, 0xF0, 0xFF, 0xE0, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC1, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x1C,
  0x01, 0xC6, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00,
  0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xC6, 0x00, 0x63,
  0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x01, 0xC3, 0x80, 0x70, 0xF0,
  0x3C, 0x1E, 0x3E, 0x07, 0xFF, 0x00, 0x7F, 0x00, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0x38,
  0x60, 0x70, 0x60, 0x70, 0x60, 0xE0, 0x60, 0xE0, 0x71, 0xC0, 0x71, 0xC0,
  0x71, 0x80, 0x73, 0x80, 0x73, 0x00, 0x77, 0x00, 0x76, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x38, 0x00, 0xE0, 0x1C, 0x01, 0xF8,
  0x07, 0x00, 0xEE, 0x01, 0xC0, 0x3B, 0x80, 0xF0, 0x1C, 0xE0, 0x3C, 0x07,
  0x38, 0x1F, 0x03, 0x8E, 0x06, 0xC0, 0xE3, 0x83, 0xB0, 0x38, 0xE0, 0xEC,
  0x1C, 0x38, 0x33, 0x07, 0x0E, 0x1C, 0xC3, 0x83, 0x86, 0x38, 0xE0, 0xE3,
  0x8E, 0x30, 0x18, 0xC3, 0x9C, 0x06, 0x70, 0xE7, 0x01, 0x98, 0x3B, 0x80,
  0x66, 0x0E, 0xE0, 0x1B, 0x83, 0xB0, 0x06, 0xC0, 0xFC, 0x01, 0xF0, 0x3E,
  0x00, 0x78, 0x0F, 0x80, 0x1E, 0x03, 0xC0, 0x07, 0x00, 0xF0, 0x01, 0xC0,
  0x3C, 0x00, 0x03, 0x80, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x18, 0x1C,
  0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC7, 0x00, 0x0C, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x3B, 0x80, 0x07, 0x18, 0x00, 0x71, 0xC0, 0x0E,
  0x1C, 0x01, 0xC1, 0xC0, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x0E, 0x0F,
  0x00, 0xF0, 0xE0, 0x0F, 0xC0, 0x3B, 0x80, 0x73, 0x01, 0xC7, 0x07, 0x0E,
  0x0E, 0x1C, 0x38, 0x38, 0x70, 0x31, 0xC0, 0x67, 0x00, 0xEE, 0x01, 0xF8,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x03,
  0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0x00,
  0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00,
  0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xE1, 0x86, 0x18, 0x71, 0xC7, 0x1C, 0x30,
  0xC3, 0x0E, 0x38, 0xE3, 0x86, 0x18, 0x61, 0xC7, 0x1C, 0x70, 0xC3, 0x03,
  0xF0, 0x3F, 0x07, 0xF0, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E,
  0x00, 0xE0, 0x0E, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0x80, 0x03, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x6E, 0x01, 0xCC, 0x03, 0x1C, 0x0E, 0x38, 0x18, 0x30,
  0x70, 0x70, 0xC0, 0x63, 0x80, 0xE6, 0x00, 0xDC, 0x01, 0xC0, 0xFF, 0xFF,
  0xFF, 0xE3, 0x1C, 0x61, 0x80, 0x03, 0xC7, 0x07, 0xF6, 0x0F, 0x76, 0x1C,
  0x1E, 0x38, 0x1E, 0x38, 0x1E, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x60,
  0x1C, 0xE0, 0x18, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x78, 0xE0, 0xF8, 0x71,
  0xB0, 0x7F, 0xB0, 0x3E, 0x30, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x7C, 0x1D, 0xFC, 0x3F, 0x78,
  0x78, 0x39, 0xE0, 0x73, 0xC0, 0xE7, 0x01, 0xCE, 0x03, 0x98, 0x07, 0x70,
  0x0C, 0xE0, 0x39, 0xC0, 0x73, 0x80, 0xE7, 0x03, 0x9E, 0x0F, 0x3E, 0x3C,
  0x6F, 0xF0, 0xCF, 0xC0, 0x03, 0xF0, 0x3F, 0xC3, 0xCC, 0x38, 0x03, 0x80,
  0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x01, 0xC0, 0x0F, 0x08, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x07, 0x8E, 0x0F, 0xF6, 0x0F, 0xBF, 0x07, 0x07, 0x87, 0x03, 0xC3,
  0x81, 0xC3, 0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x38, 0x60, 0x1C, 0x70, 0x1C,
  0x38, 0x0E, 0x1C, 0x07, 0x0E, 0x07, 0x87, 0x07, 0xC1, 0xC6, 0xC0, 0xFE,
  0x60, 0x3E, 0x30, 0x00, 0x03, 0xE0, 0x3F, 0xC3, 0x9E, 0x38, 0x73, 0x81,
  0x9C, 0x1D, 0xC1, 0xEE, 0x1E, 0x7F, 0xE7, 0xFC, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x01, 0xC0, 0x0F, 0x0C, 0x3F, 0xE0, 0xFE, 0x00, 0x00, 0x0F,
  0x80, 0x0F, 0xC0, 0x0E, 0x20, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x02, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF3, 0x81,
  0xFD, 0x81, 0xEE, 0xC1, 0xC1, 0xE1, 0xC0, 0xF0, 0xE0, 0x70, 0xE0, 0x38,
  0x70, 0x1C, 0x38, 0x0E, 0x18, 0x07, 0x1C, 0x07, 0x0E, 0x03, 0x87, 0x01,
  0xC3, 0x81, 0xE1, 0xC1, 0xF0, 0x71, 0xB0, 0x3F, 0xF8, 0x0F, 0x9C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x82, 0x03, 0x81, 0xEF, 0xC0,
  0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x7C, 0x1D, 0xFC, 0x37, 0x78,
  0x78, 0x39, 0xE0, 0x73, 0xC0, 0xC7, 0x03, 0x8E, 0x07, 0x18, 0x0E, 0x70,
  0x1C, 0xE0, 0x31, 0xC0, 0xE3, 0x81, 0xC6, 0x03, 0x9C, 0x07, 0x38, 0x0C,
  0x70, 0x38, 0xC0, 0x70, 0x06, 0x1C, 0x38, 0x00, 0x00, 0x07, 0x0E, 0x1C,
  0x30, 0xE1, 0xC3, 0x87, 0x0C, 0x38, 0x70, 0xE1, 0xC3, 0x0E, 0x1C, 0x38,
  0x60, 0x00, 0x30, 0x07, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x0B, 0xC0, 0xF8, 0x0F,
  0x00, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80,
  0x07, 0x00, 0x0E, 0x0F, 0x1C, 0x1C, 0x38, 0x70, 0x61, 0xC1, 0xC7, 0x03,
  0x9C, 0x07, 0x70, 0x0D, 0xC0, 0x1F, 0x80, 0x7F, 0x80, 0xF7, 0x01, 0xC6,
  0x03, 0x0E, 0x06, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x70, 0xC0, 0x70,
  0x07, 0x06, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x38,
  0x38, 0x38, 0x38, 0x30, 0x70, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xE0,
  0xC0, 0x1C, 0xF0, 0x7C, 0x33, 0xF1, 0xFC, 0x6E, 0xF7, 0x78, 0xF0, 0xF8,
  0x73, 0xC1, 0xE0, 0xE7, 0x83, 0xC1, 0xCE, 0x07, 0x03, 0x9C, 0x0E, 0x07,
  0x30, 0x18, 0x0C, 0xE0, 0x70, 0x39, 0xC0, 0xE0, 0x73, 0x81, 0xC0, 0xE7,
  0x03, 0x81, 0xCC, 0x06, 0x03, 0x38, 0x1C, 0x0E, 0x70, 0x38, 0x1C, 0xE0,
  0x70, 0x39, 0x80, 0xE0, 0x70, 0x0E, 0x7C, 0x0E, 0xFE, 0x0D, 0xFE, 0x0F,
  0x07, 0x1E, 0x07, 0x1E, 0x07, 0x1C, 0x0E, 0x1C, 0x0E, 0x38, 0x0E, 0x38,
  0x0E, 0x38, 0x0C, 0x38, 0x1C, 0x38, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70,
  0x38, 0x70, 0x38, 0xF0, 0x38, 0x03, 0xE0, 0x1F, 0xE1, 0xF7, 0x87, 0x07,
  0x38, 0x1C, 0xE0, 0x37, 0x00, 0xDC, 0x07, 0x70, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x3B, 0x80, 0xE7, 0x07, 0x1E, 0x3C, 0x3F, 0xE0, 0x7E,
  0x00, 0x07, 0x3E, 0x03, 0xBF, 0x81, 0xBB, 0xC0, 0xF0, 0x70, 0xF0, 0x38,
  0x78, 0x1C, 0x38, 0x0E, 0x1C, 0x07, 0x0C, 0x03, 0x8E, 0x01, 0x87, 0x01,
  0xC3, 0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x70, 0xF0, 0x78, 0x7C, 0x78, 0x3F,
  0xF8, 0x19, 0xF8, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x03, 0xE7, 0x07,
  0xF6, 0x0F, 0x76, 0x1C, 0x1E, 0x38, 0x1E, 0x38, 0x1C, 0x70, 0x1C, 0x70,
  0x1C, 0x70, 0x1C, 0x60, 0x1C, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0,
  0x78, 0xE0, 0xF8, 0x71, 0xB0, 0x7F, 0xF0, 0x3E, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01,
  0xC0, 0x1C, 0xF1, 0x9F, 0x1B, 0xE1, 0xE0, 0x3C, 0x03, 0xC0, 0x38, 0x03,
  0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0C, 0x00, 0x07, 0xE0, 0xFF, 0xC7, 0x9C, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x98, 0x78, 0xFF, 0x87, 0xF8, 0x00, 0x06, 0x01,
  0x80, 0xE0, 0x30, 0x3F, 0xDF, 0xF7, 0xF8, 0x60, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x01, 0xC0, 0x7E,
  0x1F, 0x80, 0x1C, 0x06, 0x38, 0x1C, 0x70, 0x39, 0xC0, 0x73, 0x80, 0xE7,
  0x01, 0x8E, 0x07, 0x18, 0x0E, 0x70, 0x1C, 0xE0, 0x31, 0xC0, 0xE3, 0x81,
  0xC6, 0x03, 0x9C, 0x0F, 0x38, 0x3C, 0x38, 0xD8, 0x7F, 0x30, 0x7C, 0xE0,
  0xE0, 0x3F, 0x01, 0xF8, 0x1D, 0xC0, 0xEE, 0x0E, 0x70, 0x73, 0x87, 0x1C,
  0x38, 0xE3, 0x87, 0x1C, 0x18, 0xC0, 0xCE, 0x06, 0x60, 0x37, 0x01, 0xB0,
  0x0F, 0x80, 0x78, 0x03, 0xC0, 0x00, 0xE0, 0x70, 0x3F, 0x07, 0x81, 0xF8,
  0x3C, 0x1D, 0xC3, 0xE0, 0xEE, 0x1B, 0x0E, 0x70, 0xD8, 0x73, 0x8E, 0xC3,
  0x1C, 0x66, 0x38, 0xE7, 0x31, 0x87, 0x31, 0x9C, 0x3B, 0x8C, 0xE1, 0xD8,
  0x6E, 0x0E, 0xC3, 0x70, 0x7E, 0x1B, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0x80,
  0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x00, 0x0C, 0x07, 0x0E, 0x0E, 0x0E, 0x0E,
  0x06, 0x1C, 0x07, 0x38, 0x07, 0x70, 0x03, 0x70, 0x03, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x06, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x38, 0x70,
  0x38, 0x70, 0x70, 0x30, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0xE0, 0x38, 0x1C,
  0x0E, 0x03, 0x81, 0xC0, 0x70, 0x30, 0x0E, 0x0E, 0x01, 0xC1, 0x80, 0x18,
  0x70, 0x03, 0x0C, 0x00, 0x63, 0x80, 0x0C, 0x60, 0x01, 0x9C, 0x00, 0x33,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x05, 0xF0, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0x7F, 0xE3, 0xFF, 0x80, 0x00, 0x18, 0x07, 0xC0, 0x7E, 0x03, 0x80, 0x18,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00,
  0xE0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x06, 0x00, 0x78, 0x07, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x1C, 0x00, 0xF0, 0x1F, 0x03, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x0F, 0x80, 0xF0,
  0x00, 0x3C, 0x07, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0x80, 0x20,
};

const GFXglyph NotoSans_SemiCondensed_Italic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 8, 24, 8, 1, -24 },
  { 25, 10, 9, 12, 3, -24 },
  { 37, 18, 24, 19, 1, -24 },
  { 91, 15, 27, 16, 1, -25 },
  { 142, 21, 24, 24, 2, -24 },
  { 205, 18, 24, 19, 1, -24 },
  { 259, 4, 9, 7, 4, -24 },
  { 264, 11, 29, 9, 1, -24 },
  { 304, 11, 29, 9, -3, -24 },
  { 344, 14, 14, 16, 3, -25 },
  { 369, 14, 16, 17, 2, -20 },
  { 397, 6, 8, 8, -1, -4 },
  { 403, 8, 2, 10, 1, -10 },
  { 405, 3, 4, 8, 1, -4 },
  { 407, 16, 24, 11, -2, -24 },
  { 455, 15, 24, 16, 1, -24 },
  { 500, 10, 24, 16, 4, -24 },
  { 530, 16, 24, 16, 0, -24 },
  { 578, 16, 24, 16, 0, -24 },
  { 626, 16, 24, 16, 0, -24 },
  { 674, 15, 24, 16, 1, -24 },
  { 719, 14, 24, 16, 2, -24 },
  { 761, 15, 24, 16, 2, -24 },
  { 806, 15, 24, 16, 1, -24 },
  { 851, 15, 24, 16, 1, -24 },
  { 896, 7, 18, 8, 0, -18 },
  { 912, 9, 22, 8, -2, -18 },
  { 937, 14, 16, 17, 2, -20 },
  { 965, 14, 9, 17, 2, -16 },
  { 981, 14, 16, 17, 2, -20 },
  { 1009, 12, 24, 12, 2, -24 },
  { 1045, 23, 27, 25, 1, -24 },
  { 1123, 17, 24, 17, -2, -24 },
  { 1174, 17, 24, 18, 1, -24 },
  { 1225, 17, 24, 17, 2, -24 },
  { 1276, 18, 24, 20, 1, -24 },
  { 1330, 16, 24, 15, 1, -24 },
  { 1378, 16, 24, 14, 1, -24 },
  { 1426, 18, 24, 20, 2, -24 },
  { 1480, 19, 24, 20, 1, -24 },
  { 1537, 13, 24, 10, -1, -24 },
  { 1576, 14, 30, 8, -5, -24 },
  { 1629, 19, 24, 17, 1, -24 },
  { 1686, 11, 24, 14, 1, -24 },
  { 1719, 25, 24, 25, 1, -24 },
  { 1794, 20, 24, 21, 1, -24 },
  { 1854, 18, 24, 21, 2, -24 },
  { 1908, 16, 24, 17, 1, -24 },
  { 1956, 18, 30, 21, 2, -24 },
  { 2024, 16, 24, 17, 1, -24 },
  { 2072, 16, 24, 15, 0, -24 },
  { 2120, 14, 24, 15, 3, -24 },
  { 2162, 18, 24, 20, 2, -24 },
  { 2216, 16, 24, 16, 3, -24 },
  { 2264, 26, 24, 26, 3, -24 },
  { 2342, 20, 24, 16, -2, -24 },
  { 2402, 15, 24, 15, 3, -24 },
  { 2447, 18, 24, 15, -1, -24 },
  { 2501, 13, 29, 9, -1, -24 },
  { 2549, 6, 24, 12, 3, -24 },
  { 2567, 12, 29, 9, -2, -24 },
  { 2611, 15, 14, 17, 1, -24 },
  { 2638, 12, 2, 12, -3, 3 },
  { 2641, 5, 5, 9, 5, -25 },
  { 2645, 16, 18, 17, 1, -18 },
  { 2681, 15, 25, 17, 1, -25 },
  { 2728, 13, 18, 13, 1, -18 },
  { 2758, 17, 25, 17, 1, -25 },
  { 2812, 13, 18, 15, 1, -18 },
  { 2842, 17, 33, 9, -4, -25 },
  { 2913, 17, 26, 17, 0, -18 },
  { 2969, 15, 25, 17, 1, -25 },
  { 3016, 7, 24, 8, 1, -24 },
  { 3037, 12, 32, 8, -4, -24 },
  { 3085, 15, 25, 15, 1, -25 },
  { 3132, 8, 25, 8, 1, -25 },
  { 3157, 23, 18, 26, 1, -18 },
  { 3209, 16, 18, 17, 0, -18 },
  { 3245, 14, 18, 17, 1, -18 },
  { 3277, 17, 26, 17, -1, -18 },
  { 3333, 16, 26, 17, 1, -18 },
  { 3385, 12, 18, 12, 1, -18 },
  { 3412, 13, 18, 13, 0, -18 },
  { 3442, 10, 22, 10, 1, -22 },
  { 3470, 15, 18, 17, 1, -18 },
  { 3504, 13, 18, 14, 2, -18 },
  { 3534, 21, 18, 22, 2, -18 },
  { 3582, 16, 18, 14, -1, -18 },
  { 3618, 19, 26, 14, -3, -18 },
  { 3680, 14, 18, 13, -1, -18 },
  { 3712, 13, 29, 11, 0, -24 },
  { 3760, 3, 33, 16, 7, -25 },
  { 3773, 12, 29, 11, -1, -24 },
  { 3817, 14, 5, 17, 2, -14 },
};

const GFXfont NotoSans_SemiCondensed_Italic33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic33pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC33PT7B_H_
