#ifndef _NOTOSANS_SEMICONDENSED_ITALIC26PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x30, 0x60, 0xC3, 0x86, 0x0C, 0x18, 0x30, 0xC1, 0x83,
  0x06, 0x00, 0x00, 0x61, 0xE3, 0x80, 0x66, 0xCF, 0x9E, 0x3C, 0xD9, 0xA3,
  0x00, 0x01, 0x8C, 0x03, 0x18, 0x0C, 0x60, 0x18, 0xC0, 0x31, 0x80, 0x42,
  0x0F, 0xFF, 0x9F, 0xFF, 0x04, 0x20, 0x18, 0xC0, 0x31, 0x80, 0x63, 0x07,
  0xFF, 0x93, 0x18, 0x06, 0x30, 0x08, 0x40, 0x31, 0x80, 0x63, 0x00, 0xC4,
  0x00, 0x01, 0x80, 0x10, 0x03, 0x80, 0xFF, 0x1F, 0x63, 0x30, 0x32, 0x03,
  0x20, 0x36, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x05, 0xC0, 0xCC, 0x0C, 0xC0,
  0x9C, 0x8B, 0x8F, 0xF0, 0x7C, 0x01, 0x80, 0x10, 0x01, 0x00, 0x1C, 0x06,
  0x3E, 0x0C, 0x66, 0x0C, 0x66, 0x18, 0xC6, 0x30, 0xC6, 0x30, 0xC6, 0x60,
  0xC6, 0xC0, 0xCC, 0xDE, 0xCD, 0xB3, 0xFB, 0x23, 0x73, 0x63, 0x06, 0x63,
  0x0C, 0x63, 0x0C, 0x42, 0x18, 0xC6, 0x30, 0x46, 0x30, 0x6C, 0x60, 0x78,
  0x01, 0xC0, 0x0F, 0xE0, 0x18, 0xC0, 0x61, 0x80, 0xC3, 0x01, 0x8E, 0x03,
  0x18, 0x07, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x6C, 0x39, 0x8C, 0x66, 0x1D,
  0xCC, 0x1B, 0x38, 0x3C, 0x70, 0x30, 0x60, 0xF0, 0xFF, 0x70, 0xFC, 0x60,
  0x6F, 0xED, 0xA0, 0x03, 0x06, 0x0C, 0x0C, 0x18, 0x38, 0x30, 0x70, 0x60,
  0x60, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0x60, 0x60, 0x06, 0x06, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x07, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x60,
  0xE0, 0x06, 0x01, 0x80, 0xC3, 0x30, 0xFC, 0x47, 0xF1, 0xC0, 0xD8, 0xE6,
  0x11, 0xC0, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC1, 0xFF, 0xFF,
  0xF8, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x39, 0x9C, 0xC6, 0x60,
  0xFF, 0xF0, 0x6F, 0xE0, 0x00, 0x30, 0x07, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x01,
  0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x80, 0xFE,
  0x1C, 0xE1, 0x86, 0x30, 0x63, 0x07, 0x70, 0x66, 0x06, 0x60, 0x66, 0x06,
  0xE0, 0x6C, 0x0E, 0xC0, 0xEC, 0x0C, 0xC1, 0xCE, 0x18, 0x63, 0x87, 0xF0,
  0x3E, 0x00, 0x03, 0x0E, 0x1E, 0x7E, 0xE6, 0x4E, 0x0C, 0x0C, 0x0C, 0x0C,
  0x1C, 0x18, 0x18, 0x18, 0x38, 0x30, 0x30, 0x30, 0x70, 0x03, 0xC0, 0xFE,
  0x1C, 0x70, 0x83, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0F, 0xFC,
  0xFF, 0xC0, 0x03, 0xC0, 0xFF, 0x1C, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x06, 0x0F, 0xC0, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00,
  0xE0, 0x0E, 0x81, 0xCF, 0xF8, 0x7F, 0x00, 0x00, 0x30, 0x07, 0x00, 0xF0,
  0x0F, 0x01, 0xB0, 0x36, 0x06, 0x60, 0xE6, 0x0C, 0x61, 0x8E, 0x30, 0xC7,
  0x0C, 0x60, 0xCF, 0xFF, 0xFF, 0xF0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80,
  0x07, 0xF8, 0x3F, 0x83, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x3F, 0xC0, 0xDF, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x1C, 0x81, 0xC7, 0xFC, 0x1F, 0xC0, 0x01, 0xF0, 0x7F, 0x0E, 0x01,
  0xC0, 0x18, 0x03, 0x00, 0x30, 0x07, 0x30, 0x6F, 0xC7, 0x9C, 0x70, 0xEE,
  0x0E, 0xE0, 0xEC, 0x0C, 0xC0, 0xCE, 0x0C, 0x61, 0x87, 0xF8, 0x3E, 0x00,
  0x7F, 0xEF, 0xFC, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xE0, 0x18, 0x07,
  0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x1C,
  0x03, 0x00, 0x00, 0x07, 0xC0, 0xFE, 0x1C, 0x71, 0x87, 0x38, 0x33, 0x07,
  0x18, 0x61, 0x8C, 0x0F, 0x81, 0xF0, 0x3B, 0x86, 0x1C, 0xE0, 0xCC, 0x0C,
  0xC0, 0xCC, 0x0C, 0xE1, 0xCF, 0xF8, 0x7F, 0x00, 0x07, 0x83, 0xF8, 0x63,
  0x98, 0x37, 0x06, 0xC0, 0xD8, 0x1B, 0x03, 0x60, 0xEE, 0x3C, 0xFF, 0x8F,
  0x60, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0x07, 0x1F, 0xC3, 0xF0, 0x00, 0x1C,
  0x71, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0xE3, 0x80, 0x0E, 0x1C,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC3, 0x0E, 0x18, 0x30,
  0xC0, 0x00, 0x20, 0x0C, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x38, 0x07, 0x00,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x02, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x80, 0x18, 0x03, 0xC0, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x0F, 0x07, 0x87, 0xC3, 0xE0, 0x60, 0x08, 0x00, 0x0F,
  0x1F, 0xE2, 0x18, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x30, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x38, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x7F, 0x80, 0x70, 0x30, 0x30, 0x06, 0x18, 0x00, 0xCC, 0x08,
  0x33, 0x1F, 0xCD, 0x8E, 0x63, 0x63, 0x18, 0xD1, 0x86, 0x3C, 0x61, 0x8F,
  0x10, 0xC2, 0xC4, 0x31, 0xB1, 0x1C, 0x6C, 0x6D, 0xF3, 0x1E, 0x78, 0x40,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xF1, 0xC0, 0x0F, 0xF0, 0x00, 0x00,
  0x30, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xD8, 0x06, 0x60, 0x19, 0x80,
  0xC6, 0x03, 0x18, 0x18, 0x60, 0x61, 0x83, 0xFE, 0x0F, 0xF8, 0x70, 0x61,
  0x81, 0x8E, 0x06, 0x30, 0x19, 0xC0, 0x7E, 0x01, 0xC0, 0x0F, 0x00, 0xFF,
  0x86, 0x1C, 0x30, 0x71, 0x81, 0x8C, 0x1C, 0xE0, 0xC6, 0x0E, 0x3F, 0xE1,
  0xFC, 0x1C, 0x38, 0xE0, 0xC6, 0x07, 0x30, 0x39, 0x81, 0x9C, 0x1C, 0xC1,
  0xE7, 0xFE, 0x3F, 0xC0, 0x01, 0xE0, 0x7F, 0xC7, 0x84, 0x70, 0x03, 0x00,
  0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0xFC, 0x0F, 0xE0, 0x0F,
  0x80, 0x7F, 0x81, 0x8F, 0x06, 0x0E, 0x18, 0x18, 0x60, 0x73, 0x81, 0xCC,
  0x07, 0x30, 0x1C, 0xC0, 0x77, 0x01, 0x98, 0x06, 0x60, 0x39, 0x80, 0xC6,
  0x07, 0x38, 0x38, 0xC1, 0xC3, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xF1, 0xFF,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x3F, 0xC3, 0xFC,
  0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0F, 0xF8,
  0xFF, 0x00, 0x0F, 0xF1, 0xFF, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38,
  0x03, 0x00, 0x30, 0x03, 0xFC, 0x7F, 0xC7, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x1F, 0xF1, 0xE1,
  0x8E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x07,
  0xEC, 0x1F, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0xCC, 0x07, 0x38, 0x18, 0xE0,
  0x61, 0xFF, 0x83, 0xFC, 0x00, 0x0C, 0x06, 0x38, 0x0C, 0x60, 0x38, 0xC0,
  0x61, 0x80, 0xC3, 0x01, 0x8E, 0x03, 0x18, 0x0E, 0x3F, 0xF8, 0x7F, 0xF1,
  0xC0, 0x63, 0x81, 0xC6, 0x03, 0x8C, 0x06, 0x18, 0x0C, 0x70, 0x18, 0xC0,
  0x71, 0x80, 0xC3, 0x01, 0x80, 0x0F, 0xC3, 0xF0, 0x30, 0x0C, 0x07, 0x01,
  0x80, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80,
  0x60, 0x18, 0x0F, 0x0F, 0xE0, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x06,
  0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x38, 0x3E,
  0x07, 0x80, 0x0C, 0x0C, 0x70, 0x61, 0x83, 0x86, 0x1C, 0x18, 0xE0, 0x67,
  0x03, 0xB8, 0x0C, 0xC0, 0x36, 0x00, 0xF8, 0x07, 0xF0, 0x1C, 0xC0, 0x63,
  0x01, 0x8E, 0x06, 0x18, 0x38, 0x60, 0xC1, 0xC3, 0x03, 0x0C, 0x0E, 0x00,
  0x0C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x38, 0x30, 0x30, 0x30, 0x70, 0x60,
  0x60, 0x60, 0x60, 0xE0, 0xC0, 0xFF, 0xFF, 0x0E, 0x00, 0xE3, 0xC0, 0x3C,
  0x78, 0x07, 0x8F, 0x01, 0xB1, 0xE0, 0x3C, 0x7C, 0x0D, 0x8D, 0x81, 0xB1,
  0xB0, 0x66, 0x36, 0x0D, 0xC6, 0x63, 0x31, 0xCC, 0x66, 0x31, 0x98, 0xC6,
  0x33, 0x18, 0xC6, 0xC7, 0x18, 0xD8, 0xC7, 0x1E, 0x18, 0xC3, 0xC3, 0x18,
  0x70, 0xE3, 0x0E, 0x18, 0x00, 0x0C, 0x03, 0x1C, 0x07, 0x1E, 0x06, 0x1E,
  0x06, 0x1E, 0x06, 0x3F, 0x06, 0x33, 0x0E, 0x33, 0x0C, 0x33, 0x0C, 0x31,
  0x8C, 0x71, 0x8C, 0x61, 0x98, 0x60, 0xD8, 0x60, 0xD8, 0x60, 0xD8, 0xE0,
  0xF8, 0xC0, 0x70, 0xC0, 0x70, 0xC0, 0x70, 0x03, 0xC0, 0x3F, 0xC1, 0xE3,
  0x8E, 0x06, 0x30, 0x1D, 0xC0, 0x36, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x06, 0xC0, 0x1B, 0x00, 0xEC, 0x03, 0x30, 0x1C, 0xE0,
  0xE1, 0xFF, 0x03, 0xF0, 0x00, 0x0F, 0x01, 0xFE, 0x18, 0xF1, 0x83, 0x18,
  0x31, 0x83, 0x38, 0x33, 0x03, 0x30, 0x73, 0x1E, 0x7F, 0xC7, 0xE0, 0x60,
  0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x03, 0xC0,
  0x3F, 0xC1, 0xE3, 0x8E, 0x06, 0x30, 0x1D, 0xC0, 0x36, 0x00, 0xF8, 0x03,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x06, 0xC0, 0x1B, 0x00, 0xEC, 0x03,
  0x30, 0x1C, 0xE0, 0xE1, 0xFF, 0x03, 0xF8, 0x00, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x1E, 0x00, 0x0F, 0x01, 0xFE, 0x18, 0xF1, 0x83, 0x18, 0x31, 0x83,
  0x38, 0x33, 0x07, 0x30, 0x63, 0xFE, 0x7F, 0x86, 0x30, 0x63, 0x86, 0x18,
  0x61, 0x8E, 0x1C, 0xC1, 0xCC, 0x0C, 0xC0, 0xE0, 0x03, 0xE0, 0xFF, 0x1E,
  0x31, 0x80, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x03,
  0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x81, 0xCF, 0xF8, 0xFF,
  0x00, 0x7F, 0xFF, 0xFE, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03,
  0x00, 0x30, 0x07, 0x00, 0x60, 0x00, 0x38, 0x0C, 0xC0, 0x33, 0x01, 0xCC,
  0x06, 0x30, 0x19, 0xC0, 0x66, 0x01, 0x98, 0x0E, 0x60, 0x33, 0x80, 0xCE,
  0x03, 0x30, 0x1C, 0xC0, 0x73, 0x01, 0x8C, 0x06, 0x30, 0x38, 0xE1, 0xC3,
  0xFE, 0x07, 0xF0, 0x00, 0xE0, 0x1F, 0x01, 0xF8, 0x0C, 0xC0, 0xE6, 0x06,
  0x30, 0x71, 0x83, 0x0C, 0x38, 0x61, 0x83, 0x1C, 0x18, 0xC0, 0xC6, 0x06,
  0x60, 0x33, 0x01, 0xB0, 0x0D, 0x80, 0x78, 0x01, 0xC0, 0x0C, 0x00, 0xC0,
  0xE0, 0x7C, 0x0E, 0x06, 0xC0, 0xE0, 0xEC, 0x1E, 0x0C, 0xC1, 0xE1, 0xCC,
  0x36, 0x18, 0xC3, 0x61, 0x8C, 0x66, 0x30, 0xC6, 0x63, 0x0C, 0xC6, 0x70,
  0xCC, 0x66, 0x0C, 0xC6, 0x60, 0xD8, 0x6C, 0x0D, 0x86, 0xC0, 0xF0, 0x78,
  0x0F, 0x07, 0x80, 0xE0, 0x78, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0x00, 0x0C,
  0x06, 0x18, 0x1C, 0x38, 0x70, 0x30, 0xC0, 0x63, 0x00, 0xEE, 0x00, 0xD8,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3E, 0x00, 0xCC, 0x03,
  0x98, 0x06, 0x30, 0x18, 0x70, 0x70, 0x60, 0xC0, 0xC3, 0x01, 0xC0, 0xE0,
  0x36, 0x06, 0x60, 0xE6, 0x0C, 0x61, 0xC7, 0x18, 0x33, 0x03, 0x70, 0x36,
  0x03, 0xC0, 0x3C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30,
  0x07, 0x00, 0x70, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x01, 0xC0, 0x0E, 0x00,
  0x30, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01,
  0x80, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xFF, 0x8F,
  0xFE, 0x00, 0x0F, 0x87, 0xC3, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18,
  0x1C, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x18,
  0x0C, 0x07, 0xC3, 0xE0, 0xCC, 0xCC, 0xCC, 0x66, 0x66, 0x66, 0x63, 0x33,
  0x33, 0x30, 0x07, 0xC1, 0xF0, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x3F, 0x0F, 0x80, 0x06, 0x00, 0x60, 0x0F, 0x00,
  0xF0, 0x19, 0x81, 0x98, 0x31, 0x83, 0x0C, 0x60, 0xC6, 0x06, 0xC0, 0x70,
  0xFF, 0xFF, 0xC0, 0xCE, 0x63, 0x0F, 0x31, 0xFB, 0x38, 0xF7, 0x06, 0x60,
  0x66, 0x06, 0xE0, 0xEE, 0x0E, 0xC0, 0xCC, 0x1C, 0xC1, 0xCE, 0x3C, 0x7E,
  0x87, 0xD8, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00,
  0x67, 0x83, 0x7E, 0x1E, 0x30, 0xE1, 0x8E, 0x0E, 0x70, 0x63, 0x03, 0x18,
  0x18, 0xC0, 0xCE, 0x0E, 0x70, 0x63, 0x87, 0x1F, 0xF1, 0x9F, 0x00, 0x0F,
  0xC7, 0xF3, 0x81, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x80, 0x7F, 0x0F, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70,
  0x03, 0x00, 0x18, 0x3C, 0xC3, 0xF6, 0x38, 0xF3, 0x83, 0x18, 0x18, 0xC0,
  0xCE, 0x0E, 0x70, 0x63, 0x03, 0x18, 0x38, 0xC1, 0xC7, 0x1E, 0x1F, 0xE0,
  0xFB, 0x00, 0x0F, 0x87, 0xF3, 0x8D, 0xC3, 0x60, 0xD8, 0xEF, 0xF3, 0xF0,
  0xC0, 0x30, 0x0C, 0x03, 0x82, 0x7F, 0x0F, 0xC0, 0x00, 0x7C, 0x03, 0xE0,
  0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x7E, 0x03, 0xF8, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80,
  0x06, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x07, 0x98, 0x7E, 0xC7, 0x1E, 0x70,
  0x63, 0x03, 0x18, 0x19, 0xC1, 0xCE, 0x0E, 0x60, 0x63, 0x07, 0x18, 0x38,
  0xE3, 0xC3, 0xFC, 0x1F, 0x60, 0x03, 0x00, 0x18, 0x01, 0x84, 0x1C, 0x3F,
  0xC1, 0xFC, 0x00, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x19, 0xE1, 0xBF, 0x1C, 0x31, 0xC3, 0x38, 0x33, 0x83, 0x30, 0x73, 0x07,
  0x30, 0x67, 0x06, 0x60, 0x66, 0x0E, 0x60, 0xCE, 0x0C, 0x0E, 0x1C, 0x30,
  0x00, 0x03, 0x86, 0x0C, 0x18, 0x70, 0xC1, 0x83, 0x06, 0x1C, 0x30, 0x60,
  0xC3, 0x80, 0x01, 0xC0, 0x70, 0x08, 0x00, 0x00, 0x00, 0xE0, 0x30, 0x0C,
  0x03, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x83, 0xC0, 0xE0, 0x00, 0x06, 0x00,
  0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0xE3, 0x0C, 0x18,
  0xC0, 0xCC, 0x0E, 0xC0, 0x6E, 0x03, 0xE0, 0x1F, 0x80, 0xCC, 0x0E, 0x60,
  0x63, 0x83, 0x0C, 0x18, 0x71, 0xC1, 0x80, 0x06, 0x1C, 0x30, 0x60, 0xC1,
  0x87, 0x0C, 0x18, 0x30, 0xE1, 0x83, 0x06, 0x0C, 0x38, 0x60, 0xC1, 0x87,
  0x00, 0x19, 0xE3, 0xC3, 0x7E, 0xFC, 0x70, 0xE1, 0x8E, 0x1C, 0x33, 0x83,
  0x06, 0x70, 0xE0, 0xCC, 0x18, 0x39, 0x83, 0x06, 0x30, 0x60, 0xCE, 0x0C,
  0x19, 0x83, 0x87, 0x30, 0x60, 0xC6, 0x0C, 0x19, 0xC1, 0x83, 0x00, 0x19,
  0xE1, 0xBF, 0x1E, 0x31, 0xC3, 0x38, 0x33, 0x83, 0x30, 0x73, 0x07, 0x30,
  0x67, 0x06, 0x60, 0x66, 0x0E, 0x60, 0xCE, 0x0C, 0x0F, 0x83, 0xF8, 0xE3,
  0xB8, 0x36, 0x06, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x1B, 0x07, 0x70,
  0xC7, 0xF0, 0x7C, 0x00, 0x0C, 0xF0, 0x37, 0xE0, 0xF1, 0x83, 0x86, 0x1C,
  0x1C, 0x70, 0x61, 0x81, 0x86, 0x06, 0x18, 0x18, 0xE0, 0xE3, 0x83, 0x0E,
  0x1C, 0x3F, 0xE0, 0xDF, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x30, 0x00, 0x0F, 0x31, 0xFB, 0x38, 0xF7, 0x06, 0x60, 0x66, 0x06,
  0xE0, 0xEC, 0x0C, 0xC0, 0xCC, 0x1C, 0xC1, 0xCE, 0x3C, 0x7F, 0x87, 0xD8,
  0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x19, 0xC6, 0xF1,
  0xE0, 0x70, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80,
  0x60, 0x38, 0x00, 0x1F, 0x8F, 0xF3, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0xC0,
  0x3C, 0x07, 0x00, 0xC0, 0x32, 0x0C, 0xFF, 0x3F, 0x80, 0x08, 0x18, 0x18,
  0x7F, 0xFE, 0x30, 0x30, 0x70, 0x60, 0x60, 0x60, 0x60, 0xE0, 0xC0, 0xC0,
  0xF8, 0x78, 0x38, 0x33, 0x07, 0x30, 0x63, 0x06, 0x70, 0x66, 0x06, 0x60,
  0xE6, 0x0C, 0xE0, 0xCE, 0x1C, 0xC1, 0xCC, 0x3C, 0xFF, 0x87, 0xD8, 0xE0,
  0x7C, 0x19, 0x83, 0x30, 0xC6, 0x18, 0xC6, 0x18, 0xC3, 0x30, 0x66, 0x0D,
  0x81, 0xB0, 0x3C, 0x07, 0x80, 0xE0, 0x00, 0xC3, 0x83, 0xC3, 0x87, 0xC7,
  0x86, 0xC7, 0x8E, 0xC5, 0x8C, 0xCD, 0x8C, 0xCD, 0x98, 0xD9, 0x98, 0xD9,
  0xB0, 0xF1, 0xB0, 0xF1, 0xB0, 0xE1, 0xE0, 0xE1, 0xE0, 0xE1, 0xC0, 0x18,
  0x38, 0x61, 0x83, 0x18, 0x19, 0x80, 0x7C, 0x03, 0xC0, 0x1C, 0x00, 0xE0,
  0x0F, 0x00, 0xEC, 0x06, 0x60, 0x63, 0x07, 0x0C, 0x70, 0x60, 0x1C, 0x0C,
  0x30, 0x70, 0xC1, 0x83, 0x0E, 0x0C, 0x30, 0x31, 0x80, 0xC6, 0x03, 0x30,
  0x0C, 0xC0, 0x36, 0x00, 0xD8, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x00, 0x60, 0x0F, 0x80, 0x3C, 0x00, 0x0F, 0xE3, 0xFC,
  0x03, 0x00, 0xE0, 0x38, 0x06, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x00, 0xE0,
  0x38, 0x07, 0xF9, 0xFF, 0x00, 0x00, 0x40, 0xF0, 0x38, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x30, 0x0C, 0x03, 0x03, 0x81, 0xC0, 0xF0, 0x06, 0x01, 0x80,
  0x60, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0x01, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x03, 0xC0, 0x70, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x70, 0x0F, 0x07, 0x83, 0x80, 0xC0,
  0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x3C, 0x0E, 0x00, 0x70, 0x3F,
  0xCE, 0x3F, 0xC0, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_Italic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 7, 19, 7, 0, -19 },
  { 18, 7, 7, 10, 3, -19 },
  { 25, 15, 19, 15, 0, -19 },
  { 61, 12, 22, 13, 1, -20 },
  { 94, 16, 19, 19, 2, -19 },
  { 132, 15, 19, 15, 0, -19 },
  { 168, 3, 7, 5, 3, -19 },
  { 171, 8, 23, 7, 1, -19 },
  { 194, 8, 23, 7, -2, -19 },
  { 217, 10, 11, 13, 3, -20 },
  { 231, 11, 12, 14, 2, -15 },
  { 248, 5, 6, 6, -1, -3 },
  { 252, 6, 2, 8, 1, -8 },
  { 254, 4, 3, 6, 0, -3 },
  { 256, 12, 19, 9, -1, -19 },
  { 285, 12, 19, 13, 1, -19 },
  { 314, 8, 19, 13, 3, -19 },
  { 333, 12, 19, 13, 0, -19 },
  { 362, 12, 19, 13, 0, -19 },
  { 391, 12, 19, 13, 0, -19 },
  { 420, 13, 19, 13, 0, -19 },
  { 451, 12, 19, 13, 1, -19 },
  { 480, 11, 19, 13, 2, -19 },
  { 507, 12, 19, 13, 1, -19 },
  { 536, 11, 19, 13, 1, -19 },
  { 563, 6, 14, 6, 0, -14 },
  { 574, 7, 17, 6, -1, -14 },
  { 589, 11, 13, 14, 2, -16 },
  { 607, 11, 7, 14, 2, -13 },
  { 617, 11, 13, 14, 2, -16 },
  { 635, 10, 19, 10, 1, -19 },
  { 659, 18, 21, 20, 1, -19 },
  { 707, 14, 19, 13, -2, -19 },
  { 741, 13, 19, 14, 1, -19 },
  { 772, 13, 19, 13, 2, -19 },
  { 803, 14, 19, 15, 1, -19 },
  { 837, 12, 19, 12, 1, -19 },
  { 866, 12, 19, 11, 1, -19 },
  { 895, 14, 19, 16, 2, -19 },
  { 929, 15, 19, 16, 1, -19 },
  { 965, 10, 19, 8, -1, -19 },
  { 989, 11, 24, 6, -4, -19 },
  { 1022, 14, 19, 13, 1, -19 },
  { 1056, 8, 19, 11, 1, -19 },
  { 1075, 19, 19, 20, 1, -19 },
  { 1121, 16, 19, 17, 1, -19 },
  { 1159, 14, 19, 17, 2, -19 },
  { 1193, 12, 19, 13, 1, -19 },
  { 1222, 14, 23, 17, 2, -19 },
  { 1263, 12, 19, 13, 1, -19 },
  { 1292, 12, 19, 12, 0, -19 },
  { 1321, 12, 19, 12, 2, -19 },
  { 1350, 14, 19, 16, 2, -19 },
  { 1384, 13, 19, 13, 2, -19 },
  { 1415, 20, 19, 20, 3, -19 },
  { 1463, 15, 19, 12, -1, -19 },
  { 1499, 12, 19, 12, 2, -19 },
  { 1528, 14, 19, 12, -1, -19 },
  { 1562, 9, 23, 7, 0, -19 },
  { 1588, 4, 19, 9, 3, -19 },
  { 1598, 10, 23, 7, -2, -19 },
  { 1627, 12, 11, 13, 1, -19 },
  { 1644, 9, 2, 9, -2, 2 },
  { 1647, 4, 4, 7, 4, -20 },
  { 1649, 12, 14, 13, 1, -14 },
  { 1670, 13, 20, 14, 0, -20 },
  { 1703, 10, 14, 10, 1, -14 },
  { 1721, 13, 20, 14, 1, -20 },
  { 1754, 10, 14, 12, 1, -14 },
  { 1772, 14, 26, 7, -3, -20 },
  { 1818, 13, 20, 14, 0, -14 },
  { 1851, 12, 20, 13, 0, -20 },
  { 1881, 7, 19, 6, 0, -19 },
  { 1898, 10, 25, 6, -3, -19 },
  { 1930, 13, 20, 12, 0, -20 },
  { 1963, 7, 20, 6, 0, -20 },
  { 1981, 19, 14, 20, 0, -14 },
  { 2015, 12, 14, 13, 0, -14 },
  { 2036, 11, 14, 13, 1, -14 },
  { 2056, 14, 20, 14, -1, -14 },
  { 2091, 12, 20, 14, 1, -14 },
  { 2121, 10, 14, 9, 0, -14 },
  { 2139, 10, 14, 10, 0, -14 },
  { 2157, 8, 17, 8, 1, -17 },
  { 2174, 12, 14, 13, 1, -14 },
  { 2195, 11, 14, 11, 1, -14 },
  { 2215, 16, 14, 17, 2, -14 },
  { 2243, 13, 14, 11, -1, -14 },
  { 2266, 14, 20, 11, -2, -14 },
  { 2301, 11, 14, 10, -1, -14 },
  { 2321, 10, 23, 9, 0, -19 },
  { 2350, 2, 26, 13, 6, -20 },
  { 2357, 10, 23, 9, -1, -19 },
  { 2386, 11, 4, 14, 2, -11 },
};

const GFXfont NotoSans_SemiCondensed_Italic26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic26pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC26PT7B_H_
