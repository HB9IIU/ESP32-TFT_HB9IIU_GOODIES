#ifndef _NOTOSANS_SEMICONDENSED_ITALIC55PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0,
  0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x01, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x18, 0x00, 0x3E,
  0x1F, 0x3C, 0x1F, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x3C, 0x78,
  0x3C, 0x78, 0x3C, 0x70, 0x3C, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xE0,
  0x70, 0xE0, 0x70, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x01, 0xE0, 0x00,
  0x1E, 0x03, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x0E, 0x00, 0x00, 0xE0, 0x3C,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x1C, 0x07, 0x80, 0x00, 0x78, 0x0E, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x80,
  0x1E, 0x07, 0x80, 0x00, 0x38, 0x0F, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x38, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0,
  0x38, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFC, 0xE1, 0xC0, 0x3E, 0x38, 0x10, 0x1F,
  0x0E, 0x00, 0x07, 0x83, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x78, 0x70, 0x00,
  0x1E, 0x1C, 0x00, 0x07, 0xC7, 0x00, 0x01, 0xF1, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0x7E, 0x00,
  0x01, 0xCF, 0xC0, 0x00, 0x71, 0xF0, 0x00, 0x38, 0x7C, 0x00, 0x0E, 0x0F,
  0x00, 0x03, 0x87, 0xC0, 0x00, 0xE1, 0xF0, 0x00, 0x78, 0x78, 0x20, 0x1C,
  0x3E, 0x0F, 0x07, 0x3F, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x00, 0xFF, 0x00, 0x07, 0x80, 0xFF,
  0xC0, 0x01, 0xE0, 0x3F, 0xF8, 0x00, 0xF0, 0x1E, 0x1E, 0x00, 0x78, 0x0F,
  0x83, 0x80, 0x1E, 0x03, 0xC0, 0xE0, 0x0F, 0x00, 0xE0, 0x38, 0x07, 0x80,
  0x78, 0x0E, 0x01, 0xE0, 0x1E, 0x03, 0x80, 0xF0, 0x07, 0x01, 0xE0, 0x78,
  0x03, 0xC0, 0x78, 0x1E, 0x00, 0xF0, 0x1E, 0x0F, 0x00, 0x3C, 0x07, 0x87,
  0x80, 0x0F, 0x01, 0xC1, 0xE0, 0x03, 0xC0, 0xF0, 0xF0, 0x00, 0xF0, 0x3C,
  0x78, 0x7E, 0x38, 0x0E, 0x1E, 0x3F, 0xCF, 0x07, 0x8F, 0x1F, 0xFB, 0xC1,
  0xE7, 0x8F, 0x9E, 0xF0, 0xF1, 0xE7, 0x83, 0xFF, 0xF8, 0xF1, 0xE0, 0xF7,
  0xFC, 0x78, 0xF0, 0x3C, 0xFE, 0x1E, 0x3C, 0x0F, 0x0F, 0x0F, 0x1E, 0x03,
  0xC0, 0x07, 0x87, 0x80, 0xF0, 0x01, 0xE1, 0xE0, 0x3C, 0x00, 0xF0, 0x78,
  0x0E, 0x00, 0x78, 0x1C, 0x07, 0x80, 0x1E, 0x0F, 0x01, 0xE0, 0x0F, 0x03,
  0xC0, 0x78, 0x07, 0x80, 0xF0, 0x1C, 0x01, 0xE0, 0x3C, 0x0F, 0x00, 0xF0,
  0x0F, 0x03, 0xC0, 0x78, 0x03, 0xC1, 0xE0, 0x1E, 0x00, 0xF0, 0x78, 0x0F,
  0x00, 0x1E, 0x3C, 0x07, 0xC0, 0x07, 0xFF, 0x01, 0xE0, 0x01, 0xFF, 0x80,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x7C, 0x1F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x3C, 0x03, 0xE0, 0x00, 0xF0, 0x0F, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x0F,
  0x01, 0xF0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0xF0, 0x3E, 0x00, 0x03, 0xC1,
  0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xBE, 0x01, 0xF0, 0xFC, 0xF8, 0x07, 0x87,
  0xE1, 0xF0, 0x3E, 0x3E, 0x07, 0xC0, 0xF8, 0xF8, 0x0F, 0x87, 0xC7, 0xC0,
  0x3E, 0x1F, 0x1E, 0x00, 0x7C, 0xF8, 0xF8, 0x01, 0xFF, 0xC3, 0xE0, 0x03,
  0xFF, 0x0F, 0x80, 0x07, 0xF8, 0x3E, 0x00, 0x1F, 0xC0, 0xF8, 0x00, 0x3E,
  0x03, 0xE0, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0xF0, 0x1F, 0x00, 0xFF, 0xE0,
  0x7F, 0x9F, 0xEF, 0x80, 0xFF, 0xFF, 0x1F, 0x01, 0xFF, 0xF0, 0x7E, 0x03,
  0xFF, 0x00, 0xF8, 0x01, 0x80, 0x00, 0x00, 0x3E, 0x7C, 0xF3, 0xE7, 0xCF,
  0x1E, 0x3C, 0x78, 0xE3, 0xC7, 0x8E, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x01, 0x00, 0xE0,
  0x07, 0x03, 0x80, 0x3F, 0x0E, 0x00, 0xFF, 0x38, 0x03, 0xFF, 0xC3, 0xF0,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xE0, 0x00, 0x7B,
  0xC0, 0x03, 0xE7, 0x00, 0x1F, 0x1E, 0x00, 0xF8, 0x78, 0x07, 0xC1, 0xF0,
  0x0F, 0x03, 0xC0, 0x18, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xC3, 0xE0,
  0xF8, 0x7E, 0x1F, 0x07, 0xC3, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC0,
  0xF0, 0x00, 0x7F, 0xFD, 0xFF, 0xE7, 0xFF, 0xBF, 0xFE, 0x11, 0xFF, 0xFF,
  0xFF, 0xFF, 0x98, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0xFC, 0x7E, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x1F,
  0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x0F, 0x0F, 0x80, 0x0F, 0x0F, 0x80, 0x0F,
  0x0F, 0x80, 0x0F, 0x1F, 0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x1E, 0x00, 0x0F,
  0x3E, 0x00, 0x0F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3C, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x3E,
  0x78, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0xF8, 0x00, 0x7C,
  0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8,
  0x78, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x7C, 0x07, 0xE0,
  0x7E, 0x0F, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFE,
  0x03, 0xFE, 0x07, 0xFE, 0x1F, 0xFC, 0x3F, 0xBC, 0xFE, 0x7C, 0x7C, 0x7C,
  0x78, 0x7C, 0x20, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xE0, 0x0F, 0xF1, 0xFC, 0x00, 0xF0, 0x0F, 0xC0, 0x18, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x38, 0x03, 0xF0, 0x0C,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x08, 0x00, 0x0F, 0x83, 0xC0, 0x0F, 0xE0,
  0xFF, 0xBF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xEF, 0x00, 0x01,
  0xF3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x7C, 0x00, 0x1F, 0x1F, 0x00,
  0x0F, 0x87, 0x80, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0xF8, 0x3E,
  0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x07, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x3C,
  0x00, 0x78, 0x1F, 0x00, 0x3E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x08, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x20,
  0x00, 0x7E, 0x0E, 0x00, 0x7F, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F,
  0x83, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x3C, 0x7F,
  0xC0, 0x7C, 0xFF, 0xE0, 0x7D, 0xFF, 0xF0, 0x7B, 0xC3, 0xF8, 0x7F, 0x00,
  0xF8, 0xFE, 0x00, 0xF8, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0x7C, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0x78, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF0, 0xF8, 0x01,
  0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x80,
  0x00, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x1F,
  0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0,
  0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x03,
  0xE0, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0xFE, 0x1F, 0x00, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0x7C,
  0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x78, 0x00,
  0x3E, 0x1E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF8,
  0x00, 0x3C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0,
  0x3F, 0xCF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xF8, 0xFE, 0x07, 0xE0, 0x3E, 0x07,
  0xC0, 0x3E, 0x0F, 0x80, 0x1F, 0x0F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F,
  0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E,
  0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x3E,
  0x00, 0x7E, 0x1F, 0x00, 0xFE, 0x1F, 0x01, 0xFE, 0x1F, 0xEF, 0xFE, 0x0F,
  0xFF, 0xBE, 0x07, 0xFF, 0x3C, 0x03, 0xFC, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x80, 0x3F, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x03, 0xC0, 0xFC, 0x1F,
  0x87, 0xF0, 0xFE, 0x1F, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF0, 0x18, 0x00, 0x00, 0x3C, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0x0F, 0xE1, 0x80,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x70, 0x03, 0xC1, 0xE0, 0x0F,
  0xFC, 0x0F, 0x0F, 0x00, 0xFF, 0xF8, 0x3C, 0x78, 0x07, 0xFF, 0xC0, 0xF1,
  0xE0, 0x3E, 0x0F, 0x03, 0xC7, 0x01, 0xF0, 0x3C, 0x0F, 0x3C, 0x0F, 0x80,
  0xF0, 0x3C, 0xF0, 0x3C, 0x03, 0x80, 0xF3, 0x81, 0xE0, 0x1E, 0x03, 0xDE,
  0x07, 0x80, 0x78, 0x0F, 0x78, 0x1C, 0x01, 0xE0, 0x3D, 0xE0, 0xF0, 0x0F,
  0x00, 0xE7, 0x03, 0xC0, 0x3C, 0x07, 0x9C, 0x0F, 0x00, 0xF0, 0x1E, 0xF0,
  0x3C, 0x07, 0xC0, 0x73, 0xC0, 0xF0, 0x1E, 0x03, 0xCF, 0x03, 0xC0, 0x78,
  0x0F, 0x3C, 0x0F, 0x03, 0xE0, 0x78, 0xF0, 0x3C, 0x1F, 0xC3, 0xC3, 0xC0,
  0xF8, 0xEF, 0x9F, 0x0F, 0x01, 0xFF, 0x9F, 0xF8, 0x1E, 0x07, 0xFC, 0x7F,
  0xC0, 0x78, 0x07, 0xC0, 0x7C, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x04, 0x00, 0x03, 0xF8,
  0x00, 0x70, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x1F, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3E, 0x78, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x7C, 0x78, 0x00, 0x07, 0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00,
  0x0F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x03, 0xC0, 0x03, 0xE0,
  0x3C, 0x00, 0x3E, 0x03, 0xC0, 0x07, 0xC0, 0x3C, 0x00, 0x7C, 0x03, 0xC0,
  0x0F, 0x80, 0x3C, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x3E,
  0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE1, 0xF8,
  0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x1E, 0x3E, 0x00, 0x01,
  0xE7, 0xE0, 0x00, 0x1E, 0x7C, 0x00, 0x01, 0xEF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xF0, 0x07, 0xF0, 0x0F, 0x00, 0x3F,
  0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x1E,
  0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01,
  0xF0, 0x3E, 0x00, 0x3E, 0x03, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0x83, 0xFE, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x80,
  0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x1F, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8,
  0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF8, 0x3E, 0x00, 0x3F, 0x03, 0xC0,
  0x07, 0xF0, 0x7C, 0x01, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xE3, 0xE0, 0x0F, 0xE0, 0x06, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8,
  0x01, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0xF0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xC0, 0x1F, 0x00, 0x1F, 0x80, 0x7C,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0xFC, 0x07, 0x80, 0x01, 0xF0, 0x3E, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01,
  0xF0, 0x3C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C,
  0x1F, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xC0,
  0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x3F, 0x07, 0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0xE0, 0x3C, 0x00, 0x7F, 0x00,
  0xF0, 0x07, 0xF8, 0x07, 0xC0, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0x00, 0x7F,
  0x00, 0x02, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x03, 0xFF, 0x87, 0xC0, 0x0F, 0xFF, 0x0F, 0x80, 0x1F, 0xFE,
  0x3E, 0x00, 0x3F, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1E, 0x0F,
  0x80, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x03, 0xC0, 0x7E, 0x00, 0x07, 0x80, 0xFC, 0x00, 0x1F, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0xFE, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x03, 0xC0, 0x1F, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x01, 0xF0, 0x07,
  0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3C, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x03, 0xE0,
  0x0F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x07,
  0xC0, 0x1E, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xE0, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x07, 0x80, 0x3E, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x78, 0x00, 0x7F, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x00,
  0xF0, 0x03, 0xE0, 0x00, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0xC0, 0x01,
  0xF0, 0x1F, 0x80, 0x01, 0xF0, 0x3F, 0x00, 0x01, 0xE0, 0x7E, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x03, 0xC7, 0xE0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x07,
  0xDF, 0x80, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x07, 0xBF, 0x80, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xE7, 0xC0, 0x00, 0x0F,
  0xC7, 0xC0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1E,
  0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0x80,
  0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x1E, 0xF0, 0x00, 0x1F, 0xF8, 0x07, 0xBC, 0x00, 0x07, 0xBC, 0x01, 0xEF,
  0x00, 0x03, 0xFF, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0xC0, 0x3E, 0xF0, 0x00,
  0x7D, 0xF0, 0x0F, 0xBC, 0x00, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x0F, 0x9E,
  0x00, 0xF3, 0xE0, 0x03, 0xCF, 0x80, 0x3C, 0x78, 0x01, 0xF3, 0xE0, 0x1F,
  0x1E, 0x00, 0x78, 0xF8, 0x07, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xE1, 0xE0,
  0x0F, 0x1F, 0x00, 0x78, 0x78, 0x07, 0xC7, 0xC0, 0x3E, 0x1E, 0x01, 0xE1,
  0xF0, 0x0F, 0x87, 0x80, 0xF0, 0x7C, 0x03, 0xE1, 0xE0, 0x3C, 0x1E, 0x00,
  0xF0, 0x78, 0x1E, 0x0F, 0x80, 0x3C, 0x1E, 0x07, 0x83, 0xE0, 0x1F, 0x07,
  0xC3, 0xC0, 0xF8, 0x07, 0xC0, 0xF0, 0xF0, 0x3E, 0x01, 0xE0, 0x3C, 0x78,
  0x0F, 0x00, 0x78, 0x0F, 0x1E, 0x07, 0xC0, 0x1E, 0x03, 0xCF, 0x01, 0xF0,
  0x0F, 0x80, 0xF3, 0xC0, 0x7C, 0x03, 0xE0, 0x3D, 0xE0, 0x1E, 0x00, 0xF0,
  0x0F, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xFC, 0x03, 0xE0, 0x0F, 0x00, 0xFF,
  0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0xE0, 0x0F,
  0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x0F,
  0x80, 0x1E, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x80,
  0x00, 0x78, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x0F,
  0xE0, 0x00, 0x7C, 0x03, 0xFE, 0x00, 0x0F, 0x00, 0x7F, 0xC0, 0x01, 0xE0,
  0x0F, 0x78, 0x00, 0x7C, 0x01, 0xEF, 0x80, 0x0F, 0x80, 0x3D, 0xF0, 0x01,
  0xF0, 0x0F, 0x9E, 0x00, 0x3C, 0x01, 0xF3, 0xC0, 0x07, 0x80, 0x3C, 0x7C,
  0x01, 0xF0, 0x07, 0x8F, 0x80, 0x3E, 0x00, 0xF0, 0xF0, 0x07, 0x80, 0x3E,
  0x1F, 0x00, 0xF0, 0x07, 0xC3, 0xE0, 0x3E, 0x00, 0xF0, 0x3C, 0x07, 0xC0,
  0x1E, 0x07, 0x80, 0xF8, 0x07, 0xC0, 0xF8, 0x1E, 0x00, 0xF8, 0x0F, 0x03,
  0xC0, 0x1F, 0x01, 0xE0, 0xF8, 0x03, 0xC0, 0x3E, 0x1F, 0x00, 0x78, 0x07,
  0xC3, 0xE0, 0x1F, 0x00, 0x78, 0x78, 0x03, 0xE0, 0x0F, 0x8F, 0x00, 0x7C,
  0x01, 0xF3, 0xE0, 0x0F, 0x00, 0x1E, 0x7C, 0x01, 0xE0, 0x03, 0xCF, 0x80,
  0x7C, 0x00, 0x7D, 0xE0, 0x0F, 0x80, 0x07, 0xBC, 0x01, 0xE0, 0x00, 0xF7,
  0x80, 0x3C, 0x00, 0x1F, 0xF0, 0x07, 0x80, 0x03, 0xFC, 0x01, 0xF0, 0x00,
  0x3F, 0x80, 0x3E, 0x00, 0x07, 0xF0, 0x07, 0x80, 0x00, 0xFE, 0x00, 0xF0,
  0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x0F, 0xF8, 0xFF, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0xF8, 0x3E,
  0x00, 0x01, 0xF0, 0xFC, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x1F, 0x3E, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0x1F, 0x7C, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x1F,
  0x1F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xFC, 0x07, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0x01, 0xFC, 0x01, 0xE0, 0x0F, 0xC0, 0x7C, 0x00, 0xF8, 0x0F,
  0x80, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x3C, 0x00, 0x7C, 0x0F, 0x80, 0x0F,
  0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF0,
  0x01, 0xF8, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x03, 0xF0,
  0x1E, 0x01, 0xFC, 0x03, 0xC3, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7C, 0x1F, 0x80,
  0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x01, 0xF1, 0xF0, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x0F, 0x9F, 0x00, 0x00,
  0x1F, 0x3E, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x03, 0xF0, 0x7C, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0xFC, 0x01, 0xFC, 0x07, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0x00, 0xFC, 0x01, 0xE0, 0x0F, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x1F,
  0x01, 0xF0, 0x03, 0xE0, 0x3C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0,
  0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF0, 0x01, 0xF0,
  0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x07, 0xF0, 0x1E, 0x07,
  0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x00, 0x78, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x3C,
  0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xE0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x7C,
  0x07, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0,
  0x03, 0xE0, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF,
  0xBF, 0x80, 0x7E, 0x00, 0xE0, 0x3F, 0x00, 0x08, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x08,
  0x00, 0x1F, 0x83, 0xC0, 0x1F, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03,
  0xC0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x03, 0xE0,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1E, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x78, 0x1F, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8,
  0x1F, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x01,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x34, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9,
  0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC3, 0xC0, 0x01, 0xF0, 0x78, 0x00,
  0x3E, 0x0F, 0x00, 0x0F, 0x81, 0xE0, 0x01, 0xF0, 0x3C, 0x00, 0x7C, 0x07,
  0x80, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F,
  0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x78, 0x01, 0xF0, 0x1F, 0x00, 0x3E,
  0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x07, 0xC0,
  0x01, 0xE0, 0xF8, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0x87, 0xC0, 0x00, 0xF1,
  0xF0, 0x00, 0x1E, 0x3E, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x79, 0xF0, 0x00,
  0x0F, 0x3C, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xEF, 0x00, 0x07, 0xE0, 0x00, 0xF9, 0xE0, 0x00, 0xFC, 0x00, 0x3E, 0x3C,
  0x00, 0x1F, 0x80, 0x07, 0xC7, 0x80, 0x07, 0xF0, 0x00, 0xF8, 0xF0, 0x00,
  0xFE, 0x00, 0x3E, 0x1E, 0x00, 0x3F, 0xC0, 0x07, 0xC3, 0xC0, 0x07, 0xF8,
  0x01, 0xF0, 0x78, 0x01, 0xEF, 0x00, 0x3E, 0x0F, 0x00, 0x3D, 0xE0, 0x07,
  0x81, 0xE0, 0x0F, 0xBC, 0x01, 0xF0, 0x3C, 0x01, 0xE7, 0x80, 0x3E, 0x07,
  0x80, 0x3C, 0xF0, 0x0F, 0x80, 0xF0, 0x0F, 0x1E, 0x01, 0xF0, 0x1E, 0x01,
  0xE3, 0xC0, 0x7C, 0x03, 0xC0, 0x7C, 0x78, 0x0F, 0x80, 0x78, 0x0F, 0x0F,
  0x01, 0xE0, 0x0F, 0x03, 0xE1, 0xE0, 0x7C, 0x01, 0xE0, 0x78, 0x3C, 0x0F,
  0x80, 0x3C, 0x0F, 0x07, 0x83, 0xE0, 0x07, 0x83, 0xC0, 0xF0, 0x7C, 0x00,
  0xF0, 0x78, 0x1E, 0x0F, 0x00, 0x1E, 0x1E, 0x03, 0xC3, 0xE0, 0x03, 0xC3,
  0xC0, 0x78, 0x78, 0x00, 0x78, 0xF8, 0x0F, 0x1F, 0x00, 0x0F, 0x1E, 0x01,
  0xE3, 0xC0, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x00, 0x3C, 0xF0, 0x07, 0x9F,
  0x00, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x00, 0xF7, 0x80, 0x1E, 0xF8, 0x00,
  0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x1E, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0xF0,
  0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F,
  0x03, 0xE0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00,
  0xF1, 0xF0, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3E, 0xF0, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x3E, 0x3E, 0x00,
  0x00, 0x1F, 0x1F, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0x3C,
  0x00, 0x07, 0xC0, 0x1F, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0xF8, 0x03, 0xE0, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xBE, 0x00, 0x0F, 0x8F, 0x00, 0x0F, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x07,
  0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x3C, 0x03, 0xE0, 0x1E, 0x01,
  0xF0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x01, 0xE0, 0xF8, 0x00, 0xF0,
  0xF8, 0x00, 0x78, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3C, 0x00, 0x07,
  0xBE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x20, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x7C, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xBC, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x01,
  0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x3E, 0x00, 0x78, 0x0F, 0x00,
  0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x3E, 0x00, 0xF0, 0x1E, 0x00, 0x3C,
  0x1F, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xC7, 0x80, 0x01,
  0xE7, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFC, 0xF8, 0x3E, 0x1F, 0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x0E,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x40, 0x1F, 0xF0, 0xE0, 0x1F, 0xFE, 0x78,
  0x0F, 0xFF, 0xDE, 0x07, 0xF0, 0xF7, 0x81, 0xF0, 0x0F, 0xE0, 0xF8, 0x03,
  0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xC3, 0xE0,
  0x01, 0xF0, 0xF8, 0x00, 0x78, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87,
  0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0x3C, 0x3E, 0x00, 0x1F,
  0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0xF8, 0x3E, 0x00,
  0x7E, 0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x0F, 0xE0, 0x7C, 0x07, 0xF8, 0x1F,
  0x03, 0xFC, 0x07, 0xF3, 0xEF, 0x00, 0xFF, 0xF3, 0xC0, 0x3F, 0xF8, 0xF0,
  0x03, 0xF8, 0x3C, 0x00, 0x10, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x0F, 0x80,
  0x1F, 0x1F, 0xF0, 0x0F, 0x3F, 0xFC, 0x07, 0xBF, 0xFE, 0x07, 0xFE, 0x1F,
  0x83, 0xFC, 0x07, 0xC1, 0xFC, 0x03, 0xE0, 0xFC, 0x00, 0xF0, 0xFE, 0x00,
  0x78, 0x7E, 0x00, 0x3C, 0x3F, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x0F, 0x80,
  0x07, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xE0,
  0x00, 0xF8, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E,
  0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0x87,
  0xF0, 0x0F, 0x83, 0xF8, 0x0F, 0xC1, 0xEF, 0xBF, 0xC1, 0xF7, 0xFF, 0xC0,
  0xF1, 0xFF, 0xC0, 0x78, 0x7F, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x03, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x08, 0x0F, 0xE7, 0xC0, 0x7F, 0xFE, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0xFC, 0x78, 0x01, 0xFF, 0xE7,
  0x80, 0x3F, 0xFF, 0x78, 0x07, 0xF0, 0xFF, 0x80, 0x7C, 0x03, 0xF8, 0x0F,
  0x80, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x01,
  0xF0, 0x3E, 0x00, 0x1E, 0x03, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x3E, 0x07,
  0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xC0, 0xF8, 0x00,
  0x7C, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0xC0,
  0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x80, 0xF8, 0x01, 0xF8, 0x0F, 0x80,
  0x3F, 0x80, 0xF8, 0x07, 0xF8, 0x07, 0xC0, 0xFF, 0x00, 0x7F, 0x3E, 0xF0,
  0x03, 0xFF, 0xCF, 0x00, 0x3F, 0xF8, 0xF0, 0x00, 0xFE, 0x0E, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFE, 0x07, 0xE0, 0xF8, 0x3F, 0x01, 0xF0, 0xF8, 0x07, 0xC7, 0xC0,
  0x1F, 0x1F, 0x00, 0x7C, 0xF8, 0x01, 0xE3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C,
  0x7C, 0x0F, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF,
  0xF0, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x03, 0x03, 0xF8, 0x7C, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x10, 0x03, 0xFF,
  0x0E, 0x00, 0x7F, 0xF9, 0xE0, 0x0F, 0xFF, 0xDE, 0x01, 0xFC, 0x3D, 0xE0,
  0x1F, 0x00, 0xFE, 0x03, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xC0,
  0x07, 0xC0, 0xFC, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0xF8,
  0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F,
  0x03, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xE0, 0x3E,
  0x00, 0x7E, 0x03, 0xE0, 0x0F, 0xE0, 0x3E, 0x01, 0xFE, 0x01, 0xF0, 0x3F,
  0xC0, 0x1F, 0xCF, 0xBC, 0x00, 0xFF, 0xF7, 0xC0, 0x0F, 0xFE, 0x7C, 0x00,
  0x3F, 0x87, 0xC0, 0x00, 0x40, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x08, 0x00, 0x7E, 0x00, 0xF0, 0x0F, 0xC0, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x3F, 0xF0, 0x0F, 0x3F, 0xFC,
  0x07, 0xBF, 0xFE, 0x07, 0xFE, 0x1F, 0x83, 0xFC, 0x07, 0xC1, 0xFC, 0x03,
  0xE0, 0xFC, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x7E, 0x00, 0x7C, 0x3E, 0x00,
  0x3E, 0x1F, 0x00, 0x1E, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0,
  0x07, 0xC3, 0xE0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x01, 0xF0, 0xF8,
  0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F,
  0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xC1,
  0xE0, 0x01, 0xE0, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x0F, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x3C, 0x01, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0xFC, 0x0F, 0x00,
  0xFC, 0x07, 0x80, 0xFC, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x7C, 0x01, 0xF0,
  0x7C, 0x00, 0xF0, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x0F, 0x7E, 0x00, 0x0F, 0xBE, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFD, 0xE0, 0x00, 0xFC, 0xF8, 0x00,
  0xFC, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1E, 0x07, 0xC0,
  0x0F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F,
  0x01, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x7C, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0x8F, 0xF8, 0x1F, 0xF8, 0x0F, 0x3F, 0xF8,
  0x7F, 0xF0, 0x1E, 0xFF, 0xF9, 0xFF, 0xF0, 0x7F, 0xC3, 0xF7, 0x87, 0xE0,
  0xFF, 0x03, 0xFE, 0x07, 0xC1, 0xFC, 0x03, 0xF8, 0x07, 0x83, 0xF0, 0x07,
  0xE0, 0x0F, 0x0F, 0xC0, 0x0F, 0x80, 0x1E, 0x1F, 0x80, 0x3F, 0x00, 0x7C,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0xF0, 0x01,
  0xF0, 0x03, 0xC3, 0xE0, 0x03, 0xC0, 0x07, 0x87, 0xC0, 0x0F, 0x80, 0x1F,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0xF8, 0x00, 0xF0, 0x01, 0xE1, 0xF0, 0x03, 0xE0, 0x07,
  0xC3, 0xE0, 0x07, 0xC0, 0x0F, 0x87, 0x80, 0x0F, 0x80, 0x1F, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0xF8, 0x01, 0xF0, 0x03, 0xE1, 0xE0, 0x03, 0xC0, 0x07, 0xC7, 0xC0,
  0x07, 0x80, 0x0F, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x03, 0xC1, 0xFC, 0x01, 0xE3, 0xFF, 0x00, 0xF3, 0xFF, 0xC0,
  0xFB, 0xFF, 0xF0, 0x7F, 0xE1, 0xF8, 0x3F, 0xC0, 0x7C, 0x1F, 0xC0, 0x3E,
  0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x0F, 0x87, 0xE0, 0x07, 0xC3, 0xE0, 0x03,
  0xE1, 0xF0, 0x01, 0xE0, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00,
  0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80,
  0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x03, 0xE1, 0xF0,
  0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3C, 0x1E,
  0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x07, 0xF0, 0xFC, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x1E,
  0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3C, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x3E,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x7C,
  0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x78, 0x01, 0xF0,
  0x7C, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x3F, 0xDF, 0xC0, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x07, 0x87, 0xFC, 0x00, 0x79, 0xFF, 0xE0, 0x07, 0xBF, 0xFE, 0x00,
  0xFF, 0xC3, 0xF0, 0x0F, 0x70, 0x1F, 0x00, 0xFE, 0x01, 0xF0, 0x0F, 0xC0,
  0x0F, 0x00, 0xFC, 0x00, 0xF0, 0x1F, 0x80, 0x0F, 0x01, 0xF8, 0x00, 0xF0,
  0x1F, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0,
  0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xC0, 0x01, 0xF0, 0x3C, 0x00, 0x1E,
  0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0x7C,
  0x00, 0x7C, 0x07, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xF8, 0x0F, 0xE0, 0x1F,
  0x00, 0xFE, 0x03, 0xF0, 0x0F, 0x7D, 0xFE, 0x00, 0xF7, 0xFF, 0xC0, 0x1F,
  0x3F, 0xF8, 0x01, 0xF1, 0xFE, 0x00, 0x1F, 0x02, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x40, 0x1F, 0xF0, 0xE0, 0x1F,
  0xFE, 0x78, 0x0F, 0xFF, 0xDE, 0x07, 0xF0, 0xF7, 0x81, 0xF0, 0x0F, 0xE0,
  0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x07,
  0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00,
  0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0x7C, 0x3E,
  0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0xF8,
  0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x0F, 0xE0, 0xF8, 0x07,
  0xF8, 0x1F, 0x03, 0xFC, 0x07, 0xF3, 0xEF, 0x00, 0xFF, 0xF7, 0xC0, 0x3F,
  0xF9, 0xF0, 0x03, 0xF8, 0x7C, 0x00, 0x10, 0x1E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x3C, 0x7F, 0x03, 0xCF, 0xF0, 0x3D, 0xFF, 0x07, 0xFF,
  0x20, 0x7B, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFC, 0x07, 0x07, 0xC0, 0x08, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x80, 0x0F, 0x86, 0x00, 0xFC, 0x3F,
  0x1F, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x04, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x0F, 0xC0, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7E, 0x60, 0x7F, 0xE0, 0x7F, 0xE0, 0x1F,
  0xE0, 0x03, 0x00, 0x07, 0xC0, 0x07, 0x83, 0xC0, 0x07, 0xC3, 0xE0, 0x03,
  0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x7C, 0x00,
  0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x07, 0x80,
  0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xE0, 0xF0,
  0x00, 0xF0, 0x78, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F,
  0x00, 0x3E, 0x0F, 0x00, 0x1F, 0x07, 0x80, 0x1F, 0x87, 0xC0, 0x0F, 0xC3,
  0xE0, 0x0F, 0xE1, 0xF0, 0x0F, 0xE0, 0x7C, 0x0E, 0xF0, 0x3F, 0xBF, 0x78,
  0x1F, 0xFF, 0x3C, 0x07, 0xFF, 0x1C, 0x01, 0xFE, 0x1E, 0x00, 0x10, 0x00,
  0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xE7, 0xC0, 0x07,
  0xCF, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0,
  0x78, 0x07, 0xC0, 0xF0, 0x0F, 0x81, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07,
  0x81, 0xF0, 0x0F, 0x03, 0xE0, 0x1E, 0x07, 0x80, 0x3C, 0x1F, 0x00, 0x7C,
  0x3C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xCF,
  0x00, 0x07, 0xBE, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x0F,
  0xC0, 0x1F, 0x7C, 0x03, 0xF8, 0x03, 0xEF, 0x80, 0x7F, 0x00, 0x79, 0xF0,
  0x0E, 0xE0, 0x1F, 0x3E, 0x03, 0xDC, 0x03, 0xC7, 0xC0, 0x7B, 0x80, 0xF8,
  0xF8, 0x1E, 0x70, 0x1E, 0x1F, 0x03, 0xCE, 0x07, 0xC3, 0xE0, 0xF1, 0xC0,
  0xF8, 0x7C, 0x1E, 0x3C, 0x1E, 0x0F, 0x87, 0x87, 0x87, 0xC0, 0xF0, 0xF0,
  0xF0, 0xF0, 0x1E, 0x1E, 0x1E, 0x3E, 0x03, 0xC7, 0x83, 0xC7, 0x80, 0x78,
  0xF0, 0x79, 0xF0, 0x0F, 0x3C, 0x0F, 0x3E, 0x01, 0xE7, 0x81, 0xE7, 0x80,
  0x3D, 0xE0, 0x3D, 0xF0, 0x07, 0xBC, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0xF7,
  0x80, 0x1F, 0xE0, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x07, 0xE0,
  0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x78, 0x0F, 0x80, 0x0F, 0x81,
  0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x1E, 0x1F, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x7C, 0xF8, 0x00, 0x07, 0xBE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xF9, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0,
  0x78, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x00, 0xF0, 0x07, 0xE0, 0x1F, 0x00,
  0xF8, 0x03, 0xE0, 0x3E, 0x00, 0x3C, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x7E, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0xF0, 0x0F,
  0x80, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E, 0x1F, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x01, 0xE7, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0xBE, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x0C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFC, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0x3F, 0xF0, 0x01, 0x7F, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFE, 0x80, 0x03, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_Italic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 14, 40, 14, 1, -39 },
  { 71, 16, 14, 20, 6, -39 },
  { 99, 31, 39, 31, 1, -39 },
  { 251, 26, 45, 27, 1, -42 },
  { 398, 34, 41, 40, 4, -40 },
  { 573, 30, 41, 32, 1, -40 },
  { 727, 7, 14, 11, 6, -39 },
  { 740, 17, 48, 15, 2, -39 },
  { 842, 17, 48, 15, -4, -39 },
  { 944, 22, 23, 26, 6, -42 },
  { 1008, 24, 27, 29, 3, -33 },
  { 1089, 10, 13, 13, -2, -6 },
  { 1106, 14, 4, 16, 1, -17 },
  { 1113, 6, 8, 13, 1, -7 },
  { 1119, 27, 39, 19, -3, -39 },
  { 1251, 24, 41, 27, 2, -40 },
  { 1374, 16, 39, 27, 7, -39 },
  { 1452, 27, 40, 27, -1, -40 },
  { 1587, 26, 41, 27, 0, -40 },
  { 1721, 26, 39, 27, 0, -39 },
  { 1848, 26, 40, 27, 1, -39 },
  { 1978, 24, 41, 27, 3, -40 },
  { 2101, 25, 39, 27, 3, -39 },
  { 2223, 26, 41, 27, 1, -40 },
  { 2357, 24, 41, 27, 2, -40 },
  { 2480, 11, 31, 13, 1, -30 },
  { 2523, 15, 37, 13, -3, -30 },
  { 2593, 24, 26, 29, 3, -33 },
  { 2671, 24, 15, 29, 3, -27 },
  { 2716, 24, 26, 29, 3, -33 },
  { 2794, 20, 41, 21, 3, -40 },
  { 2897, 38, 44, 41, 2, -39 },
  { 3106, 28, 39, 28, -3, -39 },
  { 3243, 28, 39, 30, 1, -39 },
  { 3380, 28, 41, 28, 3, -40 },
  { 3524, 30, 39, 33, 1, -39 },
  { 3671, 27, 39, 25, 1, -39 },
  { 3803, 27, 39, 24, 1, -39 },
  { 3935, 31, 41, 34, 3, -40 },
  { 4094, 33, 39, 33, 1, -39 },
  { 4255, 22, 39, 17, -2, -39 },
  { 4363, 23, 50, 14, -8, -39 },
  { 4507, 32, 39, 28, 1, -39 },
  { 4663, 19, 39, 23, 1, -39 },
  { 4756, 42, 39, 42, 1, -39 },
  { 4961, 35, 39, 35, 1, -39 },
  { 5132, 31, 41, 35, 3, -40 },
  { 5291, 27, 39, 28, 1, -39 },
  { 5423, 31, 49, 35, 3, -40 },
  { 5613, 27, 39, 28, 1, -39 },
  { 5745, 26, 41, 25, 0, -40 },
  { 5879, 24, 39, 24, 5, -39 },
  { 5996, 31, 40, 33, 3, -39 },
  { 6151, 27, 39, 27, 5, -39 },
  { 6283, 43, 39, 43, 5, -39 },
  { 6493, 33, 39, 26, -3, -39 },
  { 6654, 25, 39, 25, 5, -39 },
  { 6776, 29, 39, 25, -1, -39 },
  { 6918, 21, 48, 16, -1, -39 },
  { 7044, 10, 39, 19, 6, -39 },
  { 7093, 21, 48, 16, -4, -39 },
  { 7219, 25, 23, 28, 2, -39 },
  { 7291, 21, 3, 20, -5, 5 },
  { 7299, 9, 9, 15, 8, -42 },
  { 7310, 26, 31, 28, 2, -30 },
  { 7411, 25, 43, 29, 1, -42 },
  { 7546, 21, 31, 22, 2, -30 },
  { 7628, 28, 43, 29, 2, -42 },
  { 7779, 22, 31, 25, 2, -30 },
  { 7865, 28, 55, 16, -6, -42 },
  { 8058, 28, 43, 29, 0, -30 },
  { 8209, 25, 42, 28, 1, -42 },
  { 8341, 13, 40, 13, 1, -40 },
  { 8406, 21, 53, 13, -7, -40 },
  { 8546, 25, 42, 25, 1, -42 },
  { 8678, 13, 42, 13, 1, -42 },
  { 8747, 39, 30, 43, 1, -30 },
  { 8894, 25, 30, 28, 1, -30 },
  { 8988, 24, 31, 28, 2, -30 },
  { 9081, 28, 43, 29, -2, -30 },
  { 9232, 26, 43, 29, 2, -30 },
  { 9372, 20, 30, 19, 1, -30 },
  { 9447, 21, 31, 21, 0, -30 },
  { 9529, 16, 37, 16, 2, -36 },
  { 9603, 25, 30, 28, 2, -29 },
  { 9697, 23, 29, 23, 3, -29 },
  { 9781, 35, 29, 36, 3, -29 },
  { 9908, 27, 29, 24, -2, -29 },
  { 10006, 31, 42, 23, -5, -29 },
  { 10169, 23, 29, 21, -1, -29 },
  { 10253, 21, 48, 19, 1, -39 },
  { 10379, 4, 55, 27, 12, -42 },
  { 10407, 20, 48, 19, -2, -39 },
  { 10527, 24, 7, 29, 3, -23 },
};

const GFXfont NotoSans_SemiCondensed_Italic55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic55pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC55PT7B_H_
