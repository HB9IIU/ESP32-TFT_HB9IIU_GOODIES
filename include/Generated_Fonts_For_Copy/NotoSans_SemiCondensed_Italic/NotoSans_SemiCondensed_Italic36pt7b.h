#ifndef _NOTOSANS_SEMICONDENSED_ITALIC36PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0x81, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x1E, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0xC1, 0xE0, 0xF0, 0x70, 0x00, 0x71, 0xDC, 0x77, 0x1D, 0xC7,
  0x63, 0xB8, 0xEE, 0x3B, 0x0C, 0xC3, 0x30, 0xC0, 0x00, 0x60, 0xC0, 0x0E,
  0x1C, 0x00, 0xE1, 0x80, 0x0C, 0x18, 0x00, 0xC1, 0x80, 0x1C, 0x38, 0x01,
  0x83, 0x00, 0x18, 0x30, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x03, 0x06, 0x00,
  0x30, 0xE0, 0x07, 0x0E, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0xE1, 0xC0,
  0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x1C, 0x38, 0x01, 0xC3, 0x00, 0x18, 0x30,
  0x01, 0x87, 0x00, 0x38, 0x70, 0x03, 0x06, 0x00, 0x30, 0xE0, 0x07, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x01, 0xFE, 0x07, 0xFF, 0x0F,
  0x6F, 0x1E, 0x61, 0x1C, 0x60, 0x1C, 0xC0, 0x1C, 0xC0, 0x1C, 0xC0, 0x1E,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xBC, 0x01,
  0x9C, 0x03, 0x1C, 0x03, 0x1C, 0x03, 0x1C, 0x83, 0x38, 0xF7, 0xF8, 0xFF,
  0xF0, 0x7F, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x07,
  0x80, 0x18, 0x3F, 0x80, 0x70, 0x73, 0x01, 0xC1, 0xC7, 0x03, 0x03, 0x0E,
  0x0E, 0x0E, 0x1C, 0x38, 0x1C, 0x38, 0x60, 0x30, 0x61, 0xC0, 0x60, 0xC7,
  0x00, 0xC1, 0x8C, 0x03, 0x87, 0x39, 0xC7, 0x0C, 0xE7, 0xE6, 0x39, 0x9F,
  0xCE, 0xE7, 0x71, 0xDF, 0x9C, 0xC3, 0x9E, 0x33, 0x87, 0x00, 0xE7, 0x0E,
  0x03, 0x8C, 0x1C, 0x06, 0x18, 0x30, 0x1C, 0x30, 0x60, 0x70, 0x61, 0xC0,
  0xC0, 0xC3, 0x83, 0x81, 0x86, 0x0E, 0x03, 0x1C, 0x18, 0x07, 0xF0, 0x70,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0x78, 0x03, 0x83, 0x80,
  0x70, 0x70, 0x0E, 0x0E, 0x01, 0x83, 0x80, 0x38, 0x70, 0x07, 0x1C, 0x00,
  0xE7, 0x80, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x0F,
  0x38, 0x3B, 0xC7, 0x0F, 0x70, 0x71, 0xDC, 0x0F, 0x73, 0x80, 0xEE, 0x70,
  0x1F, 0x8E, 0x01, 0xE1, 0xC0, 0x3C, 0x38, 0x0F, 0xC7, 0xC7, 0xB8, 0x7F,
  0xE7, 0x87, 0xF0, 0x78, 0x7B, 0x9C, 0xE6, 0x73, 0x98, 0xC6, 0x00, 0x00,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C,
  0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0x80, 0x01,
  0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07,
  0x00, 0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0x38, 0x30, 0xE0, 0xF3, 0x03, 0xFC, 0x11, 0xFF, 0xC1,
  0xFF, 0x0F, 0x80, 0x76, 0x03, 0x9C, 0x1C, 0x70, 0x60, 0xE0, 0x83, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x0E, 0x3C,
  0x70, 0xE3, 0x87, 0x1C, 0x30, 0xE0, 0xFF, 0xFF, 0xBF, 0xC0, 0xFF, 0xFE,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xF8,
  0x3F, 0xF0, 0x70, 0xF1, 0xC0, 0xE7, 0x81, 0xCE, 0x03, 0x9C, 0x07, 0x70,
  0x0E, 0xE0, 0x1D, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07,
  0xF0, 0x0E, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0xE7, 0x01, 0xCE, 0x07, 0x9C,
  0x0E, 0x38, 0x38, 0x7C, 0xF0, 0x7F, 0xC0, 0x7E, 0x00, 0x01, 0xC1, 0xF0,
  0xF8, 0x7E, 0x7F, 0xBC, 0xEE, 0x71, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x1C, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x83, 0xFF,
  0xC0, 0xE0, 0xF0, 0x40, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F,
  0xFE, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0xC0, 0xC0, 0xF0, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x07, 0x80, 0x7F, 0x80, 0x3F, 0x00, 0x3F, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xE2, 0x00, 0xF1, 0xF1, 0xF0, 0xFF, 0xF0, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xB0, 0x01, 0xF8, 0x01,
  0xDC, 0x01, 0xCE, 0x01, 0xC6, 0x00, 0xE7, 0x00, 0xE3, 0x80, 0xE1, 0xC0,
  0xE0, 0xE0, 0x70, 0xE0, 0x70, 0x70, 0x70, 0x38, 0x70, 0x1C, 0x70, 0x0E,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0x81, 0xFF,
  0xC0, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0x80, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xE2, 0x01, 0xE1, 0xC3, 0xE0, 0xFF, 0xE0, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x73, 0xF0,
  0x77, 0xF8, 0x7E, 0x78, 0xF8, 0x3C, 0xF0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C,
  0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0x38, 0xF0, 0x70,
  0x79, 0xF0, 0x7F, 0xE0, 0x1F, 0x80, 0x3F, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF,
  0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0xF7, 0xC1, 0xE0, 0xE0, 0xE0,
  0x78, 0x70, 0x1C, 0x38, 0x0E, 0x1C, 0x0E, 0x0E, 0x07, 0x07, 0x07, 0x01,
  0xCF, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x7F, 0x80, 0x79, 0xE0, 0x70, 0x78,
  0x70, 0x1C, 0x78, 0x0E, 0x38, 0x07, 0x9C, 0x03, 0xCE, 0x01, 0xC7, 0x00,
  0xE3, 0xC0, 0xF0, 0xF0, 0xF0, 0x7F, 0xF0, 0x0F, 0xF0, 0x00, 0x01, 0xF8,
  0x07, 0xFC, 0x0F, 0xFE, 0x0E, 0x0E, 0x1C, 0x07, 0x1C, 0x07, 0x38, 0x07,
  0x38, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x0F, 0x38, 0x0F, 0x38, 0x1F,
  0x3C, 0x3E, 0x1F, 0xEE, 0x0F, 0xCE, 0x03, 0x1E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0xC3, 0xE0, 0xFF, 0x80,
  0xFF, 0x00, 0x04, 0x0F, 0x0F, 0x1E, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x78, 0xF8, 0x70, 0x00, 0x80,
  0xF0, 0x3C, 0x0F, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x38,
  0x0C, 0x07, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x0F, 0xC3,
  0xFF, 0x8F, 0xFC, 0x40, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x03, 0x00,
  0x38, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xF0, 0x01,
  0xFD, 0xF8, 0x03, 0xC0, 0x1C, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x06, 0x1C,
  0x00, 0x07, 0x18, 0x0F, 0x03, 0x38, 0x3F, 0xC3, 0x70, 0x79, 0xC3, 0x70,
  0xE1, 0xC3, 0x61, 0xC1, 0x83, 0xE1, 0x81, 0x83, 0xE3, 0x83, 0x83, 0xC3,
  0x83, 0x87, 0xC3, 0x03, 0x06, 0xC3, 0x07, 0x06, 0xC3, 0x07, 0x0E, 0xC3,
  0x0F, 0x0C, 0xC3, 0x9B, 0x1C, 0xC3, 0xFB, 0xF8, 0xC1, 0xF1, 0xE0, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3E,
  0x03, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1B, 0x00, 0x0E, 0xE0, 0x03, 0x38,
  0x01, 0xCE, 0x00, 0x63, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x07, 0x0E, 0x01,
  0xC3, 0x80, 0xE0, 0xE0, 0x38, 0x38, 0x1F, 0xFE, 0x07, 0xFF, 0x83, 0xFF,
  0xE0, 0xE0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x1D,
  0xC0, 0x07, 0x70, 0x01, 0xF8, 0x00, 0x70, 0x07, 0xFC, 0x01, 0xFF, 0xC0,
  0x7F, 0xF8, 0x1C, 0x0F, 0x0F, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x38,
  0x07, 0x0E, 0x03, 0xC7, 0x80, 0xE1, 0xC0, 0x78, 0x7F, 0xF8, 0x1F, 0xF8,
  0x07, 0xFF, 0x03, 0x80, 0xE0, 0xE0, 0x1C, 0x38, 0x07, 0x0E, 0x01, 0xC3,
  0x80, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x03, 0xC7, 0x01, 0xE3, 0xFF,
  0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x3F,
  0xFC, 0x1F, 0x02, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xFC, 0xE0,
  0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFE,
  0x03, 0x83, 0xE0, 0xF0, 0x1C, 0x1C, 0x03, 0xC3, 0x80, 0x38, 0x70, 0x07,
  0x0E, 0x00, 0xE3, 0xC0, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0E,
  0x38, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x0F, 0x38, 0x01, 0xC7, 0x00, 0x78,
  0xE0, 0x0E, 0x38, 0x03, 0xC7, 0x00, 0xF0, 0xE0, 0x3E, 0x1C, 0x0F, 0x87,
  0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xE0, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0xE0, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xFF, 0xE0, 0xFF, 0xF0,
  0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7C, 0x06, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x1F, 0xCF, 0x01, 0xFC, 0xF0, 0x3F,
  0xCE, 0x00, 0x1C, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0x8F, 0x00,
  0x38, 0x70, 0x03, 0x87, 0x80, 0x70, 0x78, 0x07, 0x03, 0xF1, 0xF0, 0x1F,
  0xFF, 0x00, 0xFF, 0xC0, 0x07, 0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x0E,
  0x0E, 0x00, 0xF0, 0x70, 0x07, 0x07, 0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0,
  0x0E, 0x0E, 0x00, 0xF0, 0xF0, 0x07, 0x07, 0x00, 0x38, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x38, 0x01,
  0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x38,
  0x01, 0xC1, 0xC0, 0x1E, 0x1E, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38,
  0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x7F,
  0x00, 0x7E, 0x00, 0xF8, 0x00, 0x07, 0x00, 0xF0, 0x70, 0x0E, 0x07, 0x01,
  0xC0, 0x70, 0x3C, 0x0F, 0x07, 0x80, 0xE0, 0xF0, 0x0E, 0x1E, 0x00, 0xE3,
  0xC0, 0x0E, 0x78, 0x01, 0xE7, 0x00, 0x1C, 0xE0, 0x01, 0xDE, 0x00, 0x1F,
  0xC0, 0x01, 0xFE, 0x00, 0x3E, 0xE0, 0x03, 0xCF, 0x00, 0x38, 0x70, 0x03,
  0x87, 0x00, 0x38, 0x78, 0x07, 0x03, 0x80, 0x70, 0x38, 0x07, 0x03, 0xC0,
  0x70, 0x1C, 0x0F, 0x01, 0xC0, 0xE0, 0x1E, 0x0E, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01,
  0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x83,
  0xE0, 0x03, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xB0, 0x07,
  0x70, 0x76, 0x00, 0xEE, 0x0E, 0xC0, 0x3B, 0x83, 0x9C, 0x07, 0x70, 0x73,
  0x81, 0xCE, 0x0E, 0x70, 0x39, 0xC1, 0xCE, 0x0E, 0x78, 0x31, 0xC1, 0xCE,
  0x0E, 0x38, 0x71, 0xC1, 0xC7, 0x0C, 0x38, 0x38, 0xE3, 0x87, 0x07, 0x0C,
  0x61, 0xC1, 0xC1, 0x9C, 0x38, 0x38, 0x33, 0x07, 0x07, 0x06, 0xE0, 0xE0,
  0xE0, 0xF8, 0x1C, 0x1C, 0x1F, 0x07, 0x07, 0x03, 0xC0, 0xE0, 0xE0, 0x78,
  0x1C, 0x1C, 0x0E, 0x03, 0x80, 0x07, 0x80, 0x1C, 0x1E, 0x00, 0x70, 0x78,
  0x01, 0xC1, 0xF0, 0x07, 0x0F, 0xC0, 0x38, 0x3F, 0x00, 0xE0, 0xEE, 0x03,
  0x83, 0xB8, 0x0E, 0x0C, 0xE0, 0x38, 0x71, 0x81, 0xC1, 0xC7, 0x07, 0x07,
  0x1C, 0x1C, 0x1C, 0x70, 0x70, 0x60, 0xE1, 0xC3, 0x83, 0x8E, 0x0E, 0x0E,
  0x38, 0x38, 0x1C, 0xE0, 0xE0, 0x73, 0x87, 0x01, 0xCC, 0x1C, 0x03, 0x70,
  0x70, 0x0F, 0xC1, 0xC0, 0x3F, 0x07, 0x00, 0xFC, 0x38, 0x01, 0xE0, 0xE0,
  0x07, 0x83, 0x80, 0x1E, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0xC0, 0x78, 0x1E, 0x0F, 0x00, 0xE1, 0xE0, 0x0F, 0x1C, 0x00, 0x73, 0xC0,
  0x07, 0x38, 0x00, 0x77, 0x80, 0x07, 0x70, 0x00, 0x77, 0x00, 0x07, 0x70,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE,
  0x00, 0x1E, 0xE0, 0x01, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0x87, 0x00, 0x78,
  0x78, 0x0F, 0x03, 0xF7, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1C, 0x1E, 0x0F, 0x03, 0x83, 0x80, 0xE0,
  0xE0, 0x3C, 0x38, 0x0E, 0x0E, 0x03, 0x87, 0x80, 0xE1, 0xC0, 0x78, 0x70,
  0x1C, 0x1C, 0x1F, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x78, 0x1E, 0x0F, 0x00, 0xE1, 0xE0, 0x0F,
  0x1C, 0x00, 0x73, 0xC0, 0x07, 0x38, 0x00, 0x77, 0x80, 0x07, 0x70, 0x00,
  0x77, 0x00, 0x07, 0x70, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xEE, 0x00,
  0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x1E, 0xE0, 0x01, 0xCF, 0x00, 0x3C, 0xF0,
  0x03, 0x87, 0x00, 0x78, 0x78, 0x0F, 0x03, 0xF7, 0xE0, 0x1F, 0xFC, 0x00,
  0xFF, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x07, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xF0,
  0x1C, 0x1E, 0x0F, 0x03, 0x83, 0x80, 0xE0, 0xE0, 0x3C, 0x38, 0x0F, 0x0E,
  0x03, 0x87, 0x80, 0xE1, 0xC0, 0x78, 0x70, 0x3C, 0x1C, 0x7E, 0x07, 0xFF,
  0x03, 0xFF, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x03, 0x83, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0x07, 0x01, 0xC3, 0xC0, 0x70, 0xE0,
  0x1E, 0x38, 0x03, 0x80, 0x00, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xF0,
  0x20, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xE2, 0x01, 0xF1, 0xF7, 0xF0, 0xFF, 0xF0, 0x3F, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x71,
  0xE0, 0x0F, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x0E,
  0x38, 0x01, 0xE3, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x78, 0x01,
  0xC7, 0x00, 0x38, 0x70, 0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x8F, 0x00,
  0x78, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x0F, 0x0F, 0x00, 0xE0, 0x70,
  0x1E, 0x07, 0xEF, 0xC0, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0xE0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x3B, 0xC0, 0x1E, 0x70, 0x07, 0x1C, 0x03, 0xC7, 0x00,
  0xE1, 0xC0, 0x78, 0x70, 0x1C, 0x1C, 0x0F, 0x07, 0x03, 0x81, 0xC1, 0xE0,
  0x70, 0x70, 0x1C, 0x3C, 0x07, 0x0E, 0x01, 0xC7, 0x80, 0x71, 0xC0, 0x1C,
  0x70, 0x03, 0x38, 0x00, 0xCE, 0x00, 0x37, 0x00, 0x0D, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0xFC,
  0x03, 0xC0, 0x3F, 0x80, 0x78, 0x07, 0x70, 0x1F, 0x00, 0xEE, 0x03, 0xE0,
  0x39, 0xC0, 0x7C, 0x07, 0x38, 0x1F, 0x81, 0xC7, 0x03, 0x70, 0x38, 0xE0,
  0xEE, 0x0F, 0x1C, 0x1D, 0xC1, 0xC3, 0x87, 0x38, 0x38, 0x70, 0xE7, 0x0E,
  0x0E, 0x38, 0x61, 0xC1, 0xC7, 0x0C, 0x70, 0x38, 0xC1, 0x8E, 0x07, 0x38,
  0x31, 0xC0, 0xE7, 0x06, 0x70, 0x1D, 0xC0, 0xCE, 0x03, 0xB8, 0x1B, 0x80,
  0x76, 0x03, 0x70, 0x0F, 0xC0, 0x6C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01,
  0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x3C, 0x0E, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0x70, 0x38, 0x01,
  0xC1, 0xE0, 0x07, 0x87, 0x00, 0x0E, 0x38, 0x00, 0x39, 0xE0, 0x00, 0xE7,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xDC, 0x00, 0x0E,
  0x70, 0x00, 0x78, 0xE0, 0x01, 0xC3, 0x80, 0x0E, 0x0E, 0x00, 0x70, 0x38,
  0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x07, 0x03, 0xC0, 0x1E, 0x00,
  0xE0, 0x07, 0xF8, 0x07, 0x9C, 0x03, 0x8E, 0x03, 0xC7, 0x01, 0xC3, 0x81,
  0xC1, 0xC1, 0xE0, 0x70, 0xE0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x70, 0x03,
  0x78, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x1F, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0x80, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xE3, 0x8E, 0x38, 0xE1, 0x86, 0x1C,
  0x71, 0xC7, 0x1C, 0x70, 0xC3, 0x8E, 0x38, 0xE3, 0x8E, 0x18, 0x71, 0xC7,
  0x1C, 0x70, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x30, 0x01, 0xC0, 0x07, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xC0,
  0x01, 0xC0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0x70, 0x07, 0x70, 0x06, 0x30,
  0x0E, 0x38, 0x0C, 0x18, 0x1C, 0x1C, 0x18, 0x1C, 0x38, 0x0E, 0x30, 0x0E,
  0x70, 0x07, 0x60, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF1,
  0xC7, 0x0E, 0x18, 0x70, 0x00, 0xE0, 0x01, 0xF9, 0xC1, 0xFE, 0xE1, 0xE3,
  0xF1, 0xE0, 0xF1, 0xE0, 0x78, 0xE0, 0x1C, 0x70, 0x1E, 0x70, 0x0E, 0x38,
  0x07, 0x1C, 0x03, 0x8E, 0x01, 0xCF, 0x01, 0xE7, 0x80, 0xE3, 0xC0, 0xF1,
  0xE0, 0x78, 0x70, 0x7C, 0x3C, 0xEE, 0x1F, 0xE6, 0x07, 0xE3, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x38, 0x0E, 0xFE, 0x1D, 0xFE, 0x1F, 0x8F, 0x1F, 0x07, 0x1E,
  0x07, 0x3C, 0x07, 0x3C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x07, 0x70,
  0x0F, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x1E, 0x70, 0x1C, 0xF8, 0x3C, 0xFC,
  0x78, 0xEF, 0xF0, 0xC7, 0xE0, 0x00, 0x60, 0x0F, 0xF0, 0x7F, 0xC3, 0xC2,
  0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xF1,
  0x83, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x06, 0x1C, 0x03,
  0xF3, 0x81, 0xFF, 0x70, 0x3C, 0x7C, 0x0F, 0x07, 0x83, 0xC0, 0xF0, 0x70,
  0x0E, 0x0E, 0x03, 0xC3, 0x80, 0x70, 0x70, 0x0E, 0x0E, 0x01, 0xC1, 0xC0,
  0x38, 0x78, 0x0F, 0x0F, 0x01, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0x83,
  0xE0, 0x79, 0xDC, 0x0F, 0xF3, 0x00, 0xFC, 0x60, 0x00, 0x00, 0xE0, 0x07,
  0xF0, 0x1F, 0xF0, 0x70, 0xE1, 0xC0, 0xE7, 0x81, 0x8E, 0x07, 0x3C, 0x1E,
  0x70, 0x78, 0xFF, 0xE1, 0xFF, 0x07, 0xE0, 0x0F, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xF8, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0x00,
  0x01, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x3F, 0xE0, 0x0F,
  0xF8, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x7E, 0x70, 0x7F, 0xDC, 0x1E, 0x3F,
  0x0F, 0x07, 0x87, 0x81, 0xE1, 0xC0, 0x78, 0x70, 0x1E, 0x38, 0x07, 0x0E,
  0x01, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x78, 0x0F, 0x1E, 0x03, 0x87, 0x81,
  0xE1, 0xE0, 0x78, 0x38, 0x3E, 0x0F, 0x3B, 0x83, 0xFD, 0xC0, 0x7E, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x30,
  0x3C, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x18, 0x0E, 0xFE, 0x1D, 0xFF, 0x1F, 0x8F, 0x1E, 0x07, 0x1E, 0x07, 0x3C,
  0x07, 0x3C, 0x07, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x70, 0x0E, 0x70,
  0x0E, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0,
  0x38, 0xE0, 0x38, 0x02, 0x07, 0x07, 0x07, 0x02, 0x00, 0x00, 0x00, 0x0E,
  0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70,
  0x70, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0x00, 0x08, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x03, 0xC0, 0x0E, 0x03, 0xF8, 0x0F, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x0F, 0x1C, 0x1E, 0x1C, 0x3C, 0x1C, 0x78, 0x1C, 0x70, 0x38,
  0xE0, 0x39, 0xC0, 0x3B, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x7D, 0xC0, 0x79,
  0xC0, 0x71, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0xE0, 0xF0, 0xE0, 0x70, 0xE0,
  0x70, 0xE0, 0x78, 0x07, 0x07, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70,
  0x70, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0x00, 0x30, 0x0C, 0x06, 0x7E, 0x1F,
  0x87, 0x7F, 0x9F, 0xE3, 0xF1, 0xD8, 0x71, 0xE0, 0xF8, 0x38, 0xF0, 0x78,
  0x1C, 0xF0, 0x3C, 0x0E, 0x78, 0x1C, 0x07, 0x38, 0x0E, 0x03, 0x9C, 0x07,
  0x01, 0xCE, 0x03, 0x81, 0xCE, 0x03, 0x80, 0xE7, 0x01, 0xC0, 0x73, 0x80,
  0xE0, 0x39, 0xC0, 0x70, 0x1C, 0xE0, 0x78, 0x1C, 0xE0, 0x38, 0x0E, 0x70,
  0x1C, 0x07, 0x38, 0x0E, 0x03, 0x9C, 0x07, 0x03, 0xC0, 0x00, 0x38, 0x1C,
  0xFE, 0x1D, 0xFF, 0x1F, 0x8F, 0x1F, 0x07, 0x1E, 0x07, 0x3C, 0x07, 0x3C,
  0x0F, 0x38, 0x0F, 0x38, 0x0E, 0x38, 0x0E, 0x78, 0x0E, 0x70, 0x1E, 0x70,
  0x1C, 0x70, 0x1C, 0xF0, 0x1C, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0x38, 0xE0,
  0x38, 0x00, 0x40, 0x03, 0xF8, 0x0F, 0xFC, 0x0F, 0x1E, 0x1C, 0x0E, 0x3C,
  0x07, 0x38, 0x07, 0x78, 0x07, 0x70, 0x07, 0x70, 0x07, 0x70, 0x0F, 0x70,
  0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x1C, 0x70, 0x3C, 0x70, 0x38, 0x7C,
  0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x00, 0x06, 0x00, 0xCF, 0xE0, 0x77, 0xF8,
  0x1F, 0x8F, 0x07, 0xC1, 0xC1, 0xE0, 0x70, 0xF0, 0x1C, 0x3C, 0x07, 0x0E,
  0x01, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x70, 0x07, 0x1C, 0x03, 0x87, 0x00,
  0xE1, 0xC0, 0x78, 0x70, 0x1C, 0x3E, 0x0F, 0x0F, 0xC7, 0x83, 0xBF, 0xC0,
  0xE7, 0xE0, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xC0, 0x01, 0xF9, 0xC3, 0xFE, 0xE1, 0xE3, 0xE1, 0xE0, 0xF1, 0xE0, 0x78,
  0xE0, 0x3C, 0x70, 0x1E, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x01,
  0xCF, 0x01, 0xE7, 0x80, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0x70, 0x7C, 0x3C,
  0xEE, 0x1F, 0xEE, 0x07, 0xE7, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x67, 0xC7, 0x7E, 0x3F, 0x01, 0xF0, 0x0F, 0x00, 0xF0,
  0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x3F, 0xF1, 0xFF, 0x87, 0x06, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x3C, 0x80, 0xE3, 0x8F, 0x8F, 0xFC, 0x1F, 0xE0, 0x06, 0x03, 0x00,
  0xC0, 0x70, 0x1C, 0x3F, 0xFF, 0xF8, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xC0,
  0x70, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x8F, 0xC1, 0xF0, 0x3C, 0x07, 0x38, 0x07, 0x38, 0x0E, 0x38, 0x0E, 0x38,
  0x0E, 0x70, 0x0E, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0xF0, 0x1C, 0xE0,
  0x1C, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x78, 0xE0, 0x78, 0xE0, 0xF8, 0xF3,
  0xB0, 0xFF, 0x30, 0x7E, 0x70, 0xE0, 0x1F, 0xC0, 0x3B, 0x80, 0xE7, 0x01,
  0xCE, 0x07, 0x1C, 0x0E, 0x38, 0x38, 0x70, 0x70, 0x61, 0xC0, 0xC3, 0x81,
  0xCE, 0x03, 0x9C, 0x07, 0x70, 0x0E, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xE0, 0x00, 0xE0, 0x38, 0x0F, 0xC0, 0xF0, 0x3B, 0x81,
  0xE0, 0x77, 0x07, 0xC1, 0xEE, 0x0D, 0x83, 0x9C, 0x3B, 0x07, 0x38, 0x66,
  0x1C, 0x71, 0xCC, 0x38, 0xE3, 0x98, 0xE1, 0xC6, 0x31, 0xC3, 0x9C, 0x67,
  0x07, 0x30, 0xCE, 0x0E, 0xE1, 0x9C, 0x1D, 0x83, 0x70, 0x3F, 0x06, 0xE0,
  0x7E, 0x0D, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3C, 0x03, 0xC0, 0x78, 0x00,
  0x0E, 0x03, 0xC3, 0x81, 0xC0, 0x70, 0xF0, 0x1C, 0x78, 0x03, 0x1C, 0x00,
  0xEE, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x0F, 0x70, 0x03, 0x9C, 0x01, 0xC7, 0x00, 0xE0, 0xE0,
  0x78, 0x38, 0x1C, 0x0E, 0x0E, 0x01, 0xC0, 0x07, 0x00, 0xF0, 0x70, 0x0E,
  0x07, 0x01, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0x30, 0x38, 0x03, 0x87,
  0x80, 0x38, 0x70, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0x9C, 0x00, 0x39,
  0xC0, 0x03, 0xB8, 0x00, 0x3B, 0x80, 0x03, 0xB0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x00, 0x18, 0x07, 0xC0, 0x7E, 0x03, 0x80,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0xE0, 0x07, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x60, 0x03, 0x80, 0x1F, 0x00, 0x78, 0x00, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x00, 0x0F, 0x80, 0x3F, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x7C,
  0x07, 0xE0, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x03, 0xF0, 0x0F, 0x80,
  0x30, 0x00, 0x3E, 0x01, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFE, 0x80, 0x18,
};

const GFXglyph NotoSans_SemiCondensed_Italic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 9, 26, 9, 1, -26 },
  { 31, 10, 10, 13, 4, -26 },
  { 44, 20, 26, 20, 1, -26 },
  { 109, 16, 29, 18, 1, -27 },
  { 167, 23, 26, 26, 2, -26 },
  { 242, 19, 26, 21, 1, -26 },
  { 304, 5, 10, 7, 4, -26 },
  { 311, 12, 32, 10, 1, -26 },
  { 359, 12, 32, 10, -3, -26 },
  { 407, 14, 14, 17, 4, -27 },
  { 432, 16, 17, 19, 2, -21 },
  { 466, 7, 9, 9, -2, -4 },
  { 474, 9, 3, 11, 1, -11 },
  { 478, 4, 4, 9, 1, -4 },
  { 480, 17, 26, 13, -2, -26 },
  { 536, 15, 26, 18, 2, -26 },
  { 585, 10, 26, 18, 5, -26 },
  { 618, 17, 26, 18, 0, -26 },
  { 674, 17, 26, 18, 0, -26 },
  { 730, 17, 26, 18, 0, -26 },
  { 786, 17, 26, 18, 1, -26 },
  { 842, 16, 26, 18, 2, -26 },
  { 894, 17, 26, 18, 2, -26 },
  { 950, 17, 26, 18, 1, -26 },
  { 1006, 16, 26, 18, 1, -26 },
  { 1058, 8, 20, 9, 0, -20 },
  { 1078, 10, 25, 9, -2, -20 },
  { 1110, 16, 17, 19, 2, -21 },
  { 1144, 16, 10, 19, 2, -18 },
  { 1164, 16, 17, 19, 2, -21 },
  { 1198, 13, 26, 14, 2, -26 },
  { 1241, 24, 29, 27, 2, -26 },
  { 1328, 18, 26, 18, -2, -26 },
  { 1387, 18, 26, 19, 1, -26 },
  { 1446, 18, 26, 18, 2, -26 },
  { 1505, 19, 26, 21, 1, -26 },
  { 1567, 17, 26, 17, 1, -26 },
  { 1623, 17, 26, 15, 1, -26 },
  { 1679, 20, 26, 22, 2, -26 },
  { 1744, 21, 26, 22, 1, -26 },
  { 1813, 14, 26, 11, -1, -26 },
  { 1859, 16, 33, 9, -6, -26 },
  { 1925, 20, 26, 18, 1, -26 },
  { 1990, 12, 26, 15, 1, -26 },
  { 2029, 27, 26, 28, 1, -26 },
  { 2117, 22, 26, 23, 1, -26 },
  { 2189, 20, 26, 23, 2, -26 },
  { 2254, 18, 26, 18, 1, -26 },
  { 2313, 20, 32, 23, 2, -26 },
  { 2393, 18, 26, 19, 1, -26 },
  { 2452, 17, 26, 16, 0, -26 },
  { 2508, 16, 26, 16, 3, -26 },
  { 2560, 20, 26, 22, 2, -26 },
  { 2625, 18, 26, 18, 3, -26 },
  { 2684, 27, 26, 28, 4, -26 },
  { 2772, 22, 26, 17, -2, -26 },
  { 2844, 17, 26, 16, 3, -26 },
  { 2900, 19, 26, 17, -1, -26 },
  { 2962, 14, 32, 10, -1, -26 },
  { 3018, 6, 26, 13, 4, -26 },
  { 3038, 14, 32, 10, -3, -26 },
  { 3094, 16, 16, 18, 1, -26 },
  { 3126, 13, 3, 13, -3, 3 },
  { 3131, 6, 6, 10, 5, -28 },
  { 3136, 17, 20, 19, 1, -20 },
  { 3179, 16, 27, 19, 1, -27 },
  { 3233, 14, 20, 15, 1, -20 },
  { 3268, 19, 27, 19, 1, -27 },
  { 3333, 15, 20, 16, 1, -20 },
  { 3371, 19, 37, 10, -4, -28 },
  { 3459, 18, 29, 19, 0, -20 },
  { 3525, 16, 27, 19, 1, -27 },
  { 3579, 8, 27, 8, 1, -27 },
  { 3606, 14, 36, 8, -5, -27 },
  { 3669, 16, 27, 16, 1, -27 },
  { 3723, 8, 27, 8, 1, -27 },
  { 3750, 25, 20, 28, 1, -20 },
  { 3813, 16, 20, 19, 1, -20 },
  { 3853, 16, 20, 18, 1, -20 },
  { 3893, 18, 29, 19, -1, -20 },
  { 3959, 17, 29, 19, 1, -20 },
  { 4021, 13, 20, 13, 1, -20 },
  { 4054, 14, 20, 14, 0, -20 },
  { 4089, 10, 24, 11, 2, -24 },
  { 4119, 16, 19, 19, 2, -19 },
  { 4157, 15, 19, 15, 2, -19 },
  { 4193, 23, 19, 24, 2, -19 },
  { 4248, 18, 19, 16, -1, -19 },
  { 4291, 20, 28, 15, -3, -19 },
  { 4361, 15, 19, 14, -1, -19 },
  { 4397, 13, 32, 12, 1, -26 },
  { 4449, 2, 36, 17, 8, -27 },
  { 4458, 14, 32, 12, -2, -26 },
  { 4514, 16, 5, 19, 2, -15 },
};

const GFXfont NotoSans_SemiCondensed_Italic36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic36pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC36PT7B_H_
