#ifndef _NOTOSANS_SEMICONDENSED_ITALIC59PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x07, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xC0, 0x00, 0x3F, 0x0F,
  0xCF, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x1F, 0x0F, 0x07, 0xC7,
  0xC1, 0xF1, 0xF0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0,
  0xF0, 0x70, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x1E, 0x01,
  0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x02, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1E, 0x01, 0xE0, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xDD, 0xF8,
  0x07, 0xC7, 0x83, 0x01, 0xF0, 0xE0, 0x00, 0x3E, 0x1C, 0x00, 0x0F, 0x83,
  0x80, 0x01, 0xF0, 0x70, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0xC3, 0x80, 0x00,
  0xF8, 0x70, 0x00, 0x0F, 0x8E, 0x00, 0x01, 0xF9, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0x3F,
  0x00, 0x00, 0xE3, 0xE0, 0x00, 0x3C, 0x7C, 0x00, 0x07, 0x87, 0xC0, 0x00,
  0xE0, 0xF8, 0x00, 0x1C, 0x1F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0xF8,
  0x40, 0x1C, 0x3F, 0x0E, 0x03, 0x8F, 0xC1, 0xF8, 0x77, 0xF8, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x01, 0xFF, 0x80, 0x01, 0xE0, 0x1F, 0xFE,
  0x00, 0x1F, 0x00, 0xF8, 0xF0, 0x00, 0xF0, 0x0F, 0x87, 0xC0, 0x0F, 0x00,
  0x78, 0x1E, 0x00, 0xF8, 0x07, 0x80, 0xF0, 0x07, 0x80, 0x3C, 0x07, 0x80,
  0x78, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x1E, 0x01, 0xE0, 0x3C, 0x00, 0xF0,
  0x0F, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x3E, 0x00, 0x7C, 0x07, 0x81, 0xE0,
  0x03, 0xC0, 0x3C, 0x1E, 0x00, 0x1E, 0x01, 0xE1, 0xF0, 0x00, 0xF0, 0x1F,
  0x0F, 0x00, 0x07, 0x80, 0xF0, 0xF0, 0x78, 0x3C, 0x07, 0x8F, 0x8F, 0xF1,
  0xE0, 0x78, 0x78, 0xFF, 0xCF, 0x03, 0xC7, 0x8F, 0xFF, 0x7C, 0x3E, 0x7C,
  0xF8, 0x7B, 0xE3, 0xE3, 0xC7, 0x83, 0xCF, 0xFE, 0x3C, 0x7C, 0x1F, 0x7F,
  0xE3, 0xE3, 0xC0, 0x79, 0xFE, 0x1E, 0x1E, 0x03, 0xC3, 0x81, 0xE1, 0xE0,
  0x3E, 0x00, 0x1F, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x78, 0x0F, 0x00, 0x0F,
  0x07, 0xC0, 0x78, 0x00, 0xF8, 0x3C, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x1E,
  0x00, 0x7C, 0x0F, 0x01, 0xF0, 0x07, 0xC0, 0x78, 0x0F, 0x00, 0x3C, 0x03,
  0xC0, 0x78, 0x03, 0xE0, 0x1E, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x3C, 0x01,
  0xE0, 0x07, 0x83, 0xE0, 0x1F, 0x00, 0x3C, 0x1E, 0x01, 0xF0, 0x01, 0xF1,
  0xF0, 0x0F, 0x00, 0x07, 0xFF, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x0F, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x7C, 0x03, 0xC0, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0xF8, 0x03, 0xC0,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0xF8, 0x1F, 0x80, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x7C, 0x7E, 0x00,
  0x00, 0x7C, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xF7, 0xC0, 0x1F, 0x0F, 0xC7, 0xE0, 0x1F,
  0x1F, 0x83, 0xE0, 0x3E, 0x3F, 0x03, 0xF0, 0x3E, 0x3E, 0x01, 0xF0, 0x7C,
  0x7C, 0x01, 0xF8, 0x7C, 0x7C, 0x00, 0xFC, 0xF8, 0xF8, 0x00, 0x7D, 0xF0,
  0xF8, 0x00, 0x7F, 0xF0, 0xF8, 0x00, 0x3F, 0xE0, 0xF8, 0x00, 0x3F, 0xC0,
  0xF8, 0x00, 0x1F, 0xC0, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7F, 0xC0,
  0x7C, 0x00, 0xFF, 0xC0, 0x7E, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0xF3, 0xE0,
  0x3F, 0xFF, 0xE3, 0xF0, 0x1F, 0xFF, 0x81, 0xF8, 0x07, 0xFE, 0x01, 0xFC,
  0x00, 0xF0, 0x00, 0x00, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x7C,
  0x7C, 0x78, 0x78, 0x78, 0x70, 0x70, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x40, 0x1E, 0x00, 0x70, 0x1E,
  0x00, 0x7C, 0x1C, 0x00, 0xFF, 0x1C, 0x00, 0xFF, 0xDC, 0x00, 0x3F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFD, 0xFF, 0x01, 0xFE,
  0x00, 0x03, 0xDE, 0x00, 0x07, 0xCF, 0x00, 0x0F, 0x8F, 0x00, 0x1F, 0x0F,
  0x80, 0x7F, 0x07, 0x80, 0x3E, 0x07, 0xC0, 0x1C, 0x07, 0xC0, 0x08, 0x03,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F,
  0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF0, 0x00, 0x7F, 0xFE,
  0xFF, 0xF9, 0xFF, 0xF7, 0xFF, 0xE0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0x18, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x0F, 0xC1, 0xF8, 0x0F,
  0xC0, 0x7E, 0x0F, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x87, 0xE0, 0x07, 0xC3,
  0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C,
  0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0xBF, 0x00, 0x07,
  0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00,
  0x0F, 0xBE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0,
  0x01, 0xF3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xFC, 0x7C,
  0x00, 0x7C, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x3F, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x3F, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x3F, 0xFE,
  0x7F, 0x3E, 0xFE, 0x7C, 0xFC, 0x7C, 0x70, 0x7C, 0x60, 0x7C, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xE0, 0x07, 0xE0,
  0x04, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x7E, 0x00, 0x60, 0x03, 0xF0, 0x04,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x0C, 0x00, 0x0F, 0xE0, 0xF8,
  0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xBE,
  0x00, 0x00, 0xFB, 0xC0, 0x00, 0x1F, 0x3C, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x3C, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0x78, 0x00, 0x1F, 0x0F,
  0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC0, 0xF0, 0x00,
  0xF8, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xE0, 0x1F, 0x00, 0x3E, 0x01,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x01,
  0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFE, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xC3, 0xFE,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0xC0, 0x01, 0xFC, 0x0F, 0x00, 0x7F, 0x80,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x01,
  0x00, 0x0F, 0x87, 0xF8, 0x03, 0xE7, 0xFF, 0x80, 0xF3, 0xFF, 0xE0, 0x7D,
  0xFF, 0xFC, 0x1F, 0xF0, 0x3F, 0x87, 0xF0, 0x07, 0xE1, 0xF8, 0x00, 0xF8,
  0xFE, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xE3, 0xE0, 0x00,
  0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0,
  0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3,
  0xE0, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x1F, 0x00, 0x7C, 0x07, 0xE0, 0x7F,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x01, 0xF8, 0x1F, 0x00,
  0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x81,
  0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x01, 0xF0, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x03,
  0xF7, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0x9F, 0x80, 0x0F, 0xC1, 0xF8, 0x03, 0xF0,
  0x1F, 0x80, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE1,
  0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00,
  0x3F, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F,
  0x80, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x7F, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x74, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0xFC, 0x07, 0xE0, 0x7E,
  0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xC3, 0xE0, 0x01, 0xF1,
  0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x01,
  0xF1, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0xCF, 0x80,
  0x03, 0xF3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x7E, 0x1F, 0x00, 0x3F, 0x87,
  0xE0, 0x1F, 0xE1, 0xFC, 0x0F, 0xF8, 0x3F, 0xFF, 0xBE, 0x07, 0xFF, 0xDF,
  0x01, 0xFF, 0xE7, 0xC0, 0x1F, 0xE1, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x08, 0x03, 0xF8, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0xE0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC,
  0x0F, 0xC0, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xF8,
  0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0x01, 0xFC, 0x20, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x78,
  0x00, 0xF0, 0x78, 0x01, 0xFF, 0xC0, 0x78, 0x7C, 0x03, 0xFF, 0xF0, 0x3C,
  0x3C, 0x03, 0xFF, 0xF8, 0x1E, 0x3E, 0x03, 0xF0, 0x78, 0x0F, 0x1E, 0x03,
  0xE0, 0x3C, 0x07, 0x8F, 0x01, 0xE0, 0x1E, 0x03, 0xCF, 0x01, 0xF0, 0x0F,
  0x01, 0xE7, 0x80, 0xF0, 0x0F, 0x00, 0xF3, 0xC0, 0xF0, 0x07, 0x80, 0x7B,
  0xE0, 0x78, 0x03, 0xC0, 0x3D, 0xE0, 0x7C, 0x03, 0xE0, 0x3C, 0xF0, 0x3C,
  0x01, 0xE0, 0x1E, 0x78, 0x1E, 0x00, 0xF0, 0x0F, 0x3C, 0x0F, 0x00, 0x78,
  0x0F, 0x9E, 0x07, 0x80, 0x7C, 0x07, 0x8F, 0x03, 0xC0, 0x3C, 0x03, 0xCF,
  0x81, 0xE0, 0x3E, 0x03, 0xC7, 0xC0, 0xF0, 0x1F, 0x01, 0xE3, 0xE0, 0x78,
  0x1F, 0x81, 0xE0, 0xF0, 0x3E, 0x1D, 0xE1, 0xE0, 0x78, 0x1F, 0xFE, 0xFF,
  0xF0, 0x3C, 0x07, 0xFE, 0x3F, 0xF0, 0x1E, 0x01, 0xFC, 0x0F, 0xE0, 0x0F,
  0x80, 0x30, 0x00, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x08, 0x00, 0x01,
  0xFC, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xF3, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x7D, 0xF0, 0x00,
  0x01, 0xE7, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x01,
  0xF0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0xF8,
  0x3C, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x0F,
  0x80, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xE0,
  0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x7F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x3F, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x1F, 0x07, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF3,
  0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0xFF, 0x00, 0xF8, 0x01,
  0xFC, 0x07, 0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8,
  0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3E,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0xFC, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x7E, 0x07, 0xC0, 0x07, 0xE0, 0x3E, 0x01, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x3E,
  0x01, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0xC0, 0xF8, 0x00,
  0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7E,
  0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3E,
  0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x07, 0xE0, 0xF8, 0x00,
  0x7F, 0x07, 0xC0, 0x07, 0xF0, 0x7E, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x07, 0x00,
  0x3F, 0x80, 0x02, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x40, 0x07, 0xF8, 0x07, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0xB0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x3F, 0xF8, 0x01,
  0xF0, 0x03, 0xF8, 0x01, 0xF0, 0x01, 0xFC, 0x01, 0xF0, 0x00, 0xFC, 0x01,
  0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xFC, 0x1F,
  0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF8, 0x3E,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x07, 0xE0, 0x3E,
  0x00, 0x0F, 0xE0, 0x7C, 0x00, 0x1F, 0xC0, 0x7C, 0x00, 0x3F, 0x80, 0x7C,
  0x00, 0x7F, 0x00, 0x7C, 0x01, 0xFE, 0x00, 0xFC, 0x7F, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x01, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x20, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0xF8, 0x03, 0xFC,
  0x00, 0x18, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x01, 0xFF, 0xE1, 0xF0, 0x00, 0xFF, 0xF0, 0xF8, 0x00, 0x7F, 0xF8,
  0x7C, 0x00, 0x7F, 0xFC, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E,
  0x1F, 0x80, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01,
  0xF0, 0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0xF8, 0x07, 0xE0, 0x00,
  0x7C, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x7F, 0x80,
  0x3F, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x03,
  0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0xFC, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x7E, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0xC3, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x7C, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x07, 0xC0,
  0x1F, 0x80, 0x03, 0xE0, 0x1F, 0x80, 0x01, 0xF0, 0x1F, 0x80, 0x01, 0xF0,
  0x1F, 0x80, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x3E,
  0x0F, 0xC0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x0F,
  0x8F, 0xC0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x01, 0xF7, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xDF, 0x00, 0x00, 0x3F, 0xCF, 0x80, 0x00,
  0x1F, 0x87, 0xC0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xE0, 0x00,
  0xF8, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x03, 0xDE,
  0x00, 0x00, 0xFF, 0xC0, 0x1E, 0xF0, 0x00, 0x0F, 0xBC, 0x00, 0xF7, 0x80,
  0x00, 0x7F, 0xE0, 0x0F, 0xBC, 0x00, 0x07, 0xDF, 0x00, 0x7D, 0xE0, 0x00,
  0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x03, 0xE7, 0xC0, 0x1E, 0x7C, 0x00, 0x1F,
  0x7C, 0x01, 0xF3, 0xE0, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x0F, 0x9F,
  0x00, 0x7C, 0xF8, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xC0, 0x07, 0xC7, 0xC0,
  0x1E, 0x1E, 0x00, 0x7C, 0x7C, 0x01, 0xF0, 0xF0, 0x03, 0xE3, 0xE0, 0x0F,
  0x87, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3C, 0x01, 0xE0, 0xF8, 0x03, 0xE1,
  0xE0, 0x1F, 0x0F, 0x80, 0x1E, 0x0F, 0x80, 0xF0, 0x7C, 0x01, 0xF0, 0x7C,
  0x0F, 0x83, 0xE0, 0x0F, 0x83, 0xE0, 0x78, 0x1F, 0x00, 0x7C, 0x1F, 0x07,
  0xC0, 0xF8, 0x03, 0xE0, 0x78, 0x3C, 0x0F, 0x80, 0x1E, 0x03, 0xC3, 0xE0,
  0x7C, 0x01, 0xF0, 0x1E, 0x1E, 0x03, 0xE0, 0x0F, 0x80, 0xF1, 0xF0, 0x1F,
  0x00, 0x7C, 0x07, 0x8F, 0x00, 0xF8, 0x03, 0xC0, 0x3C, 0xF8, 0x0F, 0x80,
  0x3E, 0x01, 0xE7, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xFC, 0x03, 0xE0, 0x0F,
  0x80, 0x7F, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xFE, 0x01, 0xF8, 0x03, 0xC0,
  0x1F, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7F, 0x00, 0x7C, 0x01, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0xC0, 0x00, 0x3E, 0x00,
  0xFE, 0x00, 0x01, 0xE0, 0x0F, 0xF0, 0x00, 0x1F, 0x00, 0x7F, 0xC0, 0x00,
  0xF8, 0x03, 0xFE, 0x00, 0x07, 0xC0, 0x1F, 0xF0, 0x00, 0x3E, 0x00, 0xF7,
  0xC0, 0x03, 0xE0, 0x0F, 0xBE, 0x00, 0x1F, 0x00, 0x7D, 0xF0, 0x00, 0xF8,
  0x03, 0xE7, 0x80, 0x07, 0xC0, 0x1E, 0x3E, 0x00, 0x3E, 0x01, 0xF1, 0xF0,
  0x03, 0xE0, 0x0F, 0x87, 0x80, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x03,
  0xE1, 0xF0, 0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x3E, 0x03,
  0xE0, 0x0F, 0x81, 0xF0, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0xF8, 0x03, 0xE0,
  0x3C, 0x07, 0xC0, 0x1E, 0x01, 0xF0, 0x3C, 0x01, 0xF0, 0x0F, 0x83, 0xE0,
  0x0F, 0x80, 0x7C, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0x0F,
  0x87, 0xC0, 0x1E, 0x00, 0x7C, 0x7C, 0x01, 0xF0, 0x01, 0xF3, 0xE0, 0x0F,
  0x80, 0x0F, 0x9F, 0x00, 0x7C, 0x00, 0x7C, 0xF8, 0x03, 0xE0, 0x01, 0xE7,
  0xC0, 0x3E, 0x00, 0x0F, 0xBC, 0x01, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0x80,
  0x03, 0xFF, 0x00, 0x7C, 0x00, 0x0F, 0xF8, 0x03, 0xC0, 0x00, 0x7F, 0x80,
  0x3E, 0x00, 0x03, 0xFC, 0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x0F, 0x80, 0x00,
  0x7F, 0x00, 0x7C, 0x00, 0x03, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x0F,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x01, 0xF0, 0xFC, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x7C, 0x7E, 0x00,
  0x00, 0x3E, 0x3E, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x0F, 0x9F, 0x80,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x01, 0xF7, 0xE0,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00, 0x7E, 0xF8,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x01, 0xF8,
  0x7C, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xF8, 0x3F, 0xE0, 0x1F, 0x00, 0x7E, 0x01,
  0xF0, 0x03, 0xF0, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x3E, 0x00,
  0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0,
  0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x3F, 0x07, 0xC0,
  0x03, 0xE0, 0x7C, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC0, 0xF8, 0x01, 0xFC,
  0x0F, 0x80, 0x7F, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x03, 0xF0,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0xF8, 0xFC,
  0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x1F, 0x3F,
  0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0xFD,
  0xF0, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1F,
  0x3E, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07,
  0xCF, 0xC0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFE, 0x03, 0xF0, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xF8,
  0x3F, 0xE0, 0x1F, 0x00, 0x7F, 0x01, 0xF0, 0x03, 0xF0, 0x1F, 0x00, 0x1F,
  0x01, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E,
  0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03,
  0xF0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x7E, 0x0F,
  0xC0, 0x1F, 0xC0, 0xF8, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01,
  0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x01,
  0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0xC0, 0x7C, 0x00, 0x7C, 0x07, 0xC0,
  0x07, 0xC0, 0x7C, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x3E,
  0x0F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x3E, 0x01, 0xF8, 0x00, 0x40,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x0C, 0x00, 0x1F, 0xC0,
  0xF8, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0xC0, 0xF8, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x1F, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xE7, 0xC0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xF0,
  0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7E, 0x07, 0xC0, 0x01, 0xF0, 0x1F,
  0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0,
  0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x03,
  0xE0, 0x03, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x7B, 0xE0,
  0x00, 0x01, 0xEF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xE0, 0x00,
  0x7D, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xEF, 0x80, 0x03, 0xF8, 0x00, 0x3E,
  0x7C, 0x00, 0x3F, 0xC0, 0x03, 0xF3, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0x1F,
  0x00, 0x0F, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xF7, 0x80, 0x0F, 0x87, 0xC0,
  0x07, 0xBC, 0x00, 0x7C, 0x3E, 0x00, 0x7D, 0xE0, 0x07, 0xE1, 0xF0, 0x03,
  0xCF, 0x00, 0x3E, 0x0F, 0x80, 0x3E, 0x78, 0x03, 0xF0, 0x7C, 0x01, 0xE3,
  0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x1E, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0xF0,
  0x0F, 0x80, 0xF8, 0x07, 0x87, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x3C, 0x07,
  0xC0, 0x3E, 0x03, 0xC1, 0xE0, 0x3E, 0x01, 0xF0, 0x3E, 0x0F, 0x01, 0xF0,
  0x0F, 0x81, 0xE0, 0x78, 0x1F, 0x00, 0x7C, 0x1F, 0x03, 0xC0, 0xF8, 0x03,
  0xE0, 0xF8, 0x1E, 0x0F, 0x80, 0x1F, 0x07, 0x80, 0xF0, 0x7C, 0x00, 0xF8,
  0x7C, 0x07, 0x87, 0xC0, 0x07, 0xC3, 0xC0, 0x3C, 0x3E, 0x00, 0x3E, 0x3E,
  0x01, 0xE1, 0xF0, 0x01, 0xF1, 0xE0, 0x0F, 0x1F, 0x00, 0x0F, 0x9F, 0x00,
  0x78, 0xF8, 0x00, 0x7C, 0xF8, 0x03, 0xCF, 0x80, 0x03, 0xE7, 0x80, 0x1E,
  0x7C, 0x00, 0x1F, 0x7C, 0x00, 0xF3, 0xC0, 0x00, 0xFB, 0xC0, 0x07, 0xBE,
  0x00, 0x07, 0xDE, 0x00, 0x3D, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xEF, 0x00,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x1F, 0x80,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x3F,
  0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x7C,
  0x7C, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00,
  0x7C, 0xF8, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x01, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x07,
  0xEF, 0x80, 0x01, 0xF9, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0xC7, 0xC0,
  0x01, 0xF0, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x81, 0xF0, 0x03, 0xE0,
  0x3E, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x01,
  0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xC1, 0xF0, 0x00,
  0xF8, 0x7C, 0x00, 0x0F, 0x1F, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0xF8,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0xF8,
  0x1F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x1E, 0x3E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x3C,
  0x07, 0x80, 0x0F, 0x80, 0xF8, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0,
  0x0F, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0x7C, 0x1F, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE7,
  0xC0, 0x00, 0x3E, 0xF0, 0x00, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xF8, 0x7E, 0x1F, 0x0F, 0x83, 0xE0,
  0xF0, 0x7C, 0x1E, 0x07, 0x80, 0x00, 0x1F, 0xC0, 0xF0, 0x07, 0xFF, 0x1E,
  0x00, 0xFF, 0xF1, 0xE0, 0x1F, 0xFF, 0x9E, 0x03, 0xF8, 0x7F, 0xE0, 0x7F,
  0x01, 0xFE, 0x07, 0xE0, 0x1F, 0xC0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x0F,
  0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xF8, 0x3E,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0x87, 0xC0, 0x01,
  0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x0F,
  0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00,
  0x7E, 0x0F, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0xFE, 0x07, 0xC0, 0x1F, 0xC0,
  0x7C, 0x03, 0xFC, 0x07, 0xE0, 0x7F, 0xC0, 0x7F, 0xFF, 0x7C, 0x03, 0xFF,
  0xE7, 0x80, 0x1F, 0xFC, 0x78, 0x00, 0xFF, 0x07, 0x80, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE1, 0xFC,
  0x00, 0xF8, 0x7F, 0xC0, 0x1F, 0x3F, 0xFC, 0x03, 0xEF, 0xFF, 0xC0, 0x7F,
  0xE1, 0xF8, 0x0F, 0x70, 0x1F, 0x83, 0xFC, 0x01, 0xF0, 0x7F, 0x00, 0x3E,
  0x0F, 0xE0, 0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x0F, 0xC0,
  0x03, 0xE1, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF1,
  0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF0, 0xF8, 0x00,
  0x3E, 0x1F, 0x00, 0x07, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3E, 0x1F,
  0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0x7E, 0x1F, 0xC0, 0x0F,
  0x83, 0xF8, 0x03, 0xF0, 0x7F, 0x81, 0xFC, 0x0F, 0x7F, 0xFF, 0x01, 0xE7,
  0xFF, 0xC0, 0x78, 0x7F, 0xF0, 0x0F, 0x07, 0xFC, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x3F, 0x81, 0x80, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x06, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x7F, 0x07, 0xC0, 0x07, 0xFF, 0x1E, 0x00, 0x3F, 0xFC, 0xF8,
  0x01, 0xFF, 0xFB, 0xE0, 0x0F, 0xE0, 0xFF, 0x80, 0x7F, 0x01, 0xFE, 0x01,
  0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF0,
  0x00, 0xFC, 0x07, 0xC0, 0x03, 0xE0, 0x3F, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0,
  0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xE0, 0x3E,
  0x00, 0x1F, 0x80, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xC0,
  0x1F, 0xC0, 0x1F, 0x00, 0xFF, 0x00, 0x7E, 0x07, 0xFC, 0x01, 0xFF, 0xFD,
  0xF0, 0x03, 0xFF, 0xE7, 0x80, 0x07, 0xFF, 0x1E, 0x00, 0x0F, 0xF0, 0x78,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0x87, 0xE0, 0xFC, 0x07, 0xC3, 0xF0,
  0x07, 0x87, 0xC0, 0x0F, 0x1F, 0x80, 0x3E, 0x3E, 0x00, 0x7C, 0xFC, 0x00,
  0xF9, 0xF0, 0x03, 0xE3, 0xE0, 0x1F, 0xCF, 0x80, 0xFF, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x81, 0xF8,
  0x07, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x40,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x21, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x3C, 0x00, 0x7F, 0xF1,
  0xE0, 0x03, 0xFF, 0xE7, 0x80, 0x1F, 0xFF, 0x9E, 0x00, 0xFE, 0x0F, 0xF8,
  0x07, 0xF0, 0x1F, 0xE0, 0x1F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x07,
  0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x81, 0xF8, 0x00,
  0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x7E, 0x03, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0xE0, 0x3F,
  0x00, 0x7F, 0x80, 0x7C, 0x01, 0xFC, 0x01, 0xF0, 0x0F, 0xF0, 0x07, 0xE0,
  0xFF, 0xC0, 0x1F, 0xFF, 0xDF, 0x00, 0x3F, 0xFE, 0x78, 0x00, 0x7F, 0xF3,
  0xE0, 0x00, 0xFF, 0x0F, 0x80, 0x00, 0x60, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0xC0,
  0x03, 0xF0, 0x03, 0xE0, 0x3F, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE1, 0xFC, 0x00, 0x78, 0xFF,
  0xE0, 0x1F, 0x3F, 0xFE, 0x03, 0xEF, 0xFF, 0xC0, 0x7F, 0xE1, 0xFC, 0x0F,
  0x70, 0x1F, 0x83, 0xFC, 0x01, 0xF0, 0x7F, 0x00, 0x3E, 0x0F, 0xC0, 0x07,
  0xC1, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xC1, 0xF0,
  0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0xF8,
  0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00,
  0x0F, 0x87, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83,
  0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01,
  0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF0, 0x7C,
  0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x08, 0x7E, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x7C,
  0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x07, 0xE0, 0x0F, 0x81, 0xF8, 0x03, 0xE0,
  0x7E, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0x87, 0xE0, 0x01, 0xF0, 0xF8, 0x00,
  0x3C, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0xF8,
  0x00, 0x07, 0xBF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFE, 0x7C, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xE1, 0xF8,
  0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x7C,
  0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0,
  0x0F, 0x80, 0x3F, 0x01, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x00, 0x01, 0xE0, 0xFE, 0x00, 0xFE, 0x00, 0xF8, 0xFF, 0xC0,
  0xFF, 0xC0, 0x3E, 0x7F, 0xF8, 0x7F, 0xF8, 0x0F, 0x3F, 0xFE, 0x3F, 0xFF,
  0x03, 0xDF, 0x0F, 0xDF, 0x0F, 0xC0, 0xFF, 0x01, 0xFF, 0x01, 0xF0, 0x7F,
  0x80, 0x7F, 0x80, 0x7C, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xC1, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0x83,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC0,
  0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC3, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC0, 0x03,
  0xE1, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC3, 0xE0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xE0, 0xFF, 0x00, 0x7C, 0x7F, 0xF0, 0x0F, 0x9F,
  0xFF, 0x01, 0xF7, 0xFF, 0xE0, 0x3D, 0xF8, 0xFE, 0x0F, 0xFC, 0x0F, 0xC1,
  0xFE, 0x00, 0xF8, 0x3F, 0x80, 0x1F, 0x07, 0xF0, 0x03, 0xE0, 0xFC, 0x00,
  0x7C, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x7C, 0x1F,
  0x00, 0x0F, 0x83, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x00, 0x0F,
  0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xC3, 0xF0,
  0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8,
  0x7E, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00,
  0x1F, 0x07, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xF8, 0x7F, 0x01, 0xF8, 0x07, 0xC0, 0xFC,
  0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0x87, 0xC0, 0x03, 0xE3,
  0xF0, 0x00, 0xFC, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0xDF, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00,
  0x03, 0xEF, 0xC0, 0x01, 0xFB, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E,
  0x00, 0x0F, 0xCF, 0x80, 0x03, 0xE3, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x7C,
  0x1F, 0x00, 0x3F, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x3C, 0x1F, 0xC0, 0x00, 0xF0, 0xFF, 0x80, 0x07,
  0xCF, 0xFF, 0x00, 0x1E, 0x7F, 0xFE, 0x00, 0x7B, 0xE1, 0xF8, 0x01, 0xEE,
  0x03, 0xF0, 0x0F, 0xF0, 0x07, 0xC0, 0x3F, 0x80, 0x1F, 0x00, 0xFE, 0x00,
  0x7C, 0x03, 0xF0, 0x01, 0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x7E, 0x00, 0x1F,
  0x01, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x3E,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF8, 0x1F, 0x80,
  0x07, 0xC0, 0x7E, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0xF8, 0x07, 0xE0, 0x07,
  0xE0, 0x3F, 0x80, 0x1F, 0x00, 0xFE, 0x00, 0xFC, 0x03, 0xFC, 0x0F, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0x3C, 0xFF, 0xF8, 0x01, 0xF1, 0xFF, 0xC0, 0x07,
  0xC3, 0xFE, 0x00, 0x1F, 0x01, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0xF0,
  0x07, 0xFF, 0x1E, 0x00, 0xFF, 0xF9, 0xE0, 0x1F, 0xFF, 0x9E, 0x03, 0xF8,
  0x3F, 0xE0, 0x7F, 0x01, 0xFE, 0x07, 0xC0, 0x1F, 0xC0, 0xFC, 0x00, 0xFC,
  0x1F, 0x80, 0x0F, 0xC1, 0xF0, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0x83, 0xF0,
  0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x0F,
  0x87, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C,
  0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3E, 0x0F, 0x80, 0x07,
  0xE0, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xE0, 0xFC, 0x01, 0xFE, 0x07,
  0xC0, 0x1F, 0xC0, 0x7C, 0x03, 0xFC, 0x07, 0xE0, 0xFF, 0xC0, 0x7F, 0xFF,
  0x7C, 0x03, 0xFF, 0xE7, 0x80, 0x1F, 0xFC, 0xF8, 0x00, 0xFF, 0x0F, 0x80,
  0x01, 0x80, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0xFC, 0x0F, 0x8F, 0xF0, 0x3E, 0x7F, 0x80, 0xF3, 0xFE,
  0x03, 0xDF, 0xF8, 0x0F, 0x78, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7E, 0x03, 0x81, 0xF8, 0x01, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC2, 0x00, 0x1F, 0x87, 0x00,
  0x7E, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x07, 0x00,
  0x0F, 0xC0, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00,
  0x1F, 0x0F, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C,
  0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xC3, 0xE0, 0x01, 0xF0,
  0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC7, 0xC0, 0x03,
  0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0,
  0x07, 0xE3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x3F, 0x0F,
  0x80, 0x0F, 0xC3, 0xE0, 0x07, 0xE0, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0xFE,
  0x0F, 0x80, 0x7F, 0x83, 0xF0, 0x7B, 0xE0, 0xFF, 0xFE, 0xF0, 0x1F, 0xFF,
  0x3C, 0x07, 0xFF, 0x0F, 0x00, 0xFF, 0x83, 0xC0, 0x03, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xDF, 0x00, 0x07,
  0xCF, 0x80, 0x07, 0xE7, 0xC0, 0x03, 0xE1, 0xE0, 0x03, 0xF0, 0xF0, 0x01,
  0xF0, 0x7C, 0x01, 0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0x80,
  0x7C, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x3F, 0x00, 0xF8,
  0x1F, 0x00, 0x7C, 0x1F, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x0F, 0xC0, 0x07,
  0x87, 0xC0, 0x03, 0xC7, 0xC0, 0x01, 0xE3, 0xE0, 0x00, 0xF1, 0xE0, 0x00,
  0x79, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0x78, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xF0,
  0x01, 0xF7, 0x80, 0x0F, 0xC0, 0x0F, 0x9E, 0x00, 0x7F, 0x00, 0x3E, 0x78,
  0x01, 0xFC, 0x01, 0xF1, 0xE0, 0x0F, 0xF0, 0x07, 0xC7, 0x80, 0x3F, 0xC0,
  0x3F, 0x1E, 0x01, 0xEF, 0x00, 0xF8, 0x78, 0x07, 0xBC, 0x03, 0xE1, 0xE0,
  0x3E, 0xF0, 0x1F, 0x07, 0x80, 0xF3, 0xC0, 0x7C, 0x1E, 0x03, 0xCF, 0x03,
  0xE0, 0x78, 0x1E, 0x3C, 0x0F, 0x81, 0xE0, 0x78, 0xF0, 0x3C, 0x07, 0x83,
  0xC3, 0xC1, 0xF0, 0x1E, 0x0F, 0x0F, 0x07, 0xC0, 0x78, 0x7C, 0x3C, 0x3E,
  0x01, 0xE1, 0xE0, 0xF0, 0xF8, 0x07, 0x87, 0x83, 0xC7, 0xC0, 0x1E, 0x3C,
  0x0F, 0x1F, 0x00, 0x78, 0xF0, 0x3C, 0x78, 0x01, 0xE7, 0x80, 0xF3, 0xE0,
  0x07, 0x9E, 0x03, 0xCF, 0x80, 0x1E, 0xF8, 0x0F, 0x7C, 0x00, 0x7B, 0xC0,
  0x3D, 0xF0, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x07, 0xF8, 0x03, 0xFE, 0x00,
  0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0xFC, 0x01,
  0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF0,
  0x7E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x0F, 0xBF, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x7C, 0x3E, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0,
  0x3E, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0xF8, 0x1F, 0x80, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x03, 0xE0,
  0x07, 0xE0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x01, 0xE0, 0x3E, 0x00,
  0x00, 0x78, 0x1F, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x1F, 0x1F,
  0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x3D,
  0xF0, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x20, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x47, 0xFC, 0x00, 0x17, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xF2, 0x00,
  0x03, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_Italic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 15, 43, 15, 1, -42 },
  { 82, 18, 15, 22, 6, -42 },
  { 116, 33, 42, 33, 1, -42 },
  { 290, 27, 48, 29, 1, -45 },
  { 452, 37, 44, 43, 4, -43 },
  { 656, 32, 44, 34, 1, -43 },
  { 832, 8, 15, 12, 6, -42 },
  { 847, 19, 51, 16, 2, -42 },
  { 969, 18, 51, 16, -4, -42 },
  { 1084, 24, 24, 28, 6, -45 },
  { 1156, 26, 28, 31, 3, -35 },
  { 1247, 12, 15, 14, -3, -7 },
  { 1270, 15, 4, 17, 1, -18 },
  { 1278, 7, 8, 14, 1, -7 },
  { 1285, 28, 42, 21, -3, -42 },
  { 1432, 25, 44, 29, 3, -43 },
  { 1570, 16, 42, 29, 8, -42 },
  { 1654, 29, 43, 29, -1, -43 },
  { 1810, 28, 44, 29, 0, -43 },
  { 1964, 28, 42, 29, 0, -42 },
  { 2111, 28, 43, 29, 1, -42 },
  { 2262, 26, 44, 29, 3, -43 },
  { 2405, 26, 42, 29, 4, -42 },
  { 2542, 27, 44, 29, 2, -43 },
  { 2691, 26, 44, 29, 2, -43 },
  { 2834, 12, 33, 14, 1, -32 },
  { 2884, 16, 40, 14, -3, -32 },
  { 2964, 26, 28, 31, 3, -35 },
  { 3055, 25, 16, 31, 4, -29 },
  { 3105, 26, 28, 31, 3, -35 },
  { 3196, 21, 44, 22, 3, -43 },
  { 3312, 41, 47, 44, 2, -42 },
  { 3553, 30, 42, 30, -4, -42 },
  { 3711, 29, 42, 32, 2, -42 },
  { 3864, 31, 44, 30, 3, -43 },
  { 4035, 32, 42, 35, 2, -42 },
  { 4203, 28, 42, 27, 2, -42 },
  { 4350, 28, 42, 25, 2, -42 },
  { 4497, 33, 44, 36, 3, -43 },
  { 4679, 34, 42, 36, 2, -42 },
  { 4858, 23, 42, 18, -2, -42 },
  { 4979, 25, 53, 15, -9, -42 },
  { 5145, 33, 42, 30, 2, -42 },
  { 5319, 20, 42, 25, 2, -42 },
  { 5424, 45, 42, 45, 1, -42 },
  { 5661, 37, 42, 38, 1, -42 },
  { 5856, 33, 44, 38, 3, -43 },
  { 6038, 28, 42, 30, 2, -42 },
  { 6185, 33, 53, 38, 3, -43 },
  { 6404, 28, 42, 30, 2, -42 },
  { 6551, 28, 44, 27, 0, -43 },
  { 6705, 26, 42, 26, 5, -42 },
  { 6842, 32, 43, 36, 4, -42 },
  { 7014, 30, 42, 29, 5, -42 },
  { 7172, 45, 42, 46, 6, -42 },
  { 7409, 35, 42, 28, -3, -42 },
  { 7593, 27, 42, 27, 5, -42 },
  { 7735, 31, 42, 27, -1, -42 },
  { 7898, 22, 51, 17, -1, -42 },
  { 8039, 11, 42, 21, 6, -42 },
  { 8097, 22, 51, 17, -4, -42 },
  { 8238, 27, 25, 30, 2, -42 },
  { 8323, 22, 4, 21, -5, 5 },
  { 8334, 9, 9, 16, 9, -45 },
  { 8345, 28, 33, 30, 2, -32 },
  { 8461, 27, 46, 31, 1, -45 },
  { 8617, 23, 33, 24, 2, -32 },
  { 8712, 30, 46, 31, 2, -45 },
  { 8885, 23, 33, 27, 2, -32 },
  { 8980, 31, 59, 17, -7, -45 },
  { 9209, 30, 46, 31, 0, -32 },
  { 9382, 27, 45, 31, 1, -45 },
  { 9534, 14, 43, 14, 1, -43 },
  { 9610, 23, 57, 14, -8, -43 },
  { 9774, 27, 45, 26, 1, -45 },
  { 9926, 15, 45, 14, 1, -45 },
  { 10011, 42, 32, 46, 1, -32 },
  { 10179, 27, 32, 31, 1, -32 },
  { 10287, 26, 33, 30, 2, -32 },
  { 10395, 30, 46, 31, -2, -32 },
  { 10568, 28, 46, 31, 2, -32 },
  { 10729, 22, 32, 21, 1, -32 },
  { 10817, 23, 33, 23, 0, -32 },
  { 10912, 16, 40, 18, 3, -39 },
  { 10992, 26, 33, 31, 3, -32 },
  { 11100, 25, 32, 25, 3, -32 },
  { 11200, 38, 32, 39, 3, -32 },
  { 11352, 29, 32, 25, -2, -32 },
  { 11468, 34, 46, 25, -6, -32 },
  { 11664, 24, 32, 23, -1, -32 },
  { 11760, 22, 51, 20, 1, -42 },
  { 11901, 4, 59, 29, 13, -45 },
  { 11931, 22, 51, 20, -3, -42 },
  { 12072, 26, 8, 31, 3, -25 },
};

const GFXfont NotoSans_SemiCondensed_Italic59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic59pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC59PT7B_H_
