#ifndef _NOTOSANS_SEMICONDENSED_ITALIC12PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0xA4, 0x90, 0xC0, 0x55, 0xAA, 0x14, 0x28, 0x53, 0xF2, 0x85,
  0x37, 0x28, 0x50, 0x10, 0xF5, 0x14, 0x30, 0xA2, 0xBE, 0x20, 0x80, 0x63,
  0x4A, 0xA5, 0x4B, 0x7B, 0x4A, 0xA5, 0xCC, 0x18, 0x48, 0xA1, 0x43, 0x0A,
  0xA3, 0x44, 0x74, 0x5A, 0x12, 0x24, 0x44, 0x88, 0x84, 0x40, 0x21, 0x11,
  0x11, 0x12, 0x24, 0x80, 0x37, 0x0E, 0xA5, 0x00, 0x21, 0x3E, 0x42, 0x10,
  0x6A, 0x00, 0xE0, 0xC0, 0x04, 0x10, 0x84, 0x10, 0x82, 0x10, 0xC0, 0x32,
  0xE3, 0x18, 0xCA, 0x52, 0xE0, 0x2F, 0x24, 0x94, 0x80, 0x19, 0xB0, 0x42,
  0x08, 0x42, 0x10, 0xF8, 0x19, 0xB0, 0x42, 0x30, 0x20, 0x82, 0xF0, 0x04,
  0x31, 0x8A, 0x49, 0x2F, 0xC4, 0x10, 0x3C, 0x82, 0x10, 0x78, 0x20, 0x82,
  0xF0, 0x1B, 0x11, 0x0F, 0x4A, 0x52, 0xE0, 0xF8, 0x44, 0x22, 0x11, 0x08,
  0x80, 0x18, 0x92, 0x4A, 0x31, 0x28, 0xA2, 0x70, 0x18, 0xA4, 0x51, 0x4C,
  0xE0, 0x84, 0xE0, 0x28, 0x00, 0x30, 0x13, 0x00, 0x02, 0x44, 0x80, 0x09,
  0xB0, 0xC1, 0x84, 0xF8, 0x3E, 0x83, 0x06, 0x6C, 0x40, 0x69, 0x12, 0x64,
  0x80, 0x80, 0x0E, 0x08, 0x88, 0x29, 0xD5, 0x4C, 0xA6, 0x94, 0xB4, 0x40,
  0x1E, 0x00, 0x04, 0x31, 0x45, 0x14, 0xF2, 0x51, 0xC4, 0x38, 0x92, 0x59,
  0x79, 0x14, 0x53, 0xF8, 0x19, 0x94, 0x20, 0x82, 0x08, 0x20, 0x70, 0x38,
  0x48, 0x8B, 0x14, 0x28, 0xD1, 0x26, 0xF0, 0x3C, 0x82, 0x18, 0x79, 0x04,
  0x10, 0xF0, 0x3C, 0x82, 0x18, 0x79, 0x04, 0x10, 0x80, 0x19, 0x94, 0x20,
  0x9E, 0x18, 0xA2, 0x78, 0x22, 0x44, 0x8B, 0x17, 0xE8, 0x91, 0x22, 0x84,
  0x72, 0x22, 0x24, 0x44, 0xE0, 0x08, 0x42, 0x31, 0x08, 0x42, 0x21, 0x38,
  0x22, 0x48, 0xA2, 0x87, 0x0A, 0x16, 0x24, 0x88, 0x22, 0x26, 0x44, 0x44,
  0xF0, 0x30, 0x98, 0xCC, 0x6A, 0x55, 0x3A, 0xA9, 0x54, 0xB2, 0x99, 0x00,
  0x21, 0x31, 0x32, 0x52, 0x52, 0x4A, 0x4C, 0x4C, 0x84, 0x19, 0x94, 0x61,
  0x86, 0x18, 0x62, 0x70, 0x38, 0x92, 0x59, 0x4D, 0xC4, 0x10, 0x80, 0x19,
  0x94, 0x61, 0x86, 0x18, 0x62, 0x70, 0x41, 0x80, 0x38, 0x92, 0x59, 0x49,
  0xC4, 0x92, 0x88, 0x19, 0x94, 0x10, 0x30, 0x60, 0x86, 0xF0, 0xF9, 0x08,
  0x44, 0x21, 0x08, 0xC0, 0x45, 0x14, 0x61, 0x86, 0x28, 0xA2, 0xF0, 0x86,
  0x38, 0xA6, 0x92, 0xCA, 0x18, 0x40, 0x88, 0xC4, 0x66, 0x53, 0x2A, 0x95,
  0x52, 0xA9, 0x88, 0xC4, 0x00, 0x23, 0x12, 0x14, 0x18, 0x18, 0x18, 0x28,
  0x48, 0xC4, 0x8E, 0x29, 0x14, 0x61, 0x04, 0x10, 0xC0, 0x3D, 0x10, 0x84,
  0x30, 0x84, 0x30, 0xF8, 0x32, 0x24, 0x44, 0x44, 0x88, 0xC0, 0xA5, 0x55,
  0x40, 0x38, 0x84, 0x21, 0x08, 0x84, 0x21, 0x38, 0x10, 0xC2, 0x92, 0x4A,
  0x10, 0xF0, 0x90, 0x10, 0xB4, 0x52, 0x4B, 0x27, 0x80, 0x20, 0x83, 0x9B,
  0x45, 0x14, 0x92, 0xB0, 0x11, 0x50, 0x8C, 0x21, 0xC0, 0x06, 0x08, 0x51,
  0x64, 0x49, 0x32, 0x6C, 0x68, 0x11, 0x52, 0xE8, 0x21, 0xC0, 0x1C, 0x41,
  0x8C, 0x20, 0x82, 0x08, 0x41, 0x04, 0x20, 0x10, 0xB4, 0xD2, 0xCB, 0x66,
  0x82, 0x13, 0x80, 0x20, 0x82, 0x9F, 0x45, 0x24, 0x92, 0x88, 0x24, 0xA4,
  0x92, 0x80, 0x08, 0x42, 0x21, 0x08, 0x42, 0x21, 0x09, 0x80, 0x20, 0x82,
  0x52, 0x51, 0x85, 0x14, 0x98, 0x24, 0xA4, 0x92, 0x80, 0x19, 0x35, 0x53,
  0x29, 0x14, 0x92, 0x4A, 0x24, 0x19, 0xB4, 0x52, 0x49, 0x28, 0x80, 0x10,
  0xA4, 0x51, 0xC9, 0x27, 0x00, 0x19, 0xB4, 0x51, 0x49, 0x2B, 0x20, 0x82,
  0x00, 0x10, 0xB4, 0xD2, 0xCB, 0x66, 0x82, 0x10, 0x40, 0x0B, 0x90, 0x84,
  0x22, 0x00, 0x32, 0x50, 0xC1, 0x0B, 0x80, 0x4E, 0x49, 0x26, 0xCC, 0x65,
  0x2B, 0x68, 0x9C, 0xA9, 0x4C, 0x60, 0x93, 0x66, 0xD6, 0xAD, 0x93, 0x00,
  0x4C, 0xC2, 0x18, 0x52, 0x40, 0x26, 0x48, 0xA1, 0x43, 0x06, 0x08, 0x10,
  0xC0, 0x78, 0x88, 0x8C, 0x78, 0x08, 0x88, 0x42, 0x61, 0x08, 0x42, 0x18,
  0xFF, 0xF0, 0x20, 0x84, 0x21, 0x0C, 0x44, 0x21, 0x30, 0xEC, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_Italic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 4, 4, 4, 1, -9 },
  { 7, 7, 9, 7, 0, -9 },
  { 15, 6, 10, 6, 0, -9 },
  { 23, 7, 9, 9, 1, -9 },
  { 31, 7, 9, 7, 0, -9 },
  { 39, 2, 4, 3, 1, -9 },
  { 40, 4, 11, 3, 0, -9 },
  { 46, 4, 11, 3, -1, -9 },
  { 52, 5, 5, 6, 1, -9 },
  { 56, 5, 6, 6, 1, -7 },
  { 60, 3, 3, 3, -1, -1 },
  { 62, 3, 1, 4, 0, -4 },
  { 63, 2, 1, 3, 0, -1 },
  { 64, 6, 9, 4, -1, -9 },
  { 71, 5, 9, 6, 1, -9 },
  { 77, 3, 9, 6, 2, -9 },
  { 81, 6, 9, 6, 0, -9 },
  { 88, 6, 9, 6, 0, -9 },
  { 95, 6, 9, 6, 0, -9 },
  { 102, 6, 9, 6, 0, -9 },
  { 109, 5, 9, 6, 1, -9 },
  { 115, 5, 9, 6, 1, -9 },
  { 121, 6, 9, 6, 0, -9 },
  { 128, 6, 9, 6, 0, -9 },
  { 135, 3, 7, 3, 0, -7 },
  { 138, 4, 9, 3, -1, -7 },
  { 143, 5, 6, 6, 1, -7 },
  { 147, 5, 3, 6, 1, -6 },
  { 149, 5, 6, 6, 1, -7 },
  { 153, 4, 9, 5, 1, -9 },
  { 158, 9, 10, 9, 0, -9 },
  { 170, 6, 9, 6, -1, -9 },
  { 177, 6, 9, 6, 0, -9 },
  { 184, 6, 9, 6, 1, -9 },
  { 191, 7, 9, 7, 0, -9 },
  { 199, 6, 9, 6, 0, -9 },
  { 206, 6, 9, 5, 0, -9 },
  { 213, 6, 9, 7, 1, -9 },
  { 220, 7, 9, 7, 0, -9 },
  { 228, 4, 9, 4, 0, -9 },
  { 233, 5, 11, 3, -2, -9 },
  { 240, 7, 9, 6, 0, -9 },
  { 248, 4, 9, 5, 0, -9 },
  { 253, 9, 9, 9, 0, -9 },
  { 264, 8, 9, 8, 0, -9 },
  { 273, 6, 9, 8, 1, -9 },
  { 280, 6, 9, 6, 0, -9 },
  { 287, 6, 11, 8, 1, -9 },
  { 296, 6, 9, 6, 0, -9 },
  { 303, 6, 9, 6, 0, -9 },
  { 310, 5, 9, 5, 1, -9 },
  { 316, 6, 9, 7, 1, -9 },
  { 323, 6, 9, 6, 1, -9 },
  { 330, 9, 9, 9, 1, -9 },
  { 341, 8, 9, 6, -1, -9 },
  { 350, 6, 9, 5, 1, -9 },
  { 357, 6, 9, 6, 0, -9 },
  { 364, 4, 11, 3, 0, -9 },
  { 370, 2, 9, 4, 1, -9 },
  { 373, 5, 11, 3, -1, -9 },
  { 380, 6, 6, 6, 0, -9 },
  { 385, 4, 1, 4, -1, 1 },
  { 386, 2, 2, 3, 2, -9 },
  { 387, 6, 7, 6, 0, -7 },
  { 393, 6, 9, 6, 0, -9 },
  { 400, 5, 7, 5, 0, -7 },
  { 405, 7, 9, 6, 0, -9 },
  { 413, 5, 7, 5, 0, -7 },
  { 418, 6, 12, 3, -1, -9 },
  { 427, 6, 10, 6, 0, -7 },
  { 435, 6, 9, 6, 0, -9 },
  { 442, 3, 9, 3, 0, -9 },
  { 446, 5, 12, 3, -2, -9 },
  { 454, 6, 9, 5, 0, -9 },
  { 461, 3, 9, 3, 0, -9 },
  { 465, 9, 7, 9, 0, -7 },
  { 473, 6, 7, 6, 0, -7 },
  { 479, 6, 7, 6, 0, -7 },
  { 485, 6, 10, 6, 0, -7 },
  { 493, 6, 10, 6, 0, -7 },
  { 501, 5, 7, 4, 0, -7 },
  { 506, 5, 7, 5, 0, -7 },
  { 511, 3, 8, 4, 1, -8 },
  { 514, 5, 6, 6, 1, -6 },
  { 518, 5, 6, 5, 1, -6 },
  { 522, 7, 6, 8, 1, -6 },
  { 528, 6, 6, 5, 0, -6 },
  { 533, 7, 9, 5, -1, -6 },
  { 541, 5, 6, 5, 0, -6 },
  { 545, 5, 11, 4, 0, -9 },
  { 552, 1, 12, 6, 3, -9 },
  { 554, 5, 11, 4, -1, -9 },
  { 561, 5, 2, 6, 1, -5 },
};

const GFXfont NotoSans_SemiCondensed_Italic12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic12pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC12PT7B_H_
