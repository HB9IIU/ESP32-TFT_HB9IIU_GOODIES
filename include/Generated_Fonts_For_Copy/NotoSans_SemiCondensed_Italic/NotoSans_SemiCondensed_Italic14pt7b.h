#ifndef _NOTOSANS_SEMICONDENSED_ITALIC14PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x22, 0x64, 0x40, 0x4C, 0x5A, 0x95, 0x20, 0x0A, 0x12, 0x12,
  0x7F, 0x24, 0x24, 0xFE, 0x28, 0x48, 0x48, 0x08, 0x10, 0xF9, 0x47, 0x06,
  0x06, 0x0A, 0x15, 0xF0, 0x81, 0x00, 0x71, 0x29, 0x25, 0x12, 0x8A, 0xB7,
  0xA4, 0x52, 0x4A, 0x45, 0x63, 0x00, 0x1C, 0x26, 0x24, 0x2C, 0x10, 0x79,
  0x4A, 0x8E, 0xCC, 0x7A, 0x56, 0x18, 0x88, 0xC4, 0x21, 0x18, 0xC2, 0x10,
  0x80, 0x11, 0x11, 0x11, 0x11, 0x22, 0x4C, 0x10, 0x4F, 0x0F, 0x71, 0x20,
  0x20, 0x82, 0x3F, 0x20, 0x80, 0x2D, 0x40, 0xF0, 0x70, 0x02, 0x08, 0x30,
  0x41, 0x82, 0x08, 0x10, 0x41, 0x80, 0x39, 0x34, 0x61, 0x8E, 0x28, 0xA2,
  0x93, 0x80, 0x36, 0xA2, 0x26, 0x44, 0x4C, 0x3C, 0x4C, 0x18, 0x20, 0x41,
  0x04, 0x10, 0x41, 0xF8, 0x3C, 0x4C, 0x18, 0x23, 0x81, 0x01, 0x02, 0x8D,
  0xF0, 0x06, 0x18, 0x70, 0xA2, 0x49, 0xA2, 0xFE, 0x08, 0x30, 0x3E, 0x40,
  0x81, 0x07, 0x80, 0x81, 0x02, 0x8D, 0xF0, 0x1D, 0x84, 0x30, 0xFA, 0x28,
  0xA2, 0x9B, 0xC0, 0xFC, 0x10, 0x86, 0x10, 0xC2, 0x10, 0x42, 0x00, 0x1C,
  0x44, 0x89, 0x21, 0x8D, 0x11, 0x62, 0xC4, 0xF0, 0x3C, 0x49, 0x1A, 0x34,
  0x4F, 0x81, 0x06, 0x09, 0xE0, 0x2C, 0x00, 0x16, 0x13, 0x00, 0x00, 0x26,
  0x48, 0x0C, 0xCC, 0x30, 0x30, 0x30, 0xFC, 0x00, 0x3F, 0xC1, 0x81, 0x83,
  0x73, 0x00, 0xF0, 0xC6, 0x22, 0x21, 0x10, 0x84, 0x00, 0x1F, 0x10, 0xD0,
  0x33, 0xD9, 0x2D, 0x26, 0x93, 0x5A, 0x92, 0x40, 0x1F, 0x00, 0x06, 0x14,
  0x28, 0xD1, 0x26, 0x4F, 0xB1, 0x43, 0x84, 0x3E, 0x44, 0x89, 0x13, 0xCC,
  0x91, 0xA3, 0x45, 0xF0, 0x1E, 0xC1, 0x06, 0x08, 0x10, 0x20, 0x40, 0xC0,
  0xF0, 0x3E, 0x23, 0x21, 0x21, 0x21, 0x63, 0x42, 0x42, 0x4C, 0xF8, 0x3E,
  0x40, 0x81, 0x03, 0xCC, 0x10, 0x20, 0x41, 0xF0, 0x3E, 0x40, 0x81, 0x02,
  0x0F, 0x90, 0x20, 0x41, 0x80, 0x1F, 0x61, 0x40, 0xC0, 0x80, 0x8E, 0x86,
  0x84, 0xC4, 0x7C, 0x31, 0x90, 0x88, 0x44, 0x23, 0xF3, 0x11, 0x08, 0x84,
  0x42, 0x63, 0x00, 0x39, 0x88, 0x42, 0x11, 0x88, 0x47, 0x00, 0x0C, 0x20,
  0x82, 0x08, 0x61, 0x04, 0x10, 0xC2, 0x38, 0xC0, 0x33, 0x22, 0x24, 0x28,
  0x30, 0x78, 0x48, 0x48, 0x4C, 0xC4, 0x31, 0x08, 0x42, 0x31, 0x08, 0x47,
  0xC0, 0x30, 0x66, 0x1C, 0xC3, 0x18, 0xA2, 0x94, 0x94, 0x92, 0xB2, 0x64,
  0x4C, 0x99, 0x10, 0x30, 0x98, 0x4E, 0x65, 0x22, 0x92, 0x49, 0x14, 0x8C,
  0x46, 0x63, 0x00, 0x3E, 0x62, 0x43, 0xC3, 0x83, 0x82, 0x82, 0x86, 0xCC,
  0x78, 0x3C, 0x44, 0x89, 0x12, 0x6F, 0x90, 0x20, 0x41, 0x80, 0x3E, 0x62,
  0x43, 0xC3, 0x83, 0x82, 0x82, 0x86, 0xCC, 0x78, 0x18, 0x0C, 0x3C, 0x44,
  0x89, 0x12, 0x6F, 0x12, 0x24, 0x45, 0x88, 0x3E, 0x41, 0x83, 0x03, 0x03,
  0x03, 0x06, 0x89, 0xE0, 0xFC, 0xC2, 0x08, 0x20, 0x86, 0x10, 0x41, 0x00,
  0x63, 0x42, 0x42, 0x42, 0xC6, 0x84, 0x84, 0x84, 0x8C, 0x78, 0x83, 0x8B,
  0x12, 0x44, 0x8A, 0x14, 0x38, 0x60, 0xC0, 0xC4, 0x38, 0x8B, 0x31, 0x66,
  0x6D, 0x49, 0xA9, 0x19, 0x43, 0x28, 0x66, 0x08, 0xC0, 0x11, 0x89, 0x84,
  0x81, 0x80, 0xC0, 0xC0, 0x50, 0x48, 0x64, 0x63, 0x00, 0xC6, 0x99, 0x22,
  0x85, 0x0C, 0x18, 0x20, 0x40, 0x80, 0x3E, 0x0C, 0x30, 0x41, 0x06, 0x08,
  0x20, 0xC1, 0xF0, 0x39, 0x08, 0x46, 0x21, 0x08, 0x44, 0x21, 0xC0, 0xC9,
  0x24, 0x91, 0x24, 0x38, 0x42, 0x31, 0x08, 0x42, 0x21, 0x09, 0xC0, 0x10,
  0x30, 0xA1, 0x24, 0x58, 0x40, 0xF8, 0x94, 0x35, 0xBC, 0xE2, 0x8A, 0x29,
  0xBA, 0x30, 0x40, 0x81, 0x63, 0x6C, 0x51, 0xA3, 0x44, 0x9A, 0xE0, 0x33,
  0x71, 0x08, 0x42, 0x1E, 0x02, 0x08, 0x11, 0xA6, 0xD9, 0xA2, 0x44, 0x89,
  0x33, 0xE0, 0x32, 0x63, 0x3E, 0x42, 0x1E, 0x07, 0x04, 0x08, 0x0E, 0x18,
  0x08, 0x18, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0xE0, 0x1A, 0x6D, 0x9A,
  0x24, 0x48, 0x93, 0x3E, 0x08, 0x13, 0xC0, 0x30, 0x40, 0x81, 0x63, 0x6C,
  0xD1, 0x22, 0x44, 0x8B, 0x30, 0x30, 0x22, 0x64, 0x44, 0x4C, 0x0C, 0x00,
  0x82, 0x18, 0x41, 0x04, 0x10, 0xC2, 0x08, 0xE0, 0x30, 0x40, 0x81, 0x32,
  0xCD, 0x14, 0x38, 0x58, 0x93, 0x20, 0x32, 0x22, 0x26, 0x44, 0x44, 0xC0,
  0x2C, 0x8D, 0x56, 0x65, 0x11, 0x44, 0x51, 0x34, 0xCB, 0x22, 0x2C, 0x6D,
  0x9A, 0x24, 0x48, 0x91, 0x66, 0x31, 0x28, 0xA3, 0x8A, 0x29, 0xBC, 0x2C,
  0x6D, 0x8A, 0x34, 0x68, 0x93, 0x7C, 0x81, 0x02, 0x00, 0x35, 0xBC, 0xE2,
  0x8A, 0x29, 0xBE, 0x10, 0x41, 0x00, 0x29, 0xD8, 0x84, 0x21, 0x18, 0x33,
  0x50, 0xC3, 0x0C, 0x5E, 0x4F, 0x4C, 0x88, 0x88, 0xC0, 0x45, 0x1C, 0xE2,
  0x8A, 0x29, 0xBC, 0x8E, 0x29, 0xA4, 0xB2, 0x8E, 0x30, 0x88, 0xCC, 0xA6,
  0x55, 0x4A, 0xA6, 0x73, 0x31, 0x98, 0x22, 0x6C, 0x50, 0xC1, 0x87, 0x0A,
  0x62, 0x23, 0x22, 0x26, 0x24, 0x2C, 0x28, 0x38, 0x30, 0x30, 0x20, 0xC0,
  0x7C, 0x21, 0x84, 0x21, 0x0C, 0x3C, 0x0C, 0x41, 0x0C, 0x21, 0x8C, 0x08,
  0x41, 0x04, 0x18, 0xFF, 0xFC, 0x10, 0x20, 0x84, 0x10, 0x71, 0x84, 0x20,
  0x82, 0x38, 0xE6, 0x70,
};

const GFXglyph NotoSans_SemiCondensed_Italic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 10, 4, 0, -10 },
  { 6, 5, 4, 5, 1, -10 },
  { 9, 8, 10, 8, 0, -10 },
  { 19, 7, 12, 7, 0, -11 },
  { 30, 9, 10, 10, 1, -10 },
  { 42, 8, 10, 8, 0, -10 },
  { 52, 2, 4, 3, 1, -10 },
  { 53, 5, 12, 4, 0, -10 },
  { 61, 4, 12, 4, -1, -10 },
  { 67, 6, 6, 7, 1, -11 },
  { 72, 6, 6, 7, 1, -8 },
  { 77, 3, 4, 3, -1, -2 },
  { 79, 4, 1, 4, 0, -4 },
  { 80, 2, 2, 3, 0, -2 },
  { 81, 7, 10, 5, -1, -10 },
  { 90, 6, 10, 7, 1, -10 },
  { 98, 4, 10, 7, 2, -10 },
  { 103, 7, 10, 7, 0, -10 },
  { 112, 7, 10, 7, 0, -10 },
  { 121, 7, 10, 7, 0, -10 },
  { 130, 7, 10, 7, 0, -10 },
  { 139, 6, 10, 7, 1, -10 },
  { 147, 6, 10, 7, 1, -10 },
  { 155, 7, 10, 7, 0, -10 },
  { 164, 7, 10, 7, 0, -10 },
  { 173, 3, 8, 3, 0, -8 },
  { 176, 4, 10, 3, -1, -8 },
  { 181, 6, 6, 7, 1, -8 },
  { 186, 6, 4, 7, 1, -7 },
  { 189, 6, 6, 7, 1, -8 },
  { 194, 5, 10, 5, 1, -10 },
  { 201, 9, 11, 11, 1, -10 },
  { 214, 7, 10, 7, -1, -10 },
  { 223, 7, 10, 8, 0, -10 },
  { 232, 7, 10, 7, 1, -10 },
  { 241, 8, 10, 8, 0, -10 },
  { 251, 7, 10, 6, 0, -10 },
  { 260, 7, 10, 6, 0, -10 },
  { 269, 8, 10, 9, 1, -10 },
  { 279, 9, 10, 9, 0, -10 },
  { 291, 5, 10, 4, 0, -10 },
  { 298, 6, 13, 3, -2, -10 },
  { 308, 8, 10, 7, 0, -10 },
  { 318, 5, 10, 6, 0, -10 },
  { 325, 11, 10, 11, 0, -10 },
  { 339, 9, 10, 9, 0, -10 },
  { 351, 8, 10, 9, 1, -10 },
  { 361, 7, 10, 7, 0, -10 },
  { 370, 8, 12, 9, 1, -10 },
  { 382, 7, 10, 7, 0, -10 },
  { 391, 7, 10, 6, 0, -10 },
  { 400, 6, 10, 6, 1, -10 },
  { 408, 8, 10, 8, 1, -10 },
  { 418, 7, 10, 7, 1, -10 },
  { 427, 11, 10, 11, 1, -10 },
  { 441, 9, 10, 7, -1, -10 },
  { 453, 7, 10, 6, 1, -10 },
  { 462, 7, 10, 6, 0, -10 },
  { 471, 5, 12, 4, 0, -10 },
  { 479, 3, 10, 5, 1, -10 },
  { 483, 5, 12, 4, -1, -10 },
  { 491, 7, 6, 7, 0, -10 },
  { 497, 5, 1, 5, -1, 1 },
  { 498, 2, 3, 4, 2, -11 },
  { 499, 6, 8, 7, 1, -8 },
  { 505, 7, 11, 7, 0, -11 },
  { 515, 5, 8, 6, 1, -8 },
  { 520, 7, 11, 7, 1, -11 },
  { 530, 5, 8, 6, 1, -8 },
  { 535, 8, 14, 4, -2, -11 },
  { 549, 7, 11, 7, 0, -8 },
  { 559, 7, 11, 7, 0, -11 },
  { 569, 4, 10, 3, 0, -10 },
  { 574, 6, 13, 3, -2, -10 },
  { 584, 7, 11, 6, 0, -11 },
  { 594, 4, 11, 3, 0, -11 },
  { 600, 10, 8, 11, 0, -8 },
  { 610, 7, 8, 7, 0, -8 },
  { 617, 6, 8, 7, 1, -8 },
  { 623, 7, 11, 7, 0, -8 },
  { 633, 6, 11, 7, 1, -8 },
  { 642, 5, 8, 5, 0, -8 },
  { 647, 5, 8, 5, 0, -8 },
  { 652, 4, 9, 4, 1, -9 },
  { 657, 6, 8, 7, 1, -8 },
  { 663, 6, 8, 6, 1, -8 },
  { 669, 9, 8, 9, 1, -8 },
  { 678, 7, 8, 6, -1, -8 },
  { 685, 8, 11, 6, -1, -8 },
  { 696, 6, 8, 5, 0, -8 },
  { 702, 6, 12, 5, 0, -10 },
  { 711, 1, 14, 7, 3, -11 },
  { 713, 6, 12, 5, -1, -10 },
  { 722, 6, 2, 7, 1, -6 },
};

const GFXfont NotoSans_SemiCondensed_Italic14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic14pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC14PT7B_H_
