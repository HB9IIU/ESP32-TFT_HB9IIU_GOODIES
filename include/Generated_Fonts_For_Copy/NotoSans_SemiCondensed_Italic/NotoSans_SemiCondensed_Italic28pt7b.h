#ifndef _NOTOSANS_SEMICONDENSED_ITALIC28PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x1C, 0x38, 0x70, 0xC1, 0x87, 0x0E, 0x18, 0x30, 0x60, 0xC3,
  0x06, 0x00, 0x00, 0x00, 0xE3, 0xC3, 0x00, 0x73, 0x67, 0x67, 0xE6, 0xC6,
  0xC6, 0xC4, 0x01, 0x8C, 0x06, 0x10, 0x0C, 0x60, 0x18, 0xC0, 0x61, 0x80,
  0xC6, 0x1F, 0xFF, 0xBF, 0xFF, 0x0C, 0x60, 0x18, 0xC0, 0x21, 0x80, 0xC2,
  0x0F, 0xFF, 0x9F, 0xFF, 0x0C, 0x30, 0x18, 0xC0, 0x31, 0x80, 0xC3, 0x01,
  0x8C, 0x03, 0x18, 0x00, 0x00, 0x80, 0x0C, 0x01, 0xF8, 0x1F, 0xF1, 0xD3,
  0x1C, 0x80, 0xCC, 0x06, 0x60, 0x3B, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x7C, 0x02, 0x70, 0x13, 0x81, 0x9C, 0x8C, 0xC7, 0x7E, 0x3F, 0xE0, 0x38,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x1E, 0x03, 0x1F, 0x83, 0x18, 0xC3,
  0x8C, 0x61, 0x8C, 0x31, 0x86, 0x18, 0xC3, 0x0C, 0xC1, 0x8C, 0xC0, 0xC6,
  0x6F, 0x66, 0x6F, 0xFF, 0x66, 0x6F, 0x36, 0x30, 0x33, 0x18, 0x31, 0x8C,
  0x19, 0x86, 0x18, 0xC3, 0x18, 0x63, 0x0C, 0x31, 0x8C, 0x0F, 0x8C, 0x07,
  0x80, 0x03, 0xF0, 0x07, 0xF8, 0x06, 0x18, 0x0E, 0x18, 0x0E, 0x18, 0x0E,
  0x38, 0x0E, 0x70, 0x06, 0xE0, 0x07, 0xC0, 0x07, 0x00, 0x1F, 0x81, 0x39,
  0x86, 0x71, 0xC6, 0x60, 0xEC, 0x60, 0x7C, 0xE0, 0x78, 0x60, 0x70, 0x70,
  0xF8, 0x7F, 0xDC, 0x3F, 0x1E, 0x76, 0x66, 0xCC, 0xC0, 0x03, 0x83, 0x81,
  0x81, 0x81, 0xC0, 0xC0, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x1C, 0x0E, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x03, 0x01, 0x80, 0xE0,
  0x06, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1C, 0x0E, 0x03, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x30, 0x18, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x03, 0x81, 0x81,
  0x81, 0xC1, 0xC0, 0x07, 0x00, 0xC2, 0x18, 0x73, 0x0F, 0xCE, 0x1F, 0xC7,
  0x81, 0xB0, 0x73, 0x0C, 0x60, 0x8E, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x39, 0x9C, 0xC6, 0x63, 0x00, 0xFF, 0xFF, 0xC0,
  0x7F, 0x60, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E,
  0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x00, 0x07,
  0xE0, 0xFF, 0x1C, 0x71, 0x83, 0x38, 0x33, 0x03, 0x70, 0x37, 0x03, 0x60,
  0x36, 0x03, 0x60, 0x3E, 0x07, 0xE0, 0x7E, 0x06, 0xE0, 0xEE, 0x0C, 0xE1,
  0xC6, 0x38, 0x7F, 0x83, 0xE0, 0x07, 0x1E, 0x3E, 0xFE, 0xEE, 0x8C, 0x0C,
  0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30, 0x30, 0x70, 0x70,
  0x60, 0x07, 0xF0, 0xFF, 0xC3, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x07, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x07, 0xF0,
  0xFF, 0xC3, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x0E, 0x01,
  0xE0, 0x7C, 0x03, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x64, 0x07, 0x3F, 0xF0, 0xFF, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x1E,
  0x01, 0xB0, 0x1B, 0x01, 0xD8, 0x0C, 0xC0, 0xCE, 0x0C, 0x70, 0xE3, 0x06,
  0x18, 0x60, 0xC6, 0x0E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x0E,
  0x00, 0x60, 0x03, 0x00, 0x0F, 0xF8, 0x7F, 0x83, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0xE0, 0x06, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x38, 0x01, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC4, 0x1E, 0x3F, 0xE1, 0xFC,
  0x00, 0x01, 0xF8, 0x3F, 0xC3, 0xC0, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xC0,
  0x06, 0x20, 0x7F, 0xC3, 0xEF, 0x1C, 0x18, 0xC0, 0xEE, 0x07, 0x70, 0x33,
  0x81, 0x9C, 0x0C, 0x60, 0xE3, 0x8E, 0x1F, 0xE0, 0x7E, 0x00, 0x7F, 0xF7,
  0xFF, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80,
  0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07,
  0x00, 0x60, 0x0E, 0x00, 0x07, 0xE0, 0x7F, 0x87, 0x0E, 0x30, 0x71, 0x83,
  0x8C, 0x1C, 0x60, 0xC3, 0x8C, 0x0F, 0xC0, 0x78, 0x07, 0xE0, 0xE3, 0x86,
  0x0E, 0x70, 0x33, 0x01, 0x98, 0x0C, 0xC0, 0xE7, 0x06, 0x1F, 0xF0, 0x7E,
  0x00, 0x07, 0xC1, 0xFE, 0x18, 0x73, 0x83, 0x30, 0x37, 0x03, 0x70, 0x36,
  0x03, 0x70, 0x77, 0x0F, 0x3B, 0xF3, 0xF6, 0x0C, 0x60, 0x0E, 0x00, 0xC0,
  0x1C, 0x01, 0x80, 0x78, 0xFF, 0x0F, 0xC0, 0x1C, 0x71, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x73, 0xCE, 0x00, 0x0E, 0x1C, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x86, 0x1C, 0x30, 0x61, 0x83, 0x00,
  0x00, 0x10, 0x07, 0x01, 0xF0, 0x7C, 0x0F, 0x03, 0xC0, 0xF0, 0x0E, 0x00,
  0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x00, 0xC0, 0x08, 0x00, 0x3F, 0x3F, 0xD0, 0x60, 0x30, 0x18,
  0x0C, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x06, 0x06, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x38, 0x18, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x1C, 0x07,
  0x07, 0x00, 0x71, 0xC0, 0x06, 0x30, 0x60, 0xCC, 0x3F, 0x99, 0x8E, 0x61,
  0x63, 0x8C, 0x2C, 0x61, 0x8D, 0x98, 0x31, 0xE3, 0x0C, 0x3C, 0x61, 0x87,
  0x8C, 0x31, 0xB1, 0x8E, 0x76, 0x3F, 0x7C, 0xC3, 0xCF, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0xC3, 0x80, 0x1F, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x66, 0x00,
  0xCE, 0x03, 0x1C, 0x06, 0x38, 0x1C, 0x30, 0x30, 0x60, 0xFF, 0xC1, 0xFF,
  0x87, 0x03, 0x0C, 0x06, 0x38, 0x0C, 0x60, 0x19, 0xC0, 0x37, 0x00, 0x70,
  0x0F, 0xE0, 0x3F, 0xE1, 0xC3, 0xC7, 0x07, 0x18, 0x1C, 0x60, 0x71, 0x81,
  0xCE, 0x0E, 0x39, 0xF0, 0xFF, 0x03, 0xFE, 0x0C, 0x1C, 0x70, 0x31, 0xC0,
  0xE6, 0x03, 0x18, 0x0C, 0xE0, 0x73, 0x83, 0x8F, 0xFC, 0x3F, 0xC0, 0x03,
  0xF8, 0x1F, 0xF1, 0xE0, 0x87, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0xE0, 0x01, 0xC1, 0x07, 0xFC, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xF0, 0x70, 0xF0, 0xE0, 0xE1, 0x80, 0xE3, 0x01, 0xC6, 0x03, 0x9C,
  0x07, 0x38, 0x0E, 0x60, 0x1C, 0xC0, 0x39, 0x80, 0x67, 0x01, 0xCE, 0x03,
  0x98, 0x0E, 0x30, 0x1C, 0xE0, 0x71, 0xC3, 0xC3, 0xFF, 0x07, 0xF0, 0x00,
  0x0F, 0xF8, 0x7F, 0xC7, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07,
  0x00, 0x3F, 0xE1, 0xFF, 0x0F, 0xF0, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80,
  0x0C, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x0F, 0xF8, 0x7F,
  0xC7, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01,
  0xFF, 0x0F, 0xF0, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0,
  0x07, 0x00, 0x30, 0x01, 0x80, 0x00, 0x03, 0xFC, 0x0F, 0xFC, 0x78, 0x10,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC1,
  0xFB, 0x03, 0xF6, 0x07, 0xCC, 0x01, 0x98, 0x03, 0x30, 0x0E, 0x70, 0x1C,
  0xE0, 0x30, 0xE0, 0x61, 0xFF, 0xC0, 0xFF, 0x00, 0x0C, 0x03, 0x0C, 0x03,
  0x1C, 0x07, 0x1C, 0x07, 0x18, 0x06, 0x18, 0x06, 0x18, 0x06, 0x38, 0x0E,
  0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x30, 0x1C, 0x70, 0x1C, 0x70, 0x18,
  0x60, 0x18, 0x60, 0x18, 0xE0, 0x38, 0xE0, 0x38, 0xC0, 0x30, 0xC0, 0x30,
  0x0F, 0xE0, 0xF8, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x06,
  0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x03,
  0x01, 0xF8, 0x7F, 0x00, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01,
  0x80, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00,
  0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x07, 0x07,
  0xE0, 0xF8, 0x00, 0x0C, 0x0F, 0x0C, 0x1C, 0x1C, 0x18, 0x1C, 0x38, 0x18,
  0x70, 0x18, 0xE0, 0x19, 0xC0, 0x3B, 0x80, 0x3F, 0x00, 0x37, 0x00, 0x3F,
  0x00, 0x3B, 0x80, 0x73, 0x80, 0x71, 0x80, 0x61, 0xC0, 0x61, 0xC0, 0xE0,
  0xC0, 0xE0, 0xE0, 0xC0, 0xE0, 0xC0, 0x70, 0x0C, 0x06, 0x07, 0x03, 0x81,
  0x80, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x01, 0x80,
  0xC0, 0xE0, 0x70, 0x3F, 0xFF, 0xF0, 0x0E, 0x00, 0x78, 0x70, 0x07, 0xC7,
  0xC0, 0x3C, 0x36, 0x03, 0xE1, 0xB0, 0x1B, 0x0D, 0x81, 0xF8, 0x6C, 0x0D,
  0x87, 0x60, 0xEC, 0x33, 0x06, 0x61, 0x98, 0x77, 0x0C, 0xC3, 0x38, 0xE6,
  0x39, 0x87, 0x31, 0x8C, 0x31, 0xDC, 0x61, 0x86, 0xC7, 0x0C, 0x3C, 0x38,
  0xE1, 0xE1, 0x87, 0x0E, 0x0C, 0x30, 0x70, 0x61, 0x83, 0x07, 0x00, 0x0E,
  0x01, 0x87, 0x01, 0xC7, 0x80, 0xE3, 0xE0, 0x61, 0xB0, 0x30, 0xD8, 0x18,
  0x6E, 0x1C, 0x73, 0x0E, 0x31, 0x86, 0x18, 0xC3, 0x0C, 0x71, 0x8E, 0x19,
  0xC7, 0x0C, 0xC3, 0x07, 0x61, 0x81, 0xB0, 0xC0, 0xD8, 0xE0, 0x7C, 0x70,
  0x3C, 0x30, 0x0E, 0x18, 0x07, 0x00, 0x03, 0xF0, 0x1F, 0xF8, 0x78, 0x71,
  0xC0, 0x73, 0x80, 0xEE, 0x00, 0xDC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xD8, 0x03, 0xB0, 0x07, 0x60, 0x1C,
  0xE0, 0x78, 0xE1, 0xE1, 0xFF, 0x80, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x87,
  0x0E, 0x38, 0x31, 0x81, 0x8C, 0x0C, 0x60, 0x67, 0x07, 0x38, 0x39, 0x83,
  0x8F, 0xF8, 0x7F, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07,
  0x00, 0x30, 0x01, 0x80, 0x00, 0x03, 0xF0, 0x1F, 0xF8, 0x78, 0x71, 0xC0,
  0x73, 0x80, 0xEE, 0x00, 0xDC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xD8, 0x03, 0xB0, 0x07, 0x60, 0x1C, 0xE0,
  0x70, 0xE1, 0xE1, 0xFF, 0x80, 0xFC, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xF0, 0x0F, 0xE0, 0x7F, 0x87, 0x0E, 0x38, 0x31, 0x81,
  0x8C, 0x0C, 0x60, 0x67, 0x07, 0x38, 0x39, 0x8F, 0x8F, 0xF0, 0x7F, 0x07,
  0x18, 0x38, 0xC1, 0x87, 0x0C, 0x18, 0xE0, 0xC7, 0x07, 0x30, 0x39, 0x80,
  0xE0, 0x03, 0xF8, 0x7F, 0xC7, 0x86, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0xE4, 0x0E, 0x3F, 0xF1, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x81, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00,
  0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x00, 0x18, 0x06, 0x70, 0x0C, 0xE0,
  0x39, 0x80, 0x73, 0x00, 0xC6, 0x01, 0x9C, 0x03, 0x38, 0x0E, 0x60, 0x1C,
  0xC0, 0x31, 0x80, 0x67, 0x01, 0xCC, 0x03, 0x98, 0x06, 0x30, 0x0C, 0x60,
  0x38, 0xC0, 0x61, 0xC1, 0xC1, 0xFF, 0x01, 0xFC, 0x00, 0xC0, 0x1E, 0x01,
  0xF0, 0x0D, 0x80, 0xEC, 0x06, 0x60, 0x73, 0x03, 0x18, 0x38, 0xC1, 0x86,
  0x1C, 0x38, 0xC1, 0xCE, 0x0E, 0x60, 0x77, 0x01, 0xB0, 0x0F, 0x80, 0x78,
  0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x00, 0xC0, 0x70, 0x3E, 0x03, 0x81, 0xF0,
  0x3C, 0x0D, 0x81, 0xE0, 0xEC, 0x1B, 0x06, 0x60, 0xD8, 0x73, 0x0E, 0xC3,
  0x18, 0x66, 0x18, 0xC3, 0x31, 0xC6, 0x31, 0x8C, 0x31, 0x8C, 0xE1, 0x98,
  0x66, 0x0C, 0xC3, 0x70, 0x6E, 0x1B, 0x03, 0x60, 0xD8, 0x1B, 0x07, 0xC0,
  0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x00, 0x07,
  0x03, 0x81, 0x81, 0x80, 0xC1, 0xC0, 0x61, 0xC0, 0x38, 0xC0, 0x0C, 0xC0,
  0x06, 0xE0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x36, 0x00, 0x3B, 0x80, 0x38, 0xC0, 0x18, 0x60, 0x18, 0x30, 0x1C,
  0x1C, 0x1C, 0x06, 0x1C, 0x03, 0x00, 0xE0, 0x3B, 0x01, 0x98, 0x1C, 0xE1,
  0xC7, 0x0C, 0x18, 0xE0, 0xC6, 0x06, 0x70, 0x37, 0x01, 0xF0, 0x07, 0x80,
  0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C,
  0x00, 0xE0, 0x00, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x30, 0x00, 0xE0, 0x03,
  0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x07, 0xC3, 0xF0, 0xC0, 0x30, 0x0C, 0x03,
  0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x01,
  0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0xE0, 0xC6,
  0x31, 0xC6, 0x31, 0x8C, 0x63, 0x1C, 0x63, 0x18, 0xC6, 0x31, 0xC6, 0x30,
  0x07, 0xE0, 0xF8, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00,
  0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x07, 0xE0, 0x03, 0x00, 0x38,
  0x01, 0xC0, 0x1B, 0x00, 0xD8, 0x0C, 0x60, 0x63, 0x06, 0x0C, 0x70, 0x63,
  0x03, 0x38, 0x0D, 0x80, 0x70, 0x7F, 0xFF, 0xFC, 0xE6, 0x33, 0x0F, 0x98,
  0xFE, 0xCE, 0x1E, 0x60, 0xE7, 0x03, 0x30, 0x39, 0x81, 0xDC, 0x0C, 0xE0,
  0x67, 0x07, 0x38, 0x39, 0xC3, 0xCE, 0x3C, 0x3F, 0x60, 0xF3, 0x00, 0x06,
  0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x37, 0xC3, 0xFF,
  0x1E, 0x18, 0xE0, 0xC7, 0x06, 0x70, 0x33, 0x81, 0x98, 0x0C, 0xC0, 0xE6,
  0x07, 0x70, 0x33, 0x83, 0x9E, 0x38, 0xDF, 0x8E, 0xF8, 0x00, 0x07, 0xE3,
  0xF8, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x08, 0xFE, 0x0F, 0xC0, 0x00, 0x0C, 0x00, 0x30, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0xF9, 0x87, 0xFE, 0x38, 0x78, 0xC1,
  0xC7, 0x03, 0x18, 0x1C, 0x60, 0x73, 0x81, 0x8E, 0x06, 0x38, 0x38, 0xE0,
  0xE3, 0x87, 0x8E, 0x3C, 0x1F, 0xB0, 0x7C, 0xC0, 0x0F, 0xC3, 0xFC, 0xE1,
  0x98, 0x37, 0x0E, 0xC1, 0x9F, 0xF7, 0xF8, 0xE0, 0x18, 0x03, 0x00, 0x70,
  0x06, 0x08, 0xFF, 0x0F, 0xE0, 0x00, 0x7C, 0x03, 0xF0, 0x0C, 0x00, 0x30,
  0x01, 0xC0, 0x06, 0x00, 0x7F, 0x03, 0xFC, 0x03, 0x80, 0x0E, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x18,
  0x02, 0xE0, 0x0F, 0x00, 0x38, 0x00, 0x07, 0xCC, 0x3F, 0xB1, 0xC3, 0xC6,
  0x0E, 0x38, 0x38, 0xC0, 0xE3, 0x03, 0x9C, 0x0C, 0x70, 0x31, 0xC1, 0xC7,
  0x07, 0x1C, 0x3C, 0x71, 0xE0, 0xFD, 0x83, 0xE6, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x00, 0x1C, 0x38, 0xE0, 0xFF, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x30,
  0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x37, 0xC3, 0xFF, 0x1E, 0x38,
  0xE0, 0xC7, 0x06, 0x30, 0x33, 0x83, 0x98, 0x1C, 0xC0, 0xC6, 0x06, 0x70,
  0x73, 0x83, 0x98, 0x18, 0xC0, 0xCE, 0x06, 0x00, 0x04, 0x1C, 0x38, 0x20,
  0x00, 0x03, 0x0E, 0x18, 0x30, 0x61, 0xC3, 0x86, 0x0C, 0x18, 0x70, 0xE1,
  0x83, 0x0E, 0x00, 0x00, 0x40, 0x1C, 0x03, 0x80, 0x20, 0x00, 0x00, 0x00,
  0x30, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0,
  0x18, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60,
  0x0C, 0x13, 0x83, 0xE0, 0x70, 0x00, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0xE3, 0x8E, 0x18, 0xE0, 0xC6, 0x06, 0x60,
  0x76, 0x03, 0xF0, 0x1F, 0x80, 0xEE, 0x06, 0x70, 0x71, 0x83, 0x8E, 0x18,
  0x70, 0xC1, 0x8E, 0x0E, 0x00, 0x06, 0x0C, 0x38, 0x70, 0xC1, 0x83, 0x0E,
  0x18, 0x30, 0x61, 0xC3, 0x86, 0x0C, 0x18, 0x70, 0xE1, 0x83, 0x0E, 0x00,
  0x0D, 0xF1, 0xF0, 0xDF, 0x9F, 0x87, 0x8F, 0x8E, 0x38, 0x78, 0x71, 0x83,
  0x83, 0x1C, 0x1C, 0x18, 0xE0, 0xC0, 0xC6, 0x06, 0x0E, 0x30, 0x30, 0x71,
  0x83, 0x83, 0x1C, 0x1C, 0x18, 0xE0, 0xC0, 0xC6, 0x06, 0x0E, 0x30, 0x30,
  0x73, 0x83, 0x83, 0x00, 0x1D, 0xF0, 0xDF, 0xC7, 0x86, 0x38, 0x31, 0xC1,
  0x9C, 0x1C, 0xE0, 0xE6, 0x07, 0x30, 0x31, 0x81, 0x9C, 0x1C, 0xE0, 0xE6,
  0x06, 0x30, 0x33, 0x83, 0x80, 0x0F, 0xC1, 0xFE, 0x38, 0x73, 0x07, 0x70,
  0x36, 0x03, 0x60, 0x3E, 0x07, 0xE0, 0x7E, 0x06, 0xE0, 0xEE, 0x0E, 0x61,
  0xC7, 0xF8, 0x3F, 0x00, 0x06, 0xF8, 0x37, 0xF0, 0xF0, 0xC3, 0x83, 0x0E,
  0x0C, 0x30, 0x31, 0xC0, 0xC6, 0x03, 0x18, 0x1C, 0x60, 0x73, 0x81, 0x8E,
  0x0E, 0x3C, 0x70, 0xDF, 0x83, 0x7C, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x0F, 0x98, 0xFE, 0xCE, 0x1E,
  0x60, 0xE7, 0x07, 0x30, 0x39, 0x81, 0xDC, 0x0C, 0xE0, 0x67, 0x07, 0x38,
  0x39, 0xC3, 0xCE, 0x3C, 0x3F, 0x61, 0xF3, 0x00, 0x38, 0x01, 0xC0, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0D, 0xE3, 0x7C, 0x78, 0x0E,
  0x01, 0xC0, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x06,
  0x00, 0xC0, 0x38, 0x00, 0x0F, 0xE3, 0xF8, 0xE1, 0x18, 0x03, 0x00, 0x70,
  0x07, 0x00, 0x78, 0x07, 0x80, 0x70, 0x06, 0x00, 0xC8, 0x39, 0xFE, 0x3F,
  0x80, 0x0C, 0x18, 0x18, 0x7F, 0xFF, 0x38, 0x30, 0x30, 0x30, 0x70, 0x60,
  0x60, 0x60, 0xE0, 0xE0, 0xE0, 0xFC, 0x7C, 0x38, 0x19, 0xC1, 0xCC, 0x0C,
  0x60, 0x63, 0x03, 0x38, 0x39, 0xC1, 0xCC, 0x0C, 0x60, 0x63, 0x07, 0x38,
  0x39, 0xC3, 0xCE, 0x3C, 0x3F, 0x61, 0xF3, 0x00, 0x60, 0x76, 0x06, 0x60,
  0xE6, 0x0C, 0x61, 0xC6, 0x18, 0x63, 0x86, 0x30, 0x67, 0x06, 0x60, 0x6E,
  0x06, 0xC0, 0x6C, 0x03, 0x80, 0x38, 0x00, 0xC1, 0xC1, 0xF0, 0x70, 0xEC,
  0x3C, 0x33, 0x0F, 0x0C, 0xC6, 0xC7, 0x31, 0xB1, 0x8C, 0xCC, 0xE3, 0x33,
  0x30, 0xDC, 0xCC, 0x36, 0x36, 0x0D, 0x8D, 0x83, 0xC3, 0xE0, 0xF0, 0xF0,
  0x38, 0x3C, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x30, 0xE0, 0xC7, 0x03, 0x98,
  0x06, 0xE0, 0x1F, 0x00, 0x78, 0x00, 0xC0, 0x07, 0x80, 0x36, 0x01, 0xD8,
  0x06, 0x70, 0x30, 0xC1, 0xC3, 0x8E, 0x0E, 0x00, 0x06, 0x07, 0x06, 0x06,
  0x06, 0x0E, 0x06, 0x0C, 0x06, 0x1C, 0x06, 0x18, 0x06, 0x38, 0x06, 0x30,
  0x07, 0x70, 0x07, 0x60, 0x03, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x9C, 0x00,
  0xF8, 0x00, 0x60, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0xC0,
  0x38, 0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x07,
  0xFC, 0xFF, 0x80, 0x00, 0xE0, 0x3C, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x01, 0x80, 0x70, 0x3C, 0x0F, 0x00, 0x70, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0F, 0x00, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x03, 0xC0, 0x38, 0x0E,
  0x03, 0x80, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x30, 0x0F, 0x01, 0xC1,
  0xC0, 0xE0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x0F, 0x03,
  0xC0, 0x30, 0x1F, 0xE3, 0xCF, 0xF8, 0x3E,
};

const GFXglyph NotoSans_SemiCondensed_Italic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 7, 20, 7, 0, -20 },
  { 19, 8, 7, 10, 3, -20 },
  { 26, 15, 20, 16, 1, -20 },
  { 64, 13, 23, 14, 1, -21 },
  { 102, 17, 20, 20, 2, -20 },
  { 145, 16, 20, 16, 0, -20 },
  { 185, 4, 7, 6, 3, -20 },
  { 189, 9, 24, 8, 1, -20 },
  { 216, 9, 24, 8, -2, -20 },
  { 243, 11, 11, 13, 3, -21 },
  { 259, 12, 14, 15, 2, -17 },
  { 280, 5, 7, 7, -1, -3 },
  { 285, 6, 3, 8, 1, -9 },
  { 288, 4, 3, 7, 0, -3 },
  { 290, 13, 20, 10, -1, -20 },
  { 323, 12, 20, 14, 1, -20 },
  { 353, 8, 20, 14, 4, -20 },
  { 373, 13, 20, 14, 0, -20 },
  { 406, 13, 20, 14, 0, -20 },
  { 439, 13, 20, 14, 0, -20 },
  { 472, 13, 20, 14, 1, -20 },
  { 505, 13, 20, 14, 1, -20 },
  { 538, 12, 20, 14, 2, -20 },
  { 568, 13, 20, 14, 1, -20 },
  { 601, 12, 20, 14, 1, -20 },
  { 631, 6, 15, 7, 0, -15 },
  { 643, 7, 19, 7, -1, -15 },
  { 660, 12, 14, 15, 2, -17 },
  { 681, 12, 8, 15, 2, -14 },
  { 693, 12, 14, 15, 2, -17 },
  { 714, 9, 20, 11, 2, -20 },
  { 737, 19, 22, 21, 1, -20 },
  { 790, 15, 20, 14, -2, -20 },
  { 828, 14, 20, 15, 1, -20 },
  { 863, 14, 20, 14, 2, -20 },
  { 898, 15, 20, 17, 1, -20 },
  { 936, 13, 20, 13, 1, -20 },
  { 969, 13, 20, 12, 1, -20 },
  { 1002, 15, 20, 17, 2, -20 },
  { 1040, 16, 20, 17, 1, -20 },
  { 1080, 11, 20, 8, -1, -20 },
  { 1108, 11, 25, 7, -4, -20 },
  { 1143, 16, 20, 14, 1, -20 },
  { 1183, 9, 20, 12, 1, -20 },
  { 1206, 21, 20, 22, 1, -20 },
  { 1259, 17, 20, 18, 1, -20 },
  { 1302, 15, 20, 18, 2, -20 },
  { 1340, 13, 20, 14, 1, -20 },
  { 1373, 15, 25, 18, 2, -20 },
  { 1420, 13, 20, 14, 1, -20 },
  { 1453, 13, 20, 13, 0, -20 },
  { 1486, 13, 20, 12, 2, -20 },
  { 1519, 15, 20, 17, 2, -20 },
  { 1557, 13, 20, 14, 3, -20 },
  { 1590, 21, 20, 22, 3, -20 },
  { 1643, 17, 20, 13, -2, -20 },
  { 1686, 13, 20, 13, 2, -20 },
  { 1719, 15, 20, 13, -1, -20 },
  { 1757, 10, 24, 8, 0, -20 },
  { 1787, 5, 20, 10, 3, -20 },
  { 1800, 11, 24, 8, -2, -20 },
  { 1833, 13, 12, 14, 1, -20 },
  { 1853, 11, 2, 10, -3, 2 },
  { 1856, 4, 4, 7, 4, -21 },
  { 1858, 13, 15, 14, 1, -15 },
  { 1883, 13, 21, 15, 0, -21 },
  { 1918, 11, 15, 11, 1, -15 },
  { 1939, 14, 21, 15, 1, -21 },
  { 1976, 11, 15, 13, 1, -15 },
  { 1997, 14, 28, 8, -3, -21 },
  { 2046, 14, 22, 15, 0, -15 },
  { 2085, 13, 21, 14, 0, -21 },
  { 2120, 7, 21, 7, 0, -21 },
  { 2139, 11, 28, 7, -4, -21 },
  { 2178, 13, 21, 12, 0, -21 },
  { 2213, 7, 21, 7, 0, -21 },
  { 2232, 21, 15, 22, 0, -15 },
  { 2272, 13, 15, 14, 0, -15 },
  { 2297, 12, 15, 14, 1, -15 },
  { 2320, 14, 22, 15, -1, -15 },
  { 2359, 13, 22, 15, 1, -15 },
  { 2395, 11, 15, 10, 0, -15 },
  { 2416, 11, 15, 11, 0, -15 },
  { 2437, 8, 18, 8, 1, -18 },
  { 2455, 13, 15, 15, 1, -15 },
  { 2480, 12, 15, 12, 1, -15 },
  { 2503, 18, 15, 18, 2, -15 },
  { 2537, 14, 15, 12, -1, -15 },
  { 2564, 16, 22, 12, -3, -15 },
  { 2608, 12, 15, 11, -1, -15 },
  { 2631, 11, 24, 10, 0, -20 },
  { 2664, 2, 28, 14, 6, -21 },
  { 2671, 10, 24, 10, -1, -20 },
  { 2701, 12, 4, 15, 2, -12 },
};

const GFXfont NotoSans_SemiCondensed_Italic28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic28pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC28PT7B_H_
