#ifndef _NOTOSANS_SEMICONDENSED_ITALIC11PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0x24, 0x84, 0xF6, 0x80, 0x14, 0x97, 0xCA, 0x2B, 0xF5, 0x14,
  0x13, 0xD4, 0xC3, 0x16, 0xCC, 0x40, 0x65, 0x52, 0xA5, 0xAE, 0xA6, 0x55,
  0x46, 0x38, 0xA2, 0x8C, 0x56, 0x58, 0x9F, 0x68, 0x12, 0x44, 0x48, 0x88,
  0x84, 0x21, 0x11, 0x12, 0x22, 0x48, 0x27, 0xD9, 0x60, 0x22, 0x2F, 0x22,
  0xE0, 0xE0, 0x80, 0x04, 0x21, 0x04, 0x20, 0x84, 0x30, 0x3B, 0x52, 0x94,
  0xC5, 0x4E, 0x3E, 0x22, 0x24, 0x44, 0x78, 0x42, 0x11, 0x11, 0x1E, 0x78,
  0x42, 0x61, 0x04, 0x5E, 0x08, 0xCA, 0x55, 0x7C, 0x42, 0x39, 0x10, 0xE0,
  0x84, 0x7E, 0x34, 0x8E, 0x99, 0x9E, 0xF8, 0x84, 0x42, 0x22, 0x10, 0x3A,
  0x52, 0x65, 0x46, 0x2E, 0x3A, 0x52, 0x97, 0x84, 0x5C, 0x40, 0x20, 0x20,
  0x02, 0xB0, 0x13, 0xCC, 0x31, 0xF0, 0xF0, 0x8C, 0x33, 0xC8, 0xE1, 0x26,
  0x48, 0x08, 0x1E, 0x21, 0x4D, 0x55, 0xA5, 0xA9, 0x96, 0x40, 0x3C, 0x08,
  0x51, 0x45, 0x24, 0xF4, 0x71, 0x38, 0x94, 0x5E, 0x49, 0x24, 0xBC, 0x3A,
  0x21, 0x08, 0x42, 0x1E, 0x38, 0x94, 0x51, 0x45, 0x14, 0xBC, 0x3C, 0x84,
  0x1E, 0x41, 0x04, 0x3C, 0x3C, 0x84, 0x10, 0x79, 0x04, 0x20, 0x3D, 0x08,
  0x20, 0x9A, 0x28, 0xBC, 0x22, 0x45, 0x13, 0xE4, 0x48, 0x92, 0x44, 0x72,
  0x24, 0x44, 0x4C, 0x08, 0x44, 0x21, 0x08, 0x44, 0x27, 0x00, 0x26, 0x51,
  0x43, 0x85, 0x0A, 0x14, 0x44, 0x22, 0x44, 0x44, 0x4F, 0x21, 0x91, 0x94,
  0xCA, 0xA5, 0x52, 0xD1, 0x69, 0x24, 0x22, 0x45, 0x4A, 0xA5, 0x49, 0x93,
  0x46, 0x39, 0x38, 0x61, 0x86, 0x28, 0xBC, 0x38, 0x94, 0x52, 0x71, 0x04,
  0x20, 0x39, 0x38, 0x61, 0x86, 0x28, 0xBC, 0x30, 0x40, 0x38, 0x94, 0x52,
  0x71, 0x45, 0x22, 0x3A, 0x10, 0xC1, 0x08, 0x5E, 0xF9, 0x10, 0x84, 0x21,
  0x10, 0x45, 0x18, 0xA2, 0x8A, 0x29, 0x3C, 0x8C, 0x65, 0x2A, 0x53, 0x08,
  0x89, 0xCC, 0xA6, 0x55, 0x4A, 0xA6, 0x63, 0x31, 0x10, 0x22, 0x28, 0x60,
  0xC1, 0x85, 0x12, 0x66, 0x8C, 0xA4, 0xC4, 0x21, 0x10, 0x7C, 0x21, 0x04,
  0x21, 0x0C, 0x3C, 0x32, 0x44, 0x44, 0x88, 0x8C, 0xA9, 0x55, 0x31, 0x11,
  0x12, 0x22, 0x2C, 0x21, 0x94, 0x98, 0x80, 0xF0, 0x80, 0x35, 0x24, 0xA2,
  0x99, 0xC0, 0x21, 0x16, 0xD4, 0xA5, 0x3E, 0x3A, 0x11, 0x08, 0x38, 0x04,
  0x13, 0x92, 0x4A, 0x29, 0x9C, 0x3A, 0x5D, 0x08, 0x38, 0x18, 0x8E, 0x42,
  0x10, 0x88, 0x42, 0x20, 0x35, 0x24, 0xA2, 0x99, 0xC1, 0x24, 0x60, 0x21,
  0x16, 0xD4, 0xA6, 0x32, 0x21, 0x24, 0xA4, 0x10, 0x22, 0x22, 0x44, 0x44,
  0x80, 0x21, 0x12, 0xA6, 0x32, 0x52, 0x25, 0x24, 0xA4, 0x7F, 0x49, 0x49,
  0x49, 0x91, 0x92, 0x5B, 0x52, 0x98, 0xC8, 0x3A, 0x53, 0x18, 0xB8, 0x5B,
  0x52, 0x94, 0xFA, 0x10, 0x80, 0x35, 0x24, 0xA2, 0x99, 0xC1, 0x04, 0x10,
  0x56, 0x44, 0x88, 0x74, 0x42, 0x1E, 0x27, 0x44, 0x48, 0x60, 0x4A, 0x52,
  0x99, 0xB8, 0x9A, 0xAC, 0xC8, 0xB3, 0x6B, 0x56, 0xC9, 0x92, 0x00, 0x4A,
  0x88, 0xC6, 0x48, 0x24, 0xA2, 0x8C, 0x30, 0x82, 0x10, 0x80, 0x71, 0x24,
  0x4E, 0x12, 0x22, 0xC4, 0x44, 0x44, 0xFF, 0xE0, 0x30, 0x84, 0x21, 0x88,
  0x84, 0x26, 0x00, 0xDB,
};

const GFXglyph NotoSans_SemiCondensed_Italic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 8, 3, 0, -8 },
  { 4, 3, 3, 4, 1, -8 },
  { 6, 6, 8, 6, 0, -8 },
  { 12, 5, 9, 5, 0, -8 },
  { 18, 7, 8, 8, 1, -8 },
  { 25, 6, 8, 6, 0, -8 },
  { 31, 2, 3, 2, 1, -8 },
  { 32, 4, 10, 3, 0, -8 },
  { 37, 4, 10, 3, -1, -8 },
  { 42, 5, 4, 5, 1, -8 },
  { 45, 4, 6, 6, 1, -7 },
  { 48, 2, 2, 3, 0, -1 },
  { 49, 3, 1, 3, 0, -3 },
  { 50, 1, 1, 3, 0, -1 },
  { 51, 6, 8, 4, -1, -8 },
  { 57, 5, 8, 5, 0, -8 },
  { 62, 4, 8, 5, 1, -8 },
  { 66, 5, 8, 5, 0, -8 },
  { 71, 5, 8, 5, 0, -8 },
  { 76, 5, 8, 5, 0, -8 },
  { 81, 5, 8, 5, 0, -8 },
  { 86, 4, 8, 5, 1, -8 },
  { 90, 5, 8, 5, 1, -8 },
  { 95, 5, 8, 5, 0, -8 },
  { 100, 5, 8, 5, 0, -8 },
  { 105, 2, 6, 3, 0, -6 },
  { 107, 3, 7, 3, -1, -6 },
  { 110, 4, 6, 6, 1, -7 },
  { 113, 4, 3, 6, 1, -5 },
  { 115, 4, 6, 6, 1, -7 },
  { 118, 4, 8, 4, 1, -8 },
  { 122, 8, 9, 8, 0, -8 },
  { 131, 6, 8, 6, -1, -8 },
  { 137, 6, 8, 6, 0, -8 },
  { 143, 5, 8, 6, 1, -8 },
  { 148, 6, 8, 7, 0, -8 },
  { 154, 6, 8, 5, 0, -8 },
  { 160, 6, 8, 5, 0, -8 },
  { 166, 6, 8, 7, 1, -8 },
  { 172, 7, 8, 7, 0, -8 },
  { 179, 4, 8, 3, 0, -8 },
  { 183, 5, 10, 3, -2, -8 },
  { 190, 7, 8, 6, 0, -8 },
  { 197, 4, 8, 5, 0, -8 },
  { 201, 9, 8, 8, 0, -8 },
  { 210, 7, 8, 7, 0, -8 },
  { 217, 6, 8, 7, 1, -8 },
  { 223, 6, 8, 6, 0, -8 },
  { 229, 6, 10, 7, 1, -8 },
  { 237, 6, 8, 6, 0, -8 },
  { 243, 5, 8, 5, 0, -8 },
  { 248, 5, 8, 5, 1, -8 },
  { 253, 6, 8, 7, 1, -8 },
  { 259, 5, 8, 5, 1, -8 },
  { 264, 9, 8, 9, 1, -8 },
  { 273, 7, 8, 5, -1, -8 },
  { 280, 5, 8, 5, 1, -8 },
  { 285, 6, 8, 5, 0, -8 },
  { 291, 4, 10, 3, 0, -8 },
  { 296, 2, 8, 4, 1, -8 },
  { 298, 4, 10, 3, -1, -8 },
  { 303, 5, 5, 6, 0, -8 },
  { 307, 4, 1, 4, -1, 1 },
  { 308, 1, 1, 3, 2, -8 },
  { 309, 6, 6, 6, 0, -6 },
  { 314, 5, 8, 6, 0, -8 },
  { 319, 5, 6, 4, 0, -6 },
  { 323, 6, 8, 6, 0, -8 },
  { 329, 5, 6, 5, 0, -6 },
  { 333, 5, 11, 3, -1, -8 },
  { 340, 6, 9, 6, 0, -6 },
  { 347, 5, 8, 6, 0, -8 },
  { 352, 3, 8, 3, 0, -8 },
  { 355, 4, 11, 3, -1, -8 },
  { 361, 5, 8, 5, 0, -8 },
  { 366, 3, 8, 3, 0, -8 },
  { 369, 8, 6, 9, 0, -6 },
  { 375, 5, 6, 6, 0, -6 },
  { 379, 5, 6, 6, 0, -6 },
  { 383, 5, 9, 6, 0, -6 },
  { 389, 6, 9, 6, 0, -6 },
  { 396, 4, 6, 4, 0, -6 },
  { 399, 4, 6, 4, 0, -6 },
  { 402, 4, 7, 3, 0, -7 },
  { 406, 5, 6, 6, 0, -6 },
  { 410, 4, 6, 5, 1, -6 },
  { 413, 7, 6, 7, 1, -6 },
  { 419, 5, 6, 5, 0, -6 },
  { 423, 6, 9, 5, -1, -6 },
  { 430, 4, 6, 4, 0, -6 },
  { 433, 4, 10, 4, 0, -8 },
  { 438, 1, 11, 5, 2, -8 },
  { 440, 5, 10, 4, -1, -8 },
  { 447, 4, 2, 6, 1, -5 },
};

const GFXfont NotoSans_SemiCondensed_Italic11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic11pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC11PT7B_H_
