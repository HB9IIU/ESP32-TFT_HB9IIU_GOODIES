#ifndef _NOTOSANS_SEMICONDENSED_ITALIC50PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80,
  0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x07,
  0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0x60, 0x00, 0x3E, 0x3E, 0x78,
  0x7C, 0xF0, 0xF1, 0xE1, 0xE3, 0xC3, 0xCF, 0x07, 0x9E, 0x1E, 0x3C, 0x3C,
  0x70, 0x78, 0xE0, 0xE1, 0xC1, 0xC7, 0x83, 0x8E, 0x0F, 0x00, 0x00, 0x07,
  0x03, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x78,
  0x00, 0x1E, 0x07, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x1C, 0x0F, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x1E,
  0x01, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x00,
  0x70, 0x38, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x0E, 0x07,
  0x00, 0x01, 0xE0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0xF0, 0x00,
  0x3C, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x80, 0x78, 0x1C, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x70, 0x38, 0x00,
  0x0F, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x07, 0x80, 0x01, 0xE0,
  0x70, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x1C, 0x0E, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFF,
  0x81, 0xFF, 0xFE, 0x03, 0xE7, 0x1C, 0x0F, 0x0E, 0x08, 0x1E, 0x18, 0x00,
  0x78, 0x70, 0x00, 0xF0, 0xE0, 0x01, 0xE1, 0xC0, 0x03, 0xC3, 0x00, 0x03,
  0xCE, 0x00, 0x07, 0xDC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1C,
  0xF0, 0x00, 0x31, 0xF0, 0x00, 0xE1, 0xE0, 0x01, 0xC3, 0xC0, 0x03, 0x87,
  0x80, 0x07, 0x0F, 0x00, 0x1C, 0x3C, 0x30, 0x38, 0xF8, 0x7C, 0x77, 0xE0,
  0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x3C, 0x0F, 0xF0, 0x00, 0xF0, 0x3F, 0xF0,
  0x03, 0xC0, 0xF8, 0xE0, 0x07, 0x01, 0xE1, 0xE0, 0x1E, 0x07, 0x83, 0xC0,
  0x78, 0x0F, 0x07, 0x80, 0xE0, 0x1C, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x0F,
  0x00, 0xF0, 0x38, 0x1C, 0x01, 0xC0, 0x70, 0x78, 0x03, 0x80, 0xE1, 0xE0,
  0x07, 0x03, 0xC3, 0x80, 0x1E, 0x07, 0x8F, 0x00, 0x3C, 0x0E, 0x3C, 0x3C,
  0x78, 0x3C, 0x71, 0xFE, 0xF0, 0x71, 0xE7, 0xFE, 0xE1, 0xE7, 0x9F, 0x3D,
  0xE7, 0x8F, 0x3C, 0x3B, 0xFF, 0x3C, 0xF0, 0x73, 0xFC, 0xF1, 0xC0, 0xE3,
  0xE1, 0xE7, 0x81, 0xC0, 0x07, 0x8F, 0x03, 0x80, 0x1E, 0x1C, 0x07, 0x00,
  0x3C, 0x38, 0x0E, 0x00, 0xF0, 0xF0, 0x3C, 0x01, 0xC1, 0xE0, 0x78, 0x07,
  0x83, 0xC0, 0xE0, 0x1E, 0x07, 0x81, 0xC0, 0x38, 0x0F, 0x07, 0x80, 0xF0,
  0x1E, 0x0E, 0x03, 0xC0, 0x3C, 0x3C, 0x07, 0x00, 0x78, 0xF0, 0x1E, 0x00,
  0x7F, 0xE0, 0x78, 0x00, 0xFF, 0x81, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x78,
  0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x0F, 0x80,
  0x07, 0x81, 0xE0, 0x00, 0xF0, 0x7C, 0x00, 0x1E, 0x1F, 0x00, 0x01, 0xEF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xEF, 0x00, 0xF1, 0xF1, 0xF0,
  0x3E, 0x7C, 0x1E, 0x07, 0x8F, 0x03, 0xE1, 0xF3, 0xC0, 0x3C, 0x3C, 0x78,
  0x07, 0xCF, 0x9E, 0x00, 0x7F, 0xE3, 0xC0, 0x0F, 0xF8, 0x78, 0x00, 0xFF,
  0x0F, 0x00, 0x0F, 0xC1, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x7F, 0x07, 0xC0,
  0x3F, 0xE0, 0x7E, 0x1F, 0xFE, 0x0F, 0xFF, 0xE3, 0xC0, 0xFF, 0xF8, 0x7C,
  0x07, 0xFC, 0x07, 0xC0, 0x10, 0x00, 0x00, 0x3E, 0x78, 0xF1, 0xE3, 0xCF,
  0x1E, 0x3C, 0x78, 0xE1, 0xC3, 0x8E, 0x00, 0x00, 0x1F, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x40, 0x78, 0x06, 0x07, 0x00, 0x78, 0x70, 0x0F, 0xE7, 0x00, 0x7F,
  0xF3, 0xF0, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0x1F, 0x03, 0xB8, 0x00,
  0x7B, 0x80, 0x1F, 0x3C, 0x03, 0xE1, 0xC0, 0x7C, 0x1E, 0x03, 0xC1, 0xE0,
  0x18, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x0F, 0x87, 0xC3, 0xE3, 0xE1, 0xF0, 0xF0, 0xF8, 0x78, 0x78,
  0x3C, 0x1C, 0x1E, 0x0E, 0x00, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0x39,
  0xFF, 0xFF, 0xFB, 0xE2, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFE,
  0x03, 0xE0, 0xF8, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC3, 0xE0, 0x0F, 0x0F,
  0x00, 0x3C, 0x7C, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x3E, 0x00,
  0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7D,
  0xE0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x7B, 0xE0,
  0x03, 0xEF, 0x80, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x01, 0xF3, 0xC0, 0x07,
  0x8F, 0x00, 0x1E, 0x3C, 0x00, 0xF8, 0xF8, 0x03, 0xC3, 0xE0, 0x1F, 0x07,
  0x80, 0xF8, 0x1F, 0x07, 0xC0, 0x7E, 0x3F, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xC0, 0x03, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x03,
  0xF0, 0x1F, 0xE0, 0x7F, 0xC3, 0xFF, 0x0F, 0xDE, 0x7F, 0x3C, 0x7C, 0x78,
  0x61, 0xF0, 0x83, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0x01, 0xF0, 0x02, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFD, 0xFE, 0x01, 0xE0, 0x3E, 0x00,
  0x80, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xC0, 0x00,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0xC0, 0x03, 0xE0, 0xFC, 0x1F, 0xC0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xDE, 0x00, 0x07, 0x9C, 0x00,
  0x07, 0xBC, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x7C, 0x00,
  0x3C, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x78, 0x01,
  0xE0, 0xF0, 0x03, 0xC0, 0xF0, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1F,
  0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xDF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x60, 0x07, 0xE0, 0xF0, 0x3F, 0x81, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFE, 0xE0, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x80, 0x0F, 0x9F, 0xE0, 0x1E, 0x7F, 0xE0, 0x3D, 0xFF, 0xE0, 0xFF,
  0x87, 0xE1, 0xFC, 0x07, 0xC3, 0xF0, 0x07, 0x87, 0xC0, 0x0F, 0x0F, 0x80,
  0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0xF8, 0x00, 0xF1, 0xF0, 0x01,
  0xE3, 0xE0, 0x03, 0xC7, 0xC0, 0x0F, 0x87, 0x80, 0x1E, 0x0F, 0x00, 0x7C,
  0x1E, 0x00, 0xF0, 0x3E, 0x03, 0xE0, 0x3F, 0x1F, 0x80, 0x7F, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x1F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xFC, 0x01, 0xFC, 0xFE, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x1E, 0x03,
  0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1E, 0x07,
  0xC0, 0x1E, 0x03, 0xC0, 0x3E, 0x03, 0xC0, 0x7C, 0x03, 0xE0, 0xF8, 0x01,
  0xF1, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x07, 0xEF, 0xC0, 0x0F, 0x83, 0xE0, 0x1F, 0x01, 0xE0, 0x3E,
  0x01, 0xF0, 0x7C, 0x00, 0xF0, 0x78, 0x00, 0xF8, 0x78, 0x00, 0xF8, 0xF8,
  0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF0, 0xF8, 0x00, 0xF0, 0x78,
  0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x7F, 0x07, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3E, 0x07, 0xC0, 0xF8,
  0x07, 0x83, 0xE0, 0x0F, 0x07, 0x80, 0x1F, 0x0F, 0x00, 0x3E, 0x3E, 0x00,
  0x7C, 0x78, 0x00, 0xF8, 0xF0, 0x01, 0xF1, 0xE0, 0x03, 0xE3, 0xC0, 0x07,
  0x87, 0x80, 0x0F, 0x0F, 0x00, 0x3E, 0x1E, 0x00, 0xFC, 0x3E, 0x01, 0xF8,
  0x3E, 0x0F, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xF7, 0x80, 0x7F, 0xCF, 0x00,
  0x3C, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0xE0, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x00, 0x07, 0x83, 0xF0, 0xFC, 0x3F,
  0x0F, 0x83, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x0F, 0x83,
  0xF0, 0xFC, 0x3E, 0x0F, 0x81, 0x80, 0x00, 0xF0, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF0,
  0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00,
  0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x07, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xF3, 0x80, 0xF8,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x07, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x00, 0x78, 0x3C, 0x01, 0xFC, 0x07, 0x07, 0x00, 0xFF, 0xE0,
  0xE1, 0xE0, 0x3F, 0xFC, 0x1C, 0x38, 0x0F, 0x07, 0x83, 0xCF, 0x03, 0xC0,
  0xE0, 0x79, 0xC0, 0xF0, 0x3C, 0x0E, 0x78, 0x1C, 0x07, 0x81, 0xCF, 0x07,
  0x80, 0xF0, 0x39, 0xC0, 0xE0, 0x1C, 0x07, 0x38, 0x3C, 0x07, 0x80, 0xEF,
  0x07, 0x80, 0xF0, 0x3D, 0xE0, 0xE0, 0x1C, 0x07, 0x3C, 0x1C, 0x07, 0x80,
  0xE7, 0x83, 0x80, 0xF0, 0x3C, 0xF0, 0x70, 0x1E, 0x07, 0x1E, 0x0E, 0x07,
  0xC1, 0xE3, 0xC1, 0xE1, 0xF8, 0x78, 0x78, 0x3E, 0xF7, 0xFE, 0x0F, 0x03,
  0xFC, 0x7F, 0x81, 0xE0, 0x3F, 0x0F, 0xE0, 0x1C, 0x01, 0x00, 0x20, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x80, 0x00, 0xFC, 0x00,
  0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0x78, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xC7, 0x00, 0x01,
  0xE3, 0x80, 0x01, 0xE1, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0x78, 0x00,
  0x78, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x3E, 0x07, 0x80,
  0x1E, 0x03, 0xC0, 0x1F, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xE0, 0x07,
  0xC1, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0xF8, 0x00,
  0x3C, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0xBE, 0x00,
  0x03, 0xDE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xE0, 0x1F,
  0x80, 0x78, 0x03, 0xE0, 0x1E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xC0,
  0x07, 0xC0, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x78, 0x1F, 0x00, 0x1E, 0x07,
  0xC0, 0x0F, 0x81, 0xE0, 0x07, 0xC0, 0x78, 0x03, 0xE0, 0x1E, 0x0F, 0xF0,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3C, 0x07,
  0xE0, 0x0F, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x81, 0xE0, 0x03, 0xE0, 0x78,
  0x00, 0x78, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x83, 0xE0, 0x03, 0xE0,
  0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x3E, 0x0F, 0x00, 0x1F, 0x07, 0xC0, 0x0F,
  0xC1, 0xF0, 0x07, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xC0, 0x30, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x40, 0x3F, 0xC7, 0xE0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x1E, 0x03, 0xF8, 0x03, 0xC0, 0x1F, 0x80, 0x78, 0x01,
  0xF0, 0x1F, 0x00, 0x1F, 0x03, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0x7C, 0x0F,
  0x00, 0x07, 0x83, 0xE0, 0x00, 0xF0, 0x7C, 0x00, 0x1E, 0x0F, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x0F, 0x80, 0x01, 0xE1, 0xE0,
  0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x87, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x3E,
  0x3E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x3E, 0x1E, 0x00,
  0x0F, 0x83, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x83,
  0xC0, 0x07, 0xE0, 0x78, 0x01, 0xF8, 0x1F, 0x00, 0x7E, 0x03, 0xE0, 0x3F,
  0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xC0, 0x1C, 0x07, 0xE0, 0x00, 0x81,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1F, 0x00, 0x3F, 0xF3, 0xE0, 0x07, 0xFE, 0x7C, 0x01, 0xFF, 0xCF, 0x80,
  0x3F, 0xF9, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x78,
  0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x78, 0x7C, 0x00,
  0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0x01,
  0xF8, 0x01, 0xE0, 0x3F, 0xE1, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x3C,
  0x03, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x78, 0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x1F, 0x00, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x1E, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x00, 0xF0, 0x0F,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x07, 0x80,
  0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x7C,
  0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x78, 0x07, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x00, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x07, 0xFF, 0x80,
  0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x02, 0x3F, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x08, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xF8, 0x07, 0x80,
  0x1F, 0x80, 0x7C, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0xF8,
  0x00, 0xF0, 0x0F, 0x80, 0x07, 0x80, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x03,
  0xC0, 0xF8, 0x00, 0x1E, 0x0F, 0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x1E, 0x7C, 0x00,
  0x00, 0xF7, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7B, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x0F, 0x87,
  0x80, 0x00, 0x78, 0x3E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0xF0, 0x3E, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x78, 0x07, 0xC0, 0x03,
  0xC0, 0x3E, 0x00, 0x1E, 0x00, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0xC0, 0x1E, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x3F,
  0xC0, 0x7F, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x3D, 0xC0, 0x00, 0xF7, 0x80, 0xF7, 0x00, 0x03, 0xFC,
  0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x3D, 0xE0,
  0x03, 0xCF, 0x01, 0xE7, 0x80, 0x0F, 0x7C, 0x07, 0x9E, 0x00, 0x79, 0xE0,
  0x1E, 0x78, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x0F, 0x1E, 0x01, 0xE7, 0x80,
  0x3C, 0x78, 0x0F, 0x0E, 0x01, 0xE3, 0xE0, 0x3C, 0x38, 0x07, 0x8F, 0x00,
  0xF0, 0xE0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x0F, 0x0F, 0x07,
  0x87, 0xC0, 0x78, 0x3C, 0x1E, 0x1F, 0x01, 0xE0, 0xF0, 0xF0, 0x78, 0x07,
  0x83, 0xC3, 0xC1, 0xE0, 0x1E, 0x0F, 0x1E, 0x07, 0x80, 0xF8, 0x3C, 0x78,
  0x3E, 0x03, 0xC0, 0xF3, 0xC0, 0xF8, 0x0F, 0x01, 0xCE, 0x03, 0xC0, 0x3C,
  0x07, 0x78, 0x0F, 0x00, 0xF0, 0x1F, 0xC0, 0x3C, 0x07, 0x80, 0x7F, 0x01,
  0xF0, 0x1E, 0x01, 0xF8, 0x07, 0x80, 0x78, 0x07, 0xE0, 0x1E, 0x01, 0xE0,
  0x1F, 0x00, 0x78, 0x07, 0x80, 0x7C, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x3C, 0x07, 0xE0, 0x00,
  0x78, 0x0F, 0xE0, 0x00, 0xF0, 0x1F, 0xC0, 0x03, 0xC0, 0x3F, 0x80, 0x07,
  0x80, 0xFF, 0x00, 0x0F, 0x01, 0xEF, 0x00, 0x1E, 0x03, 0xDE, 0x00, 0x7C,
  0x07, 0xBC, 0x00, 0xF0, 0x0F, 0x7C, 0x01, 0xE0, 0x3C, 0x78, 0x03, 0xC0,
  0x78, 0xF0, 0x07, 0x80, 0xF1, 0xE0, 0x1F, 0x01, 0xE1, 0xE0, 0x3C, 0x03,
  0xC3, 0xC0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x81, 0xE0, 0x3C,
  0x0F, 0x07, 0xC0, 0x78, 0x1E, 0x0F, 0x00, 0xF0, 0x3E, 0x1E, 0x03, 0xC0,
  0x3C, 0x3C, 0x07, 0x80, 0x78, 0x78, 0x0F, 0x00, 0xF1, 0xE0, 0x1E, 0x00,
  0xF3, 0xC0, 0x7C, 0x01, 0xE7, 0x80, 0xF0, 0x03, 0xCF, 0x01, 0xE0, 0x03,
  0xDE, 0x03, 0xC0, 0x07, 0xF8, 0x07, 0x80, 0x0F, 0xF0, 0x1F, 0x00, 0x1F,
  0xE0, 0x3C, 0x00, 0x1F, 0xC0, 0x78, 0x00, 0x3F, 0x80, 0xF0, 0x00, 0x7E,
  0x01, 0xE0, 0x00, 0x7C, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03,
  0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00,
  0x3E, 0x0F, 0x80, 0x01, 0xE1, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1E,
  0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x3E, 0xF0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF0, 0xF8,
  0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x1F,
  0xC0, 0x3F, 0xC7, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1E, 0x07, 0xF0, 0x0F,
  0x00, 0xF8, 0x07, 0x80, 0x3C, 0x07, 0xC0, 0x1F, 0x03, 0xC0, 0x0F, 0x81,
  0xE0, 0x07, 0xC0, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF0,
  0x3C, 0x00, 0x78, 0x1E, 0x00, 0x7C, 0x0F, 0x00, 0x7C, 0x0F, 0x80, 0x7E,
  0x07, 0x80, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0xF8, 0x03, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x03,
  0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xE1, 0xF0, 0x00, 0x1E, 0x1E,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xEF,
  0x80, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x7C,
  0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80,
  0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x7C,
  0x03, 0xE0, 0x1F, 0xC0, 0x3F, 0xC7, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x1E, 0x07, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3E,
  0x07, 0xC0, 0x1F, 0x03, 0xC0, 0x0F, 0x81, 0xE0, 0x07, 0xC0, 0xF0, 0x03,
  0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF0, 0x3C, 0x00, 0xF8, 0x1E, 0x00,
  0x7C, 0x0F, 0x00, 0x7C, 0x0F, 0x80, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xF8, 0x3C, 0x00, 0x78,
  0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x07, 0xC0, 0x0F, 0x01, 0xE0, 0x0F,
  0x80, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x01,
  0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x7C,
  0x1E, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xF0, 0x0E, 0x03, 0xE0,
  0x02, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0xC0, 0x07, 0xE0, 0xFC, 0x7F, 0xC0, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xE0,
  0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x0F, 0x00,
  0x03, 0xE0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C,
  0x1F, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x78, 0x3E, 0x00, 0x07, 0x83, 0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0xF0, 0x78,
  0x00, 0x1F, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01,
  0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0x3C, 0x0F,
  0x00, 0x07, 0xC0, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00,
  0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xBC, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xCF, 0x00, 0x03, 0xE7,
  0x80, 0x01, 0xE3, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0xF8,
  0x78, 0x00, 0x78, 0x3C, 0x00, 0x7C, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x3E,
  0x07, 0xC0, 0x1E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x0F,
  0x80, 0x3C, 0x07, 0x80, 0x1E, 0x07, 0xC0, 0x0F, 0x03, 0xC0, 0x07, 0x83,
  0xE0, 0x03, 0xC1, 0xE0, 0x01, 0xE1, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x78,
  0x78, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x07,
  0x9E, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0xC0, 0x03, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0xBC, 0x00, 0x3E, 0x00, 0x3E, 0xF0,
  0x01, 0xF8, 0x00, 0xF3, 0xC0, 0x07, 0xE0, 0x03, 0xCF, 0x00, 0x3F, 0x80,
  0x1F, 0x3C, 0x00, 0xEE, 0x00, 0x78, 0xF0, 0x07, 0xB8, 0x03, 0xE3, 0xC0,
  0x1E, 0xE0, 0x0F, 0x0F, 0x00, 0x73, 0x80, 0x7C, 0x3C, 0x03, 0xCE, 0x01,
  0xE0, 0xF0, 0x0E, 0x38, 0x07, 0x83, 0xC0, 0x78, 0xE0, 0x3E, 0x0F, 0x01,
  0xE3, 0x80, 0xF0, 0x3C, 0x0F, 0x0E, 0x07, 0xC0, 0xF0, 0x3C, 0x3C, 0x1E,
  0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x0F, 0x07, 0x83, 0xC3, 0xC0, 0x3C, 0x1C,
  0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x3C, 0x7C, 0x03, 0xC3, 0xC0, 0xF1, 0xE0,
  0x0F, 0x1E, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x0F, 0x3C, 0x00, 0xF3, 0xC0,
  0x3C, 0xF0, 0x03, 0xCF, 0x00, 0xF7, 0x80, 0x0F, 0x38, 0x03, 0xDE, 0x00,
  0x3D, 0xE0, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x3C, 0x01,
  0xE0, 0x01, 0xF0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x3C,
  0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x78, 0x7C, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x03, 0xCF, 0x80, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0xF8, 0xF0, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0xF8, 0x1E, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x1E, 0x01, 0xF0, 0x00,
  0xF8, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8,
  0x00, 0xF8, 0x07, 0xC0, 0x01, 0xE0, 0x3E, 0x00, 0x07, 0x80, 0xF8, 0x00,
  0x3E, 0xF0, 0x00, 0x79, 0xE0, 0x01, 0xF3, 0xC0, 0x07, 0xC7, 0xC0, 0x0F,
  0x87, 0x80, 0x3E, 0x0F, 0x00, 0x78, 0x1E, 0x01, 0xF0, 0x3C, 0x07, 0xC0,
  0x78, 0x0F, 0x00, 0x78, 0x3E, 0x00, 0xF0, 0x78, 0x01, 0xE1, 0xF0, 0x03,
  0xC7, 0xC0, 0x07, 0x8F, 0x00, 0x07, 0xBE, 0x00, 0x0F, 0x78, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xE0, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00,
  0xF0, 0x78, 0x1C, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x1C, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x1C, 0x0E, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x0E, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x0E,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x73,
  0xC0, 0x01, 0xE3, 0xC0, 0x03, 0x87, 0x80, 0x0F, 0x07, 0x00, 0x1C, 0x0F,
  0x00, 0x78, 0x0E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0x3C,
  0x1E, 0x00, 0x78, 0x78, 0x00, 0x70, 0xF0, 0x00, 0xF3, 0xC0, 0x00, 0xE7,
  0x80, 0x01, 0xFE, 0x00, 0x03, 0xC0, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x7C, 0x3C, 0x3C, 0x1E, 0x0E, 0x0F, 0x07,
  0x00, 0x7E, 0x0E, 0x03, 0xFF, 0x3C, 0x0F, 0xFE, 0x78, 0x3F, 0x1E, 0xE0,
  0xFC, 0x0F, 0xC1, 0xF0, 0x1F, 0x87, 0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x3E,
  0x00, 0x78, 0x78, 0x00, 0xF1, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0xC7, 0x80,
  0x0F, 0x8F, 0x00, 0x1E, 0x3E, 0x00, 0x3C, 0x7C, 0x00, 0x78, 0xF0, 0x01,
  0xF1, 0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x87, 0x80, 0x1F, 0x0F, 0x00, 0x7E,
  0x1F, 0x01, 0xFC, 0x3E, 0x07, 0x70, 0x3E, 0x1F, 0xE0, 0x7F, 0xFB, 0xC0,
  0x7F, 0xE7, 0x80, 0x7F, 0x0F, 0x00, 0x10, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x3F, 0x80, 0x78, 0xFF, 0x80, 0xF3,
  0xFF, 0x81, 0xEF, 0x3F, 0x03, 0xF8, 0x1F, 0x0F, 0xE0, 0x3E, 0x1F, 0x80,
  0x3C, 0x3E, 0x00, 0x78, 0x7C, 0x00, 0xF0, 0xF0, 0x01, 0xE3, 0xE0, 0x03,
  0xC7, 0xC0, 0x07, 0x8F, 0x00, 0x1F, 0x1E, 0x00, 0x3E, 0x7C, 0x00, 0x78,
  0xF8, 0x00, 0xF1, 0xE0, 0x03, 0xE3, 0xC0, 0x07, 0xC7, 0x80, 0x0F, 0x1F,
  0x00, 0x3E, 0x3E, 0x00, 0x78, 0x7E, 0x01, 0xF0, 0xFC, 0x07, 0xC1, 0xDC,
  0x3F, 0x07, 0xBF, 0xFE, 0x0F, 0x3F, 0xF0, 0x1C, 0x3F, 0xC0, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xF8, 0xE0,
  0xFC, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x83, 0xF0, 0x70, 0x3F,
  0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xC3, 0xC0, 0x1F,
  0xF9, 0xE0, 0x1F, 0xFC, 0xF0, 0x1F, 0x8F, 0xF0, 0x1F, 0x81, 0xF8, 0x1F,
  0x00, 0xFC, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x03,
  0xC0, 0x07, 0x83, 0xE0, 0x03, 0xC1, 0xE0, 0x03, 0xE0, 0xF0, 0x01, 0xE0,
  0xF8, 0x00, 0xF0, 0x7C, 0x00, 0x78, 0x3E, 0x00, 0x7C, 0x1E, 0x00, 0x3E,
  0x0F, 0x00, 0x1E, 0x07, 0x80, 0x1F, 0x03, 0xC0, 0x0F, 0x81, 0xE0, 0x0F,
  0xC0, 0xF8, 0x0F, 0xE0, 0x7C, 0x0F, 0xE0, 0x1F, 0x0E, 0xF0, 0x0F, 0xFF,
  0x78, 0x03, 0xFF, 0x3C, 0x00, 0xFE, 0x1E, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7E, 0x3E, 0x0F, 0x81, 0xE1,
  0xF0, 0x1F, 0x1E, 0x01, 0xF3, 0xE0, 0x1E, 0x3C, 0x01, 0xE7, 0xC0, 0x3E,
  0x78, 0x0F, 0xC7, 0x83, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x01, 0x07, 0xE0, 0x70, 0x3F,
  0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xE2, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x83, 0x80, 0x3F, 0xF3, 0xC0, 0x3F,
  0xF9, 0xE0, 0x3F, 0x1E, 0xE0, 0x3F, 0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x1F,
  0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1E, 0x07, 0x80, 0x0F, 0x07,
  0xC0, 0x07, 0x83, 0xC0, 0x07, 0xC1, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xE0,
  0xF8, 0x00, 0xF0, 0x7C, 0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x1E, 0x00, 0x3C,
  0x0F, 0x00, 0x3E, 0x07, 0x80, 0x1F, 0x03, 0xC0, 0x1F, 0x81, 0xF0, 0x1F,
  0xC0, 0xF8, 0x1F, 0xC0, 0x3E, 0x1F, 0xE0, 0x1F, 0xFE, 0xF0, 0x07, 0xFE,
  0x78, 0x01, 0xFC, 0x7C, 0x00, 0x10, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x40,
  0x03, 0xC0, 0x38, 0x07, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x3F, 0x80, 0x78, 0xFF, 0x80, 0xF7, 0xFF, 0x81, 0xEF,
  0x3F, 0x03, 0xF8, 0x1E, 0x0F, 0xE0, 0x3E, 0x1F, 0x80, 0x7C, 0x3E, 0x00,
  0xF0, 0x7C, 0x01, 0xE0, 0xF0, 0x03, 0xC3, 0xE0, 0x07, 0x87, 0xC0, 0x1F,
  0x0F, 0x00, 0x3E, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0xF8, 0x01, 0xE1,
  0xE0, 0x07, 0xC3, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x1F, 0x00, 0x3C, 0x3C,
  0x00, 0x78, 0x78, 0x01, 0xF0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x87, 0xC0,
  0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x7C, 0x00, 0x00, 0x60, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xE0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C,
  0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8,
  0x0F, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x01, 0xF0,
  0x78, 0x07, 0xC0, 0xF0, 0x1F, 0x01, 0xE0, 0x7C, 0x03, 0xC1, 0xF0, 0x0F,
  0x87, 0xC0, 0x1E, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0xF8, 0x00, 0xF3,
  0xE0, 0x03, 0xCF, 0x80, 0x07, 0xBE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFC, 0xF0, 0x01, 0xF1, 0xF0, 0x03, 0xC1, 0xE0,
  0x07, 0x83, 0xC0, 0x1F, 0x07, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00,
  0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x07, 0xC0, 0x3E, 0x0F, 0x00, 0x7C, 0x1E,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78,
  0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0,
  0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x00,
  0x07, 0x87, 0xE0, 0x1F, 0x80, 0x79, 0xFF, 0x87, 0xFC, 0x07, 0xBF, 0xF8,
  0xFF, 0xE0, 0x7F, 0xCF, 0xDE, 0x7E, 0x07, 0x70, 0x7F, 0x81, 0xF0, 0xFE,
  0x03, 0xF0, 0x1F, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0x1F,
  0x0F, 0x80, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0xC0, 0x1E, 0x1F, 0x00, 0x78,
  0x01, 0xE1, 0xF0, 0x07, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x03, 0xE1, 0xE0,
  0x0F, 0x80, 0x3C, 0x3E, 0x00, 0xF0, 0x03, 0xC3, 0xE0, 0x0F, 0x00, 0x3C,
  0x3C, 0x00, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x00, 0x7C, 0x3C, 0x01, 0xF0,
  0x07, 0x87, 0xC0, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE0, 0x07, 0x87, 0x80,
  0x1E, 0x00, 0xF8, 0x78, 0x01, 0xE0, 0x0F, 0x87, 0x80, 0x3E, 0x00, 0xF0,
  0xF8, 0x03, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC0,
  0x1F, 0x00, 0x07, 0x87, 0xF0, 0x0F, 0x3F, 0xF0, 0x1E, 0xFF, 0xF0, 0x3F,
  0xF7, 0xE0, 0x7F, 0x03, 0xE1, 0xFC, 0x07, 0xC3, 0xF0, 0x0F, 0x87, 0xC0,
  0x1F, 0x0F, 0x80, 0x3C, 0x3E, 0x00, 0x78, 0x7C, 0x00, 0xF0, 0xF8, 0x03,
  0xE1, 0xE0, 0x07, 0xC3, 0xC0, 0x0F, 0x0F, 0x80, 0x1E, 0x1F, 0x00, 0x3C,
  0x3C, 0x00, 0xF8, 0x78, 0x01, 0xF0, 0xF0, 0x03, 0xC3, 0xE0, 0x07, 0x87,
  0xC0, 0x1F, 0x0F, 0x00, 0x3E, 0x1E, 0x00, 0x78, 0x7C, 0x00, 0xF0, 0xF8,
  0x01, 0xE1, 0xE0, 0x07, 0xC3, 0xC0, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xC7, 0xE0, 0xF8, 0x0F, 0x0F, 0x80, 0x7C,
  0x78, 0x01, 0xE7, 0xC0, 0x0F, 0x3C, 0x00, 0x7B, 0xE0, 0x03, 0xDE, 0x00,
  0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x7D, 0xE0, 0x03,
  0xCF, 0x80, 0x3E, 0x7C, 0x03, 0xE1, 0xF0, 0x3F, 0x0F, 0xC3, 0xF0, 0x3F,
  0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x70, 0xFE, 0x00, 0x3C,
  0x7F, 0xC0, 0x0F, 0x3F, 0xF8, 0x03, 0xDE, 0x7E, 0x00, 0xFE, 0x07, 0xC0,
  0x7F, 0x01, 0xF0, 0x1F, 0x80, 0x3C, 0x07, 0xC0, 0x0F, 0x01, 0xF0, 0x03,
  0xC0, 0x78, 0x00, 0xF0, 0x3E, 0x00, 0x3C, 0x0F, 0x80, 0x0F, 0x03, 0xC0,
  0x07, 0xC0, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x78, 0x1F, 0x00, 0x1E, 0x07,
  0x80, 0x0F, 0x81, 0xE0, 0x03, 0xE0, 0x78, 0x00, 0xF0, 0x3E, 0x00, 0x7C,
  0x0F, 0x80, 0x1E, 0x03, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3F, 0x87,
  0xE0, 0x1E, 0x7F, 0xF8, 0x07, 0x9F, 0xF8, 0x01, 0xE3, 0xFC, 0x00, 0x78,
  0x10, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x7E, 0x0E, 0x03, 0xFF, 0x3C, 0x0F, 0xFE, 0x78, 0x3F,
  0x1E, 0xE0, 0xFC, 0x0F, 0xC3, 0xE0, 0x1F, 0x87, 0xC0, 0x1F, 0x1F, 0x00,
  0x3E, 0x3E, 0x00, 0x78, 0x78, 0x00, 0xF1, 0xF0, 0x01, 0xE3, 0xC0, 0x07,
  0xC7, 0x80, 0x0F, 0x9F, 0x00, 0x1E, 0x3E, 0x00, 0x3C, 0x7C, 0x00, 0xF8,
  0xF0, 0x01, 0xF1, 0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x87, 0x80, 0x1F, 0x0F,
  0x00, 0x7E, 0x1F, 0x01, 0xFC, 0x3E, 0x07, 0xF0, 0x3E, 0x1F, 0xE0, 0x7F,
  0xFB, 0xC0, 0x7F, 0xE7, 0x80, 0x7F, 0x1F, 0x00, 0x10, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x87, 0xE0, 0xF3, 0xF8,
  0x1E, 0xFF, 0x03, 0xDF, 0xE0, 0x77, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0x87, 0xE3, 0xE0, 0xF0, 0x04,
  0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x20, 0x07, 0xC7, 0x83, 0xF0, 0xFF, 0xFE, 0x1F,
  0xFF, 0x81, 0xFF, 0xC0, 0x01, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x3C,
  0x00, 0xE0, 0x07, 0x80, 0x1E, 0x01, 0xFF, 0xDF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xF0, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF8, 0x03, 0xE1, 0x07,
  0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0x10, 0x00, 0x0F, 0x80, 0x1E, 0x1E, 0x00,
  0x7C, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE1, 0xF0, 0x03, 0xC3, 0xC0, 0x07,
  0x87, 0x80, 0x1F, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x7C, 0x00, 0xF0,
  0xF0, 0x01, 0xE1, 0xE0, 0x07, 0xC3, 0xC0, 0x0F, 0x0F, 0x80, 0x1E, 0x1F,
  0x00, 0x3C, 0x3C, 0x00, 0xF8, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC3, 0xE0,
  0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x7E, 0x1F, 0x01, 0xF8, 0x3E, 0x07,
  0xF0, 0x7E, 0x3D, 0xE0, 0x7F, 0xF3, 0xC0, 0xFF, 0xC7, 0x80, 0xFF, 0x0E,
  0x00, 0x10, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xEF,
  0x00, 0x3E, 0xF0, 0x03, 0xCF, 0x00, 0x7C, 0xF0, 0x07, 0x8F, 0x00, 0xF8,
  0xF0, 0x0F, 0x0F, 0x01, 0xF0, 0xF0, 0x1E, 0x0F, 0x03, 0xE0, 0x78, 0x3C,
  0x07, 0x87, 0xC0, 0x78, 0x78, 0x07, 0x8F, 0x80, 0x78, 0xF0, 0x07, 0x9F,
  0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00, 0x7B, 0xC0, 0x07, 0xBC, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x07, 0xC0, 0x1F, 0xF0, 0x07, 0xC0, 0x1E, 0xF0, 0x0F, 0xC0, 0x1E,
  0xF0, 0x0F, 0xC0, 0x3E, 0xF0, 0x0F, 0xC0, 0x3C, 0xF0, 0x1F, 0xC0, 0x7C,
  0xF0, 0x1D, 0xC0, 0x78, 0xF0, 0x3D, 0xC0, 0xF8, 0xF0, 0x39, 0xC0, 0xF0,
  0xF0, 0x79, 0xC0, 0xF0, 0xF0, 0x79, 0xC1, 0xE0, 0xF0, 0x71, 0xC1, 0xE0,
  0xF0, 0xF1, 0xC3, 0xE0, 0xF0, 0xE1, 0xC3, 0xC0, 0xF1, 0xE1, 0xC3, 0xC0,
  0xF1, 0xC1, 0xC7, 0x80, 0xF3, 0xC1, 0xC7, 0x80, 0xF3, 0xC1, 0xCF, 0x00,
  0xF7, 0x81, 0xCF, 0x00, 0xF7, 0x81, 0xCE, 0x00, 0xF7, 0x01, 0xDE, 0x00,
  0xFF, 0x01, 0xDE, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x07,
  0xC0, 0x1F, 0x07, 0xC0, 0x07, 0x83, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xF3,
  0xE0, 0x00, 0x7B, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xF9, 0xE0, 0x00,
  0x78, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x7C, 0x1E, 0x00, 0x7C, 0x0F, 0x00,
  0x3C, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x3E, 0x00, 0xF0, 0x3E, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0xF8, 0x07, 0x80, 0x0F, 0x80, 0x3C, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x03, 0xE0, 0x03,
  0xC0, 0x1E, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0,
  0xF8, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x73,
  0xC0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x00, 0x01,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x0F, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x05, 0xFF, 0x80, 0x3F, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFA, 0x00, 0x7F, 0xC8, 0x00, 0x38,
  0x00,
};

const GFXglyph NotoSans_SemiCondensed_Italic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 12, 37, 13, 1, -36 },
  { 57, 15, 13, 19, 5, -36 },
  { 82, 28, 36, 28, 1, -36 },
  { 208, 23, 41, 25, 1, -38 },
  { 326, 31, 37, 36, 3, -36 },
  { 470, 27, 37, 29, 1, -36 },
  { 595, 7, 13, 10, 5, -36 },
  { 607, 16, 44, 14, 2, -36 },
  { 695, 16, 44, 14, -4, -36 },
  { 783, 20, 21, 24, 5, -38 },
  { 836, 22, 24, 26, 3, -30 },
  { 902, 9, 13, 12, -2, -6 },
  { 917, 12, 4, 15, 1, -15 },
  { 923, 6, 7, 12, 1, -6 },
  { 929, 23, 36, 17, -2, -36 },
  { 1033, 22, 37, 25, 2, -36 },
  { 1135, 15, 36, 25, 6, -36 },
  { 1203, 25, 36, 25, -1, -36 },
  { 1316, 24, 37, 25, 0, -36 },
  { 1427, 24, 36, 25, 0, -36 },
  { 1535, 23, 37, 25, 1, -36 },
  { 1642, 23, 37, 25, 2, -36 },
  { 1749, 23, 36, 25, 3, -36 },
  { 1853, 24, 37, 25, 1, -36 },
  { 1964, 23, 37, 25, 1, -36 },
  { 2071, 10, 28, 12, 1, -27 },
  { 2106, 13, 34, 12, -2, -27 },
  { 2162, 22, 24, 26, 3, -30 },
  { 2228, 21, 13, 26, 3, -24 },
  { 2263, 22, 24, 26, 3, -30 },
  { 2329, 17, 37, 19, 3, -36 },
  { 2408, 35, 40, 38, 2, -36 },
  { 2583, 25, 36, 25, -3, -36 },
  { 2696, 26, 36, 27, 1, -36 },
  { 2813, 25, 37, 26, 3, -36 },
  { 2929, 27, 36, 30, 1, -36 },
  { 3051, 24, 36, 23, 1, -36 },
  { 3159, 24, 36, 21, 1, -36 },
  { 3267, 27, 37, 31, 3, -36 },
  { 3392, 30, 36, 30, 1, -36 },
  { 3527, 20, 36, 15, -2, -36 },
  { 3617, 21, 46, 12, -8, -36 },
  { 3738, 29, 36, 25, 1, -36 },
  { 3869, 17, 36, 21, 1, -36 },
  { 3946, 38, 36, 39, 1, -36 },
  { 4117, 31, 36, 32, 1, -36 },
  { 4257, 28, 37, 32, 3, -36 },
  { 4387, 25, 36, 25, 1, -36 },
  { 4500, 28, 45, 32, 3, -36 },
  { 4658, 25, 36, 26, 1, -36 },
  { 4771, 24, 37, 23, 0, -36 },
  { 4882, 22, 36, 22, 4, -36 },
  { 4981, 28, 37, 30, 3, -36 },
  { 5111, 25, 36, 25, 4, -36 },
  { 5224, 38, 36, 39, 5, -36 },
  { 5395, 30, 36, 24, -3, -36 },
  { 5530, 23, 36, 23, 4, -36 },
  { 5634, 26, 36, 23, -1, -36 },
  { 5751, 19, 44, 14, -1, -36 },
  { 5856, 9, 36, 18, 5, -36 },
  { 5897, 19, 44, 14, -4, -36 },
  { 6002, 23, 22, 25, 1, -36 },
  { 6066, 19, 4, 18, -5, 4 },
  { 6076, 8, 8, 13, 7, -38 },
  { 6084, 23, 28, 26, 2, -27 },
  { 6165, 23, 39, 26, 1, -38 },
  { 6278, 19, 28, 20, 2, -27 },
  { 6345, 25, 39, 26, 2, -38 },
  { 6467, 20, 28, 23, 2, -27 },
  { 6537, 26, 50, 14, -6, -38 },
  { 6700, 25, 39, 26, 0, -27 },
  { 6822, 23, 38, 26, 1, -38 },
  { 6932, 12, 37, 12, 1, -37 },
  { 6988, 19, 49, 12, -6, -37 },
  { 7105, 23, 38, 22, 1, -38 },
  { 7215, 12, 38, 12, 1, -38 },
  { 7272, 36, 27, 39, 1, -27 },
  { 7394, 23, 27, 26, 1, -27 },
  { 7472, 21, 27, 25, 2, -27 },
  { 7543, 26, 39, 26, -2, -27 },
  { 7670, 23, 39, 26, 2, -27 },
  { 7783, 19, 27, 18, 1, -27 },
  { 7848, 19, 28, 19, 0, -27 },
  { 7915, 14, 34, 15, 2, -33 },
  { 7975, 23, 28, 26, 2, -27 },
  { 8056, 20, 27, 21, 3, -27 },
  { 8124, 32, 27, 33, 3, -27 },
  { 8232, 25, 27, 22, -2, -27 },
  { 8317, 29, 39, 21, -5, -27 },
  { 8459, 21, 27, 19, -1, -27 },
  { 8530, 19, 44, 17, 1, -36 },
  { 8635, 3, 50, 24, 11, -38 },
  { 8654, 18, 44, 17, -2, -36 },
  { 8753, 22, 7, 26, 3, -21 },
};

const GFXfont NotoSans_SemiCondensed_Italic50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic50pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC50PT7B_H_
