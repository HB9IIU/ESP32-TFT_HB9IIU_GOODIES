#ifndef _NOTOSANS_SEMICONDENSED_ITALIC53PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7C, 0x00, 0xC0, 0x00, 0x3C, 0x3E, 0xF8, 0x7D, 0xF0, 0xFB, 0xE1,
  0xE7, 0x83, 0xCF, 0x0F, 0x9E, 0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xE0, 0xF3,
  0xC1, 0xC7, 0x03, 0x8E, 0x0F, 0x1C, 0x1C, 0x00, 0x00, 0x07, 0x80, 0xE0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x03, 0xC0,
  0x70, 0x03, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0x80, 0x1E, 0x07, 0x80, 0x00, 0x70, 0x1C, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01,
  0xE0, 0x38, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1C, 0x07, 0x80, 0x3F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFC, 0x01, 0xE0, 0x38, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0E, 0x03, 0xC0, 0x00,
  0x38, 0x0E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xF3, 0x8E, 0x01,
  0xE1, 0xC1, 0x01, 0xF1, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x78, 0x70, 0x00,
  0x3C, 0x38, 0x00, 0x1E, 0x1C, 0x00, 0x0F, 0x1C, 0x00, 0x07, 0xCE, 0x00,
  0x03, 0xF7, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x39,
  0xF8, 0x00, 0x1C, 0x7C, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x0F, 0x00, 0x03,
  0x87, 0x80, 0x03, 0x83, 0xC0, 0x01, 0xC3, 0xE1, 0x00, 0xE1, 0xE0, 0xE0,
  0x73, 0xF0, 0x7F, 0x3F, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x3C, 0x03, 0xFC, 0x00, 0x1E, 0x03, 0xFF, 0x00, 0x1E, 0x03, 0xC7,
  0x80, 0x1E, 0x03, 0xC1, 0xE0, 0x0F, 0x01, 0xE0, 0xF0, 0x0F, 0x01, 0xE0,
  0x78, 0x0F, 0x00, 0xF0, 0x3C, 0x07, 0x80, 0x70, 0x1E, 0x07, 0x80, 0x78,
  0x0F, 0x07, 0x80, 0x3C, 0x07, 0x03, 0xC0, 0x1E, 0x03, 0x83, 0xC0, 0x0F,
  0x03, 0xC3, 0xC0, 0x07, 0x01, 0xE1, 0xE0, 0x03, 0x80, 0xE1, 0xE0, 0x01,
  0xC0, 0xF1, 0xE1, 0xF8, 0xE0, 0x78, 0xF3, 0xFE, 0x70, 0x38, 0xF3, 0xFF,
  0xB8, 0x3C, 0xF1, 0xE3, 0xDE, 0x3C, 0x79, 0xE0, 0xEF, 0xFE, 0x78, 0xE0,
  0x73, 0xFE, 0x78, 0xF0, 0x3C, 0xFC, 0x3C, 0x78, 0x1C, 0x00, 0x3C, 0x38,
  0x0E, 0x00, 0x3C, 0x3C, 0x07, 0x00, 0x1E, 0x1E, 0x07, 0x80, 0x1E, 0x0F,
  0x03, 0xC0, 0x1E, 0x07, 0x01, 0xE0, 0x0F, 0x03, 0x80, 0xF0, 0x0F, 0x03,
  0xC0, 0x70, 0x07, 0x01, 0xE0, 0x78, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80,
  0x78, 0x3C, 0x03, 0x80, 0x3C, 0x1E, 0x03, 0xC0, 0x0F, 0x1E, 0x03, 0xC0,
  0x07, 0xFE, 0x01, 0xC0, 0x01, 0xFF, 0x01, 0xE0, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x78, 0x0F,
  0x80, 0x03, 0xC0, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xE0, 0x1E, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x0F,
  0x0F, 0x80, 0x00, 0x78, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFD, 0xF0, 0x0F, 0x8F, 0xC7, 0xC0, 0x78, 0x7C,
  0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0x3C, 0x7C, 0x07, 0xC3, 0xE3, 0xC0, 0x1F,
  0x1E, 0x3E, 0x00, 0x7D, 0xF1, 0xF0, 0x03, 0xFF, 0x0F, 0x00, 0x0F, 0xF0,
  0x78, 0x00, 0x7F, 0x83, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x80, 0xF8,
  0x01, 0xFE, 0x07, 0xE0, 0x1F, 0xF8, 0x1F, 0xC7, 0xFF, 0xC0, 0x7F, 0xFF,
  0x1F, 0x03, 0xFF, 0xF0, 0xFC, 0x07, 0xFE, 0x03, 0xE0, 0x07, 0x00, 0x00,
  0x00, 0x3E, 0xF9, 0xF3, 0xE7, 0x8F, 0x1E, 0x38, 0xF1, 0xE3, 0xC7, 0x0E,
  0x1C, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x40, 0x3C, 0x01, 0xC0, 0xF0, 0x07, 0xC3,
  0x80, 0x1F, 0xCE, 0x00, 0xFF, 0xF8, 0x3C, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x01, 0xF8, 0x00, 0x0F, 0x70, 0x00, 0x79, 0xC0, 0x03,
  0xC7, 0x80, 0x3F, 0x0E, 0x00, 0xF8, 0x3C, 0x01, 0xC0, 0xF0, 0x02, 0x03,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x10, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x07, 0xC3, 0xE0, 0xF8, 0x7C,
  0x1F, 0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xE0, 0x00,
  0x7F, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xE0, 0x7D, 0xFF, 0xFF, 0xFF, 0xE7,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC,
  0x01, 0xF0, 0x7E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x1E,
  0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x1E, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1E,
  0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x1E, 0x3E, 0x00, 0x1E, 0x3C, 0x00, 0x1E,
  0x3C, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E,
  0x78, 0x00, 0x3E, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x7C, 0xF8, 0x00, 0x7C,
  0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8,
  0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x78, 0x03, 0xE0, 0x78, 0x03, 0xE0,
  0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0x3F, 0xBF, 0x80, 0x3F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0xC3, 0xFF, 0x8F, 0xDE, 0x7F, 0x3C,
  0xFC, 0x78, 0xE1, 0xF1, 0x83, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xF8,
  0x0F, 0xC0, 0x18, 0x01, 0xF0, 0x04, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x1E, 0x01, 0xF8, 0x06, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x80, 0x01, 0xF8, 0x70, 0x01, 0xF8, 0x3F,
  0x87, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xBC, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xDF, 0x00, 0x03, 0xCF, 0x00, 0x03,
  0xE7, 0x80, 0x03, 0xE3, 0xC0, 0x01, 0xE3, 0xE0, 0x01, 0xE1, 0xF0, 0x01,
  0xE0, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x3E, 0x00,
  0xF0, 0x1E, 0x00, 0xF8, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x78, 0x07, 0xC0,
  0x78, 0x03, 0xE0, 0x7C, 0x01, 0xE0, 0x7C, 0x00, 0xF0, 0x3C, 0x00, 0x78,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x80, 0x03, 0xF0, 0x60, 0x03, 0xF0,
  0x3F, 0x0F, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x07, 0xC0, 0x3E,
  0x7F, 0xE0, 0x7D, 0xFF, 0xE0, 0xF7, 0xFF, 0xC1, 0xFE, 0x0F, 0xC7, 0xF0,
  0x0F, 0x8F, 0xC0, 0x0F, 0x9F, 0x80, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00,
  0x7C, 0xF0, 0x00, 0xF9, 0xE0, 0x01, 0xF3, 0xC0, 0x03, 0xC7, 0x80, 0x07,
  0x8F, 0x00, 0x1F, 0x1E, 0x00, 0x3E, 0x3C, 0x00, 0x78, 0x7C, 0x01, 0xF0,
  0xF8, 0x07, 0xC0, 0xF8, 0x1F, 0x81, 0xFC, 0xFE, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x1F, 0xCF, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x00, 0x7C, 0x0F, 0x80,
  0x3E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x07, 0xC0, 0xF0,
  0x03, 0xE0, 0x78, 0x01, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x01, 0xF0, 0x07,
  0xC1, 0xF0, 0x01, 0xF3, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0x1F, 0x80,
  0x7C, 0x07, 0xE0, 0x7C, 0x01, 0xF0, 0x3C, 0x00, 0x7C, 0x3E, 0x00, 0x3E,
  0x1E, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x03,
  0xE3, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0xF8, 0x3F, 0x00,
  0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7E, 0x07, 0xC1, 0xF8, 0x07, 0x83, 0xE0,
  0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0xF8, 0x00,
  0x79, 0xF0, 0x00, 0xF3, 0xE0, 0x03, 0xE7, 0x80, 0x07, 0xCF, 0x00, 0x0F,
  0x9E, 0x00, 0x1F, 0x3E, 0x00, 0x7E, 0x7C, 0x01, 0xF8, 0xF8, 0x03, 0xF0,
  0xF8, 0x1F, 0xE1, 0xFF, 0xFF, 0xC1, 0xFF, 0xEF, 0x81, 0xFF, 0x9E, 0x00,
  0xFC, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xCF, 0xF8, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x81,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x18, 0x00,
  0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0x78, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xC0, 0x7C, 0x20, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xF1,
  0xFF, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x03, 0x00, 0x1C, 0x1E, 0x00,
  0xFF, 0xC0, 0xF0, 0xF0, 0x1F, 0xFF, 0x07, 0x8F, 0x01, 0xFF, 0xF0, 0x3C,
  0x78, 0x1F, 0x07, 0x81, 0xE7, 0x81, 0xF0, 0x3C, 0x0F, 0x3C, 0x0F, 0x01,
  0xE0, 0x79, 0xC0, 0xF0, 0x0E, 0x03, 0xDE, 0x07, 0x80, 0xF0, 0x1C, 0xF0,
  0x78, 0x07, 0x80, 0xE7, 0x83, 0xC0, 0x3C, 0x0F, 0x38, 0x1C, 0x03, 0xC0,
  0x7B, 0xC0, 0xE0, 0x1E, 0x03, 0xDE, 0x0F, 0x00, 0xF0, 0x1C, 0xF0, 0x78,
  0x0F, 0x81, 0xE7, 0x83, 0xC0, 0x78, 0x0E, 0x3C, 0x1E, 0x07, 0xC0, 0xF1,
  0xE0, 0xF0, 0x3E, 0x0F, 0x0F, 0x03, 0xC3, 0xF8, 0xF8, 0x78, 0x1F, 0xF9,
  0xFF, 0x83, 0xC0, 0x7F, 0x8F, 0xF8, 0x0F, 0x01, 0xF8, 0x3F, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x40, 0x00, 0x3F, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x79, 0xF0,
  0x00, 0x1F, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF8, 0x78, 0x00, 0x1E,
  0x0F, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x3E, 0x07, 0x80,
  0x07, 0xC0, 0xF0, 0x01, 0xF0, 0x1E, 0x00, 0x3E, 0x03, 0xC0, 0x0F, 0x80,
  0x78, 0x01, 0xF0, 0x0F, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0x00, 0x1F, 0x03, 0xE0, 0x03,
  0xE0, 0x78, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0xF8,
  0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x0F,
  0xBE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0xC0, 0x7C, 0x00, 0xF8, 0x0F,
  0x00, 0x1F, 0x01, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F,
  0x81, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x81, 0xF0,
  0x03, 0xE0, 0x3E, 0x01, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0xF8, 0x0F, 0xE0, 0x1E, 0x00,
  0x7C, 0x03, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x83,
  0xE0, 0x01, 0xF0, 0x78, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0xC3, 0xE0, 0x01,
  0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xE0, 0x01, 0xF0, 0x3C,
  0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xE0,
  0x1C, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xF0, 0x06, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0x03, 0xFE, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x3C, 0x00,
  0x3E, 0x01, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E,
  0x07, 0xC0, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x7C, 0x1F,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0x80, 0x00, 0xF8, 0x3C, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xF0, 0x3C, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0xFC,
  0x07, 0x80, 0x0F, 0xC0, 0x3C, 0x01, 0xFC, 0x03, 0xE0, 0x3F, 0xC0, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xE0, 0x0F, 0x00, 0xFC, 0x00, 0x08, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0xF8, 0xF0, 0x01, 0xFF, 0xCF, 0x80,
  0x1F, 0xFC, 0x7C, 0x00, 0xFF, 0xE3, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3C, 0x3E, 0x00, 0x01, 0xE1,
  0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0x81, 0xF0,
  0x00, 0x3C, 0x0F, 0xC0, 0x03, 0xE0, 0x3F, 0x00, 0x1F, 0x01, 0xFC, 0x00,
  0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3C,
  0x01, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0xF8,
  0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0x01, 0xE0,
  0x0F, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE,
  0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x7C,
  0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x3F, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x78,
  0x07, 0xC0, 0x01, 0xE0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xC3, 0xF0, 0x00, 0x0F, 0x1F, 0x80,
  0x00, 0x7C, 0xFC, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0x9F, 0x00, 0x00,
  0x1E, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xEF, 0x80, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xE0, 0x3E,
  0x00, 0x07, 0x80, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0,
  0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x1E, 0x00, 0x1F, 0x00, 0x78,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xDE, 0x01, 0xFE, 0x00, 0x03,
  0xFE, 0x01, 0xFE, 0x00, 0x07, 0xBE, 0x03, 0xEF, 0x00, 0x07, 0xBC, 0x03,
  0xCF, 0x00, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x03, 0xCF, 0x00,
  0x1E, 0x7C, 0x07, 0xCF, 0x00, 0x1E, 0x7C, 0x07, 0xCF, 0x00, 0x3C, 0x78,
  0x07, 0x8F, 0x00, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0x78, 0xF8, 0x07, 0x8F,
  0x00, 0x78, 0xF8, 0x0F, 0x8F, 0x00, 0xF0, 0xF0, 0x0F, 0x87, 0x00, 0xF0,
  0xF0, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x0F, 0x07, 0x81, 0xE1, 0xF0, 0x0F,
  0x07, 0x83, 0xC1, 0xF0, 0x1F, 0x07, 0x87, 0xC1, 0xE0, 0x1F, 0x07, 0x87,
  0x81, 0xE0, 0x1E, 0x07, 0x8F, 0x83, 0xE0, 0x1E, 0x07, 0x8F, 0x03, 0xE0,
  0x1E, 0x07, 0x9F, 0x03, 0xE0, 0x3E, 0x07, 0x9E, 0x03, 0xC0, 0x3C, 0x07,
  0xBE, 0x03, 0xC0, 0x3C, 0x03, 0xBC, 0x07, 0xC0, 0x3C, 0x03, 0xFC, 0x07,
  0xC0, 0x7C, 0x03, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xF8, 0x07, 0x80, 0x78,
  0x03, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x78, 0x03, 0xE0,
  0x0F, 0x80, 0xF8, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x7E, 0x00, 0x03, 0xC0, 0x3F, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x01, 0xF0,
  0x1F, 0xE0, 0x00, 0xF0, 0x0F, 0xF0, 0x00, 0x78, 0x07, 0xF8, 0x00, 0x3C,
  0x03, 0xFE, 0x00, 0x3E, 0x01, 0xEF, 0x00, 0x1F, 0x01, 0xF7, 0x80, 0x0F,
  0x00, 0xF3, 0xC0, 0x07, 0x80, 0x79, 0xF0, 0x03, 0xC0, 0x3C, 0x78, 0x03,
  0xE0, 0x3E, 0x3C, 0x01, 0xE0, 0x1F, 0x1F, 0x00, 0xF0, 0x0F, 0x07, 0x80,
  0x78, 0x07, 0x83, 0xC0, 0x7C, 0x03, 0xC1, 0xF0, 0x3E, 0x03, 0xE0, 0xF8,
  0x1E, 0x01, 0xF0, 0x3C, 0x0F, 0x00, 0xF0, 0x1E, 0x07, 0x80, 0x78, 0x0F,
  0x87, 0xC0, 0x3C, 0x03, 0xC3, 0xE0, 0x3E, 0x01, 0xE1, 0xE0, 0x1F, 0x00,
  0xF8, 0xF0, 0x0F, 0x00, 0x3C, 0x78, 0x07, 0x80, 0x1E, 0x7C, 0x03, 0xC0,
  0x0F, 0x3E, 0x03, 0xE0, 0x07, 0xDE, 0x01, 0xE0, 0x01, 0xEF, 0x00, 0xF0,
  0x00, 0xF7, 0x80, 0x78, 0x00, 0x7F, 0xC0, 0x7C, 0x00, 0x1F, 0xC0, 0x3E,
  0x00, 0x0F, 0xE0, 0x1E, 0x00, 0x07, 0xF0, 0x0F, 0x00, 0x01, 0xF8, 0x07,
  0x80, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xC0, 0x7F, 0x01, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xC0, 0xF8, 0x00,
  0x1F, 0x0F, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x1E,
  0x3E, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x3C, 0xF8,
  0x00, 0x01, 0xEF, 0x80, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x0F, 0xCF, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x7E,
  0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x7F, 0x01, 0xF8, 0x07, 0xF0, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xF0, 0x3F, 0x80, 0x7C,
  0x03, 0xF0, 0x1F, 0x00, 0x7C, 0x07, 0x80, 0x1F, 0x01, 0xE0, 0x07, 0xC0,
  0xF8, 0x00, 0xF0, 0x3E, 0x00, 0x3C, 0x0F, 0x80, 0x1F, 0x03, 0xC0, 0x07,
  0xC0, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x78, 0x1F, 0x00, 0x3E, 0x07, 0x80,
  0x1F, 0x81, 0xE0, 0x0F, 0xC0, 0xF8, 0x0F, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xC0,
  0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x1E, 0x3E, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x07, 0x9F, 0x00, 0x00,
  0x3C, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x7B,
  0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xE1, 0xF0,
  0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x07,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xDF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x01, 0xF0, 0x3F, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x00, 0x7C,
  0x07, 0x80, 0x1F, 0x01, 0xE0, 0x07, 0xC0, 0xF8, 0x00, 0xF0, 0x3E, 0x00,
  0x3C, 0x0F, 0x80, 0x1F, 0x03, 0xC0, 0x07, 0xC0, 0xF0, 0x01, 0xF0, 0x7C,
  0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x07, 0x80, 0x1F, 0x01, 0xE0, 0x1F, 0xC0,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0,
  0x00, 0xF0, 0x7C, 0x00, 0x7C, 0x0F, 0x00, 0x1F, 0x03, 0xC0, 0x07, 0xC0,
  0xF8, 0x01, 0xE0, 0x3E, 0x00, 0x78, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0xF0, 0x03, 0xE0, 0x3C, 0x00, 0xF8,
  0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC1, 0xE0, 0x01, 0xF0, 0x78, 0x00,
  0x7C, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0x80, 0x70, 0x1F, 0x80, 0x08,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x80, 0x03, 0xF0,
  0x70, 0x03, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x0F, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x1E,
  0x07, 0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0x3C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x1F, 0x03, 0xC0, 0x00, 0x78, 0x1F, 0x00, 0x01, 0xE0, 0x7C, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0xF0, 0x3E, 0x00, 0x03,
  0xC0, 0xF8, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xF0,
  0x3C, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF8, 0x1F,
  0x00, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x80,
  0x00, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0xFC,
  0x01, 0xF8, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xEF, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xE3, 0xE0,
  0x00, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1E, 0x0F, 0x80, 0x0F, 0x81,
  0xE0, 0x03, 0xC0, 0x78, 0x01, 0xF0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x3E,
  0x01, 0xE0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x1E, 0x01, 0xF0, 0x07, 0x80,
  0xF8, 0x01, 0xE0, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07,
  0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x1F, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0xF3, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x7C,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0xBE, 0x00, 0x1F, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xC0, 0x03,
  0xCF, 0x80, 0x0F, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xF0, 0x01, 0xF3, 0xE0,
  0x03, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xFC, 0x00, 0xF8, 0xF8, 0x01, 0xFE,
  0x00, 0x78, 0x7C, 0x01, 0xEF, 0x00, 0x7C, 0x3E, 0x00, 0xF7, 0x80, 0x3C,
  0x1F, 0x00, 0xF3, 0xC0, 0x3E, 0x0F, 0x80, 0x79, 0xE0, 0x1F, 0x03, 0xC0,
  0x7C, 0xF0, 0x0F, 0x01, 0xE0, 0x3C, 0x78, 0x0F, 0x80, 0xF0, 0x1E, 0x3C,
  0x07, 0x80, 0x78, 0x1E, 0x1E, 0x07, 0xC0, 0x3C, 0x0F, 0x0F, 0x03, 0xC0,
  0x1E, 0x0F, 0x07, 0x83, 0xE0, 0x0F, 0x07, 0x83, 0xC1, 0xF0, 0x07, 0x87,
  0x81, 0xE0, 0xF0, 0x03, 0xC3, 0xC0, 0xF0, 0xF8, 0x01, 0xE1, 0xE0, 0x78,
  0x78, 0x00, 0xF1, 0xE0, 0x3C, 0x7C, 0x00, 0x78, 0xF0, 0x1E, 0x3C, 0x00,
  0x3C, 0xF0, 0x0F, 0x1E, 0x00, 0x1E, 0x78, 0x07, 0x9E, 0x00, 0x0F, 0x78,
  0x03, 0xCF, 0x00, 0x07, 0xBC, 0x01, 0xEF, 0x80, 0x03, 0xDE, 0x00, 0xF7,
  0x80, 0x01, 0xFE, 0x00, 0x7B, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1E, 0x01, 0xF0, 0x00,
  0x1E, 0x03, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x0F, 0x0F, 0x80, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00,
  0x07, 0xBE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0x7C, 0x78, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01,
  0xF0, 0x3C, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7C,
  0xF8, 0x00, 0x7C, 0x78, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0x78, 0x01, 0xF0,
  0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x3C, 0x07, 0x80,
  0x3C, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x1E, 0x00, 0x1E, 0x3E, 0x00,
  0x1E, 0x3C, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x3C,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xCF, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xE1, 0xC0, 0x00,
  0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x0F, 0x00,
  0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x3C,
  0x0F, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x00,
  0xF3, 0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x1E, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF8, 0xF8, 0x78, 0x7C, 0x3C, 0x3E, 0x1E, 0x0F, 0x07,
  0x00, 0x3E, 0x00, 0x80, 0x7F, 0xC3, 0x80, 0x7F, 0xF3, 0xC0, 0x7F, 0xFD,
  0xE0, 0x7E, 0x0E, 0xF0, 0x7E, 0x03, 0xF8, 0x3E, 0x01, 0xF8, 0x3E, 0x00,
  0x7C, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x8F, 0x80,
  0x07, 0x87, 0xC0, 0x03, 0xC3, 0xE0, 0x03, 0xE1, 0xE0, 0x01, 0xF0, 0xF0,
  0x00, 0xF8, 0xF8, 0x00, 0x78, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F,
  0x00, 0x1F, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0xC1,
  0xF0, 0x0F, 0xE0, 0x7C, 0x0E, 0xF0, 0x3F, 0x1E, 0xF0, 0x1F, 0xFE, 0x78,
  0x07, 0xFE, 0x3C, 0x01, 0xFE, 0x1E, 0x00, 0x08, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x3E, 0x00,
  0x3C, 0x7F, 0xC0, 0x1E, 0x7F, 0xF0, 0x1F, 0x7F, 0xF8, 0x0F, 0x78, 0x7E,
  0x07, 0xF0, 0x1F, 0x03, 0xF0, 0x07, 0x83, 0xF8, 0x03, 0xC1, 0xF8, 0x01,
  0xE0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x78, 0x3E, 0x00, 0x3C, 0x3E, 0x00,
  0x1E, 0x1F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x87, 0x80, 0x07, 0xC3, 0xC0,
  0x03, 0xE3, 0xE0, 0x01, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C,
  0x00, 0xF8, 0x7E, 0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x1F, 0x80, 0x7E, 0x0F,
  0xE0, 0x7E, 0x07, 0xFC, 0x7E, 0x07, 0x9F, 0xFE, 0x03, 0xC7, 0xFE, 0x01,
  0xE1, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xFF,
  0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xE0, 0x60, 0xFC, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x01, 0x07, 0xF0, 0xF0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x1F, 0x07, 0xC0, 0x0F, 0xF8, 0xF0, 0x03, 0xFF, 0x9E, 0x00, 0xFF, 0xFB,
  0xC0, 0x3F, 0x07, 0x78, 0x0F, 0xC0, 0x7F, 0x01, 0xF0, 0x07, 0xC0, 0x7C,
  0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x78,
  0x1F, 0x00, 0x0F, 0x03, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x00,
  0x0F, 0x83, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x3C, 0x0F, 0x80, 0x0F, 0x81,
  0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x03,
  0xF0, 0x1F, 0x00, 0x7E, 0x03, 0xE0, 0x1F, 0xC0, 0x3E, 0x07, 0xF8, 0x07,
  0xE3, 0xDE, 0x00, 0xFF, 0xF3, 0xC0, 0x0F, 0xFC, 0x78, 0x00, 0xFF, 0x0F,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0xE0, 0x7E, 0x0F, 0x87, 0xC0, 0x7C, 0x7E, 0x01, 0xE3,
  0xE0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0x8F, 0x00, 0x7C, 0xF8, 0x0F,
  0xC7, 0xC1, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x83, 0xF8,
  0x3C, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFC, 0x40, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x08, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x20, 0x07, 0xFC, 0x38, 0x01, 0xFF, 0xCF, 0x00, 0x7F, 0xFD, 0xE0, 0x1F,
  0x83, 0xBC, 0x07, 0xE0, 0x3F, 0x80, 0xF8, 0x07, 0xE0, 0x3E, 0x00, 0x7C,
  0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x0F, 0x80,
  0x07, 0x81, 0xF0, 0x00, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0x80, 0x07, 0xC1,
  0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00,
  0xF8, 0x1F, 0x00, 0x3F, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x01, 0xF8, 0x0F,
  0x80, 0x3F, 0x01, 0xF0, 0x0F, 0xE0, 0x1F, 0x03, 0xFC, 0x03, 0xF1, 0xEF,
  0x00, 0x7F, 0xF9, 0xE0, 0x07, 0xFE, 0x3C, 0x00, 0x7F, 0x8F, 0x80, 0x01,
  0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x0C, 0x00,
  0x7C, 0x01, 0xF0, 0x3F, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xC1, 0xF0, 0x03, 0xC7, 0xFC, 0x03, 0xCF,
  0xFE, 0x07, 0xDF, 0xFE, 0x07, 0xBC, 0x3F, 0x07, 0xF0, 0x1F, 0x07, 0xE0,
  0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80,
  0x1F, 0x0F, 0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x1F, 0x00, 0x3E, 0x1E, 0x00,
  0x3E, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x3E, 0x00,
  0x7C, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x7C, 0x00,
  0x78, 0x7C, 0x00, 0xF8, 0x78, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0xF8, 0x00,
  0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x00, 0x70, 0x07, 0x80, 0x7E,
  0x03, 0xE0, 0x1F, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x10, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x10, 0x3C, 0x01, 0xF0, 0x1E, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0x81, 0xF0, 0x03, 0xC1, 0xF0,
  0x03, 0xE1, 0xF0, 0x01, 0xF1, 0xF0, 0x00, 0xF1, 0xF0, 0x00, 0x78, 0xF0,
  0x00, 0x3C, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xF7, 0xC0, 0x03, 0xF1, 0xE0, 0x01, 0xF0,
  0xF8, 0x00, 0xF0, 0x7C, 0x00, 0x78, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E,
  0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x07,
  0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x00, 0xF8, 0x07,
  0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0,
  0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0,
  0x1E, 0x00, 0x00, 0x41, 0xF0, 0x07, 0xC0, 0x0E, 0x1F, 0xE0, 0x7F, 0xC0,
  0x38, 0xFF, 0xC3, 0xFF, 0x81, 0xE7, 0xFF, 0x9F, 0xFE, 0x07, 0xBC, 0x3E,
  0xF0, 0xFC, 0x1F, 0xC0, 0x7F, 0x81, 0xF0, 0x7E, 0x01, 0xFC, 0x07, 0xC3,
  0xF0, 0x07, 0xE0, 0x1F, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0x7C,
  0x01, 0xF0, 0xF8, 0x03, 0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x80, 0x1E, 0x1F,
  0x00, 0x3E, 0x00, 0x78, 0x7C, 0x00, 0xF0, 0x03, 0xE1, 0xE0, 0x03, 0xC0,
  0x0F, 0x87, 0x80, 0x1F, 0x00, 0x3C, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0xF8,
  0x01, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0x80, 0x1F, 0x0F, 0x00, 0x1E, 0x00,
  0x78, 0x3C, 0x00, 0xF8, 0x01, 0xE1, 0xF0, 0x03, 0xE0, 0x07, 0x87, 0xC0,
  0x0F, 0x00, 0x3E, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x78, 0x01, 0xF0, 0x03,
  0xC1, 0xE0, 0x07, 0xC0, 0x0F, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x3E, 0x00,
  0x78, 0x01, 0xF0, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x03, 0xC1, 0xF8, 0x03,
  0xC7, 0xFC, 0x07, 0x8F, 0xFE, 0x07, 0x9F, 0xFF, 0x07, 0xBC, 0x3F, 0x07,
  0xF8, 0x1F, 0x07, 0xE0, 0x1F, 0x0F, 0xE0, 0x1F, 0x0F, 0xC0, 0x1F, 0x0F,
  0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x80, 0x1E, 0x1F, 0x00, 0x3E, 0x1F,
  0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x3E,
  0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x7C,
  0x00, 0x78, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x78, 0x00, 0xF8, 0x78,
  0x00, 0xF0, 0xF8, 0x00, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7E,
  0x0F, 0x81, 0xF8, 0x0F, 0x83, 0xE0, 0x0F, 0x0F, 0x80, 0x1E, 0x3E, 0x00,
  0x3E, 0x7C, 0x00, 0x7C, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03,
  0xEF, 0x00, 0x07, 0xDE, 0x00, 0x0F, 0x7C, 0x00, 0x1E, 0xF8, 0x00, 0x7D,
  0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x9F,
  0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x3E, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0x7E,
  0x3F, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x07, 0x8F, 0xF8, 0x00, 0x71, 0xFF, 0xC0, 0x0F, 0x3F,
  0xFC, 0x00, 0xF7, 0x87, 0xE0, 0x0F, 0xE0, 0x3E, 0x00, 0xFC, 0x01, 0xE0,
  0x0F, 0xC0, 0x1E, 0x01, 0xF8, 0x01, 0xE0, 0x1F, 0x00, 0x1F, 0x01, 0xF0,
  0x01, 0xE0, 0x1F, 0x00, 0x1E, 0x03, 0xE0, 0x01, 0xE0, 0x3E, 0x00, 0x1E,
  0x03, 0xE0, 0x03, 0xE0, 0x3C, 0x00, 0x3E, 0x03, 0xC0, 0x03, 0xE0, 0x7C,
  0x00, 0x3C, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x0F,
  0x80, 0x7C, 0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xE0, 0x7E, 0x00, 0xFF, 0x8F, 0xC0, 0x1F, 0x7F, 0xF8, 0x01, 0xF3, 0xFF,
  0x00, 0x1E, 0x1F, 0xE0, 0x01, 0xE0, 0x20, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x80, 0x7F, 0xC3, 0x80, 0x7F, 0xF3, 0xC0,
  0x7F, 0xFD, 0xE0, 0x7E, 0x0E, 0xF0, 0x7E, 0x03, 0xF8, 0x3E, 0x01, 0xF8,
  0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F,
  0x8F, 0x80, 0x07, 0x87, 0xC0, 0x03, 0xC3, 0xE0, 0x03, 0xE1, 0xE0, 0x01,
  0xF1, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0x78, 0x7C, 0x00, 0x7C, 0x3E, 0x00,
  0x3E, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x1F, 0x83, 0xE0,
  0x0F, 0xC1, 0xF0, 0x0F, 0xE0, 0x7C, 0x0F, 0xF0, 0x3F, 0x1E, 0xF0, 0x1F,
  0xFE, 0x78, 0x07, 0xFE, 0x3C, 0x01, 0xFE, 0x3E, 0x00, 0x10, 0x1F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x43, 0xF0, 0x38, 0x7E, 0x03, 0x8F, 0xE0, 0x79, 0xFE,
  0x07, 0xBE, 0x20, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x7F,
  0xFF, 0x0F, 0xC0, 0xE0, 0xF8, 0x02, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0xC0, 0x1F, 0x8F, 0x87, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xC0, 0x7F, 0xF8, 0x00, 0x10, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0xFF, 0x7F, 0xFE, 0xFF,
  0xFE, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x20, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x00,
  0x10, 0x00, 0x07, 0x80, 0x0F, 0x0F, 0x80, 0x0F, 0x0F, 0x80, 0x1F, 0x0F,
  0x00, 0x1F, 0x0F, 0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x1F,
  0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x1E, 0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x3E,
  0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x7C,
  0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x78, 0x00, 0xF8, 0x78, 0x01, 0xF0, 0x78,
  0x01, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x07, 0xF0, 0xF8,
  0x0F, 0xE0, 0x7E, 0x7D, 0xE0, 0x7F, 0xF9, 0xE0, 0x3F, 0xF1, 0xE0, 0x1F,
  0xE1, 0xC0, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xEF, 0x00,
  0x0F, 0x3C, 0x00, 0x7C, 0xF0, 0x01, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3C,
  0x3E, 0x01, 0xF0, 0xF8, 0x07, 0x81, 0xE0, 0x3E, 0x07, 0x80, 0xF0, 0x1E,
  0x07, 0xC0, 0x78, 0x1E, 0x01, 0xE0, 0xF8, 0x07, 0x83, 0xC0, 0x1E, 0x1F,
  0x00, 0x78, 0x78, 0x01, 0xE3, 0xE0, 0x07, 0x8F, 0x00, 0x1E, 0x7C, 0x00,
  0x79, 0xE0, 0x01, 0xEF, 0x80, 0x03, 0xBC, 0x00, 0x0E, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x03,
  0xE0, 0x07, 0xFC, 0x00, 0xF8, 0x01, 0xEF, 0x00, 0x7E, 0x00, 0xFB, 0xC0,
  0x1F, 0x80, 0x3C, 0xF0, 0x0F, 0xE0, 0x1F, 0x3E, 0x03, 0xF8, 0x07, 0x8F,
  0x81, 0xEF, 0x03, 0xE3, 0xE0, 0x7B, 0xC0, 0xF8, 0xF8, 0x1C, 0xF0, 0x3C,
  0x3E, 0x0F, 0x3C, 0x1F, 0x0F, 0x83, 0xCF, 0x07, 0x83, 0xE1, 0xE3, 0xC3,
  0xE0, 0xF8, 0x78, 0xF0, 0xF0, 0x3E, 0x3C, 0x3C, 0x3C, 0x0F, 0x8F, 0x0F,
  0x1E, 0x03, 0xE3, 0x83, 0xC7, 0x80, 0xF9, 0xE0, 0xF3, 0xE0, 0x3E, 0x70,
  0x3C, 0xF0, 0x0F, 0xBC, 0x0F, 0x7C, 0x03, 0xEF, 0x03, 0xDE, 0x00, 0x77,
  0x80, 0xF7, 0x80, 0x1D, 0xE0, 0x3F, 0xC0, 0x07, 0x70, 0x0F, 0xF0, 0x01,
  0xFC, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x3F, 0x80,
  0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x07,
  0xE0, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x00, 0x78, 0x0F, 0x80, 0x0F,
  0x03, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC7, 0xC0,
  0x00, 0x7D, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xDF,
  0x00, 0x01, 0xF1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x87, 0xC0, 0x03,
  0xE0, 0x78, 0x00, 0xF8, 0x0F, 0x00, 0x1E, 0x01, 0xF0, 0x07, 0xC0, 0x1E,
  0x01, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x7C,
  0x03, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x1E,
  0x01, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x01, 0xE0, 0x3E, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0xF8,
  0x00, 0x07, 0xC3, 0xC0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x00, 0xF3, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x87,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x70, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x00,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x02, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0x20, 0x00, 0x78,
  0x00,
};

const GFXglyph NotoSans_SemiCondensed_Italic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 13, 39, 13, 1, -38 },
  { 65, 15, 14, 20, 6, -38 },
  { 92, 30, 38, 30, 1, -38 },
  { 235, 25, 43, 26, 1, -40 },
  { 370, 33, 39, 39, 4, -38 },
  { 531, 29, 39, 31, 1, -38 },
  { 673, 7, 14, 11, 6, -38 },
  { 686, 17, 46, 15, 2, -38 },
  { 784, 17, 46, 15, -4, -38 },
  { 882, 22, 22, 26, 5, -40 },
  { 943, 23, 25, 28, 3, -31 },
  { 1015, 10, 13, 13, -2, -6 },
  { 1032, 13, 4, 16, 1, -16 },
  { 1039, 6, 7, 13, 1, -6 },
  { 1045, 25, 38, 18, -2, -38 },
  { 1164, 24, 39, 26, 2, -38 },
  { 1281, 15, 38, 26, 7, -38 },
  { 1353, 26, 38, 26, -1, -38 },
  { 1477, 25, 39, 26, 0, -38 },
  { 1599, 25, 38, 26, 0, -38 },
  { 1718, 25, 39, 26, 1, -38 },
  { 1840, 23, 39, 26, 3, -38 },
  { 1953, 24, 38, 26, 3, -38 },
  { 2067, 25, 39, 26, 1, -38 },
  { 2189, 23, 39, 26, 2, -38 },
  { 2302, 10, 30, 13, 1, -29 },
  { 2340, 15, 36, 13, -3, -29 },
  { 2408, 23, 26, 28, 3, -32 },
  { 2483, 23, 15, 28, 3, -26 },
  { 2527, 23, 26, 28, 3, -32 },
  { 2602, 19, 39, 20, 3, -38 },
  { 2695, 37, 43, 40, 2, -38 },
  { 2894, 27, 38, 27, -3, -38 },
  { 3023, 27, 38, 29, 1, -38 },
  { 3152, 27, 39, 27, 3, -38 },
  { 3284, 29, 38, 31, 1, -38 },
  { 3422, 26, 38, 24, 1, -38 },
  { 3546, 26, 38, 23, 1, -38 },
  { 3670, 29, 39, 32, 3, -38 },
  { 3812, 32, 38, 32, 1, -38 },
  { 3964, 21, 38, 16, -2, -38 },
  { 4064, 22, 48, 13, -8, -38 },
  { 4196, 30, 38, 27, 1, -38 },
  { 4339, 18, 38, 23, 1, -38 },
  { 4425, 40, 38, 41, 1, -38 },
  { 4615, 33, 38, 34, 1, -38 },
  { 4772, 29, 39, 34, 3, -38 },
  { 4914, 26, 38, 27, 1, -38 },
  { 5038, 29, 47, 34, 3, -38 },
  { 5209, 26, 38, 27, 1, -38 },
  { 5333, 25, 39, 24, 0, -38 },
  { 5455, 23, 38, 23, 5, -38 },
  { 5565, 30, 39, 32, 3, -38 },
  { 5712, 26, 38, 26, 5, -38 },
  { 5836, 41, 38, 41, 5, -38 },
  { 6031, 32, 38, 25, -3, -38 },
  { 6183, 24, 38, 24, 5, -38 },
  { 6297, 28, 38, 24, -1, -38 },
  { 6430, 20, 46, 15, -1, -38 },
  { 6545, 9, 38, 19, 6, -38 },
  { 6588, 20, 46, 15, -4, -38 },
  { 6703, 25, 23, 27, 1, -38 },
  { 6775, 20, 3, 19, -5, 5 },
  { 6783, 8, 9, 14, 8, -41 },
  { 6792, 25, 30, 27, 2, -29 },
  { 6886, 25, 41, 28, 1, -40 },
  { 7015, 20, 30, 21, 2, -29 },
  { 7090, 27, 41, 28, 2, -40 },
  { 7229, 21, 30, 24, 2, -29 },
  { 7308, 28, 54, 15, -6, -41 },
  { 7497, 27, 42, 28, 0, -29 },
  { 7639, 24, 40, 27, 1, -40 },
  { 7759, 13, 39, 12, 1, -39 },
  { 7823, 21, 52, 12, -7, -39 },
  { 7960, 25, 40, 24, 1, -40 },
  { 8085, 13, 40, 12, 1, -40 },
  { 8150, 38, 29, 41, 1, -29 },
  { 8288, 24, 29, 27, 1, -29 },
  { 8375, 23, 29, 27, 2, -29 },
  { 8459, 28, 42, 28, -2, -29 },
  { 8606, 25, 42, 28, 2, -29 },
  { 8738, 20, 29, 19, 1, -29 },
  { 8811, 20, 30, 21, 0, -29 },
  { 8886, 15, 36, 16, 2, -35 },
  { 8954, 24, 29, 27, 2, -28 },
  { 9041, 22, 28, 22, 3, -28 },
  { 9118, 34, 28, 35, 3, -28 },
  { 9237, 27, 28, 23, -2, -28 },
  { 9332, 30, 41, 22, -5, -28 },
  { 9486, 22, 28, 20, -1, -28 },
  { 9563, 20, 46, 18, 1, -38 },
  { 9678, 3, 53, 26, 12, -40 },
  { 9698, 19, 46, 18, -2, -38 },
  { 9808, 23, 7, 28, 3, -22 },
};

const GFXfont NotoSans_SemiCondensed_Italic53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic53pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC53PT7B_H_
