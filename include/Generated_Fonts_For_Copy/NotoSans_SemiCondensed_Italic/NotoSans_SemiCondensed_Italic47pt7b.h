#ifndef _NOTOSANS_SEMICONDENSED_ITALIC47PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0,
  0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x07, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x00, 0x20, 0x00, 0x3C, 0x7C, 0xF1, 0xF7, 0x87, 0x9E,
  0x1E, 0x78, 0x79, 0xE1, 0xC7, 0x07, 0x1C, 0x3C, 0x70, 0xF3, 0x83, 0x8E,
  0x0E, 0x38, 0x38, 0xE0, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0,
  0x01, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x0F, 0x07,
  0x80, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x78, 0x3C, 0x00, 0x1C,
  0x0E, 0x01, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC0,
  0x38, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xC0, 0xE0,
  0x00, 0x70, 0x38, 0x00, 0x3C, 0x1E, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81,
  0xC0, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x07,
  0x03, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x1C, 0x00,
  0x0E, 0x0F, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x38,
  0x00, 0x3C, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x80, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xCE, 0x38, 0x1E, 0x38, 0x00,
  0xF0, 0xC0, 0x03, 0xC7, 0x00, 0x0F, 0x1C, 0x00, 0x3C, 0x70, 0x00, 0xF1,
  0x80, 0x03, 0xE6, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0x3C, 0x00,
  0x1C, 0xF0, 0x00, 0x61, 0xE0, 0x03, 0x87, 0x80, 0x0E, 0x1C, 0x00, 0x38,
  0xF0, 0x80, 0xC3, 0xC3, 0x83, 0x3E, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80,
  0x7F, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xF0,
  0x3F, 0x80, 0x0F, 0x03, 0xFE, 0x00, 0x70, 0x3C, 0x70, 0x07, 0x83, 0xC3,
  0xC0, 0x78, 0x1C, 0x1E, 0x03, 0x80, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0x83,
  0xC0, 0x70, 0x38, 0x1C, 0x03, 0x81, 0xC1, 0xE0, 0x1C, 0x0E, 0x1E, 0x01,
  0xE0, 0x70, 0xE0, 0x0F, 0x07, 0x8F, 0x00, 0x70, 0x38, 0xF0, 0xE3, 0x81,
  0xC7, 0x1F, 0xDC, 0x1E, 0x79, 0xFE, 0xF0, 0xE7, 0x9E, 0x7B, 0x8F, 0x39,
  0xE1, 0xDF, 0xF3, 0xCE, 0x0E, 0x7F, 0x1C, 0x70, 0x71, 0xE1, 0xC7, 0x03,
  0x80, 0x1E, 0x38, 0x1C, 0x00, 0xE1, 0xC0, 0xE0, 0x0E, 0x1E, 0x07, 0x00,
  0xF0, 0xF0, 0x78, 0x07, 0x07, 0x03, 0xC0, 0x70, 0x38, 0x1C, 0x07, 0x81,
  0xC0, 0xE0, 0x38, 0x0E, 0x0F, 0x03, 0x80, 0x70, 0x70, 0x3C, 0x03, 0xC7,
  0x81, 0xC0, 0x1F, 0xF8, 0x1C, 0x00, 0x7F, 0x81, 0xE0, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1E, 0x1E,
  0x00, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x07, 0x80,
  0xF0, 0x03, 0xC0, 0x70, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x7C, 0x00, 0x38,
  0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x0F, 0x7C, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xEF, 0x01, 0xE3,
  0xE7, 0xC0, 0xF3, 0xC1, 0xE0, 0xF3, 0xE0, 0x78, 0x79, 0xE0, 0x3E, 0x79,
  0xE0, 0x0F, 0x3C, 0xF0, 0x07, 0xFC, 0x78, 0x01, 0xFC, 0x3C, 0x00, 0xFE,
  0x1E, 0x00, 0x3E, 0x0F, 0x00, 0x3F, 0x07, 0xC0, 0x3F, 0xC1, 0xF0, 0x7F,
  0xE0, 0xFF, 0xFE, 0xF8, 0x3F, 0xFC, 0x3C, 0x0F, 0xF8, 0x1F, 0x00, 0x3C,
  0xF7, 0xDE, 0x79, 0xE7, 0x1C, 0x73, 0xCE, 0x38, 0xE0, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0xC1, 0xC0, 0x3E, 0x38, 0x07,
  0xF7, 0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x81, 0xF0, 0x00,
  0x77, 0x00, 0x3C, 0xE0, 0x0F, 0x9E, 0x03, 0xE1, 0xC0, 0x38, 0x3C, 0x02,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x08, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x87, 0x87, 0xC3, 0xC1, 0xE1, 0xE0,
  0xF0, 0xF0, 0x78, 0x38, 0x38, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x13,
  0xFF, 0xFF, 0xF9, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF,
  0xC0, 0x7C, 0x1F, 0x03, 0xC0, 0x78, 0x3E, 0x03, 0xC1, 0xE0, 0x1E, 0x1F,
  0x00, 0x78, 0xF0, 0x03, 0xCF, 0x80, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x0F,
  0x9E, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xF3, 0xC0,
  0x07, 0x9E, 0x00, 0x3D, 0xE0, 0x03, 0xEF, 0x00, 0x1E, 0x78, 0x00, 0xF3,
  0xC0, 0x07, 0x9E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x3E, 0x3C, 0x01,
  0xE1, 0xE0, 0x1F, 0x0F, 0x80, 0xF0, 0x3C, 0x0F, 0x81, 0xF0, 0xF8, 0x07,
  0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x38, 0x07, 0xC0,
  0x7E, 0x0F, 0xF0, 0xFF, 0x0F, 0xF9, 0xFB, 0xDF, 0x9E, 0x70, 0xF3, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x3E, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFF, 0x01, 0xC0, 0x7C, 0x06, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFE,
  0x7F, 0x01, 0xC0, 0x7C, 0x04, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x01, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE2, 0x00, 0x1F,
  0x0F, 0x01, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7B, 0x80, 0x03, 0xDE, 0x00, 0x0F,
  0x78, 0x00, 0x79, 0xE0, 0x03, 0xC7, 0x00, 0x1E, 0x3C, 0x00, 0x70, 0xF0,
  0x03, 0xC3, 0xC0, 0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x03, 0x81, 0xE0, 0x1E,
  0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0x70, 0x3C, 0x03, 0xC0, 0xF0, 0x0F,
  0x07, 0x80, 0x3C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0xC0,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x20, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC2, 0x00, 0x3E, 0x0E, 0x03, 0xF8, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFE, 0x70, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x3F, 0x00, 0xF7, 0xFE, 0x07,
  0x7F, 0xF8, 0x7F, 0x87, 0xC3, 0xF0, 0x1F, 0x1F, 0x00, 0x78, 0xF8, 0x03,
  0xC7, 0x80, 0x1E, 0x7C, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF0,
  0x01, 0xE7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x87, 0x80, 0x78,
  0x3C, 0x07, 0xC1, 0xF8, 0x7C, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7E, 0x7E, 0x03, 0xE0, 0x7C, 0x0F, 0x00,
  0xF0, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0,
  0x78, 0x07, 0x81, 0xE0, 0x1E, 0x03, 0xC0, 0xF0, 0x0F, 0x8F, 0x80, 0x1F,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0xFC, 0xF8,
  0x07, 0xC1, 0xF0, 0x3E, 0x03, 0xC0, 0xF0, 0x0F, 0x87, 0x80, 0x1E, 0x1E,
  0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00,
  0x78, 0xF8, 0x03, 0xE1, 0xE0, 0x0F, 0x07, 0xE0, 0xFC, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFE, 0x00,
  0x7F, 0xF8, 0x07, 0xF7, 0xE0, 0x7C, 0x0F, 0x03, 0xC0, 0x3C, 0x3C, 0x01,
  0xE1, 0xE0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C,
  0x00, 0xF1, 0xC0, 0x07, 0x8E, 0x00, 0x3C, 0x78, 0x03, 0xE3, 0xC0, 0x1F,
  0x1E, 0x01, 0xF8, 0xF8, 0x3F, 0x83, 0xFF, 0xFC, 0x1F, 0xFD, 0xE0, 0x3F,
  0x8F, 0x00, 0x20, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0x03, 0x03, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x07,
  0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x10, 0x00, 0x00, 0x60, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x03,
  0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07,
  0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x00,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xC0,
  0x00, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x7F, 0xFE,
  0x3F, 0x7F, 0x30, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7C, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0E,
  0x07, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0x0E, 0x01, 0xFF, 0x07,
  0x1C, 0x07, 0xFF, 0x07, 0x1C, 0x0F, 0x8F, 0x07, 0x38, 0x1E, 0x0F, 0x07,
  0x38, 0x1C, 0x0E, 0x07, 0x78, 0x38, 0x0E, 0x07, 0x70, 0x78, 0x0E, 0x07,
  0x70, 0x70, 0x1E, 0x07, 0xF0, 0x70, 0x1C, 0x07, 0xF0, 0xF0, 0x1C, 0x0F,
  0xE0, 0xE0, 0x3C, 0x0E, 0xE0, 0xE0, 0x3C, 0x0E, 0xE0, 0xE0, 0x38, 0x1C,
  0xE0, 0xE0, 0x78, 0x1C, 0xE0, 0xF0, 0xF8, 0x38, 0xE0, 0xF1, 0xDC, 0x78,
  0xE0, 0x7F, 0x9F, 0xF0, 0xF0, 0x7F, 0x0F, 0xE0, 0xF0, 0x1E, 0x07, 0x80,
  0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x04, 0x00, 0x0F, 0x80, 0x1C, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xBC, 0x00, 0x07, 0xBC,
  0x00, 0x07, 0x9C, 0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x1C, 0x00, 0x1E, 0x1C,
  0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x1C, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x1E,
  0x00, 0x78, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x1E, 0x01, 0xF0, 0x1E,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xC0, 0x1E,
  0x07, 0x80, 0x1E, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x0F, 0x1F, 0x00, 0x0F,
  0x1E, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x7C, 0x00, 0x0F,
  0x78, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xC0, 0x3E, 0x03, 0xC0, 0x1F,
  0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x0F, 0x07, 0x80, 0x0F,
  0x07, 0x80, 0x1F, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x3E, 0x07, 0x80, 0x7C,
  0x0F, 0x01, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x1F, 0x03, 0xF0, 0x1E, 0x00, 0xF8, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x7C,
  0x1E, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x7C,
  0x3C, 0x00, 0x78, 0x3C, 0x00, 0xF8, 0x78, 0x00, 0xF8, 0x78, 0x03, 0xF0,
  0x78, 0x3F, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFE,
  0x03, 0xF0, 0x04, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x03, 0x80, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xE0, 0x7F, 0x00, 0xF0,
  0x07, 0xC0, 0x3C, 0x00, 0xF8, 0x0F, 0x00, 0x3E, 0x03, 0xC0, 0x07, 0x81,
  0xE0, 0x01, 0xE0, 0x78, 0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x07, 0x80, 0x07,
  0xC1, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x1F, 0x0F, 0x00,
  0x07, 0x83, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3E, 0x1E,
  0x00, 0x0F, 0x87, 0x80, 0x03, 0xC1, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0x78,
  0x3C, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x07, 0xC0, 0xF0, 0x03,
  0xE0, 0x78, 0x03, 0xF0, 0x1E, 0x01, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x03, 0xF8, 0x03, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0x3C, 0x00, 0xFF, 0x8F,
  0x00, 0x7F, 0xE3, 0xC0, 0x1F, 0xF8, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x0F,
  0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00,
  0x0F, 0x0F, 0x80, 0x07, 0x83, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x78, 0x1F,
  0x80, 0x1E, 0x03, 0xF8, 0x1F, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x03, 0xE0, 0x01, 0xE0, 0x3C, 0x00,
  0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0,
  0x78, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x07, 0x80,
  0x07, 0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x1E,
  0x03, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x3C,
  0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x03,
  0xC0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0x78, 0x00, 0x78, 0x0F,
  0x00, 0x07, 0x80, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x3C, 0x00, 0xF8, 0x07, 0x80,
  0x3E, 0x00, 0xF0, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x07, 0x80, 0x78, 0x00,
  0xF0, 0x1E, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xC1, 0xF0, 0x00, 0xF0, 0x7C,
  0x00, 0x1E, 0x1F, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x79, 0xF0, 0x00, 0x0F,
  0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0x78, 0x00, 0x0F, 0xCF, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0x78, 0x00,
  0x3C, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x01,
  0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03,
  0xC0, 0x0F, 0x00, 0x78, 0x01, 0xF0, 0x1E, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x1F,
  0x80, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x01, 0xFE, 0x03, 0xF8, 0x00,
  0x3D, 0xC0, 0x3B, 0xC0, 0x03, 0xFC, 0x03, 0xBC, 0x00, 0x7B, 0xC0, 0x7B,
  0xC0, 0x07, 0xBC, 0x07, 0xBC, 0x00, 0xF3, 0xC0, 0x7B, 0xC0, 0x0F, 0x78,
  0x07, 0x9C, 0x01, 0xE7, 0x80, 0xF1, 0xC0, 0x1E, 0x78, 0x0F, 0x1C, 0x03,
  0xC7, 0x80, 0xF1, 0xC0, 0x3C, 0xF8, 0x0F, 0x1C, 0x07, 0x8F, 0x00, 0xF1,
  0xC0, 0x78, 0xF0, 0x1E, 0x1E, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0xF0, 0xF0,
  0x1E, 0x1E, 0x1E, 0x1E, 0x01, 0xE1, 0xE1, 0xC1, 0xE0, 0x1C, 0x1E, 0x3C,
  0x1E, 0x03, 0xC0, 0xE3, 0x81, 0xE0, 0x3C, 0x0E, 0x78, 0x1E, 0x03, 0xC0,
  0xE7, 0x03, 0xC0, 0x3C, 0x0E, 0xF0, 0x3C, 0x03, 0x80, 0xEE, 0x03, 0xC0,
  0x78, 0x0F, 0xE0, 0x3C, 0x07, 0x80, 0xFC, 0x03, 0xC0, 0x78, 0x0F, 0xC0,
  0x78, 0x07, 0x80, 0xF8, 0x07, 0x80, 0xF0, 0x0F, 0x80, 0x78, 0x0F, 0x00,
  0xF0, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x38, 0x0F, 0x80, 0x03, 0xC0, 0x7C,
  0x00, 0x1E, 0x03, 0xF0, 0x00, 0xF0, 0x3F, 0x80, 0x07, 0x81, 0xFC, 0x00,
  0x78, 0x0F, 0xF0, 0x03, 0xC0, 0x77, 0x80, 0x1E, 0x03, 0xBC, 0x00, 0xF0,
  0x3C, 0xE0, 0x07, 0x81, 0xE7, 0x80, 0x78, 0x0F, 0x3C, 0x03, 0xC0, 0x79,
  0xE0, 0x1E, 0x07, 0x87, 0x80, 0xF0, 0x3C, 0x3C, 0x07, 0x01, 0xE1, 0xE0,
  0x78, 0x0F, 0x07, 0x83, 0xC0, 0x78, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0xF0,
  0x3C, 0x07, 0x0F, 0x01, 0xE0, 0x3C, 0x78, 0x0F, 0x01, 0xE3, 0xC0, 0x70,
  0x0F, 0x1E, 0x07, 0x80, 0x3C, 0xF0, 0x3C, 0x01, 0xE7, 0x01, 0xE0, 0x0F,
  0x78, 0x0F, 0x00, 0x3B, 0xC0, 0x70, 0x01, 0xFE, 0x07, 0x80, 0x0F, 0xE0,
  0x3C, 0x00, 0x3F, 0x01, 0xE0, 0x01, 0xF8, 0x0F, 0x00, 0x0F, 0xC0, 0xF0,
  0x00, 0x7E, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xF0, 0x1F, 0x01,
  0xF0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3C, 0x00, 0x1E, 0x1F, 0x00, 0x07,
  0xC7, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x7C, 0x00,
  0x03, 0xDE, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E,
  0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x7C, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xC3, 0xE0,
  0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x7E, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3E, 0x0F,
  0xC0, 0x78, 0x07, 0xC0, 0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x03, 0xC0, 0x1E,
  0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x03, 0xE0,
  0xF0, 0x07, 0x83, 0xC0, 0x1F, 0x07, 0x80, 0x7C, 0x0F, 0x01, 0xF8, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3C,
  0x00, 0x1E, 0x1F, 0x00, 0x07, 0xC7, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x3C,
  0xF0, 0x00, 0x0F, 0x7C, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x7C, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x0F,
  0x8F, 0x80, 0x03, 0xC3, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x1F, 0x00,
  0x7C, 0x03, 0xF0, 0x7E, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x07, 0xC0, 0xF0,
  0x07, 0x81, 0xE0, 0x0F, 0x03, 0xC0, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00,
  0x78, 0x3C, 0x00, 0xF0, 0x78, 0x03, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x1F,
  0x07, 0x80, 0x7C, 0x0F, 0x0F, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00,
  0xFF, 0xF8, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x1E,
  0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0,
  0x1E, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x7C, 0x1E, 0x00, 0x78, 0x3C, 0x00,
  0xF0, 0x78, 0x01, 0xF1, 0xE0, 0x03, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3E, 0x01, 0x80, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x18, 0x01, 0xF8, 0x3E, 0x0F, 0xE0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00,
  0x3C, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0,
  0x00, 0x78, 0x7C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1,
  0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07,
  0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x1E, 0x00,
  0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x3E,
  0x00, 0x0F, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78,
  0x3C, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF8, 0x01,
  0xE0, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x7C, 0x78, 0x00, 0x78,
  0x78, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x78, 0x01, 0xE0,
  0x78, 0x03, 0xE0, 0x78, 0x03, 0xC0, 0x78, 0x07, 0xC0, 0x78, 0x07, 0x80,
  0x78, 0x0F, 0x80, 0x78, 0x0F, 0x00, 0x78, 0x1F, 0x00, 0x78, 0x1E, 0x00,
  0x78, 0x1E, 0x00, 0x38, 0x3C, 0x00, 0x38, 0x3C, 0x00, 0x3C, 0x78, 0x00,
  0x3C, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3D, 0xE0, 0x00,
  0x3D, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0x00, 0x1E, 0xF0, 0x01, 0xF0,
  0x01, 0xEF, 0x00, 0x3F, 0x00, 0x3C, 0xF0, 0x03, 0xF0, 0x03, 0xCF, 0x00,
  0x7F, 0x00, 0x7C, 0xF0, 0x07, 0xF0, 0x07, 0x8F, 0x00, 0x7F, 0x00, 0xF8,
  0xF0, 0x0F, 0xF0, 0x0F, 0x0F, 0x00, 0xEF, 0x00, 0xF0, 0xF0, 0x1E, 0xF0,
  0x1E, 0x0F, 0x01, 0xCF, 0x01, 0xE0, 0xF0, 0x3C, 0xF0, 0x3C, 0x0F, 0x03,
  0xC7, 0x03, 0xC0, 0xF0, 0x38, 0x70, 0x3C, 0x0F, 0x07, 0x87, 0x07, 0x80,
  0xF0, 0x70, 0x70, 0x78, 0x0F, 0x0F, 0x07, 0x0F, 0x00, 0xF0, 0xE0, 0x70,
  0xF0, 0x0F, 0x1E, 0x07, 0x1E, 0x00, 0xF1, 0xE0, 0x71, 0xE0, 0x0F, 0x3C,
  0x07, 0x1E, 0x00, 0xF3, 0xC0, 0x73, 0xC0, 0x0F, 0x38, 0x07, 0x3C, 0x00,
  0xF7, 0x80, 0x77, 0x80, 0x0F, 0x70, 0x07, 0x78, 0x00, 0xFF, 0x00, 0x77,
  0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0xF8, 0x07, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x07, 0xC0,
  0x07, 0x80, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x9F,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xDC,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x1E, 0x3C, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0xF8, 0x07, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0x3C, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xE7, 0x80, 0x0F, 0x1E, 0x00, 0x7C,
  0x78, 0x01, 0xE1, 0xE0, 0x0F, 0x07, 0x80, 0x7C, 0x0F, 0x01, 0xE0, 0x3C,
  0x0F, 0x80, 0xF0, 0x3C, 0x03, 0xC1, 0xE0, 0x0F, 0x0F, 0x80, 0x1C, 0x3C,
  0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0xBC, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xF0, 0xF0, 0xF0, 0xF0, 0x70,
  0x70, 0x70, 0x78, 0x78, 0x78, 0x78, 0x78, 0x38, 0x38, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x1C, 0x1C, 0x1C, 0x1E, 0x1E, 0x1E, 0x1E, 0x0E, 0x0E, 0x0E,
  0x0F, 0x0F, 0x0F, 0x0F, 0x07, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xB8, 0x00, 0x1E, 0xF0, 0x00, 0x71, 0xC0, 0x03, 0xC7, 0x80, 0x0E, 0x1E,
  0x00, 0x78, 0x38, 0x01, 0xC0, 0xF0, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x81,
  0xE0, 0x0E, 0x07, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xE0, 0x01, 0xC7, 0x80,
  0x07, 0xBC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF1,
  0xF1, 0xE1, 0xC3, 0xC3, 0x83, 0x83, 0x00, 0x38, 0x00, 0x07, 0xF8, 0xF0,
  0x3F, 0xF3, 0x81, 0xFF, 0xEE, 0x0F, 0x83, 0xF8, 0x7C, 0x07, 0xE1, 0xE0,
  0x1F, 0x0F, 0x80, 0x3C, 0x3C, 0x00, 0xF1, 0xF0, 0x03, 0xC7, 0x80, 0x0F,
  0x1E, 0x00, 0x78, 0x78, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C,
  0x00, 0xF8, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x7C, 0x3C, 0x03,
  0xF0, 0xF0, 0x0F, 0x83, 0xC0, 0x7E, 0x0F, 0x83, 0xB8, 0x1F, 0xFD, 0xE0,
  0x3F, 0xE7, 0x80, 0x7F, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x30,
  0x01, 0xE3, 0xF8, 0x07, 0xBF, 0xF0, 0x1D, 0xFF, 0xE0, 0xF7, 0x0F, 0x83,
  0xF8, 0x1E, 0x0F, 0xC0, 0x7C, 0x3E, 0x00, 0xF1, 0xF0, 0x03, 0xC7, 0xC0,
  0x0F, 0x1E, 0x00, 0x7C, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x8F, 0x00, 0x1E,
  0x3C, 0x00, 0x78, 0xF0, 0x03, 0xE3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x7C,
  0x01, 0xF1, 0xF0, 0x07, 0x87, 0xC0, 0x3E, 0x1F, 0x81, 0xF0, 0x7E, 0x0F,
  0x83, 0xDF, 0xFE, 0x0E, 0x3F, 0xF0, 0x38, 0x7F, 0x00, 0x00, 0x1C, 0x00,
  0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0x80, 0x87, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x38, 0x3C, 0x01, 0xFE, 0x38, 0x03, 0xFF, 0x78, 0x07,
  0xFF, 0xF8, 0x0F, 0x83, 0xF8, 0x1F, 0x01, 0xF8, 0x1E, 0x01, 0xF0, 0x3E,
  0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x7C, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x78,
  0x01, 0xE0, 0xF8, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0,
  0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x07, 0xC0, 0xF0, 0x07, 0xC0, 0xF0,
  0x0F, 0xC0, 0xF0, 0x0F, 0x80, 0xF8, 0x1F, 0x80, 0xF8, 0x7F, 0x80, 0x7F,
  0xF7, 0x80, 0x3F, 0xE7, 0x80, 0x1F, 0x87, 0x00, 0x00, 0x18, 0x00, 0x7F,
  0xC0, 0x3F, 0xF8, 0x1F, 0xFF, 0x0F, 0x83, 0xC7, 0xC0, 0xF1, 0xE0, 0x3C,
  0xF0, 0x0F, 0x3C, 0x03, 0xDE, 0x01, 0xE7, 0x80, 0xF9, 0xE3, 0xFC, 0xFF,
  0xFE, 0x3F, 0xFE, 0x0F, 0xFC, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x87, 0xC0, 0xE1,
  0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xF6, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x9F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0x8F, 0x00, 0xFF,
  0xCE, 0x01, 0xFF, 0xEE, 0x03, 0xE0, 0xFE, 0x07, 0xC0, 0x7E, 0x07, 0x80,
  0x7C, 0x0F, 0x80, 0x3C, 0x0F, 0x00, 0x3C, 0x1F, 0x00, 0x3C, 0x1E, 0x00,
  0x7C, 0x1E, 0x00, 0x78, 0x3E, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00,
  0x78, 0x3C, 0x00, 0xF8, 0x3C, 0x00, 0xF0, 0x3C, 0x01, 0xF0, 0x3C, 0x01,
  0xF0, 0x3C, 0x03, 0xF0, 0x3C, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x3E, 0x1F,
  0xE0, 0x1F, 0xFD, 0xE0, 0x0F, 0xF9, 0xE0, 0x07, 0xF3, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x80, 0x1F, 0x00, 0xF0, 0x3F, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0xE0,
  0x0F, 0x1F, 0xC0, 0x7B, 0xFF, 0x03, 0xBF, 0xFC, 0x3F, 0xC3, 0xE1, 0xF8,
  0x0F, 0x0F, 0x80, 0x78, 0x7C, 0x03, 0xC3, 0xC0, 0x1E, 0x3E, 0x00, 0xF1,
  0xE0, 0x07, 0x8F, 0x00, 0x78, 0x78, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00,
  0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x78, 0x78, 0x03, 0xC7, 0x80, 0x1E, 0x3C,
  0x00, 0xF1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC7, 0x80, 0x1E,
  0x3C, 0x00, 0xF1, 0xE0, 0x0F, 0x00, 0x00, 0x40, 0x3C, 0x0F, 0x81, 0xF0,
  0x3C, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x78,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x08, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x41, 0xE0, 0x3E,
  0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x03, 0xC1, 0xE0, 0x0F,
  0x0F, 0x00, 0x3C, 0x7C, 0x01, 0xE3, 0xE0, 0x07, 0x9F, 0x00, 0x1E, 0xF8,
  0x00, 0x7B, 0xC0, 0x01, 0xDF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0x78, 0x00,
  0xF9, 0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x78, 0x3E, 0x01, 0xE0,
  0x78, 0x07, 0x81, 0xE0, 0x1E, 0x07, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x3C,
  0x0F, 0x00, 0xF8, 0x3C, 0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x03, 0x00, 0x18,
  0x01, 0xC7, 0xF8, 0x3F, 0xC0, 0x73, 0xFF, 0x1F, 0xF8, 0x1D, 0xFF, 0xCF,
  0xFE, 0x0F, 0xF0, 0xF7, 0x07, 0x83, 0xF0, 0x3F, 0x81, 0xE0, 0xF8, 0x07,
  0xC0, 0x7C, 0x3E, 0x01, 0xF0, 0x1E, 0x0F, 0x00, 0xF8, 0x07, 0x87, 0xC0,
  0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC0, 0x1E, 0x1E,
  0x00, 0xF0, 0x0F, 0x0F, 0x00, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x00, 0xF0,
  0xF0, 0x07, 0x80, 0x3C, 0x3C, 0x01, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x07,
  0x87, 0x80, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC0,
  0x1E, 0x1E, 0x00, 0xF0, 0x07, 0x87, 0x80, 0x78, 0x03, 0xC3, 0xC0, 0x1E,
  0x00, 0xF0, 0xF0, 0x07, 0x80, 0x3C, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x00,
  0x83, 0x80, 0x38, 0xFF, 0x01, 0xCF, 0xFC, 0x1E, 0xFF, 0xF0, 0xFF, 0x0F,
  0x87, 0xF0, 0x3C, 0x3F, 0x01, 0xE1, 0xF0, 0x0F, 0x1F, 0x00, 0x78, 0xF8,
  0x03, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x1F, 0x00, 0x78,
  0xF0, 0x03, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xE3, 0xE0, 0x0F, 0x1E, 0x00,
  0x78, 0xF0, 0x03, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xE3, 0xE0, 0x0F, 0x1E,
  0x00, 0x78, 0xF0, 0x07, 0xC7, 0x80, 0x3C, 0x00, 0x00, 0x10, 0x00, 0x1F,
  0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0x83, 0xE1, 0xF0, 0x1E, 0x1E,
  0x01, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xF7,
  0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xEF, 0x00, 0x1E,
  0xF0, 0x01, 0xEF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x7C, 0xF0, 0x07,
  0x8F, 0x80, 0xF8, 0x7C, 0x1F, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x70, 0xFE, 0x00, 0x39, 0xFF, 0x80, 0x1D,
  0xFF, 0xE0, 0x1E, 0xE1, 0xF0, 0x0F, 0xE0, 0x78, 0x07, 0xE0, 0x3E, 0x03,
  0xE0, 0x0F, 0x01, 0xE0, 0x07, 0x81, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xE0,
  0x78, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x1C, 0x00, 0x78, 0x1E, 0x00, 0x3C,
  0x0F, 0x00, 0x3E, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x0F, 0x03, 0xE0, 0x0F,
  0x81, 0xF0, 0x07, 0x80, 0xF8, 0x07, 0xC0, 0x7E, 0x07, 0xC0, 0x3B, 0x07,
  0xC0, 0x3D, 0xFF, 0xE0, 0x1E, 0x7F, 0xC0, 0x0F, 0x1F, 0xC0, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x07, 0xF8, 0xF0, 0x3F, 0xF3, 0x81, 0xFF, 0xEE, 0x0F, 0x83, 0xF8, 0x7C,
  0x07, 0xE1, 0xE0, 0x1F, 0x0F, 0x80, 0x3C, 0x3C, 0x00, 0xF1, 0xF0, 0x03,
  0xC7, 0x80, 0x1F, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE3, 0xC0, 0x07, 0x8F,
  0x00, 0x1E, 0x3C, 0x00, 0xF8, 0xF0, 0x03, 0xC3, 0xC0, 0x1F, 0x0F, 0x00,
  0x7C, 0x3C, 0x03, 0xF0, 0xF0, 0x0F, 0x83, 0xE0, 0x7E, 0x0F, 0x87, 0xF8,
  0x1F, 0xFD, 0xE0, 0x3F, 0xE7, 0x80, 0x7F, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0x83, 0x8F, 0xC1, 0xCF, 0xE0, 0xEF, 0xF0,
  0xF7, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0x01, 0x87, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x20, 0x0F,
  0x8E, 0x07, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xF8, 0x00, 0x01, 0x80,
  0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0xF8, 0x3F, 0xC0, 0xFE,
  0x00, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1,
  0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00,
  0xF1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C,
  0x00, 0xF1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0xF0, 0x07, 0xC7, 0x80, 0x3E,
  0x3C, 0x03, 0xE1, 0xE0, 0x1F, 0x0F, 0x01, 0xF8, 0x7C, 0x3F, 0xC1, 0xFF,
  0xDE, 0x0F, 0xFC, 0xE0, 0x3F, 0x87, 0x00, 0xF0, 0x01, 0xF7, 0x00, 0x1E,
  0x78, 0x03, 0xE7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x78, 0x78, 0x07,
  0x87, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83,
  0xC0, 0x78, 0x3C, 0x03, 0x87, 0x80, 0x38, 0x78, 0x03, 0x8F, 0x00, 0x38,
  0xF0, 0x03, 0x9E, 0x00, 0x39, 0xE0, 0x03, 0xBC, 0x00, 0x3B, 0xC0, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x0F,
  0x80, 0x7F, 0xC0, 0x3E, 0x01, 0xEF, 0x01, 0xF8, 0x07, 0xBC, 0x07, 0xE0,
  0x3C, 0xF0, 0x3F, 0x80, 0xF3, 0xC0, 0xEE, 0x07, 0x8F, 0x03, 0xB8, 0x1E,
  0x3C, 0x1C, 0xE0, 0xF0, 0xF0, 0x73, 0x83, 0xC3, 0xC3, 0xCE, 0x0F, 0x0F,
  0x0E, 0x38, 0x78, 0x3C, 0x78, 0xE1, 0xE0, 0xF1, 0xC3, 0x8F, 0x03, 0xC7,
  0x0E, 0x3C, 0x0F, 0x38, 0x38, 0xE0, 0x3C, 0xE0, 0xE7, 0x80, 0xF7, 0x83,
  0x9E, 0x03, 0xDC, 0x0E, 0xF0, 0x0F, 0xF0, 0x3B, 0xC0, 0x3F, 0x80, 0xEE,
  0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00,
  0x3F, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x1F, 0x03,
  0xC0, 0x3C, 0x01, 0xE0, 0x7C, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0xF0, 0x00,
  0xF1, 0xE0, 0x00, 0xF3, 0xE0, 0x00, 0xF3, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xEE, 0x00, 0x01, 0xEF, 0x00, 0x03,
  0xCF, 0x00, 0x07, 0x87, 0x80, 0x0F, 0x87, 0x80, 0x0F, 0x07, 0x80, 0x1E,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x03, 0xC0, 0xF8, 0x01, 0xE0, 0x01,
  0xE0, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x07, 0x80,
  0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x38, 0x1E, 0x00, 0x0E, 0x07, 0x80, 0x03,
  0x83, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x1E, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x78,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x1F, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xC0, 0x03,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x3F, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xF0,
  0x00, 0xF8, 0x00, 0xFC, 0x01, 0xFE, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x17,
  0xFC, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xFC,
  0x80, 0x00, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Italic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 12, 35, 12, 1, -34 },
  { 54, 14, 13, 17, 5, -34 },
  { 77, 26, 34, 27, 1, -34 },
  { 188, 22, 39, 23, 1, -36 },
  { 296, 29, 34, 34, 3, -34 },
  { 420, 25, 34, 27, 1, -34 },
  { 527, 6, 13, 10, 5, -34 },
  { 537, 15, 41, 13, 1, -34 },
  { 614, 15, 41, 13, -4, -34 },
  { 691, 19, 20, 23, 5, -36 },
  { 739, 20, 23, 24, 3, -28 },
  { 797, 9, 11, 11, -2, -5 },
  { 810, 11, 3, 14, 1, -14 },
  { 815, 5, 7, 11, 1, -6 },
  { 820, 22, 34, 16, -2, -34 },
  { 914, 21, 34, 23, 2, -34 },
  { 1004, 13, 34, 23, 6, -34 },
  { 1060, 22, 34, 23, 0, -34 },
  { 1154, 22, 34, 23, 0, -34 },
  { 1248, 22, 34, 23, 0, -34 },
  { 1342, 22, 34, 23, 1, -34 },
  { 1436, 21, 34, 23, 2, -34 },
  { 1526, 21, 34, 23, 3, -34 },
  { 1616, 22, 34, 23, 1, -34 },
  { 1710, 21, 34, 23, 1, -34 },
  { 1800, 9, 27, 11, 1, -26 },
  { 1831, 12, 32, 11, -2, -26 },
  { 1879, 20, 22, 24, 3, -28 },
  { 1934, 20, 13, 24, 3, -23 },
  { 1967, 20, 22, 24, 3, -28 },
  { 2022, 16, 35, 18, 3, -34 },
  { 2092, 32, 38, 35, 2, -34 },
  { 2244, 24, 34, 24, -3, -34 },
  { 2346, 24, 34, 25, 1, -34 },
  { 2448, 24, 34, 24, 3, -34 },
  { 2550, 26, 34, 28, 1, -34 },
  { 2661, 23, 34, 22, 1, -34 },
  { 2759, 23, 34, 20, 1, -34 },
  { 2857, 26, 34, 29, 3, -34 },
  { 2968, 28, 34, 29, 1, -34 },
  { 3087, 18, 34, 14, -1, -34 },
  { 3164, 19, 43, 12, -7, -34 },
  { 3267, 27, 34, 24, 1, -34 },
  { 3382, 16, 34, 20, 1, -34 },
  { 3450, 36, 34, 36, 1, -34 },
  { 3603, 29, 34, 30, 1, -34 },
  { 3727, 26, 34, 30, 3, -34 },
  { 3838, 23, 34, 24, 1, -34 },
  { 3936, 26, 42, 30, 3, -34 },
  { 4073, 23, 34, 24, 1, -34 },
  { 4171, 23, 34, 22, 0, -34 },
  { 4269, 21, 34, 21, 4, -34 },
  { 4359, 26, 34, 28, 3, -34 },
  { 4470, 24, 34, 23, 4, -34 },
  { 4572, 36, 34, 37, 5, -34 },
  { 4725, 29, 34, 22, -3, -34 },
  { 4849, 22, 34, 21, 4, -34 },
  { 4943, 25, 34, 22, -1, -34 },
  { 5050, 18, 41, 13, -1, -34 },
  { 5143, 8, 34, 16, 5, -34 },
  { 5177, 17, 41, 13, -3, -34 },
  { 5265, 22, 20, 24, 1, -34 },
  { 5320, 17, 3, 17, -4, 4 },
  { 5327, 7, 8, 13, 7, -36 },
  { 5334, 22, 26, 24, 2, -26 },
  { 5406, 22, 36, 24, 1, -36 },
  { 5505, 18, 26, 19, 2, -26 },
  { 5564, 24, 36, 24, 2, -36 },
  { 5672, 18, 26, 21, 2, -26 },
  { 5731, 24, 47, 13, -5, -36 },
  { 5872, 24, 37, 25, 0, -26 },
  { 5983, 21, 36, 24, 1, -36 },
  { 6078, 11, 35, 11, 1, -35 },
  { 6127, 18, 46, 11, -6, -35 },
  { 6231, 22, 36, 21, 1, -36 },
  { 6330, 11, 36, 11, 1, -36 },
  { 6380, 34, 26, 37, 1, -26 },
  { 6491, 21, 26, 24, 1, -26 },
  { 6560, 20, 26, 24, 2, -26 },
  { 6625, 25, 37, 24, -2, -26 },
  { 6741, 22, 37, 24, 2, -26 },
  { 6843, 17, 26, 17, 1, -26 },
  { 6899, 18, 26, 18, 0, -26 },
  { 6958, 13, 31, 14, 2, -31 },
  { 7009, 21, 25, 24, 2, -25 },
  { 7075, 20, 25, 20, 2, -25 },
  { 7138, 30, 25, 31, 3, -25 },
  { 7232, 24, 25, 20, -2, -25 },
  { 7307, 26, 36, 20, -4, -25 },
  { 7424, 19, 25, 18, -1, -25 },
  { 7484, 18, 41, 16, 1, -34 },
  { 7577, 4, 47, 23, 10, -36 },
  { 7601, 17, 41, 16, -2, -34 },
  { 7689, 20, 7, 24, 3, -20 },
};

const GFXfont NotoSans_SemiCondensed_Italic47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic47pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC47PT7B_H_
