#ifndef _NOTOSANS_SEMICONDENSED_ITALIC71PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0x1F, 0xC1,
  0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0xFE, 0x3F, 0x07, 0xF1, 0xF8, 0x3F, 0x1F,
  0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x3F,
  0x0F, 0x81, 0xF8, 0xFC, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0,
  0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x0F, 0x83, 0xC0, 0x7C, 0x3E, 0x03, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x07, 0x80,
  0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x3C, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0xF0,
  0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xF0, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x03,
  0xC0, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x1E,
  0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0x3C, 0x7E, 0x01, 0xFC, 0x3C, 0x0C, 0x01, 0xF8, 0x3C, 0x04, 0x03,
  0xF0, 0x78, 0x00, 0x03, 0xF0, 0x78, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x03,
  0xE0, 0xF0, 0x00, 0x03, 0xF0, 0xF0, 0x00, 0x03, 0xF8, 0xF0, 0x00, 0x03,
  0xFD, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xDF, 0xE0, 0x00, 0x07, 0x8F, 0xE0, 0x00, 0x07, 0x87, 0xE0, 0x00,
  0x07, 0x83, 0xE0, 0x00, 0x07, 0x83, 0xF0, 0x00, 0x0F, 0x03, 0xF0, 0x00,
  0x0F, 0x03, 0xF0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x0F, 0x07, 0xE0, 0x00,
  0x0F, 0x07, 0xE0, 0x80, 0x1E, 0x0F, 0xE0, 0xC0, 0x1E, 0x1F, 0xC0, 0xF8,
  0x1E, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0x80, 0x1F, 0xFC, 0x00, 0x01, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xE0, 0x0F, 0xC3, 0xF0, 0x00, 0x7C, 0x00, 0xF8,
  0x1F, 0x00, 0x07, 0xC0, 0x1F, 0x81, 0xF0, 0x00, 0xF8, 0x01, 0xF0, 0x1F,
  0x00, 0x1F, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x00,
  0x3E, 0x00, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x00,
  0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x00, 0xF8,
  0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x03,
  0xE0, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x1F, 0x80, 0x00, 0xF8, 0x07, 0xC1,
  0xF0, 0x7F, 0x0F, 0x80, 0x7C, 0x3E, 0x1F, 0xF8, 0xF8, 0x0F, 0x87, 0xE3,
  0xFF, 0xCF, 0x80, 0xF8, 0x7C, 0x7F, 0xFE, 0xF8, 0x1F, 0x0F, 0x8F, 0xE7,
  0xEF, 0x81, 0xF1, 0xF8, 0xF8, 0x3F, 0xFC, 0x7E, 0x1F, 0x1F, 0x01, 0xF7,
  0xFF, 0xC3, 0xE1, 0xF0, 0x1F, 0x7F, 0xFC, 0x7E, 0x3E, 0x01, 0xF3, 0xFF,
  0x87, 0xC3, 0xE0, 0x1F, 0x1F, 0xE0, 0xF8, 0x7E, 0x01, 0xF0, 0x00, 0x1F,
  0x87, 0xC0, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x00, 0x3E, 0x07,
  0xC0, 0x1F, 0x00, 0x07, 0xE0, 0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80,
  0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x3E,
  0x00, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x00,
  0x7E, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0xF0, 0x0F, 0x80, 0x1F, 0x80, 0x0F, 0x00, 0xF8, 0x01, 0xF0, 0x00,
  0xF8, 0x1F, 0x00, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x07, 0xE0, 0x00, 0xFC,
  0x3E, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x7F, 0xFC,
  0x01, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x3F,
  0xC0, 0x00, 0x00, 0xFC, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xEF, 0xE0, 0x03, 0xF0, 0x7F, 0x8F,
  0xE0, 0x0F, 0xC1, 0xFC, 0x1F, 0xC0, 0x1F, 0x87, 0xF0, 0x1F, 0xC0, 0x7E,
  0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x3F, 0x80, 0x3F, 0x83, 0xF0, 0x7E, 0x00,
  0x3F, 0x07, 0xE1, 0xF8, 0x00, 0x7F, 0x1F, 0x83, 0xF0, 0x00, 0x7F, 0x3F,
  0x07, 0xE0, 0x00, 0xFE, 0xFC, 0x1F, 0x80, 0x00, 0xFF, 0xF0, 0x3F, 0x00,
  0x00, 0xFF, 0xE0, 0x7E, 0x00, 0x01, 0xFF, 0x80, 0xFC, 0x00, 0x01, 0xFE,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x03, 0xF0,
  0x00, 0x3F, 0xF0, 0x07, 0xF0, 0x01, 0xFF, 0xF0, 0x0F, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFC, 0xFF, 0xEF, 0xE0, 0x1F, 0xFF, 0xFF, 0x8F, 0xE0, 0x1F,
  0xFF, 0xFC, 0x1F, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0x8F, 0xC7, 0xE3,
  0xF3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x1F, 0x0F, 0x8F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF0, 0x78, 0x3C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x80, 0x1F, 0x00, 0x06, 0x00, 0xF8, 0x00,
  0x7C, 0x07, 0xC0, 0x03, 0xF8, 0x3C, 0x00, 0x1F, 0xF1, 0xE0, 0x01, 0xFF,
  0xEF, 0x00, 0x31, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0xF8, 0x07, 0xFE, 0x00,
  0x00, 0x7E, 0xF0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7E, 0x1E, 0x00, 0x07,
  0xF0, 0xF8, 0x00, 0x7F, 0x07, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x78, 0x07, 0xE0, 0x01, 0x80, 0x3F, 0x00, 0x04, 0x00, 0xFC,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0,
  0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xC0, 0x7E,
  0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF8, 0x3F, 0x3F,
  0x9F, 0xFF, 0xFF, 0xF7, 0xFB, 0xFC, 0xFC, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x01,
  0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x3F,
  0x80, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x9F, 0x80, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF9,
  0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x8F,
  0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF8, 0x7E,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0xFE, 0x03, 0xF0, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0,
  0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xF7,
  0xC3, 0xFE, 0xFC, 0xFF, 0x8F, 0xC7, 0xF0, 0xFC, 0x7E, 0x0F, 0xC3, 0x81,
  0xF8, 0x10, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0xFF,
  0x80, 0x07, 0xC0, 0x07, 0xF0, 0x00, 0x70, 0x00, 0x7F, 0x00, 0x08, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x01, 0xF0, 0x01, 0xFC, 0x00,
  0x60, 0x00, 0x7F, 0x00, 0x20, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x08, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x10, 0x00, 0x01, 0xFC, 0x0C, 0x00, 0x03, 0xFC, 0x07,
  0xC0, 0x03, 0xFE, 0x03, 0xFF, 0xBF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x3E, 0x3E,
  0x00, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07,
  0xE0, 0x3E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x1F, 0x00,
  0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF7, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x70, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x02, 0x00, 0x00, 0x3F,
  0x80, 0xC0, 0x00, 0x3F, 0xC0, 0x3E, 0x00, 0x3F, 0xF0, 0x0F, 0xFD, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xF8, 0x02, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x1F, 0x87, 0xFF, 0x00, 0x1F,
  0x9F, 0xFF, 0x80, 0x3F, 0x3F, 0xFF, 0xC0, 0x3F, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFC, 0x1F, 0xF0, 0x3F, 0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0x03, 0xF0, 0x7F,
  0xC0, 0x03, 0xF0, 0x7F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x01, 0xF8, 0x7F,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x7C,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x01,
  0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0xFE, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xC7, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFC, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x3F, 0x0F, 0x80, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFE, 0x1F, 0x80, 0x00,
  0xFE, 0x1F, 0xC0, 0x01, 0xFE, 0x0F, 0xC0, 0x01, 0xFE, 0x0F, 0xC0, 0x03,
  0xFE, 0x0F, 0xE0, 0x07, 0xFC, 0x07, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xFE,
  0xFC, 0x03, 0xFF, 0xFC, 0xFC, 0x01, 0xFF, 0xF9, 0xF8, 0x00, 0xFF, 0xF1,
  0xF8, 0x00, 0x3F, 0xC1, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x80, 0x07, 0xF8,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x03, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFE, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF0, 0xFC, 0x07, 0xF8, 0x38, 0x00, 0xFE, 0x10, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xFE, 0x00, 0x7C,
  0x0F, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0x07, 0xC0, 0x07, 0xFF, 0xF8, 0x0F,
  0x87, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0xF0, 0xFC, 0x03,
  0xE3, 0xE0, 0x0F, 0xE0, 0x3E, 0x01, 0xF1, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0xF8, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0xF8, 0x07, 0xE0, 0x0F, 0x80,
  0x3E, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x3E, 0x03, 0xE0, 0x03, 0xE0,
  0x0F, 0xBE, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x9F, 0x01, 0xF0, 0x01, 0xF0,
  0x07, 0xCF, 0x80, 0xF8, 0x00, 0xF8, 0x03, 0xE7, 0xC0, 0x7C, 0x00, 0x7C,
  0x01, 0xF7, 0xC0, 0x3E, 0x00, 0x7C, 0x00, 0xFB, 0xE0, 0x3E, 0x00, 0x3E,
  0x00, 0xF9, 0xF0, 0x1F, 0x00, 0x1F, 0x00, 0x7C, 0xF8, 0x0F, 0x80, 0x1F,
  0x80, 0x3E, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x3E, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x1F, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x0F, 0x80, 0xF8, 0x07,
  0xF0, 0x1F, 0x87, 0xC0, 0x7E, 0x07, 0xFC, 0x1F, 0x83, 0xE0, 0x1F, 0x87,
  0xBE, 0x1F, 0x81, 0xF0, 0x0F, 0xFF, 0xCF, 0xFF, 0x80, 0xF8, 0x03, 0xFF,
  0xC7, 0xFF, 0x80, 0x7E, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x3F,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0xF8,
  0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x7F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFE,
  0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x7E,
  0x1F, 0xC0, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0xE0, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0x03, 0xF8, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0x00, 0x3F, 0xE0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7E, 0x00,
  0x7F, 0xC0, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x3F,
  0x80, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0x7E, 0x00, 0x0F, 0xF8, 0x07, 0xE0, 0x07, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x7E, 0x00, 0x3F, 0xE0, 0x00, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x20, 0x01, 0xFF, 0x80, 0x1E,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x07,
  0xFE, 0x00, 0x1F, 0x80, 0x07, 0xFC, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xFE,
  0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x1F,
  0xC1, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0xC1, 0xF8, 0x00,
  0x00, 0xFE, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x7E, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00,
  0x1F, 0xE0, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x03,
  0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0x80, 0x03, 0xFE, 0x00, 0x7E, 0x00, 0x3F,
  0xF0, 0x01, 0xF8, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0x0E, 0x00, 0x3F, 0xE0, 0x00, 0x04,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xF0, 0xFC,
  0x00, 0x0F, 0xFF, 0xE1, 0xF8, 0x00, 0x1F, 0xFF, 0xC3, 0xF0, 0x00, 0x3F,
  0xFF, 0x0F, 0xE0, 0x00, 0x7F, 0xFE, 0x1F, 0xC0, 0x01, 0xFF, 0xFC, 0x3F,
  0x80, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00,
  0x0F, 0xC1, 0xFC, 0x00, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x01, 0xFE, 0x00, 0x01, 0xF8, 0x01, 0xFE, 0x00, 0x03, 0xF0,
  0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x08, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x1F,
  0xE0, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00,
  0x01, 0xF8, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x03, 0xF1,
  0xFC, 0x00, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0x03, 0xF3, 0xF8, 0x00,
  0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0x07, 0xEF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0xDF,
  0x00, 0x3F, 0x7C, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFB, 0xE0, 0x00, 0x07,
  0xEF, 0xC0, 0x0F, 0xDF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x7C, 0xF8, 0x00,
  0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x3F, 0x3E,
  0x00, 0x01, 0xF9, 0xF8, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x0F,
  0xCF, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0x07, 0xE3, 0xF0,
  0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xE1,
  0xF8, 0x01, 0xF8, 0x7C, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xE0, 0x01,
  0xF0, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x87, 0xF0, 0x07, 0xE0, 0xF8,
  0x00, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8,
  0x3E, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x7E, 0x00,
  0x7C, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F,
  0x00, 0x3F, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0x81, 0xF8,
  0x0F, 0xC0, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xE0,
  0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x3F, 0x00, 0x3F, 0x00,
  0xF8, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0xC0, 0x0F,
  0x80, 0x3E, 0x3F, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF1, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0xFC,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0xF0, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x07, 0xF8, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xE0, 0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xE0,
  0x07, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xE0, 0x07,
  0xFE, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xFF,
  0x00, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xDF, 0x80,
  0x00, 0xFC, 0x00, 0xF9, 0xF8, 0x00, 0x0F, 0x80, 0x0F, 0x9F, 0x80, 0x01,
  0xF8, 0x01, 0xF8, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x01, 0xF8,
  0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0x87, 0xC0, 0x03, 0xF0, 0x01,
  0xF0, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0,
  0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xF0, 0x3F,
  0x00, 0x7E, 0x00, 0x3E, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x00,
  0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x7C,
  0x00, 0x7E, 0x00, 0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC,
  0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x00,
  0x7E, 0x1F, 0x80, 0x1F, 0x80, 0x03, 0xE1, 0xF8, 0x01, 0xF8, 0x00, 0x3F,
  0x1F, 0x80, 0x1F, 0x80, 0x03, 0xF1, 0xF0, 0x01, 0xF0, 0x00, 0x1F, 0x3F,
  0x00, 0x3F, 0x00, 0x01, 0xFB, 0xF0, 0x03, 0xF0, 0x00, 0x1F, 0xBF, 0x00,
  0x3F, 0x00, 0x01, 0xFB, 0xE0, 0x03, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x3E,
  0x00, 0x00, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0xE0, 0x07, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0xC0, 0x07, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x0F,
  0xE0, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00,
  0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x00,
  0x7E, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x7E,
  0x00, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0x00, 0xFC, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00,
  0x3F, 0xC0, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x0F, 0xC0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x1F, 0x80, 0x07, 0xF8, 0x07, 0xF0, 0x03, 0xFE, 0x00, 0xFC,
  0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x07, 0xF0,
  0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x00,
  0x7E, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x1F,
  0x80, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x00, 0x7E,
  0x7F, 0x00, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00,
  0x01, 0xF8, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x0F, 0xC0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x3F,
  0xC0, 0x1F, 0x80, 0x1F, 0xF0, 0x07, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x70, 0x03, 0xFC,
  0x00, 0x04, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x02, 0x00, 0x00, 0x7F, 0x80, 0xE0,
  0x00, 0x3F, 0xC0, 0x3F, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x0F,
  0xE7, 0xE0, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x1F, 0xC7, 0xE0, 0x00,
  0x03, 0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x07, 0xF0, 0x7E,
  0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFE,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x1F,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFB, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x3F, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xF0, 0xFC, 0x00,
  0x1F, 0x7C, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFD, 0xF0, 0x00, 0x7E, 0x0F,
  0xC0, 0x03, 0xE7, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0x9F, 0x80, 0x0F,
  0xC0, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF1, 0xF8,
  0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0x3E,
  0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x03, 0xF0,
  0x07, 0xC0, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x03, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0xFC, 0x0F, 0x80, 0xFC, 0x00, 0xFC, 0x03, 0xE0, 0x3E, 0x03,
  0xF0, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0x7C, 0x03,
  0xE0, 0x7E, 0x00, 0x1F, 0x03, 0xF0, 0x0F, 0x81, 0xF8, 0x00, 0x7C, 0x0F,
  0x80, 0x3E, 0x0F, 0xC0, 0x01, 0xF0, 0x7E, 0x00, 0xF8, 0x3F, 0x00, 0x07,
  0xC1, 0xF0, 0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0x87, 0xE0,
  0x00, 0x7C, 0x3F, 0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0xF8,
  0xFC, 0x00, 0x07, 0xC7, 0xE0, 0x03, 0xE3, 0xF0, 0x00, 0x1F, 0x1F, 0x00,
  0x0F, 0x9F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xEF, 0xC0, 0x00,
  0x1F, 0x7E, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF8,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0xBF, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x3F, 0x8F, 0xC0, 0x00,
  0x1F, 0xC7, 0xE0, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x07, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8,
  0x03, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0x3E, 0x3F, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00,
  0x1F, 0x3E, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x7C, 0x1F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00,
  0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x07,
  0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x1F, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0x81, 0xF8, 0x3F,
  0x03, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x07, 0xC0, 0x0F, 0xFF, 0x87, 0xC0, 0x0F, 0xFF, 0xE3,
  0xE0, 0x0F, 0xFF, 0xF9, 0xF0, 0x0F, 0xFC, 0xFD, 0xF8, 0x0F, 0xF0, 0x1F,
  0xFC, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xF0, 0x01, 0xFE, 0x07, 0xF0, 0x00,
  0xFF, 0x03, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x0F, 0xC1, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x03, 0xF8, 0x7F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x07, 0xF0, 0x7E, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x03, 0xF8, 0x1F,
  0x80, 0x01, 0xFC, 0x0F, 0xC0, 0x01, 0xFE, 0x07, 0xE0, 0x00, 0xFF, 0x03,
  0xF0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0xFE, 0x00, 0xFF, 0xC0,
  0x3F, 0x80, 0xFF, 0xE0, 0x1F, 0xF3, 0xFB, 0xF0, 0x07, 0xFF, 0xF9, 0xF0,
  0x03, 0xFF, 0xF8, 0xF8, 0x00, 0xFF, 0xF8, 0x7C, 0x00, 0x3F, 0xF0, 0x3E,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x07, 0x00, 0x00,
  0xFC, 0x1F, 0xF8, 0x00, 0x7E, 0x3F, 0xFE, 0x00, 0x3F, 0x3F, 0xFF, 0x80,
  0x1F, 0x3F, 0xFF, 0xC0, 0x1F, 0xBF, 0x9F, 0xF0, 0x0F, 0xFE, 0x03, 0xF8,
  0x07, 0xFE, 0x00, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0x03, 0xFE, 0x00, 0x1F,
  0x81, 0xFE, 0x00, 0x0F, 0xC0, 0xFF, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x03,
  0xF0, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0xFC, 0x1F, 0xC0, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x1F, 0xC3, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7F, 0x07, 0xE0,
  0x00, 0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0x81, 0xFE,
  0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F,
  0xE0, 0x1F, 0xE0, 0x3F, 0x7E, 0x7F, 0xE0, 0x1F, 0x3F, 0xFF, 0xE0, 0x0F,
  0x8F, 0xFF, 0xE0, 0x07, 0x83, 0xFF, 0xE0, 0x07, 0xC0, 0xFF, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0x9F,
  0x00, 0xFF, 0x00, 0x20, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x08, 0x0F, 0xF0, 0x07, 0x00, 0xFF,
  0xC7, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0E, 0x01, 0xF8, 0x00, 0x0F, 0xFC, 0x1F, 0x80,
  0x03, 0xFF, 0xE3, 0xF0, 0x00, 0x7F, 0xFF, 0x3F, 0x00, 0x0F, 0xFF, 0xFB,
  0xF0, 0x01, 0xFF, 0x9F, 0xBF, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x07, 0xF8,
  0x03, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x3F, 0x80, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x01, 0xFE,
  0x00, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0x01, 0xEF, 0xC0, 0x07,
  0xFC, 0xFE, 0xFC, 0x00, 0x7F, 0xFF, 0xCF, 0x80, 0x03, 0xFF, 0xF8, 0xF8,
  0x00, 0x1F, 0xFE, 0x0F, 0x80, 0x00, 0xFF, 0xC0, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xF1, 0xFE,
  0x03, 0xFC, 0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0xFE,
  0x00, 0x3F, 0x1F, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x07,
  0xE3, 0xF0, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0xC7, 0xF0, 0x03, 0xFC, 0x7E,
  0x01, 0xFF, 0x87, 0xEF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x02, 0x07, 0xF8,
  0x01, 0xE0, 0x3F, 0xE0, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x08, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x04,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x7C, 0x00, 0x3F, 0xFE, 0x1F, 0x00, 0x0F, 0xFF, 0xE3, 0xE0, 0x03, 0xFF,
  0xFE, 0x7C, 0x00, 0xFF, 0xCF, 0xDF, 0x80, 0x3F, 0xC0, 0x3F, 0xF0, 0x0F,
  0xF0, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x0F, 0xF0,
  0x0F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x03,
  0xF0, 0x1F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x7E, 0x00,
  0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x3F, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x1F, 0x80, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x7E,
  0x00, 0x1F, 0xF0, 0x0F, 0xC0, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFF, 0x80,
  0x3F, 0x80, 0x3F, 0xF0, 0x03, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xCF, 0xEF,
  0xC0, 0x0F, 0xFF, 0xF9, 0xF0, 0x00, 0xFF, 0xFE, 0x7E, 0x00, 0x0F, 0xFF,
  0x8F, 0xC0, 0x00, 0xFF, 0xC1, 0xF8, 0x00, 0x03, 0xC0, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x80, 0x00,
  0x7F, 0x00, 0x18, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x1F, 0xF0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x07, 0x80, 0x00, 0xFC, 0x1F, 0xF8, 0x00, 0x7E, 0x3F, 0xFE, 0x00,
  0x3F, 0x3F, 0xFF, 0x80, 0x1F, 0x3F, 0xFF, 0xE0, 0x1F, 0xBF, 0xDF, 0xF0,
  0x0F, 0xFE, 0x03, 0xF8, 0x07, 0xFE, 0x00, 0xFC, 0x03, 0xFE, 0x00, 0x7E,
  0x01, 0xFE, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x0F,
  0xC0, 0x7F, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x01,
  0xF8, 0x1F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x04, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x7E,
  0x00, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x1F,
  0x80, 0x3F, 0x80, 0x0F, 0xC0, 0x3F, 0x80, 0x07, 0xE0, 0x3F, 0x80, 0x03,
  0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0xFC, 0x1F, 0xC0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x3E, 0x1F, 0xC0, 0x00,
  0x3F, 0x1F, 0xC0, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x0F, 0xDF, 0xC0, 0x00,
  0x07, 0xCF, 0xE0, 0x00, 0x03, 0xEF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xBF, 0x00, 0x00, 0x7F, 0x9F, 0xC0,
  0x00, 0x7F, 0x87, 0xE0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x1F, 0x81, 0xFC,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x1F,
  0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x3F, 0x00,
  0x1F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF8, 0x07, 0xE0,
  0x01, 0xFC, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xE1,
  0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7C, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0x0F,
  0x9F, 0xFF, 0xE3, 0xFF, 0xFC, 0x03, 0xF7, 0xF7, 0xFC, 0xFE, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xBE, 0x03, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x3F,
  0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xE0, 0x7F, 0xC0, 0x07, 0xF8, 0x00,
  0xFC, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x0F, 0xFC, 0x00, 0x3E, 0x1F, 0xFF, 0x00, 0x1F, 0x1F, 0xFF, 0xC0, 0x1F,
  0x9F, 0xFF, 0xF0, 0x0F, 0xDF, 0xFF, 0xF8, 0x07, 0xFF, 0x81, 0xFC, 0x03,
  0xFF, 0x00, 0x7F, 0x01, 0xFF, 0x00, 0x3F, 0x81, 0xFF, 0x00, 0x1F, 0xC0,
  0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x07, 0xE0, 0x3F, 0x80, 0x03, 0xF0,
  0x3F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xFE,
  0x07, 0xE0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x1F,
  0x81, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01,
  0xFC, 0x0F, 0xC0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xF0, 0x00,
  0x3F, 0x03, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x0F, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x03, 0xF0, 0x3F, 0x80,
  0x01, 0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x7E, 0x07, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xC0,
  0x7F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x07,
  0xF1, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFC,
  0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x7F,
  0x00, 0x3F, 0x81, 0xFE, 0x03, 0xFC, 0x03, 0xFF, 0x7F, 0xE0, 0x07, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x01, 0xF0,
  0x3F, 0xF0, 0x00, 0x1F, 0x0F, 0xFF, 0x80, 0x01, 0xF1, 0xFF, 0xFC, 0x00,
  0x1F, 0x3F, 0xFF, 0xC0, 0x03, 0xF7, 0xE3, 0xFE, 0x00, 0x3F, 0xF8, 0x0F,
  0xE0, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x07, 0xF0, 0x03, 0xFC,
  0x00, 0x3F, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7F, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x03, 0xF0, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0xC0,
  0x3F, 0xC0, 0x0F, 0xDF, 0x9F, 0xF8, 0x00, 0xFD, 0xFF, 0xFF, 0x00, 0x0F,
  0xCF, 0xFF, 0xE0, 0x00, 0xFC, 0x7F, 0xFC, 0x00, 0x1F, 0x83, 0xFF, 0x00,
  0x01, 0xF8, 0x07, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x07, 0xC0, 0x0F, 0xFF, 0x87, 0xC0, 0x0F, 0xFF, 0xE3, 0xE0, 0x0F, 0xFF,
  0xF9, 0xF0, 0x0F, 0xFC, 0xFD, 0xF8, 0x0F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF0,
  0x07, 0xFC, 0x07, 0xF0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x03, 0xF0,
  0x00, 0x7F, 0x83, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC1, 0xFC,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x07, 0xF0,
  0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xFC,
  0x0F, 0xC0, 0x01, 0xFE, 0x07, 0xE0, 0x01, 0xFF, 0x03, 0xF0, 0x00, 0xFF,
  0x01, 0xFC, 0x00, 0xFF, 0x80, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0x80, 0xFF,
  0xE0, 0x1F, 0xF3, 0xFB, 0xF0, 0x0F, 0xFF, 0xF9, 0xF0, 0x03, 0xFF, 0xF9,
  0xF8, 0x00, 0xFF, 0xF0, 0xFC, 0x00, 0x3F, 0xF0, 0x7E, 0x00, 0x03, 0xC0,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x1F, 0x07, 0xFC, 0x03, 0xE1, 0xFF, 0x00, 0x7C, 0x7F, 0xE0, 0x0F, 0x9F,
  0xFC, 0x03, 0xF7, 0xFF, 0x00, 0x7D, 0xF8, 0x00, 0x0F, 0xBC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x07, 0xFC, 0x3F, 0x81, 0xFC, 0x00, 0x60, 0x3F, 0x00, 0x04, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x80, 0x01, 0xFC, 0x1C,
  0x00, 0x7F, 0x83, 0xF8, 0x7F, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x1C, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x1C, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F,
  0x80, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x3F, 0xC0, 0xFC,
  0x00, 0x7F, 0xC0, 0xFE, 0x00, 0xFF, 0xC0, 0xFE, 0x03, 0xEF, 0x80, 0x7F,
  0xDF, 0xCF, 0x80, 0x7F, 0xFF, 0x8F, 0x80, 0x3F, 0xFF, 0x8F, 0x80, 0x3F,
  0xFE, 0x0F, 0x80, 0x0F, 0xFC, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F,
  0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x1F,
  0x00, 0x0F, 0xC0, 0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xE0, 0x3E, 0x00,
  0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8,
  0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x07,
  0xE0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xC3,
  0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF1, 0xF8, 0x00, 0x0F, 0x8F, 0xC0,
  0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x00,
  0xFB, 0xF0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xEF, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xBF, 0x00,
  0x0F, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF3, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x3F,
  0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xDF,
  0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x7C, 0x01, 0xF8, 0x3F, 0x00, 0xF9, 0xF0,
  0x07, 0xE0, 0xFC, 0x03, 0xE7, 0xC0, 0x3F, 0x03, 0xF0, 0x1F, 0x9F, 0x00,
  0xFC, 0x0F, 0xC0, 0x7C, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF1, 0xF0, 0x1F,
  0x80, 0xFC, 0x0F, 0x87, 0xC0, 0xFC, 0x01, 0xF0, 0x3E, 0x1F, 0x03, 0xF0,
  0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x80, 0x1F, 0x07, 0xC1, 0xF0, 0x7E, 0x00,
  0x7C, 0x3F, 0x07, 0xC1, 0xF8, 0x01, 0xF0, 0xF8, 0x1F, 0x0F, 0xC0, 0x07,
  0xC3, 0xE0, 0x3C, 0x3F, 0x00, 0x1F, 0x1F, 0x00, 0xF1, 0xF8, 0x00, 0x7C,
  0x7C, 0x03, 0xC7, 0xE0, 0x01, 0xF3, 0xE0, 0x0F, 0x1F, 0x00, 0x07, 0xCF,
  0x80, 0x3C, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0xF3, 0xF0, 0x00, 0x7D, 0xF0,
  0x03, 0xCF, 0x80, 0x01, 0xF7, 0xC0, 0x0F, 0x7E, 0x00, 0x07, 0xFE, 0x00,
  0x3D, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0xF7, 0xC0, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0xFE, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0x81, 0xF8,
  0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x7C,
  0x7E, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xBF, 0x00,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x07, 0xC0, 0x3F, 0x00,
  0x00, 0x07, 0xC0, 0x7F, 0x00, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0x07,
  0xC0, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0x07, 0xE1, 0xFC,
  0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x03, 0xE7,
  0xE0, 0x00, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x81, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x02, 0x3F,
  0xF8, 0x00, 0x04, 0xFF, 0xFC, 0x00, 0x1B, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x60, 0x00,
  0xFF, 0xFC, 0x80, 0x00, 0x7F, 0xF1, 0x00, 0x00, 0x02, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Italic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 18, 52, 18, 1, -51 },
  { 118, 21, 19, 26, 7, -51 },
  { 168, 40, 51, 40, 1, -51 },
  { 423, 32, 58, 35, 2, -54 },
  { 655, 44, 52, 52, 5, -51 },
  { 941, 39, 52, 41, 1, -51 },
  { 1195, 9, 19, 15, 8, -51 },
  { 1217, 23, 62, 20, 2, -51 },
  { 1396, 22, 62, 20, -5, -51 },
  { 1567, 29, 29, 34, 7, -54 },
  { 1673, 31, 34, 37, 4, -42 },
  { 1805, 13, 17, 17, -3, -8 },
  { 1833, 17, 6, 21, 2, -22 },
  { 1846, 9, 9, 17, 1, -8 },
  { 1857, 33, 51, 25, -3, -51 },
  { 2068, 31, 52, 35, 3, -51 },
  { 2270, 20, 51, 35, 9, -51 },
  { 2398, 35, 51, 35, -1, -51 },
  { 2622, 33, 52, 35, 1, -51 },
  { 2837, 34, 51, 35, 0, -51 },
  { 3054, 34, 52, 35, 1, -51 },
  { 3275, 32, 52, 35, 3, -51 },
  { 3483, 33, 51, 35, 4, -51 },
  { 3694, 33, 52, 35, 2, -51 },
  { 3909, 32, 52, 35, 2, -51 },
  { 4117, 14, 40, 17, 1, -39 },
  { 4187, 18, 48, 17, -3, -39 },
  { 4295, 31, 33, 37, 4, -42 },
  { 4423, 31, 20, 37, 4, -35 },
  { 4501, 31, 33, 37, 4, -42 },
  { 4629, 25, 52, 27, 4, -51 },
  { 4792, 49, 57, 53, 3, -51 },
  { 5142, 36, 51, 36, -4, -51 },
  { 5372, 36, 51, 38, 2, -51 },
  { 5602, 36, 52, 36, 4, -51 },
  { 5836, 38, 51, 42, 2, -51 },
  { 6079, 34, 51, 33, 2, -51 },
  { 6296, 34, 51, 30, 2, -51 },
  { 6513, 39, 52, 43, 4, -51 },
  { 6767, 42, 51, 43, 2, -51 },
  { 7035, 28, 51, 21, -2, -51 },
  { 7214, 30, 65, 18, -11, -51 },
  { 7458, 40, 51, 36, 2, -51 },
  { 7713, 24, 51, 30, 2, -51 },
  { 7866, 53, 51, 55, 2, -51 },
  { 8204, 44, 51, 45, 2, -51 },
  { 8485, 40, 52, 45, 4, -51 },
  { 8745, 35, 51, 36, 2, -51 },
  { 8969, 40, 63, 45, 4, -51 },
  { 9284, 35, 51, 37, 2, -51 },
  { 9508, 34, 52, 33, 0, -51 },
  { 9729, 31, 51, 31, 6, -51 },
  { 9927, 40, 52, 43, 4, -51 },
  { 10187, 36, 51, 35, 6, -51 },
  { 10417, 54, 51, 56, 7, -51 },
  { 10762, 43, 51, 33, -4, -51 },
  { 11037, 33, 51, 32, 6, -51 },
  { 11248, 37, 51, 33, -1, -51 },
  { 11484, 27, 62, 20, -1, -51 },
  { 11694, 13, 51, 25, 7, -51 },
  { 11777, 27, 62, 20, -5, -51 },
  { 11987, 32, 30, 36, 2, -51 },
  { 12107, 26, 5, 26, -6, 6 },
  { 12124, 11, 11, 19, 10, -54 },
  { 12140, 33, 40, 37, 3, -39 },
  { 12305, 33, 55, 37, 1, -54 },
  { 12532, 27, 40, 29, 3, -39 },
  { 12667, 36, 55, 37, 3, -54 },
  { 12915, 28, 40, 32, 3, -39 },
  { 13055, 37, 71, 20, -8, -54 },
  { 13384, 35, 56, 37, 1, -39 },
  { 13629, 33, 54, 37, 1, -54 },
  { 13852, 17, 52, 17, 1, -52 },
  { 13963, 27, 69, 17, -9, -52 },
  { 14196, 33, 54, 32, 1, -54 },
  { 14419, 18, 54, 17, 1, -54 },
  { 14541, 51, 39, 55, 1, -39 },
  { 14790, 33, 39, 37, 1, -39 },
  { 14951, 30, 40, 36, 3, -39 },
  { 15101, 36, 56, 37, -2, -39 },
  { 15353, 33, 56, 37, 3, -39 },
  { 15584, 27, 39, 25, 1, -39 },
  { 15716, 27, 40, 28, 0, -39 },
  { 15851, 20, 48, 21, 3, -47 },
  { 15971, 32, 39, 37, 3, -38 },
  { 16127, 29, 38, 30, 4, -38 },
  { 16265, 46, 38, 47, 4, -38 },
  { 16484, 36, 38, 31, -3, -38 },
  { 16655, 40, 55, 30, -7, -38 },
  { 16930, 30, 38, 27, -2, -38 },
  { 17073, 27, 62, 24, 1, -51 },
  { 17283, 6, 71, 34, 15, -54 },
  { 17337, 26, 62, 24, -3, -51 },
  { 17539, 31, 10, 37, 4, -30 },
};

const GFXfont NotoSans_SemiCondensed_Italic71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic71pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC71PT7B_H_
