#ifndef _NOTOSANS_SEMICONDENSED_ITALIC69PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1C, 0x00, 0x00,
  0x1F, 0x83, 0xF8, 0xFC, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0,
  0x7E, 0x1F, 0x83, 0xF0, 0xF8, 0x1F, 0x87, 0xC0, 0xF8, 0x3E, 0x07, 0xC3,
  0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3C, 0x07,
  0xC1, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x00,
  0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xC0,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xE7, 0xF0, 0x0F, 0xE3, 0xC1, 0xE0, 0x3F, 0x87,
  0x80, 0x80, 0x7E, 0x0F, 0x00, 0x00, 0xF8, 0x1C, 0x00, 0x01, 0xF0, 0x78,
  0x00, 0x07, 0xE0, 0xF0, 0x00, 0x0F, 0xC1, 0xE0, 0x00, 0x1F, 0x83, 0xC0,
  0x00, 0x3F, 0x07, 0x00, 0x00, 0x3F, 0x1E, 0x00, 0x00, 0x7E, 0x3C, 0x00,
  0x00, 0xFF, 0x78, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xCF, 0xE0, 0x00, 0x07, 0x8F, 0xC0, 0x00, 0x0E, 0x0F, 0xC0, 0x00,
  0x3C, 0x1F, 0x80, 0x00, 0x78, 0x3F, 0x00, 0x00, 0xF0, 0x7E, 0x00, 0x01,
  0xE0, 0xFC, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x1E,
  0x0F, 0xC1, 0x00, 0x3C, 0x3F, 0x03, 0xC0, 0x78, 0xFE, 0x07, 0xF9, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xC0, 0x0F,
  0xFF, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0xFE, 0xFE,
  0x00, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0xF8, 0x00,
  0x7C, 0x00, 0xF8, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x01, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0x3E,
  0x00, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x07,
  0xC0, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x03,
  0xE0, 0x00, 0xF8, 0x03, 0xC0, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x1F, 0x00,
  0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE1, 0xF0, 0x00, 0x0F,
  0x00, 0x78, 0x3E, 0x0F, 0xE1, 0xE0, 0x1F, 0x0F, 0x87, 0xFE, 0x3C, 0x03,
  0xE3, 0xF1, 0xFF, 0xE7, 0xC0, 0xF8, 0x7C, 0x7F, 0xFE, 0xF8, 0x1F, 0x1F,
  0x1F, 0x8F, 0xDF, 0x07, 0xC7, 0xE3, 0xE0, 0xFB, 0xFB, 0xF0, 0xF8, 0xF8,
  0x0F, 0x3F, 0xFE, 0x3E, 0x1F, 0x01, 0xF7, 0xFF, 0x8F, 0xC7, 0xC0, 0x3E,
  0x7F, 0xE1, 0xF0, 0xF8, 0x07, 0xC3, 0xF0, 0x7C, 0x3E, 0x00, 0xF0, 0x00,
  0x1F, 0x87, 0xC0, 0x1E, 0x00, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0x00, 0xF8,
  0x1F, 0x00, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x1F, 0x00, 0x07, 0xC0, 0xF8,
  0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x00, 0x7E, 0x03, 0xE0, 0x1F,
  0x00, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x00,
  0x7C, 0x01, 0xF0, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x00, 0x1F,
  0x03, 0xE0, 0x0F, 0x80, 0x03, 0xF0, 0xF8, 0x01, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x7C, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x7F, 0xF0, 0x07,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x7E, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x1F, 0xC0,
  0x00, 0x01, 0xF0, 0xFE, 0x00, 0x00, 0x07, 0xEF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x40, 0xFE, 0x7E, 0x00, 0x3E,
  0x07, 0xF0, 0xFC, 0x01, 0xF8, 0x3F, 0x83, 0xF8, 0x07, 0xE1, 0xFC, 0x07,
  0xE0, 0x3F, 0x0F, 0xE0, 0x1F, 0xC0, 0xFC, 0x3F, 0x00, 0x3F, 0x07, 0xE1,
  0xF8, 0x00, 0xFE, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0xFC, 0x1F, 0x00, 0x03,
  0xF7, 0xE0, 0xFC, 0x00, 0x0F, 0xFF, 0x83, 0xF0, 0x00, 0x1F, 0xFC, 0x0F,
  0xC0, 0x00, 0x7F, 0xE0, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x03,
  0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0xFF, 0xC0, 0x1F,
  0x80, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0x87, 0xFD,
  0xFC, 0x03, 0xFF, 0xFF, 0xE3, 0xF8, 0x07, 0xFF, 0xFF, 0x0F, 0xE0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0x8F, 0xC7, 0xE7, 0xE3, 0xF1, 0xF8, 0xF8, 0x7C, 0x3E,
  0x1F, 0x1F, 0x0F, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x78, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x02, 0x00, 0x78, 0x00, 0x78, 0x07, 0x80,
  0x07, 0xE0, 0x78, 0x00, 0xFF, 0x87, 0x00, 0x0F, 0xFE, 0xF0, 0x00, 0x3F,
  0xFF, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0x83, 0xF0, 0x0F, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x3F, 0x3C, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x81,
  0xF0, 0x03, 0xF8, 0x1F, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0xE0, 0x1F, 0x80,
  0x04, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x03,
  0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xE0,
  0x3F, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x3E, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7E, 0x38, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFE, 0x1F, 0xE0,
  0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xFC, 0x0F,
  0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0xFC, 0x3F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x7C, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E,
  0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F,
  0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x01,
  0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x1F,
  0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xCF, 0xDF, 0xF1,
  0xF3, 0xFC, 0x7E, 0x3E, 0x0F, 0xC3, 0x81, 0xF8, 0x40, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xE0,
  0x03, 0xF0, 0x03, 0xF8, 0x00, 0x78, 0x00, 0x7F, 0x00, 0x08, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x08, 0x1F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x7C, 0x00, 0xFE, 0x00,
  0x70, 0x00, 0x7F, 0x00, 0x40, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x80,
  0x00, 0x3F, 0xC0, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x87, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x0F, 0xC7,
  0xC0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF0,
  0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x01, 0xF8,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x7C, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0xBF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0x80, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x40, 0x00, 0x0F, 0xE0, 0x30,
  0x00, 0x0F, 0xF0, 0x1E, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0x81, 0x80, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC,
  0x0F, 0xE0, 0x01, 0xF8, 0xFF, 0xF0, 0x03, 0xE3, 0xFF, 0xF0, 0x0F, 0xCF,
  0xFF, 0xF0, 0x1F, 0xBF, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xE0, 0x7F, 0xC0,
  0x1F, 0xC1, 0xFF, 0x00, 0x1F, 0x83, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x00,
  0x3F, 0x0F, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC,
  0x3F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7E, 0x03, 0xF8, 0x01, 0xF8, 0x03,
  0xF8, 0x0F, 0xF0, 0x07, 0xFC, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xE8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x03, 0xF8, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x0F,
  0xF0, 0x3F, 0x80, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F,
  0x00, 0x07, 0xE0, 0x7F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0xE0, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x00, 0x7E, 0x01, 0xFC,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0x80,
  0x01, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x7E, 0x3F, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x7F,
  0x07, 0xE0, 0x01, 0xFE, 0x0F, 0xC0, 0x07, 0xFC, 0x1F, 0xC0, 0x1F, 0xF0,
  0x3F, 0xE0, 0xFF, 0xE0, 0x3F, 0xFF, 0xEF, 0xC0, 0x3F, 0xFF, 0x9F, 0x80,
  0x3F, 0xFE, 0x3E, 0x00, 0x3F, 0xF8, 0xFC, 0x00, 0x0F, 0x81, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x08, 0x00, 0x7F,
  0x80, 0x1F, 0xDF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x07, 0xE0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0x80, 0xFE, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0xC0, 0x7F, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F, 0xC1, 0xFE, 0x0E, 0x00,
  0x7F, 0x08, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0xE0, 0x07, 0xC1,
  0xF0, 0x00, 0xFF, 0xF8, 0x0F, 0x83, 0xE0, 0x07, 0xFF, 0xF8, 0x0F, 0x0F,
  0x80, 0x1F, 0xFF, 0xE0, 0x1E, 0x1F, 0x00, 0x7F, 0x0F, 0xC0, 0x3C, 0x7C,
  0x01, 0xF8, 0x0F, 0x80, 0x78, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xF3, 0xE0,
  0x1F, 0x80, 0x7C, 0x01, 0xE7, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xCF, 0x80,
  0xF8, 0x01, 0xF0, 0x07, 0xBE, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x7C, 0x07,
  0xC0, 0x0F, 0x80, 0x3E, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0x7D, 0xE0, 0x1E,
  0x00, 0x3E, 0x00, 0xFF, 0xC0, 0x7C, 0x00, 0x7C, 0x01, 0xEF, 0x80, 0xF8,
  0x01, 0xF0, 0x07, 0xDF, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xBE, 0x03, 0xE0,
  0x07, 0xC0, 0x1E, 0x7C, 0x07, 0xC0, 0x1F, 0x80, 0x7C, 0xF8, 0x0F, 0x80,
  0x3E, 0x00, 0xF1, 0xF0, 0x1F, 0x00, 0xFC, 0x03, 0xE3, 0xE0, 0x3E, 0x01,
  0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x07, 0xF0, 0x1F, 0x0F, 0x80, 0xFC, 0x1E,
  0xF0, 0x7C, 0x1F, 0x01, 0xFF, 0xF9, 0xFF, 0xF0, 0x3E, 0x01, 0xFF, 0xE3,
  0xFF, 0xC0, 0x7C, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0xFC, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFC, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0x7E, 0xF8,
  0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x00, 0x7C,
  0x7C, 0x00, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x00,
  0xFC, 0x3E, 0x00, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x07, 0xE0, 0xF8, 0x00,
  0x00, 0xFC, 0x1F, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x3F, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00,
  0x03, 0xF3, 0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x0F, 0xDF, 0xC0,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0x80, 0x07, 0xF0, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0xFE, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x01, 0xFC, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x1F, 0xE0, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x01, 0xFC, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xFC, 0x0F, 0xC0,
  0x00, 0x3F, 0x81, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x01, 0xFC, 0x0F,
  0xC0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFC,
  0x3F, 0x80, 0x0F, 0xF8, 0x00, 0x60, 0x03, 0xFC, 0x00, 0x04, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x1C, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x7F, 0xE0, 0x01,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x0F,
  0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7F, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x01, 0xFC, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x3F, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0x80,
  0x00, 0x7F, 0x80, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x3E, 0x00, 0x07, 0xFC, 0x03, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0x80, 0x0F,
  0xFC, 0x00, 0xFC, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x0F, 0x00, 0x1F, 0xE0, 0x00, 0x0C, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x07, 0xFF, 0xE1, 0xF8, 0x00, 0x3F, 0xFF, 0x8F, 0xE0, 0x00, 0xFF, 0xFC,
  0x3F, 0x80, 0x03, 0xFF, 0xF0, 0xFE, 0x00, 0x0F, 0xFF, 0xC3, 0xF0, 0x00,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x3F, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x3E, 0x01, 0xFE, 0x00, 0x01, 0xF8, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x40, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0xC0,
  0x00, 0x0F, 0x80, 0x7F, 0x00, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x00, 0x7E,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x7F, 0x00,
  0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x00, 0x1F,
  0x8F, 0xE0, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0xFE, 0x00,
  0x00, 0x01, 0xFB, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF7, 0xE0,
  0x00, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0x7C, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xBE, 0x00,
  0x00, 0x3E, 0xFC, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x0F, 0xBF,
  0x00, 0x00, 0x7C, 0xF8, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x1F,
  0x9F, 0x00, 0x00, 0xF9, 0xF8, 0x01, 0xF9, 0xF0, 0x00, 0x1F, 0x9F, 0x80,
  0x1F, 0x1F, 0x00, 0x01, 0xF1, 0xF8, 0x01, 0xF1, 0xF0, 0x00, 0x3F, 0x3F,
  0x00, 0x3F, 0x1F, 0x00, 0x03, 0xE3, 0xF0, 0x03, 0xF1, 0xF0, 0x00, 0x7E,
  0x3F, 0x00, 0x3F, 0x1F, 0x00, 0x07, 0xC3, 0xF0, 0x03, 0xE1, 0xF0, 0x00,
  0xFC, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xE0, 0x07, 0xE1, 0xF8,
  0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x07, 0xE0, 0x07, 0xE0,
  0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x0F,
  0xC0, 0xF8, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x0F, 0x80, 0x7C, 0x0F, 0xC0,
  0x0F, 0xC0, 0xF8, 0x0F, 0xC0, 0xFC, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0xC0, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x0F, 0x81, 0xF0,
  0x1F, 0x80, 0x1F, 0x80, 0xF8, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0x83,
  0xE0, 0x1F, 0x80, 0x1F, 0x00, 0xFC, 0x7C, 0x01, 0xF8, 0x01, 0xF0, 0x07,
  0xC7, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0x7C, 0xF8, 0x03, 0xF0, 0x03, 0xF0,
  0x07, 0xCF, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7D, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x07, 0xDF, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7F, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x07,
  0xE0, 0x07, 0xC0, 0x07, 0xFC, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7F, 0x80,
  0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x07,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x1F, 0x7E, 0x00, 0x03, 0xF0, 0x03,
  0xEF, 0xC0, 0x00, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x9F,
  0x80, 0x03, 0xF0, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x0F, 0xC0, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x7E,
  0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC1, 0xF0, 0x01, 0xF8, 0x01,
  0xF8, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x7C, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x3F, 0x00, 0x3F, 0x01, 0xF8,
  0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x3F,
  0x00, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x00,
  0xFC, 0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x83, 0xE0, 0x03, 0xE0,
  0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x80, 0x07,
  0xC3, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x7C, 0x00, 0x1F, 0x8F,
  0x80, 0x0F, 0x80, 0x01, 0xF1, 0xF0, 0x03, 0xF0, 0x00, 0x3F, 0x7E, 0x00,
  0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x0F, 0xC0, 0x00, 0x7D, 0xF0, 0x01, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xC0, 0x00,
  0x3F, 0xF8, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0xC0, 0x07, 0xC0, 0x00, 0x0F, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x1F, 0x81, 0xFC, 0x00,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x03, 0xF0,
  0xFE, 0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00,
  0x03, 0xF7, 0xF0, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xBF, 0x80, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x00, 0x1F, 0xCF, 0xC0,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x0F,
  0xC3, 0xF8, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0,
  0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x0F, 0xF8, 0x01, 0xF8, 0x01,
  0xFE, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0x80,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xF0, 0x1F,
  0x80, 0x07, 0xF0, 0x1F, 0x80, 0x07, 0xF8, 0x0F, 0xC0, 0x0F, 0xF8, 0x07,
  0xE0, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xE1, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x1F, 0x81,
  0xFC, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0xFE, 0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x00, 0x3F, 0x1F,
  0xC0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x00, 0xFD, 0xFC,
  0x00, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x00, 0x3F, 0xBF, 0x00,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x00, 0x1F,
  0xCF, 0xC0, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x03, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x1F, 0x80, 0x7F, 0xC0, 0x07, 0xE0, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x7E, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0x80,
  0x7E, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x07, 0xE0,
  0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xF8,
  0x07, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07,
  0xE0, 0x1F, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xCF, 0xF8, 0x01, 0xFE, 0x00, 0x78,
  0x01, 0xFC, 0x00, 0x04, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x20, 0x00, 0x07, 0xF0, 0x1C, 0x00, 0x07, 0xF8, 0x0F, 0x80, 0x0F, 0xF8,
  0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x00, 0xFE, 0x7C, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x1F, 0xC7,
  0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xFC, 0x07, 0xE0, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x07, 0xF0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x01, 0xF1,
  0xF8, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x07,
  0xCF, 0xC0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00,
  0x1F, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFD, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE,
  0x7E, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0x1F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0x7E, 0x0F, 0xC0,
  0x03, 0xEF, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x03,
  0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x9F, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0xF8, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x07, 0xC3, 0xE0,
  0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xE0,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x07, 0xC0, 0x3F, 0x00, 0x7E, 0x01,
  0xF0, 0x3E, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x81, 0xF0, 0x1F, 0x80, 0x1F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x7C, 0x0F, 0xC0,
  0x07, 0xE0, 0x7C, 0x03, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xE0, 0x1F, 0x07,
  0xE0, 0x01, 0xF8, 0x3E, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF0, 0x07,
  0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x03, 0xF0, 0xF8,
  0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0x8F, 0xC0, 0x00, 0xFC,
  0x7C, 0x00, 0x7C, 0x7E, 0x00, 0x07, 0xE3, 0xE0, 0x03, 0xE3, 0xE0, 0x00,
  0x3F, 0x3E, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0xF9, 0xF0,
  0x00, 0x07, 0xDF, 0x80, 0x07, 0xDF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x8F, 0x80, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0xF8, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xF3, 0xF0, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0xFE, 0x0F, 0x80, 0x01,
  0xF8, 0x1F, 0x80, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x07, 0xF0,
  0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0xFE, 0x00,
  0x0F, 0x81, 0xF8, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x01,
  0xF7, 0xE0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC0,
  0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x07, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7C, 0x7C, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x1F, 0x03, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x03,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x7E, 0x0F, 0x80, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x00, 0xF9, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x1F, 0xC1, 0xF8, 0x3F,
  0x83, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0x00, 0x3F, 0xFC, 0x1E, 0x00,
  0x7F, 0xFE, 0x3E, 0x00, 0xFF, 0xFF, 0x3E, 0x01, 0xFF, 0x3F, 0x7E, 0x03,
  0xFC, 0x07, 0xFE, 0x07, 0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x03, 0xFC, 0x0F,
  0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x1F,
  0x80, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x7F,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x03, 0xF0, 0xFE, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0xC0, 0xFC,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x7F, 0xC0, 0xFC,
  0x00, 0x7F, 0x80, 0xFE, 0x00, 0xFF, 0x80, 0x7E, 0x01, 0xEF, 0x80, 0x7F,
  0x8F, 0xCF, 0x80, 0x7F, 0xFF, 0x8F, 0x80, 0x3F, 0xFF, 0x1F, 0x00, 0x1F,
  0xFE, 0x1F, 0x00, 0x0F, 0xF8, 0x1F, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x03, 0x00, 0x00,
  0xFC, 0x1F, 0xF0, 0x00, 0xF8, 0x7F, 0xF8, 0x01, 0xF8, 0xFF, 0xFC, 0x01,
  0xF9, 0xFF, 0xFE, 0x01, 0xFB, 0xF3, 0xFE, 0x01, 0xF7, 0xC0, 0x7E, 0x01,
  0xFF, 0x00, 0x7F, 0x03, 0xFE, 0x00, 0x3F, 0x03, 0xFE, 0x00, 0x3F, 0x03,
  0xFC, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x3F,
  0x80, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0xC0, 0x07, 0xF0, 0x3F,
  0xC0, 0x0F, 0xE0, 0x7F, 0xE0, 0x1F, 0xC0, 0x7D, 0xF8, 0x7F, 0x80, 0x7C,
  0xFF, 0xFF, 0x80, 0x7C, 0x7F, 0xFF, 0x00, 0xF8, 0x7F, 0xFC, 0x00, 0xF8,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xE7, 0xE0, 0x3F, 0xC0, 0x10, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x30, 0x1F, 0xF0, 0x7C, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x30, 0x0F, 0xC0, 0x00, 0x7F, 0xC1, 0xF8,
  0x00, 0x3F, 0xFC, 0x3E, 0x00, 0x1F, 0xFF, 0xCF, 0xC0, 0x07, 0xFF, 0xFD,
  0xF8, 0x01, 0xFF, 0x9F, 0xFF, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF8, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x1F,
  0xC0, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x7E,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x1F, 0x80, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x7E, 0x00,
  0x3F, 0xE0, 0x0F, 0xC0, 0x0F, 0xF8, 0x01, 0xFC, 0x01, 0xFF, 0x00, 0x3F,
  0x80, 0xFB, 0xE0, 0x03, 0xFC, 0x7E, 0x7C, 0x00, 0x7F, 0xFF, 0x9F, 0x80,
  0x07, 0xFF, 0xE3, 0xE0, 0x00, 0x7F, 0xF8, 0x7C, 0x00, 0x07, 0xFC, 0x0F,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03,
  0xFC, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x0F, 0xE0, 0x07,
  0xE1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xE3, 0xF0,
  0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE3, 0xF0, 0x03, 0xF8,
  0x7E, 0x07, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x20, 0x7F, 0x00, 0x1C, 0x07, 0xF8, 0x1F,
  0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x06, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xEF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xFF, 0x81, 0xF0, 0x00, 0xFF, 0xF0, 0x78, 0x00, 0x7F,
  0xFE, 0x3E, 0x00, 0x7F, 0xFF, 0xCF, 0x80, 0x1F, 0xF3, 0xFF, 0xE0, 0x0F,
  0xE0, 0x1F, 0xF8, 0x07, 0xF0, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0xFF, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x01, 0xF8,
  0x0F, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07,
  0xE0, 0x7F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x0F, 0xF0,
  0x0F, 0xC0, 0x07, 0xFC, 0x03, 0xF0, 0x03, 0xFE, 0x00, 0xFE, 0x01, 0xFF,
  0x80, 0x3F, 0x80, 0xFF, 0xE0, 0x07, 0xF8, 0xFD, 0xF8, 0x01, 0xFF, 0xFE,
  0x7E, 0x00, 0x3F, 0xFF, 0x1F, 0x00, 0x07, 0xFF, 0x8F, 0xC0, 0x00, 0xFF,
  0xC3, 0xF0, 0x00, 0x07, 0x80, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x02, 0x00, 0x03, 0xF8, 0x00, 0xE0, 0x03, 0xFC,
  0x00, 0x3F, 0xC7, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x03, 0x00, 0x00, 0xFC, 0x3F, 0xF0, 0x00, 0xF8, 0x7F, 0xF8, 0x00,
  0xF8, 0xFF, 0xFC, 0x01, 0xF9, 0xFF, 0xFE, 0x01, 0xFB, 0xFB, 0xFE, 0x01,
  0xF7, 0xC0, 0x7E, 0x01, 0xFF, 0x00, 0x7E, 0x03, 0xFE, 0x00, 0x3F, 0x03,
  0xFC, 0x00, 0x3F, 0x03, 0xFC, 0x00, 0x3E, 0x03, 0xF8, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F,
  0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x0E, 0x00, 0x0F, 0x80,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x3B, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xF8,
  0x03, 0xF8, 0x01, 0xF8, 0x07, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x01, 0xF0,
  0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0,
  0x7F, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x03, 0xE1, 0xFC, 0x00, 0x07, 0xE3,
  0xF8, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x07, 0xCF,
  0xC0, 0x00, 0x07, 0xDF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xF3, 0xF0, 0x00, 0x1F, 0xE3,
  0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x1F, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x3F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x3E, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0x87, 0xFF, 0x01, 0xFF, 0xF0,
  0x07, 0xE7, 0xFF, 0xE0, 0xFF, 0xFC, 0x01, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF,
  0x80, 0x7C, 0xFC, 0xFF, 0x3F, 0x9F, 0xE0, 0x1F, 0x78, 0x0F, 0xDF, 0x01,
  0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF0, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0x81, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0x81, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x81,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0xFC, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x3F, 0xF0, 0x00,
  0xF8, 0x7F, 0xFC, 0x01, 0xF9, 0xFF, 0xFC, 0x01, 0xFB, 0xFF, 0xFE, 0x01,
  0xF7, 0xFF, 0xFE, 0x01, 0xF7, 0xC0, 0x7F, 0x03, 0xFF, 0x00, 0x7F, 0x03,
  0xFE, 0x00, 0x7F, 0x03, 0xFE, 0x00, 0x3F, 0x03, 0xFC, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x7E, 0x07, 0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7E, 0x07,
  0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F,
  0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x3F,
  0x80, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0x9F, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0xFC, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x7E, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC3,
  0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x01, 0xFE,
  0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x03, 0xE0, 0x7F, 0xC0, 0x00, 0x7C, 0x3F, 0xFC, 0x00, 0x0F,
  0x8F, 0xFF, 0xC0, 0x03, 0xE3, 0xFF, 0xFC, 0x00, 0x7C, 0xFC, 0x7F, 0x80,
  0x0F, 0xBE, 0x03, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x07,
  0xE0, 0x0F, 0xF8, 0x00, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x3F, 0x80,
  0x03, 0xF0, 0x07, 0xF0, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x3F,
  0x80, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x7C, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x7F, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x0F, 0xFC, 0x03, 0xF8, 0x01, 0xFF, 0xE1,
  0xFE, 0x00, 0x3F, 0x7F, 0xFF, 0xC0, 0x07, 0xC7, 0xFF, 0xF0, 0x00, 0xF8,
  0xFF, 0xF8, 0x00, 0x3F, 0x07, 0xFE, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x1F, 0x00, 0x3F, 0xFC, 0x1E, 0x00, 0x7F, 0xFE, 0x3E, 0x00, 0xFF,
  0xFF, 0x3E, 0x01, 0xFF, 0x3F, 0xFE, 0x03, 0xF8, 0x07, 0xFC, 0x07, 0xF0,
  0x03, 0xFC, 0x0F, 0xE0, 0x03, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0,
  0x01, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x3F, 0xC0, 0xFC, 0x00, 0x7F, 0xC0, 0xFC, 0x00, 0xFF, 0x80, 0xFE, 0x01,
  0xFF, 0x80, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0x8F, 0xDF, 0x80, 0x7F, 0xFF,
  0x9F, 0x80, 0x3F, 0xFF, 0x1F, 0x00, 0x1F, 0xFE, 0x3F, 0x00, 0x0F, 0xF8,
  0x3F, 0x00, 0x01, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x3E, 0x0F, 0xF0, 0x0F, 0x8F, 0xF8, 0x07, 0xC7, 0xFE, 0x01,
  0xF3, 0xFF, 0x80, 0x7C, 0xFF, 0xE0, 0x1F, 0x7C, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0x07, 0xE0, 0x7F, 0x00,
  0x38, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC2, 0x00, 0x07, 0xF0, 0xE0, 0x03,
  0xF8, 0x3F, 0x03, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFE, 0x18, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F,
  0xF8, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0xFC,
  0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x7C, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF8, 0x3F, 0x00, 0x07,
  0xE0, 0x7C, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x7F,
  0x07, 0xE0, 0x01, 0xFE, 0x0F, 0xC0, 0x07, 0xF8, 0x1F, 0x80, 0x1F, 0xF0,
  0x3F, 0x00, 0x7F, 0xE0, 0x7F, 0x01, 0xFF, 0xC0, 0xFF, 0x9F, 0xDF, 0x00,
  0xFF, 0xFF, 0x3E, 0x01, 0xFF, 0xFC, 0x7C, 0x01, 0xFF, 0xF0, 0xF8, 0x01,
  0xFF, 0x81, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00,
  0x0F, 0xCF, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF8,
  0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0,
  0x07, 0xE0, 0x7C, 0x00, 0xFC, 0x07, 0xC0, 0x0F, 0xC0, 0x7C, 0x01, 0xF8,
  0x07, 0xC0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x7E,
  0x07, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xF8,
  0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0xFC,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xEF, 0xC0,
  0x07, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xCF, 0xC0, 0x0F,
  0xF8, 0x00, 0xFC, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0x78,
  0x01, 0xF8, 0xFC, 0x01, 0xF7, 0x80, 0x1F, 0x8F, 0xC0, 0x1E, 0x78, 0x03,
  0xF0, 0xFC, 0x03, 0xE7, 0x80, 0x3F, 0x0F, 0xC0, 0x3E, 0x78, 0x07, 0xE0,
  0xFC, 0x07, 0xC7, 0x80, 0x7E, 0x0F, 0xC0, 0x7C, 0x78, 0x0F, 0xC0, 0xFC,
  0x0F, 0x87, 0x80, 0xFC, 0x0F, 0xC0, 0xF8, 0x78, 0x0F, 0x80, 0xFC, 0x0F,
  0x07, 0xC1, 0xF8, 0x0F, 0xC1, 0xF0, 0x7C, 0x1F, 0x80, 0xFC, 0x1F, 0x07,
  0xC3, 0xF0, 0x0F, 0xC3, 0xE0, 0x7C, 0x3F, 0x00, 0xFC, 0x3E, 0x07, 0xC3,
  0xE0, 0x0F, 0xC7, 0xC0, 0x7C, 0x7E, 0x00, 0xFC, 0x7C, 0x07, 0xC7, 0xC0,
  0x07, 0xCF, 0x80, 0x7C, 0xFC, 0x00, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x07,
  0xCF, 0x80, 0x7C, 0xF8, 0x00, 0x7D, 0xF0, 0x07, 0xDF, 0x80, 0x07, 0xDF,
  0x00, 0x7D, 0xF0, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xBE, 0x00, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x0F,
  0xC0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x07, 0xF0, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x07, 0xC0, 0x3F,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x01, 0xF0,
  0x7E, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00,
  0x7D, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0x80, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x3F, 0x80, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x3E, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00,
  0x0F, 0x83, 0xF0, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x7E,
  0x00, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x00,
  0x3E, 0x3F, 0x00, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x01, 0xF7, 0xE0,
  0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xCF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x04, 0x7F, 0xF0, 0x00, 0x17, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xB0, 0x00, 0x7F, 0xFC, 0x80, 0x00, 0x3F, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_Italic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 17, 50, 17, 1, -49 },
  { 108, 21, 18, 26, 7, -49 },
  { 156, 39, 49, 39, 1, -49 },
  { 395, 31, 56, 34, 2, -52 },
  { 612, 43, 51, 50, 5, -50 },
  { 887, 38, 51, 40, 1, -50 },
  { 1130, 9, 18, 14, 7, -49 },
  { 1151, 22, 60, 19, 2, -49 },
  { 1316, 22, 60, 19, -5, -49 },
  { 1481, 28, 29, 33, 7, -53 },
  { 1583, 30, 33, 36, 4, -41 },
  { 1707, 13, 17, 16, -3, -8 },
  { 1735, 16, 5, 20, 2, -21 },
  { 1745, 8, 9, 16, 1, -8 },
  { 1754, 33, 49, 24, -3, -49 },
  { 1957, 30, 51, 34, 3, -50 },
  { 2149, 19, 49, 34, 9, -49 },
  { 2266, 34, 50, 34, -1, -50 },
  { 2479, 32, 51, 34, 1, -50 },
  { 2683, 33, 49, 34, 0, -49 },
  { 2886, 33, 50, 34, 1, -49 },
  { 3093, 31, 51, 34, 3, -50 },
  { 3291, 32, 49, 34, 4, -49 },
  { 3487, 32, 51, 34, 2, -50 },
  { 3691, 31, 51, 34, 2, -50 },
  { 3889, 14, 39, 16, 1, -38 },
  { 3958, 18, 47, 16, -3, -38 },
  { 4064, 30, 33, 36, 4, -41 },
  { 4188, 30, 19, 36, 4, -34 },
  { 4260, 30, 33, 36, 4, -41 },
  { 4384, 24, 51, 26, 4, -50 },
  { 4537, 47, 55, 52, 3, -49 },
  { 4861, 35, 49, 35, -4, -49 },
  { 5076, 35, 49, 37, 2, -49 },
  { 5291, 35, 51, 35, 4, -50 },
  { 5515, 37, 49, 41, 2, -49 },
  { 5742, 33, 49, 32, 2, -49 },
  { 5945, 33, 49, 30, 2, -49 },
  { 6148, 38, 51, 42, 4, -50 },
  { 6391, 41, 49, 42, 2, -49 },
  { 6643, 27, 49, 21, -2, -49 },
  { 6809, 29, 62, 17, -11, -49 },
  { 7034, 39, 49, 35, 2, -49 },
  { 7273, 23, 49, 29, 2, -49 },
  { 7414, 52, 49, 53, 2, -49 },
  { 7733, 43, 49, 44, 2, -49 },
  { 7997, 38, 51, 44, 4, -50 },
  { 8240, 33, 49, 35, 2, -49 },
  { 8443, 38, 62, 44, 4, -50 },
  { 8738, 34, 49, 36, 2, -49 },
  { 8947, 33, 51, 32, 0, -50 },
  { 9158, 30, 49, 31, 6, -49 },
  { 9342, 39, 50, 42, 4, -49 },
  { 9586, 34, 49, 34, 6, -49 },
  { 9795, 53, 49, 54, 7, -49 },
  { 10120, 42, 49, 32, -4, -49 },
  { 10378, 31, 49, 31, 6, -49 },
  { 10568, 36, 49, 32, -1, -49 },
  { 10789, 26, 60, 20, -1, -49 },
  { 10984, 12, 49, 24, 7, -49 },
  { 11058, 26, 60, 20, -5, -49 },
  { 11253, 31, 29, 35, 2, -49 },
  { 11366, 26, 5, 25, -6, 6 },
  { 11383, 11, 11, 18, 10, -53 },
  { 11399, 32, 39, 36, 3, -38 },
  { 11555, 32, 53, 36, 1, -52 },
  { 11767, 26, 39, 28, 3, -38 },
  { 11894, 35, 53, 36, 3, -52 },
  { 12126, 27, 39, 31, 3, -38 },
  { 12258, 36, 70, 20, -8, -53 },
  { 12573, 34, 55, 36, 1, -38 },
  { 12807, 32, 52, 36, 1, -52 },
  { 13015, 17, 51, 16, 1, -51 },
  { 13124, 27, 68, 16, -9, -51 },
  { 13354, 32, 52, 31, 1, -52 },
  { 13562, 17, 52, 16, 1, -52 },
  { 13673, 50, 38, 54, 1, -38 },
  { 13911, 32, 38, 36, 1, -38 },
  { 14063, 29, 39, 35, 3, -38 },
  { 14205, 35, 54, 36, -2, -38 },
  { 14442, 32, 55, 36, 3, -38 },
  { 14662, 26, 38, 24, 1, -38 },
  { 14786, 26, 39, 27, 0, -38 },
  { 14913, 20, 46, 21, 3, -45 },
  { 15028, 31, 38, 36, 3, -37 },
  { 15176, 28, 37, 29, 4, -37 },
  { 15306, 44, 37, 45, 4, -37 },
  { 15510, 35, 37, 30, -3, -37 },
  { 15672, 38, 54, 29, -6, -37 },
  { 15929, 29, 37, 27, -2, -37 },
  { 16064, 26, 60, 24, 1, -49 },
  { 16259, 5, 70, 33, 15, -53 },
  { 16303, 26, 60, 24, -3, -49 },
  { 16498, 30, 9, 36, 4, -29 },
};

const GFXfont NotoSans_SemiCondensed_Italic69pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic69pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic69pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC69PT7B_H_
