#ifndef _NOTOSANS_SEMICONDENSED_ITALIC58PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC,
  0x00, 0xC0, 0x00, 0x3F, 0x0F, 0x9F, 0x07, 0xCF, 0x87, 0xC7, 0xC3, 0xE3,
  0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x1E,
  0x1E, 0x0F, 0x0E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xC3, 0x80, 0xE0, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x78,
  0x10, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1C, 0x03,
  0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1E,
  0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0x3C, 0xF8, 0x0F,
  0xC7, 0x02, 0x01, 0xF0, 0xE0, 0x00, 0x7C, 0x1C, 0x00, 0x0F, 0x87, 0x80,
  0x01, 0xF0, 0xE0, 0x00, 0x3E, 0x1C, 0x00, 0x07, 0xC3, 0x80, 0x00, 0xF8,
  0x70, 0x00, 0x0F, 0x9E, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3B, 0xF0, 0x00, 0x0F, 0x3F, 0x00,
  0x01, 0xC3, 0xE0, 0x00, 0x38, 0x7C, 0x00, 0x07, 0x07, 0x80, 0x00, 0xE1,
  0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0x07, 0xC2, 0x00, 0xE1, 0xF0, 0x60,
  0x1C, 0x7E, 0x0F, 0xC7, 0xBF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x40, 0x3F, 0xE0, 0x00,
  0x78, 0x07, 0xFE, 0x00, 0x0F, 0x00, 0xFF, 0xF0, 0x00, 0xF0, 0x1F, 0x0F,
  0x00, 0x1E, 0x01, 0xE0, 0xF0, 0x03, 0xC0, 0x3E, 0x07, 0x00, 0x3C, 0x03,
  0xC0, 0x78, 0x07, 0x80, 0x3C, 0x07, 0x80, 0xF8, 0x07, 0x80, 0xF0, 0x0F,
  0x00, 0x78, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x3E, 0x00, 0x78, 0x0F,
  0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x0F, 0x0F, 0x80, 0x0F,
  0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x1E, 0x1E, 0x00, 0x0F, 0x01, 0xE3, 0xE3,
  0xF8, 0xF0, 0x3C, 0x3C, 0x7F, 0xCF, 0x03, 0xC7, 0x8F, 0xFE, 0xF0, 0x78,
  0xF9, 0xF1, 0xEF, 0x8F, 0x8F, 0x1E, 0x1F, 0x7F, 0xF1, 0xE3, 0xC0, 0xF7,
  0xFE, 0x3E, 0x3C, 0x0F, 0x3F, 0xC3, 0xC7, 0x80, 0xF1, 0xF0, 0x78, 0x78,
  0x0F, 0x00, 0x0F, 0x87, 0x80, 0xF0, 0x00, 0xF0, 0xF0, 0x0F, 0x00, 0x1E,
  0x0F, 0x01, 0xF0, 0x03, 0xE0, 0xF0, 0x1E, 0x00, 0x3C, 0x0F, 0x01, 0xE0,
  0x07, 0x80, 0xF0, 0x1E, 0x00, 0xF8, 0x1E, 0x01, 0xE0, 0x0F, 0x01, 0xE0,
  0x3C, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x3C, 0x03, 0xC0,
  0x1E, 0x07, 0x80, 0x78, 0x00, 0xF0, 0xF8, 0x0F, 0x80, 0x0F, 0x1F, 0x00,
  0xF0, 0x00, 0xFF, 0xE0, 0x1E, 0x00, 0x07, 0xFC, 0x03, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x7D,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xC0, 0x1F, 0x0F, 0xC7, 0xC0, 0x3E, 0x1F, 0x87, 0xE0, 0x3E, 0x3F, 0x03,
  0xE0, 0x7C, 0x3E, 0x03, 0xF0, 0x7C, 0x7C, 0x01, 0xF0, 0xF8, 0x7C, 0x00,
  0xF8, 0xF8, 0x78, 0x00, 0xFD, 0xF0, 0xF8, 0x00, 0x7F, 0xE0, 0xF8, 0x00,
  0x7F, 0xE0, 0xF8, 0x00, 0x3F, 0xC0, 0xF8, 0x00, 0x3F, 0x80, 0xF8, 0x00,
  0x3F, 0x00, 0xF8, 0x00, 0x7F, 0x80, 0xFC, 0x00, 0xFF, 0xC0, 0x7E, 0x03,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF7, 0xE0, 0x3F, 0xFF, 0xE3, 0xF0, 0x1F, 0xFF,
  0x83, 0xF0, 0x0F, 0xFE, 0x01, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0x3E,
  0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0x70, 0xF0, 0xF0,
  0xF0, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x08, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x3E,
  0x1E, 0x00, 0xFF, 0x3C, 0x01, 0xFF, 0xF0, 0x1C, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0x81, 0xC0, 0xFF, 0x00, 0x03, 0xEF,
  0x00, 0x0F, 0x8E, 0x00, 0x3E, 0x1E, 0x00, 0xFC, 0x3C, 0x03, 0xF0, 0x7C,
  0x01, 0xC0, 0x78, 0x01, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x01, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xE0, 0x7C, 0x1F,
  0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0x80, 0xF0, 0x3C,
  0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0xFF, 0xF8, 0x3C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0x38, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xCF, 0xF0, 0x1F, 0x81, 0xF8,
  0x0F, 0x80, 0x7C, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x0F, 0x87, 0xC0, 0x07,
  0xC7, 0xE0, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF9, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xBE, 0x00,
  0x07, 0xDF, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF7, 0xC0,
  0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0x7C,
  0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x00, 0x07, 0xC7,
  0x80, 0x03, 0xE3, 0xC0, 0x01, 0xF1, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xF8,
  0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x7E, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x7F, 0xF8, 0x7F, 0x78, 0xFF,
  0x7C, 0xFE, 0x3E, 0x3E, 0x1F, 0x0C, 0x0F, 0x84, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0xFF, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0xC0,
  0x07, 0xC0, 0x04, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00,
  0xFE, 0x1F, 0xE0, 0x0F, 0x00, 0x7E, 0x00, 0x40, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xE0, 0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x3F, 0xC0, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xFB, 0xC0,
  0x00, 0x1F, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x07,
  0xC7, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xE0, 0xF8,
  0x00, 0x3E, 0x0F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x0F,
  0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x01, 0xE0, 0x07, 0xC0, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3E, 0x01, 0xF0, 0x03, 0xC0, 0x3E,
  0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0x20, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x40, 0x00, 0xFE, 0x0F, 0x00, 0x7F, 0x81,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xE1, 0x80, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x1F, 0xC0,
  0x0F, 0x9F, 0xFC, 0x03, 0xCF, 0xFF, 0x81, 0xF7, 0xFF, 0xE0, 0x7F, 0xC1,
  0xFC, 0x1F, 0xE0, 0x1F, 0x07, 0xF0, 0x07, 0xE3, 0xF8, 0x00, 0xF8, 0xFC,
  0x00, 0x3E, 0x3F, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF8,
  0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xC3, 0xE0, 0x01,
  0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0x83, 0xF0,
  0x07, 0xE0, 0x7C, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xC1, 0xFC, 0x03, 0xE0, 0x1F, 0x80,
  0xFC, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0xF8, 0x00,
  0x7C, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x3C, 0x00, 0x7C, 0x07,
  0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0xF8, 0x01, 0xF0, 0x7E,
  0x00, 0x1F, 0xBF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0x1F, 0xC0,
  0x1F, 0x80, 0xF8, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x01, 0xF0, 0x3E, 0x00,
  0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87,
  0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x01,
  0xF8, 0x7C, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xC7, 0xF0, 0x1F, 0x80, 0xF8,
  0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07,
  0xC7, 0xC0, 0x01, 0xE3, 0xE0, 0x00, 0xF1, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x00,
  0x0F, 0xCF, 0x80, 0x07, 0xE3, 0xE0, 0x07, 0xF1, 0xF0, 0x07, 0xF8, 0xFC,
  0x07, 0xF8, 0x3F, 0xDF, 0xFC, 0x1F, 0xFF, 0xBE, 0x07, 0xFF, 0x9F, 0x01,
  0xFF, 0x8F, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x04, 0x01, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x7C, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x81, 0xF0, 0x7F, 0x0F, 0xE1,
  0xF8, 0x3F, 0x07, 0xC0, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x3E, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xF8,
  0x7F, 0xFF, 0xE1, 0xF8, 0xFF, 0x0E, 0x00, 0xF8, 0x40, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x07, 0xC0, 0x0F,
  0xF0, 0x0F, 0x07, 0x80, 0x3F, 0xFE, 0x0F, 0x0F, 0x00, 0xFF, 0xFC, 0x0F,
  0x0F, 0x01, 0xF8, 0x7C, 0x0F, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0x1E, 0x03,
  0xC0, 0x7C, 0x0F, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x3C, 0x07, 0x80, 0x78,
  0x0F, 0x3C, 0x0F, 0x00, 0x78, 0x0F, 0x78, 0x0F, 0x00, 0xF8, 0x0F, 0x78,
  0x1E, 0x00, 0xF0, 0x0F, 0x78, 0x1E, 0x00, 0xF0, 0x0F, 0x78, 0x1E, 0x00,
  0xF0, 0x1E, 0x78, 0x1E, 0x01, 0xE0, 0x1E, 0x78, 0x3C, 0x01, 0xE0, 0x1E,
  0xF8, 0x3C, 0x03, 0xE0, 0x3C, 0xF8, 0x3C, 0x03, 0xE0, 0x3C, 0xF8, 0x3E,
  0x07, 0xE0, 0x78, 0xF8, 0x1E, 0x07, 0xE0, 0xF8, 0xF8, 0x1E, 0x0E, 0xE1,
  0xF0, 0x78, 0x1F, 0xFC, 0xFF, 0xE0, 0x78, 0x0F, 0xF8, 0xFF, 0xC0, 0x78,
  0x07, 0xF0, 0x7F, 0x80, 0x78, 0x01, 0x80, 0x0C, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x10, 0x00, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xBF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x3C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x01,
  0xF0, 0x7C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0xF8, 0x0F, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x7C, 0x03, 0xC0, 0x03, 0xE0, 0x1E, 0x00, 0x3E, 0x00, 0xF0,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3E, 0x00,
  0x1F, 0x03, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x3E,
  0x0F, 0x80, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x7E,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7D, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0x00, 0x7F, 0x00, 0xF8, 0x01, 0xF8, 0x07, 0xC0, 0x07, 0xE0, 0x3E,
  0x00, 0x3F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x3E, 0x07, 0xC0, 0x03, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8,
  0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0xC0, 0x7F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xC1, 0xFF, 0x80, 0x7C, 0x00, 0xFC, 0x03, 0xE0, 0x03, 0xF0,
  0x1F, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x01, 0xF0, 0x7C,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x3F, 0x07, 0x80, 0x01, 0xF8, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xFC,
  0x1F, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0xFE, 0x0F, 0x80, 0x7F, 0xE0, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xF3, 0xF8, 0x03, 0xFC, 0x00,
  0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x70,
  0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x1F, 0x00, 0xFF, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0xF8, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x0F,
  0x80, 0x01, 0xF8, 0x1F, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF8, 0x7C, 0x00,
  0x03, 0xF0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3F,
  0x07, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF8, 0x1E, 0x00, 0x07, 0xE0,
  0x7C, 0x00, 0x1F, 0xC0, 0xF8, 0x00, 0x7F, 0x01, 0xF0, 0x01, 0xFC, 0x03,
  0xE0, 0x0F, 0xF0, 0x0F, 0x83, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFB, 0xFE, 0x00, 0x7F, 0x80,
  0x1E, 0x00, 0xFE, 0x00, 0x02, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x3F,
  0xFC, 0x7C, 0x00, 0x7F, 0xFC, 0x7C, 0x00, 0x7F, 0xF8, 0x7C, 0x00, 0x7F,
  0xF8, 0x7C, 0x00, 0x7F, 0xF8, 0xFC, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x01,
  0xF0, 0xFC, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03,
  0xE0, 0x7E, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x07,
  0xC0, 0x3F, 0x80, 0x07, 0xC0, 0x1F, 0xE0, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x03, 0xE0, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x1F,
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03,
  0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3C, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x67, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xFC, 0x01, 0xF0,
  0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x07, 0xE0, 0x01, 0xF0,
  0x0F, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x03, 0xE0,
  0x3F, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x03, 0xE1,
  0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x0F, 0xBF,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x1F, 0xEF, 0xC0, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xF0, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x0F,
  0x78, 0x00, 0x07, 0xBE, 0x01, 0xF7, 0x80, 0x00, 0xFB, 0xC0, 0x1F, 0x78,
  0x00, 0x0F, 0x7C, 0x01, 0xF7, 0x80, 0x01, 0xF7, 0xC0, 0x1E, 0x78, 0x00,
  0x1E, 0x7C, 0x03, 0xE7, 0x80, 0x03, 0xE7, 0xC0, 0x3E, 0x78, 0x00, 0x3C,
  0xF8, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x00, 0x78, 0xF8,
  0x03, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x00, 0xF0, 0xF0, 0x07,
  0xC3, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x3C, 0x03, 0xE1, 0xF0, 0x07, 0xC3,
  0xC0, 0x3E, 0x1F, 0x00, 0x78, 0x3C, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xC0,
  0x7C, 0x3E, 0x00, 0xF8, 0x3C, 0x0F, 0x83, 0xE0, 0x0F, 0x83, 0xC0, 0xF8,
  0x3E, 0x00, 0xF0, 0x3E, 0x1F, 0x03, 0xE0, 0x0F, 0x03, 0xE1, 0xF0, 0x3E,
  0x01, 0xF0, 0x3E, 0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xE3, 0xC0, 0x7C, 0x01,
  0xF0, 0x1E, 0x7C, 0x07, 0xC0, 0x1E, 0x01, 0xE7, 0x80, 0x7C, 0x03, 0xE0,
  0x1E, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xEF, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xFE, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0xE0,
  0x0F, 0x80, 0x7C, 0x01, 0xFC, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF8, 0x01, 0xF0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00,
  0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x00, 0x7C, 0x01, 0xFE, 0x00, 0x03,
  0xE0, 0x0F, 0xF0, 0x00, 0x1F, 0x00, 0x7F, 0x80, 0x01, 0xF0, 0x03, 0xFE,
  0x00, 0x0F, 0x80, 0x1F, 0xF0, 0x00, 0x7C, 0x01, 0xF7, 0x80, 0x03, 0xE0,
  0x0F, 0xBE, 0x00, 0x1E, 0x00, 0x79, 0xF0, 0x01, 0xF0, 0x03, 0xC7, 0x80,
  0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x7C, 0x01, 0xF1, 0xF0, 0x03, 0xE0, 0x0F,
  0x8F, 0x80, 0x1E, 0x00, 0x7C, 0x3C, 0x01, 0xF0, 0x03, 0xC1, 0xF0, 0x0F,
  0x80, 0x3E, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x3C, 0x03, 0xE0, 0x0F, 0x81,
  0xF0, 0x1E, 0x00, 0x7C, 0x0F, 0x81, 0xF0, 0x03, 0xC0, 0x7C, 0x0F, 0x80,
  0x3E, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x0F, 0x83, 0xC0, 0x0F, 0x80, 0x7C,
  0x3E, 0x00, 0x78, 0x01, 0xE1, 0xF0, 0x03, 0xC0, 0x0F, 0x8F, 0x80, 0x3E,
  0x00, 0x7C, 0x7C, 0x01, 0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x80, 0x0F, 0x9E,
  0x00, 0x78, 0x00, 0x7D, 0xF0, 0x07, 0xC0, 0x03, 0xEF, 0x80, 0x3E, 0x00,
  0x0F, 0x7C, 0x01, 0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0x80, 0x03, 0xFE, 0x00,
  0x78, 0x00, 0x0F, 0xF0, 0x07, 0xC0, 0x00, 0x7F, 0x80, 0x3E, 0x00, 0x03,
  0xFC, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFE, 0xFF,
  0xC0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0x7C, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0x83, 0xF0, 0x00,
  0x07, 0xC1, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0xFC, 0x00,
  0x00, 0xFC, 0x7C, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F, 0x3E, 0x00,
  0x00, 0x1F, 0x9F, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x07, 0xCF, 0xC0,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3E, 0x7E,
  0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x01, 0xFC, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x05, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xF0, 0x1F, 0xE0, 0x1F, 0x00, 0x7E, 0x01,
  0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x3F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00,
  0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xF0,
  0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0,
  0x07, 0xE0, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x80, 0xF8, 0x07, 0xF8,
  0x0F, 0x8F, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7C, 0x03,
  0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x07, 0xC1,
  0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0xFC,
  0x7C, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x1F,
  0x1F, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00,
  0xFC, 0xF8, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00,
  0x1F, 0x3F, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x07, 0xC7, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x01, 0xF8, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x01, 0xF0, 0x1F, 0xE0, 0x1F, 0x00, 0x7E, 0x01, 0xF0,
  0x03, 0xF0, 0x1F, 0x00, 0x3F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F,
  0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xF0, 0x7C,
  0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x7E, 0x07, 0xC0, 0x07,
  0xC0, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x80, 0xF8, 0x7F, 0xF0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x03,
  0xE0, 0x1F, 0x00, 0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x01,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0xC0,
  0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0x7E, 0x0F, 0x80,
  0x07, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x1C, 0x01, 0xF8,
  0x00, 0x40, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0xC0, 0x01, 0xFC, 0x0F, 0x80,
  0x7F, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x07,
  0xC7, 0x80, 0x00, 0x7E, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3F, 0x0F,
  0x80, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0xF8, 0x1F, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x3E,
  0x01, 0xF0, 0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x0F, 0x00, 0x7C, 0x00, 0x78, 0x07, 0xC0, 0x03, 0xC0,
  0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x7C, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xEF, 0x80, 0x03, 0xF8, 0x00,
  0x7E, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xCF, 0x80, 0x07, 0xF8, 0x00, 0xFC,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0x8F, 0x80, 0x0F, 0xF8, 0x00, 0xF8, 0xF8,
  0x00, 0xFF, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0xF8, 0x01, 0xF0, 0xF8, 0x01,
  0xEF, 0x80, 0x3F, 0x0F, 0x80, 0x3E, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xCF,
  0x80, 0x3E, 0x0F, 0x80, 0x7C, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0x8F, 0x80,
  0x7C, 0x0F, 0x80, 0x78, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x87, 0x80, 0xF8,
  0x0F, 0x80, 0xF0, 0x78, 0x1F, 0x80, 0xF8, 0x1F, 0x07, 0x81, 0xF0, 0x0F,
  0x81, 0xE0, 0x78, 0x1F, 0x00, 0xF8, 0x3E, 0x07, 0x83, 0xE0, 0x0F, 0x83,
  0xC0, 0x78, 0x3E, 0x00, 0xF8, 0x7C, 0x07, 0x87, 0xC0, 0x0F, 0x87, 0xC0,
  0x78, 0x7C, 0x00, 0xF8, 0x78, 0x07, 0x87, 0x80, 0x0F, 0x8F, 0x80, 0x78,
  0xF8, 0x00, 0xF8, 0xF0, 0x07, 0x8F, 0x80, 0x0F, 0x9F, 0x00, 0x79, 0xF0,
  0x00, 0xF9, 0xE0, 0x07, 0x9F, 0x00, 0x0F, 0x9E, 0x00, 0x79, 0xE0, 0x00,
  0xFB, 0xC0, 0x07, 0xBE, 0x00, 0x0F, 0xBC, 0x00, 0x7B, 0xC0, 0x00, 0xFF,
  0xC0, 0x07, 0xBC, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x01, 0xF0, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x0F, 0x81, 0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x1E, 0x0F,
  0x80, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x1F,
  0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x0F, 0xEF, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x7E, 0x3E,
  0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0xFC, 0x0F, 0x00, 0x1F,
  0x01, 0xF0, 0x07, 0xE0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF8,
  0x0F, 0xC0, 0x0F, 0x01, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80,
  0x07, 0xC3, 0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x0F, 0x1F, 0x00, 0x01, 0xE7,
  0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x00, 0xF8, 0x3E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x83, 0xE0, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1F,
  0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x3C, 0x78,
  0x00, 0x1E, 0x1F, 0x00, 0x07, 0x83, 0xC0, 0x03, 0xC0, 0xF8, 0x00, 0xF0,
  0x1E, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x3C, 0x03,
  0xC0, 0x0F, 0x81, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x7C, 0x3C, 0x00, 0x0F,
  0x0F, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1E, 0xF0, 0x00,
  0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0xFC, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x07, 0xF8, 0x3C, 0x03, 0xFF, 0xC7, 0x80, 0xFF,
  0xF9, 0xF0, 0x3F, 0xFF, 0xBC, 0x0F, 0xE0, 0x7F, 0x81, 0xF8, 0x07, 0xF0,
  0x7E, 0x00, 0xFE, 0x0F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF0, 0x7C, 0x00,
  0x3E, 0x1F, 0x80, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x1F,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03,
  0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0,
  0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xE0, 0xF8, 0x01, 0xFC,
  0x0F, 0x80, 0x3F, 0x81, 0xF0, 0x0F, 0xF0, 0x3F, 0x03, 0xFE, 0x07, 0xFF,
  0xF7, 0x80, 0x7F, 0xFC, 0xF0, 0x07, 0xFE, 0x1E, 0x00, 0x7F, 0x83, 0xC0,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x03, 0x00,
  0x07, 0xC3, 0xFC, 0x00, 0xF8, 0xFF, 0xE0, 0x1F, 0x7F, 0xFC, 0x03, 0xEF,
  0xFF, 0xC0, 0x7B, 0xC1, 0xF8, 0x1F, 0xE0, 0x1F, 0x83, 0xFC, 0x01, 0xF0,
  0x7F, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x7E, 0x00,
  0x1F, 0x0F, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x8F,
  0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01,
  0xF0, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8,
  0x00, 0x7E, 0x1F, 0x00, 0x0F, 0x83, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0xFC,
  0x1F, 0xC0, 0x1F, 0x83, 0xFC, 0x0F, 0xE0, 0x7B, 0xFF, 0xF8, 0x0F, 0x3F,
  0xFE, 0x03, 0xC3, 0xFF, 0x80, 0x78, 0x3F, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x03,
  0xFF, 0xF8, 0x1F, 0xC0, 0x20, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x20, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0x03, 0xE0, 0x00, 0xFF, 0x0F, 0x80,
  0x0F, 0xFF, 0x3E, 0x00, 0x7F, 0xFC, 0xF8, 0x03, 0xFF, 0xFB, 0xC0, 0x1F,
  0xC0, 0xFF, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0x80,
  0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0xC0, 0x03,
  0xE0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3C, 0x07, 0xC0, 0x01, 0xF0,
  0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x07,
  0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7E, 0x03, 0xE0,
  0x01, 0xF8, 0x0F, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x3F, 0x00, 0xF8, 0x01,
  0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xC0, 0x3F, 0xC0, 0x1F, 0x83, 0xDE,
  0x00, 0x7F, 0xFF, 0x78, 0x00, 0xFF, 0xF9, 0xE0, 0x01, 0xFF, 0x87, 0x80,
  0x03, 0xFC, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xDF, 0xE0, 0xFC,
  0x07, 0xC1, 0xF0, 0x0F, 0x87, 0xC0, 0x1F, 0x1F, 0x80, 0x3E, 0x3E, 0x00,
  0x7C, 0xFC, 0x00, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x1F, 0xCF, 0x80, 0xFF,
  0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xF8, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x83, 0xF8, 0x07, 0x03, 0xFE, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x11, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0xC3, 0xC0,
  0x0F, 0xFF, 0x1E, 0x00, 0xFF, 0xF9, 0xF0, 0x0F, 0xFF, 0xEF, 0x00, 0xFE,
  0x07, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x7E, 0x00, 0xFE, 0x03, 0xE0, 0x03,
  0xF0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x1F, 0x80, 0x07, 0xC0,
  0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x03,
  0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0xFE, 0x07, 0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x7F, 0x01, 0xF8,
  0x07, 0xF8, 0x07, 0xC0, 0x3F, 0xC0, 0x3F, 0x07, 0xBE, 0x01, 0xFF, 0xFD,
  0xE0, 0x07, 0xFF, 0xDF, 0x00, 0x1F, 0xF8, 0xF8, 0x00, 0x7F, 0x87, 0xC0,
  0x00, 0xE0, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xE0, 0x10, 0x00, 0x3E, 0x00, 0xE0, 0x07, 0xF0, 0x07, 0xE0, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x30, 0x00, 0xF8, 0x7F,
  0xC0, 0x3E, 0x3F, 0xF8, 0x0F, 0xBF, 0xFE, 0x03, 0xDF, 0xFF, 0xC0, 0xF7,
  0x81, 0xF0, 0x7F, 0x80, 0x7C, 0x1F, 0xC0, 0x1F, 0x07, 0xE0, 0x07, 0xC1,
  0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x0F, 0x80, 0x07,
  0xC3, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0xF8, 0x3C, 0x00, 0x3E, 0x1F, 0x00,
  0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x7C, 0x3E,
  0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xF8,
  0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00,
  0xF0, 0x7C, 0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0,
  0x01, 0xF0, 0x00, 0x38, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xE0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x78, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x8F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x03, 0xE0, 0x1F, 0x00,
  0xFC, 0x03, 0xE0, 0x3F, 0x00, 0x78, 0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x03,
  0xE0, 0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xE1, 0xF0,
  0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3D,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xF3, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xC0,
  0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xC0, 0x3E, 0x00,
  0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01,
  0xF0, 0x0F, 0x00, 0x3F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF8,
  0x7F, 0x80, 0xFF, 0x80, 0x3C, 0x7F, 0xF0, 0x7F, 0xF0, 0x0F, 0x3F, 0xFE,
  0x3F, 0xFE, 0x03, 0xDF, 0xFF, 0x9F, 0xFF, 0x80, 0xF7, 0x03, 0xEF, 0x03,
  0xE0, 0x7F, 0x80, 0xFF, 0x80, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xC1, 0xF8, 0x01, 0xF8, 0x01, 0xE0, 0x7C, 0x00,
  0xFC, 0x00, 0xF8, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x83, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x00, 0xF0,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C,
  0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x83, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x3E,
  0x00, 0x3C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x83,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x7F, 0xC0,
  0x3E, 0x7F, 0xF8, 0x0F, 0x3F, 0xFF, 0x03, 0xDF, 0xFF, 0xC1, 0xFF, 0x83,
  0xF0, 0x7F, 0xC0, 0x7C, 0x1F, 0xC0, 0x1F, 0x07, 0xF0, 0x07, 0xC1, 0xF8,
  0x01, 0xF0, 0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xC3,
  0xE0, 0x03, 0xF0, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x3E, 0x1F, 0x00, 0x0F,
  0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00,
  0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7E,
  0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x01, 0xF8,
  0x7C, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01,
  0xF0, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0x81, 0xF8, 0x1F, 0x00, 0x7C, 0x1F,
  0x00, 0x3F, 0x1F, 0x80, 0x0F, 0x8F, 0x80, 0x07, 0xCF, 0xC0, 0x03, 0xE7,
  0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E,
  0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xBE, 0x00, 0x07,
  0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x01, 0xF3, 0xE0, 0x00,
  0xF9, 0xF0, 0x00, 0xFC, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x1F, 0x80,
  0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0xF0, 0xFF, 0x00, 0x07, 0x87, 0xFF, 0x00, 0x1E, 0x3F, 0xFC,
  0x00, 0x79, 0xF7, 0xF8, 0x01, 0xEF, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xC0,
  0x3F, 0xC0, 0x1F, 0x00, 0xFE, 0x00, 0x7C, 0x03, 0xF0, 0x01, 0xF0, 0x0F,
  0xC0, 0x07, 0xC0, 0x7E, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x7C, 0x07, 0xC0,
  0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7E,
  0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x3F, 0x01,
  0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xE0, 0x3F, 0x80, 0x3F, 0x00, 0xFE,
  0x00, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0x7F, 0xFF, 0x00, 0x3C, 0xFF,
  0xF8, 0x01, 0xF1, 0xFF, 0xC0, 0x07, 0xC3, 0xFC, 0x00, 0x1F, 0x01, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xFC, 0x3C, 0x03, 0xFF, 0xC7,
  0x80, 0xFF, 0xF9, 0xF0, 0x3F, 0xFF, 0xBC, 0x0F, 0xE0, 0x7F, 0x81, 0xF8,
  0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x01, 0xF0,
  0x7C, 0x00, 0x3E, 0x1F, 0x80, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00,
  0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F,
  0x80, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x07,
  0xE1, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x3F, 0x87, 0xC0, 0x07, 0xE0, 0xF8,
  0x01, 0xFC, 0x1F, 0x80, 0x7F, 0x81, 0xF0, 0x0F, 0xF0, 0x3F, 0x07, 0xBE,
  0x07, 0xFF, 0xF7, 0x80, 0x7F, 0xFD, 0xF0, 0x07, 0xFE, 0x3E, 0x00, 0x7F,
  0x87, 0xC0, 0x03, 0x80, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x7C, 0x0F, 0x87, 0xE0, 0x3C, 0x7F, 0x80, 0xF3,
  0xFE, 0x03, 0xDF, 0xF8, 0x0F, 0x78, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFB, 0xF8, 0x3F, 0x00, 0x60, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x88, 0x00, 0x7C, 0x38, 0x03, 0xF0, 0xFF,
  0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0xFF,
  0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x06, 0x00, 0x0F, 0x80, 0x07, 0xC3, 0xE0,
  0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87,
  0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x1E, 0x00, 0x1F,
  0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x78, 0x3E, 0x00,
  0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C,
  0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0,
  0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x0F,
  0xE0, 0xF8, 0x03, 0xF8, 0x3E, 0x01, 0xFC, 0x0F, 0x81, 0xEF, 0x03, 0xFF,
  0xF3, 0xC0, 0xFF, 0xF8, 0xF0, 0x1F, 0xFC, 0x7C, 0x03, 0xFE, 0x1E, 0x00,
  0x08, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xF8, 0x78, 0x00, 0xF8,
  0x78, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0x78, 0x03, 0xE0, 0x7C, 0x03, 0xE0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80,
  0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00,
  0x3C, 0x7C, 0x00, 0x3C, 0x7C, 0x00, 0x3C, 0xF8, 0x00, 0x3C, 0xF8, 0x00,
  0x3C, 0xF0, 0x00, 0x3D, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xF0, 0x03, 0xEF, 0x80, 0x1F,
  0xC0, 0x1F, 0x3E, 0x00, 0x7F, 0x00, 0x7C, 0x78, 0x03, 0xFC, 0x03, 0xF1,
  0xE0, 0x0F, 0xF0, 0x0F, 0x87, 0x80, 0x7B, 0xC0, 0x3E, 0x1E, 0x01, 0xEF,
  0x01, 0xF0, 0x78, 0x0F, 0x3C, 0x07, 0xC1, 0xE0, 0x3C, 0xF0, 0x3E, 0x07,
  0x81, 0xF3, 0xC0, 0xF8, 0x1E, 0x07, 0x8F, 0x03, 0xC0, 0x78, 0x1E, 0x3C,
  0x1F, 0x01, 0xE0, 0xF0, 0xF0, 0x7C, 0x07, 0x83, 0xC3, 0xC3, 0xE0, 0x1E,
  0x1E, 0x0F, 0x0F, 0x80, 0x78, 0x78, 0x3C, 0x7C, 0x01, 0xE3, 0xE0, 0xF1,
  0xF0, 0x07, 0x8F, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x0F, 0x3E, 0x00, 0x79,
  0xE0, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0xF7, 0xC0, 0x07, 0xBC, 0x03, 0xDF,
  0x00, 0x1E, 0xF0, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x3F, 0xE0, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x80,
  0x7C, 0x01, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0x3C,
  0x0F, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3C, 0x7C,
  0x00, 0x01, 0xF7, 0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0xF8, 0xF0, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x7C,
  0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x3E, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x3C, 0x1F,
  0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x3E, 0x3E,
  0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x78,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x87, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x4F, 0xFF, 0x00, 0x37, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xB0, 0x03, 0xFF, 0xC8, 0x00, 0x1F, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Italic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 14, 42, 15, 1, -41 },
  { 75, 17, 15, 22, 6, -41 },
  { 107, 33, 41, 33, 1, -41 },
  { 277, 27, 47, 29, 1, -44 },
  { 436, 36, 43, 42, 4, -42 },
  { 630, 32, 43, 34, 1, -42 },
  { 802, 8, 15, 12, 6, -41 },
  { 817, 18, 51, 16, 2, -42 },
  { 932, 18, 51, 16, -4, -42 },
  { 1047, 23, 24, 28, 6, -44 },
  { 1116, 26, 27, 30, 3, -34 },
  { 1204, 11, 15, 14, -3, -7 },
  { 1225, 14, 5, 17, 1, -18 },
  { 1234, 7, 8, 14, 1, -7 },
  { 1241, 28, 41, 20, -3, -41 },
  { 1385, 25, 43, 29, 3, -42 },
  { 1520, 17, 41, 29, 7, -41 },
  { 1608, 29, 42, 29, -1, -42 },
  { 1761, 28, 43, 29, 0, -42 },
  { 1912, 28, 42, 29, 0, -42 },
  { 2059, 27, 42, 29, 1, -41 },
  { 2201, 26, 43, 29, 3, -42 },
  { 2341, 26, 41, 29, 4, -41 },
  { 2475, 27, 43, 29, 2, -42 },
  { 2621, 25, 43, 29, 2, -42 },
  { 2756, 11, 33, 14, 1, -32 },
  { 2802, 16, 40, 14, -3, -32 },
  { 2882, 26, 28, 30, 3, -35 },
  { 2973, 24, 16, 30, 4, -28 },
  { 3021, 26, 28, 30, 3, -35 },
  { 3112, 21, 43, 22, 3, -42 },
  { 3225, 40, 47, 44, 2, -42 },
  { 3460, 29, 41, 29, -3, -41 },
  { 3609, 29, 41, 31, 2, -41 },
  { 3758, 30, 43, 30, 3, -42 },
  { 3920, 31, 41, 34, 2, -41 },
  { 4079, 27, 41, 27, 2, -41 },
  { 4218, 27, 41, 25, 2, -41 },
  { 4357, 32, 43, 35, 3, -42 },
  { 4529, 34, 41, 35, 2, -41 },
  { 4704, 23, 41, 17, -2, -41 },
  { 4822, 24, 52, 14, -9, -41 },
  { 4978, 32, 41, 29, 2, -41 },
  { 5142, 19, 41, 25, 2, -41 },
  { 5240, 44, 41, 45, 1, -41 },
  { 5466, 37, 41, 37, 1, -41 },
  { 5656, 33, 43, 37, 3, -42 },
  { 5834, 28, 41, 29, 2, -41 },
  { 5978, 33, 52, 37, 3, -42 },
  { 6193, 28, 41, 30, 2, -41 },
  { 6337, 28, 43, 27, 0, -42 },
  { 6488, 26, 41, 26, 5, -41 },
  { 6622, 32, 42, 35, 4, -41 },
  { 6790, 29, 41, 29, 5, -41 },
  { 6939, 44, 41, 45, 6, -41 },
  { 7165, 35, 41, 27, -3, -41 },
  { 7345, 27, 41, 26, 5, -41 },
  { 7484, 30, 41, 27, -1, -41 },
  { 7638, 22, 51, 17, -1, -42 },
  { 7779, 10, 41, 20, 6, -41 },
  { 7831, 22, 51, 17, -4, -42 },
  { 7972, 26, 25, 29, 2, -42 },
  { 8054, 22, 4, 21, -5, 5 },
  { 8065, 9, 9, 15, 8, -44 },
  { 8076, 27, 33, 30, 2, -32 },
  { 8188, 27, 45, 30, 1, -44 },
  { 8340, 22, 33, 23, 2, -32 },
  { 8431, 30, 45, 30, 2, -44 },
  { 8600, 23, 33, 26, 2, -32 },
  { 8695, 31, 58, 17, -7, -44 },
  { 8920, 29, 46, 30, 0, -32 },
  { 9087, 26, 44, 30, 1, -44 },
  { 9230, 14, 43, 14, 1, -43 },
  { 9306, 22, 57, 14, -7, -43 },
  { 9463, 27, 44, 26, 1, -44 },
  { 9612, 14, 44, 14, 1, -44 },
  { 9689, 42, 32, 45, 1, -32 },
  { 9857, 26, 32, 30, 1, -32 },
  { 9961, 25, 33, 29, 2, -32 },
  { 10065, 30, 46, 30, -2, -32 },
  { 10238, 27, 46, 30, 2, -32 },
  { 10394, 22, 32, 20, 1, -32 },
  { 10482, 22, 33, 23, 0, -32 },
  { 10573, 16, 39, 17, 3, -38 },
  { 10651, 26, 32, 30, 3, -31 },
  { 10755, 24, 31, 24, 3, -31 },
  { 10848, 38, 31, 38, 3, -31 },
  { 10996, 29, 31, 25, -2, -31 },
  { 11109, 32, 45, 24, -5, -31 },
  { 11289, 24, 31, 22, -1, -31 },
  { 11382, 22, 50, 20, 1, -41 },
  { 11520, 4, 58, 28, 13, -44 },
  { 11549, 22, 50, 20, -3, -41 },
  { 11687, 26, 7, 30, 3, -24 },
};

const GFXfont NotoSans_SemiCondensed_Italic58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic58pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC58PT7B_H_
