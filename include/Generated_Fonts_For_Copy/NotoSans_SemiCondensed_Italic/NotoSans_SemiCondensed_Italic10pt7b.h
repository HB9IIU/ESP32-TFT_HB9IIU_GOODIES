#ifndef _NOTOSANS_SEMICONDENSED_ITALIC10PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x29, 0x24, 0x20, 0xB4, 0x28, 0xA7, 0xD4, 0xF9, 0x46, 0x00, 0x11,
  0xD8, 0xC3, 0x1A, 0xC8, 0x40, 0xEE, 0xAD, 0x3F, 0x35, 0x59, 0x80, 0x39,
  0x23, 0x19, 0x9A, 0x6E, 0x80, 0xC0, 0x34, 0x44, 0x88, 0x88, 0x40, 0x24,
  0x92, 0x4A, 0x80, 0x2A, 0x7A, 0x20, 0x44, 0xF4, 0x40, 0xC0, 0xE0, 0x80,
  0x12, 0x24, 0x48, 0x80, 0x3A, 0x53, 0x19, 0x49, 0x80, 0x74, 0xA4, 0x90,
  0x78, 0x42, 0x22, 0x23, 0xC0, 0x78, 0x44, 0xC1, 0x0B, 0x80, 0x19, 0x4C,
  0xA9, 0x3C, 0x80, 0x3A, 0x18, 0x21, 0x0B, 0x80, 0x3A, 0x1C, 0xA8, 0xC9,
  0xC0, 0xF1, 0x24, 0x48, 0x80, 0x3A, 0x54, 0xE9, 0x49, 0xC0, 0x72, 0x52,
  0xB3, 0x0B, 0x80, 0x40, 0x80, 0x40, 0xA0, 0x16, 0x86, 0x10, 0xF0, 0xF0,
  0x86, 0x16, 0x80, 0xE4, 0xA8, 0x20, 0x3E, 0x85, 0x7D, 0x5A, 0xB6, 0x90,
  0x1C, 0x08, 0xC6, 0x53, 0xA7, 0x20, 0x3A, 0x52, 0xE4, 0xC7, 0xC0, 0x7C,
  0x21, 0x08, 0x43, 0x80, 0x39, 0x14, 0x51, 0x4A, 0x2F, 0x00, 0x3A, 0x10,
  0xE4, 0x43, 0xC0, 0x3A, 0x10, 0xE4, 0x22, 0x00, 0x7C, 0x21, 0x79, 0x4B,
  0xC0, 0x25, 0x14, 0x5E, 0x49, 0x28, 0x80, 0x72, 0x44, 0x44, 0xC0, 0x08,
  0x84, 0x21, 0x08, 0x84, 0xC0, 0x2D, 0x45, 0x18, 0x51, 0x49, 0x00, 0x24,
  0x44, 0x48, 0xF0, 0x23, 0x62, 0x66, 0x66, 0x5A, 0x92, 0x94, 0x25, 0x95,
  0x55, 0x56, 0x28, 0x80, 0x7C, 0x63, 0x18, 0xCB, 0xC0, 0x3A, 0x52, 0xE4,
  0x22, 0x00, 0x7C, 0x63, 0x18, 0xCB, 0xC4, 0x10, 0x3A, 0x52, 0xE5, 0x4A,
  0x40, 0x7A, 0x10, 0x41, 0x0B, 0x80, 0xF4, 0x44, 0x48, 0x80, 0xCC, 0x63,
  0x29, 0x4B, 0x80, 0x8C, 0xA5, 0x4A, 0x63, 0x00, 0x93, 0x92, 0xB2, 0xB4,
  0xD4, 0xC8, 0x88, 0x24, 0xA1, 0x84, 0x31, 0x2C, 0x80, 0x9A, 0xA4, 0x48,
  0x80, 0x78, 0x84, 0x44, 0x43, 0xC0, 0x34, 0x44, 0x48, 0x88, 0xC0, 0xAA,
  0x54, 0x31, 0x12, 0x22, 0x22, 0xC0, 0x22, 0x95, 0x10, 0xF0, 0x90, 0x7A,
  0x65, 0x27, 0x00, 0x22, 0x14, 0xD4, 0xA6, 0x5E, 0x74, 0x88, 0x60, 0x08,
  0x4A, 0xB4, 0xCA, 0x4E, 0x75, 0xE8, 0x70, 0x18, 0x8C, 0xC2, 0x10, 0x88,
  0x46, 0x00, 0x7A, 0x65, 0x27, 0x0B, 0x80, 0x22, 0x14, 0xD4, 0xAA, 0x52,
  0x61, 0x25, 0x20, 0x30, 0x22, 0x24, 0x44, 0xC0, 0x22, 0x12, 0xA6, 0x32,
  0x92, 0x29, 0x24, 0xA4, 0x7E, 0x95, 0x4C, 0x99, 0x20, 0x7A, 0x55, 0x29,
  0x00, 0x72, 0x63, 0x27, 0x00, 0x7A, 0x53, 0x2F, 0x42, 0x00, 0x7A, 0x65,
  0x27, 0x08, 0x40, 0x74, 0x48, 0x80, 0x74, 0x22, 0xE0, 0x2F, 0x25, 0x10,
  0x4A, 0x55, 0x27, 0x00, 0xBA, 0xCC, 0x80, 0xA7, 0xAE, 0xAC, 0x90, 0x5B,
  0x08, 0xCB, 0x00, 0x2C, 0xA3, 0x0C, 0x20, 0x8C, 0x00, 0x72, 0x44, 0xE0,
  0x32, 0x24, 0xC4, 0x44, 0x40, 0xFF, 0xC0, 0x64, 0xA2, 0x94, 0x80, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Italic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 7, 3, 0, -7 },
  { 4, 3, 2, 4, 1, -7 },
  { 5, 6, 7, 6, 0, -7 },
  { 11, 5, 9, 5, 0, -8 },
  { 17, 6, 7, 7, 1, -7 },
  { 23, 6, 7, 6, 0, -7 },
  { 29, 1, 2, 2, 1, -7 },
  { 30, 4, 9, 3, 0, -7 },
  { 35, 3, 9, 3, -1, -7 },
  { 39, 4, 5, 5, 1, -8 },
  { 42, 4, 5, 5, 1, -6 },
  { 45, 1, 2, 2, 0, -1 },
  { 46, 3, 1, 3, 0, -3 },
  { 47, 1, 1, 2, 0, -1 },
  { 48, 4, 7, 3, 0, -7 },
  { 52, 5, 7, 5, 0, -7 },
  { 57, 3, 7, 5, 1, -7 },
  { 60, 5, 7, 5, 0, -7 },
  { 65, 5, 7, 5, 0, -7 },
  { 70, 5, 7, 5, 0, -7 },
  { 75, 5, 7, 5, 0, -7 },
  { 80, 5, 7, 5, 0, -7 },
  { 85, 4, 7, 5, 1, -7 },
  { 89, 5, 7, 5, 0, -7 },
  { 94, 5, 7, 5, 0, -7 },
  { 99, 2, 5, 2, 0, -5 },
  { 101, 2, 6, 2, 0, -5 },
  { 103, 4, 5, 5, 1, -6 },
  { 106, 4, 3, 5, 1, -5 },
  { 108, 4, 5, 5, 1, -6 },
  { 111, 3, 7, 4, 1, -7 },
  { 114, 7, 8, 8, 0, -7 },
  { 121, 5, 7, 5, -1, -7 },
  { 126, 5, 7, 5, 0, -7 },
  { 131, 5, 7, 5, 1, -7 },
  { 136, 6, 7, 6, 0, -7 },
  { 142, 5, 7, 5, 0, -7 },
  { 147, 5, 7, 4, 0, -7 },
  { 152, 5, 7, 6, 1, -7 },
  { 157, 6, 7, 6, 0, -7 },
  { 163, 4, 7, 3, 0, -7 },
  { 167, 5, 9, 2, -2, -7 },
  { 173, 6, 7, 5, 0, -7 },
  { 179, 4, 7, 4, 0, -7 },
  { 183, 8, 7, 8, 0, -7 },
  { 190, 6, 7, 6, 0, -7 },
  { 196, 5, 7, 6, 1, -7 },
  { 201, 5, 7, 5, 0, -7 },
  { 206, 5, 9, 6, 1, -7 },
  { 212, 5, 7, 5, 0, -7 },
  { 217, 5, 7, 5, 0, -7 },
  { 222, 4, 7, 4, 1, -7 },
  { 226, 5, 7, 6, 1, -7 },
  { 231, 5, 7, 5, 1, -7 },
  { 236, 8, 7, 8, 1, -7 },
  { 243, 6, 7, 5, -1, -7 },
  { 249, 4, 7, 5, 1, -7 },
  { 253, 5, 7, 5, 0, -7 },
  { 258, 4, 9, 3, 0, -7 },
  { 263, 2, 7, 4, 1, -7 },
  { 265, 4, 9, 3, -1, -7 },
  { 270, 5, 4, 5, 0, -7 },
  { 273, 4, 1, 4, -1, 1 },
  { 274, 2, 2, 3, 1, -8 },
  { 275, 5, 5, 5, 0, -5 },
  { 279, 5, 8, 5, 0, -8 },
  { 284, 4, 5, 4, 0, -5 },
  { 287, 5, 8, 5, 0, -8 },
  { 292, 4, 5, 5, 0, -5 },
  { 295, 5, 10, 3, -1, -8 },
  { 302, 5, 7, 5, 0, -5 },
  { 307, 5, 8, 5, 0, -8 },
  { 312, 3, 7, 2, 0, -7 },
  { 315, 4, 9, 2, -1, -7 },
  { 320, 5, 8, 4, 0, -8 },
  { 325, 3, 8, 2, 0, -8 },
  { 328, 7, 5, 8, 0, -5 },
  { 333, 5, 5, 5, 0, -5 },
  { 337, 5, 5, 5, 0, -5 },
  { 341, 5, 7, 5, 0, -5 },
  { 346, 5, 7, 5, 0, -5 },
  { 351, 4, 5, 4, 0, -5 },
  { 354, 4, 5, 4, 0, -5 },
  { 357, 3, 7, 3, 0, -7 },
  { 360, 5, 5, 5, 0, -5 },
  { 364, 4, 5, 4, 1, -5 },
  { 367, 6, 5, 7, 1, -5 },
  { 371, 5, 5, 4, 0, -5 },
  { 375, 6, 7, 4, -1, -5 },
  { 381, 4, 5, 4, 0, -5 },
  { 384, 4, 9, 3, 0, -7 },
  { 389, 1, 10, 5, 2, -8 },
  { 391, 3, 9, 3, 0, -7 },
  { 395, 4, 1, 5, 1, -4 },
};

const GFXfont NotoSans_SemiCondensed_Italic10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic10pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC10PT7B_H_
