#ifndef _NOTOSANS_SEMICONDENSED_ITALIC48PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0,
  0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x07, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0x20, 0x00, 0x3C, 0x3C, 0xF1, 0xF7, 0xC7, 0x9E,
  0x1E, 0x78, 0x79, 0xE1, 0xE7, 0x07, 0x1C, 0x1C, 0x70, 0xF3, 0xC3, 0x8E,
  0x0E, 0x38, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x78,
  0x1C, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x78, 0x1C, 0x00,
  0x0E, 0x07, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x0F, 0x07,
  0x80, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x01,
  0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x0F, 0x03, 0x80, 0x01, 0xC0, 0xF0,
  0x00, 0x38, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x38,
  0x1C, 0x01, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0,
  0x07, 0x03, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x38, 0x1E, 0x00, 0x07, 0x03,
  0x80, 0x00, 0xE0, 0x70, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x03, 0x80, 0x00,
  0xE0, 0x70, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFB, 0x8E, 0x07, 0x8E, 0x08, 0x3C,
  0x38, 0x00, 0xF0, 0xC0, 0x03, 0xC3, 0x00, 0x0F, 0x1C, 0x00, 0x3C, 0x70,
  0x00, 0xF9, 0xC0, 0x01, 0xF6, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xDF, 0x00, 0x07,
  0x3E, 0x00, 0x1C, 0x78, 0x00, 0x71, 0xE0, 0x01, 0x87, 0x80, 0x0E, 0x1E,
  0x00, 0x38, 0x78, 0x80, 0xE3, 0xC3, 0x83, 0x3F, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x03, 0xC0, 0xFF, 0x80, 0x0E, 0x07, 0xCF, 0x00,
  0x70, 0x1C, 0x3C, 0x03, 0xC0, 0xF0, 0x70, 0x0E, 0x03, 0x81, 0xC0, 0x70,
  0x0E, 0x07, 0x03, 0xC0, 0x78, 0x1C, 0x0E, 0x01, 0xC0, 0xF0, 0x70, 0x07,
  0x03, 0xC3, 0xC0, 0x1C, 0x0E, 0x0E, 0x00, 0xF0, 0x38, 0x70, 0x03, 0xC0,
  0xE3, 0xC0, 0x0F, 0x07, 0x8E, 0x1E, 0x3C, 0x1C, 0x71, 0xFE, 0xF0, 0xF3,
  0xCF, 0xFB, 0xC3, 0x8E, 0x78, 0xF7, 0x9E, 0x79, 0xC1, 0xDF, 0xF3, 0xCF,
  0x07, 0x3F, 0x8E, 0x38, 0x1C, 0x78, 0x78, 0xE0, 0x70, 0x03, 0xC7, 0x81,
  0xC0, 0x0E, 0x1C, 0x0F, 0x00, 0x78, 0x70, 0x3C, 0x03, 0xC1, 0xC0, 0xE0,
  0x0E, 0x0F, 0x03, 0x80, 0x78, 0x3C, 0x0E, 0x03, 0xC0, 0xF0, 0x78, 0x0E,
  0x03, 0xC1, 0xC0, 0x78, 0x0F, 0x0F, 0x03, 0xC0, 0x1C, 0x38, 0x0E, 0x00,
  0x7F, 0xE0, 0x78, 0x01, 0xFF, 0x03, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xF7, 0xE0, 0x01,
  0xF0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x01, 0xE0,
  0x03, 0xC0, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x87,
  0xC0, 0x01, 0xE3, 0xE0, 0x00, 0x79, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x3E, 0xF8, 0x0F, 0x1E, 0x1E, 0x07, 0x8F, 0x07, 0xC1, 0xE7, 0xC0, 0xF0,
  0xF1, 0xE0, 0x1E, 0x3C, 0xF0, 0x07, 0xDE, 0x3C, 0x00, 0xFF, 0x8F, 0x00,
  0x3F, 0xC3, 0xC0, 0x07, 0xE0, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0xFE, 0x0F,
  0x80, 0x7F, 0x81, 0xF0, 0x7F, 0xF0, 0x7F, 0xFF, 0x3C, 0x0F, 0xFF, 0x0F,
  0x81, 0xFF, 0x81, 0xF0, 0x3C, 0xF3, 0xDE, 0x79, 0xE7, 0x1C, 0x71, 0xCE,
  0x38, 0x00, 0x3E, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0xC0, 0xE0, 0x1E, 0x1C,
  0x07, 0xF3, 0x00, 0xFF, 0xE0, 0xE1, 0xFF, 0xFC, 0x07, 0xFF, 0x81, 0xF1,
  0xF0, 0x7F, 0x00, 0x1E, 0xE0, 0x07, 0x8E, 0x01, 0xF1, 0xC0, 0x7C, 0x3C,
  0x07, 0x03, 0x80, 0x40, 0x78, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x87, 0xC3,
  0xC3, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x1C, 0x1C, 0x00, 0x7F,
  0xF7, 0xFE, 0xFF, 0xEF, 0xFE, 0x33, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3E,
  0x1F, 0x03, 0xE0, 0x7C, 0x1E, 0x01, 0xE1, 0xF0, 0x0F, 0x0F, 0x00, 0x78,
  0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x7C, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00,
  0x3D, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0xFB, 0xC0, 0x07, 0x9E,
  0x00, 0x3C, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0xFB, 0xC0, 0x07,
  0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0,
  0x0F, 0x8F, 0x00, 0x78, 0x3C, 0x07, 0xC1, 0xE0, 0x7C, 0x0F, 0x87, 0xC0,
  0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x7C, 0x03, 0xE0,
  0x3F, 0x81, 0xFE, 0x1F, 0xF8, 0xFD, 0xEF, 0xEF, 0x1E, 0x3C, 0x70, 0xF0,
  0x83, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3E, 0x07, 0xC0, 0x30,
  0x07, 0xC0, 0x40, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x1E, 0x07, 0xC0, 0x30, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x30, 0x01, 0xF0, 0x7C, 0x0F, 0xE0, 0xFF, 0xFF, 0x81,
  0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80,
  0x01, 0xEF, 0x00, 0x07, 0x9C, 0x00, 0x0E, 0x78, 0x00, 0x3C, 0xF0, 0x00,
  0xF1, 0xE0, 0x03, 0xC3, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x78,
  0x3C, 0x01, 0xE0, 0x78, 0x07, 0x81, 0xE0, 0x0F, 0x03, 0xC0, 0x3C, 0x07,
  0x80, 0xF0, 0x0F, 0x03, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0xF0,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0x1F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC2, 0x00, 0x3F, 0x0F, 0x03, 0xF8, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x70, 0x03, 0xC7, 0xF8, 0x0F,
  0x7F, 0xF0, 0x7F, 0xFF, 0xC1, 0xFE, 0x0F, 0x87, 0xE0, 0x1E, 0x1F, 0x00,
  0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0xCF, 0x80, 0x1E, 0x3E, 0x00, 0x78,
  0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0xF0, 0x78,
  0x03, 0xC1, 0xE0, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x87, 0xC0, 0x3F, 0xFF,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x07, 0x81, 0xF0,
  0x0F, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0x78, 0x1E, 0x00,
  0xF0, 0x3C, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0x7C, 0x3E, 0x00, 0x7C, 0xF8,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x7E, 0x7E, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0x7C, 0x1F, 0x00, 0x78, 0x3C,
  0x00, 0xF8, 0x78, 0x00, 0xF1, 0xF0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80,
  0x0F, 0x8F, 0x80, 0x1E, 0x1F, 0x00, 0x3C, 0x1F, 0x00, 0xF8, 0x3F, 0x07,
  0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xE0, 0xF8,
  0x1E, 0x01, 0xE0, 0xF8, 0x07, 0x83, 0xC0, 0x1F, 0x1F, 0x00, 0x3C, 0x78,
  0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x7C, 0x78, 0x01,
  0xF1, 0xE0, 0x07, 0x87, 0x80, 0x3E, 0x1E, 0x00, 0xF8, 0x7C, 0x07, 0xE1,
  0xF8, 0x7F, 0x83, 0xFF, 0xFC, 0x07, 0xFE, 0xF0, 0x0F, 0xE3, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x30,
  0x3F, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x07, 0xC3,
  0xE1, 0xF0, 0xF8, 0x78, 0x10, 0x00, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0,
  0x78, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0,
  0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x70,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0xFE, 0x1F, 0xFF, 0x87,
  0xFF, 0xE3, 0x81, 0xF1, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x70, 0x0F,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x07, 0x87,
  0x80, 0x7F, 0x03, 0xC7, 0x80, 0xFF, 0xE0, 0xE3, 0x80, 0xFF, 0xF0, 0x73,
  0xC0, 0xF0, 0x70, 0x39, 0xC0, 0xF0, 0x38, 0x1C, 0xE0, 0x70, 0x3C, 0x0E,
  0xF0, 0x78, 0x1E, 0x07, 0x70, 0x78, 0x0E, 0x03, 0xB8, 0x3C, 0x07, 0x03,
  0xFC, 0x1C, 0x07, 0x81, 0xDE, 0x0E, 0x03, 0xC0, 0xEF, 0x0F, 0x01, 0xC0,
  0x77, 0x07, 0x81, 0xE0, 0x73, 0x83, 0xC0, 0xF0, 0x39, 0xC1, 0xE0, 0xF8,
  0x3C, 0xE0, 0xF0, 0x7C, 0x3C, 0x70, 0x3C, 0xFF, 0x3C, 0x3C, 0x1F, 0xF3,
  0xFC, 0x1E, 0x07, 0xF1, 0xFC, 0x07, 0x00, 0xE0, 0x38, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x01, 0x00, 0x03, 0xE0, 0x07, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1D, 0xC0, 0x00, 0x1E, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x38,
  0x00, 0x07, 0x9E, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7, 0x80, 0x03, 0xC3,
  0xC0, 0x01, 0xE1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0xF0,
  0x3C, 0x00, 0x78, 0x1E, 0x00, 0x7C, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x3E,
  0x03, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F,
  0x80, 0x1E, 0x07, 0x80, 0x0F, 0x07, 0xC0, 0x07, 0x83, 0xC0, 0x03, 0xC3,
  0xE0, 0x01, 0xE1, 0xE0, 0x00, 0xF1, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x3C,
  0xF8, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x7C, 0x00, 0x07, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3C, 0x0F, 0xE0, 0x3E,
  0x01, 0xF0, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x3E, 0x07, 0x80, 0x1F, 0x03,
  0xC0, 0x0F, 0x83, 0xE0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x03, 0xE0,
  0x78, 0x03, 0xE0, 0x3C, 0x03, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xC0, 0x7E, 0x03, 0xC0, 0x0F,
  0x01, 0xE0, 0x07, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x7C, 0x00,
  0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x1F, 0x07, 0x80,
  0x0F, 0x07, 0xC0, 0x0F, 0x83, 0xC0, 0x1F, 0x81, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFC, 0x0E,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x40, 0x3F, 0x83, 0xC0, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x07, 0x83, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0xF0,
  0x03, 0xE0, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x1F, 0x03, 0xC0, 0x07, 0xC1,
  0xF0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03,
  0xC1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00,
  0x03, 0xC3, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x7C, 0x78, 0x00, 0x1E, 0x1E,
  0x00, 0x0F, 0x87, 0x80, 0x03, 0xE1, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x7C,
  0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x83, 0xC0, 0x07, 0xC0, 0xF0, 0x03,
  0xE0, 0x7C, 0x01, 0xF8, 0x1E, 0x01, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x01, 0xFC, 0x07, 0x80, 0xFC, 0x00, 0x20, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xCF,
  0x80, 0x3F, 0xF3, 0xC0, 0x0F, 0xFC, 0xF0, 0x07, 0xFE, 0x3C, 0x00, 0x07,
  0x8F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x3C, 0x00,
  0x0F, 0x0F, 0x80, 0x03, 0xC3, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1F,
  0x00, 0x1E, 0x07, 0xE0, 0x07, 0x80, 0xFE, 0x07, 0xE0, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x0F,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x3C,
  0x03, 0xC0, 0x01, 0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0xF0, 0x0F,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC,
  0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0xF0, 0x0F,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x3C,
  0x07, 0xC0, 0x03, 0xE0, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xF0, 0x0F,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x3C, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x01, 0xFF, 0xC0, 0xFF,
  0xE0, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x3C, 0x00, 0xF8, 0x07,
  0x80, 0x3E, 0x00, 0xF0, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x07, 0x80, 0xF8,
  0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xC1, 0xF0, 0x00, 0xF8,
  0x7C, 0x00, 0x1E, 0x1F, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x79, 0xF0, 0x00,
  0x0F, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0x78, 0x00, 0x0F, 0xCF, 0x80, 0x01,
  0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xE0, 0x01, 0xF0, 0x3C,
  0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0xF8, 0x00, 0xF0, 0x0F, 0x00, 0x1E,
  0x01, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78,
  0x03, 0xC0, 0x0F, 0x80, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x01, 0xFF, 0xFE, 0xFF, 0xFE, 0x7F, 0xFF, 0x7F, 0xFF, 0x80,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7F, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x3F,
  0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xDE,
  0x03, 0xBC, 0x00, 0x3D, 0xE0, 0x79, 0xC0, 0x07, 0xBC, 0x07, 0x9C, 0x00,
  0x7B, 0xC0, 0x79, 0xC0, 0x0F, 0x3C, 0x07, 0x9C, 0x00, 0xE3, 0xC0, 0x71,
  0xC0, 0x1E, 0x7C, 0x0F, 0x1E, 0x01, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78,
  0x0F, 0x1E, 0x03, 0x87, 0x80, 0xF1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x07,
  0x0F, 0x81, 0xE1, 0xE0, 0xF0, 0xF0, 0x1E, 0x0E, 0x0E, 0x0F, 0x01, 0xE0,
  0xE1, 0xE0, 0xF0, 0x1E, 0x0E, 0x1C, 0x0F, 0x03, 0xC0, 0xE3, 0xC1, 0xE0,
  0x3C, 0x0E, 0x38, 0x1E, 0x03, 0xC0, 0xF7, 0x81, 0xE0, 0x3C, 0x0F, 0xF0,
  0x1E, 0x03, 0x80, 0xFF, 0x03, 0xE0, 0x78, 0x0F, 0xE0, 0x3C, 0x07, 0x80,
  0xFE, 0x03, 0xC0, 0x78, 0x0F, 0xC0, 0x3C, 0x07, 0x80, 0x7C, 0x03, 0xC0,
  0x70, 0x07, 0x80, 0x7C, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x07, 0xE0, 0x00, 0xF0, 0x1F, 0x80, 0x03, 0x80, 0x7E, 0x00, 0x1E,
  0x03, 0xF8, 0x00, 0x78, 0x0F, 0xF0, 0x01, 0xE0, 0x3F, 0xC0, 0x07, 0x80,
  0xFF, 0x00, 0x3C, 0x03, 0x9E, 0x00, 0xF0, 0x1E, 0x78, 0x03, 0xC0, 0x79,
  0xE0, 0x0F, 0x01, 0xE3, 0xC0, 0x3C, 0x07, 0x8F, 0x01, 0xE0, 0x1C, 0x3C,
  0x07, 0x80, 0xF0, 0xF0, 0x1E, 0x03, 0xC1, 0xE0, 0x78, 0x0F, 0x07, 0x81,
  0xE0, 0x3C, 0x1E, 0x0F, 0x01, 0xE0, 0x3C, 0x3C, 0x07, 0x80, 0xF0, 0xF0,
  0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x07, 0x0E, 0x01, 0xE0, 0x1E, 0x78, 0x0F,
  0x00, 0x79, 0xE0, 0x3C, 0x01, 0xE7, 0x80, 0xF0, 0x03, 0xDE, 0x03, 0xC0,
  0x0F, 0x70, 0x0F, 0x00, 0x3F, 0xC0, 0x78, 0x00, 0x7F, 0x01, 0xE0, 0x01,
  0xFC, 0x07, 0x80, 0x07, 0xF0, 0x1E, 0x00, 0x0F, 0x80, 0x70, 0x00, 0x3E,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xF8, 0x3F, 0x81, 0xF8, 0x03,
  0xE0, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xC7, 0xC0,
  0x00, 0xF3, 0xE0, 0x00, 0x3C, 0xF8, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xDF,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x3E, 0xF0,
  0x00, 0x0F, 0x3C, 0x00, 0x07, 0xCF, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0xF8,
  0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x1F,
  0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xE1, 0xFE, 0x03,
  0xE0, 0x3E, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x1F, 0x03, 0xC0, 0x1F, 0x03,
  0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x1E, 0x07,
  0x80, 0x1E, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0x7C, 0x0F, 0x00, 0xFC, 0x0F,
  0x03, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xF8, 0x3F, 0x81, 0xF8, 0x03,
  0xE0, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xC7, 0xC0,
  0x00, 0xF3, 0xE0, 0x00, 0x3C, 0xF8, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xDF,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x3E, 0xF0,
  0x00, 0x0F, 0x3C, 0x00, 0x07, 0xCF, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0xF8,
  0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x1F,
  0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xE1,
  0xFE, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x1F, 0x03, 0xC0,
  0x1F, 0x03, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0x80, 0x1F, 0x07, 0x80,
  0x1E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x3E, 0x0F, 0x80, 0x7C, 0x0F, 0x01,
  0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x80, 0x1E, 0x07, 0x80, 0x3E, 0x07,
  0x80, 0x3C, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x7C, 0x03, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x01,
  0xF0, 0x78, 0x00, 0xF0, 0xF8, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0x03, 0xC0, 0x7C, 0x00,
  0x81, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x30, 0x03, 0xF0,
  0x7C, 0x1F, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x03, 0xE0, 0xF0, 0x00,
  0x78, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E,
  0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0xF8, 0x00, 0x3C, 0x1E, 0x00, 0x07,
  0x83, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x83, 0xE0,
  0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0xF0,
  0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00,
  0x1E, 0x07, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07,
  0x80, 0x03, 0xE0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x03,
  0xE0, 0x78, 0x00, 0x78, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1F,
  0xC3, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0x78, 0x00, 0x3E, 0x78, 0x00,
  0x3C, 0x78, 0x00, 0x7C, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF8, 0x78, 0x00,
  0xF0, 0x78, 0x01, 0xF0, 0x78, 0x01, 0xE0, 0x78, 0x03, 0xE0, 0x78, 0x03,
  0xC0, 0x78, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F,
  0x00, 0x78, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0xF0,
  0x00, 0x3C, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x3D, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF,
  0x80, 0x0F, 0x80, 0x0F, 0xBC, 0x00, 0x7C, 0x00, 0x79, 0xE0, 0x07, 0xE0,
  0x03, 0xCF, 0x00, 0x3F, 0x00, 0x3E, 0x78, 0x01, 0xF8, 0x01, 0xE3, 0xC0,
  0x1F, 0xC0, 0x1F, 0x1E, 0x00, 0xEE, 0x00, 0xF0, 0xF0, 0x0F, 0x70, 0x07,
  0x87, 0x80, 0x73, 0x80, 0x78, 0x3C, 0x07, 0x9C, 0x03, 0xC1, 0xE0, 0x3C,
  0xE0, 0x3C, 0x0F, 0x01, 0xC7, 0x01, 0xE0, 0x78, 0x1E, 0x38, 0x1F, 0x03,
  0xC0, 0xE1, 0xC0, 0xF0, 0x1E, 0x0F, 0x0E, 0x07, 0x80, 0xF0, 0x70, 0x70,
  0x78, 0x07, 0x87, 0x83, 0x83, 0xC0, 0x3C, 0x3C, 0x1E, 0x3C, 0x01, 0xE3,
  0xC0, 0xF1, 0xE0, 0x0F, 0x1E, 0x07, 0x8F, 0x00, 0x78, 0xE0, 0x3C, 0xF0,
  0x03, 0xCF, 0x01, 0xE7, 0x80, 0x1E, 0x70, 0x0F, 0x78, 0x00, 0xF7, 0x80,
  0x7B, 0xC0, 0x07, 0xBC, 0x03, 0xDC, 0x00, 0x3D, 0xC0, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0xF8, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF8, 0x07, 0xC0,
  0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x3E, 0x00, 0x03,
  0xC3, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x9F,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x1E, 0x1E, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0xF0, 0x3E, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0xF8, 0x07, 0x80, 0x0F, 0x80, 0x3C, 0x00, 0x78, 0x01,
  0xF0, 0x07, 0xC0, 0x07, 0x80, 0x7C, 0x00, 0x3C, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7D, 0xE0, 0x03, 0xE7, 0x80, 0x0F, 0x1E, 0x00, 0x7C,
  0x78, 0x01, 0xE1, 0xE0, 0x0F, 0x03, 0xC0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C,
  0x0F, 0x80, 0xF0, 0x3C, 0x03, 0xC1, 0xE0, 0x07, 0x8F, 0x80, 0x1E, 0x3C,
  0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80, 0x03, 0xBC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0xF0, 0x78, 0x3C,
  0x0E, 0x07, 0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x0E, 0x07, 0x03, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x0E, 0x07, 0x03, 0x81, 0xE0, 0xF0, 0x78, 0x3C,
  0x0E, 0x07, 0x03, 0x81, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x07, 0x03, 0xC0,
  0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xBC, 0x00, 0x1E, 0x70, 0x00, 0x71, 0xE0, 0x03, 0xC3, 0x80,
  0x0E, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xC0, 0x70, 0x0F, 0x01, 0xE0, 0x38,
  0x03, 0x81, 0xE0, 0x0F, 0x07, 0x00, 0x1C, 0x3C, 0x00, 0x78, 0xE0, 0x01,
  0xE7, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xF9, 0xF1, 0xE1, 0xE3, 0xC3, 0xC3, 0x87, 0x00, 0xFE, 0x1C, 0x07,
  0xFC, 0xF0, 0x3F, 0xFB, 0xC1, 0xF9, 0xEE, 0x0F, 0x81, 0xF8, 0x7C, 0x03,
  0xE1, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3C, 0x00, 0xF1, 0xF0, 0x03, 0xC7,
  0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x01, 0xF3, 0xE0, 0x07, 0x8F, 0x00,
  0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x03, 0xE3, 0xC0, 0x0F, 0x0F, 0x00, 0x7C,
  0x3C, 0x01, 0xF0, 0xF0, 0x0F, 0xC3, 0xE0, 0x7F, 0x07, 0xC3, 0xB8, 0x1F,
  0xFC, 0xE0, 0x3F, 0xE3, 0x80, 0x7F, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x7E, 0x01, 0xE7, 0xFC, 0x07, 0xBF, 0xF8, 0x1D, 0xE3, 0xE0, 0xFE,
  0x07, 0xC3, 0xF0, 0x0F, 0x0F, 0xC0, 0x3C, 0x3E, 0x00, 0xF0, 0xF0, 0x03,
  0xC7, 0xC0, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x07, 0xCF,
  0x00, 0x1F, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x8F, 0x00,
  0x3C, 0x7C, 0x00, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x3E, 0x1F, 0x81, 0xF0,
  0x77, 0x0F, 0xC3, 0xDF, 0xFE, 0x0F, 0x3F, 0xF0, 0x38, 0x7F, 0x00, 0x00,
  0x7F, 0x80, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0x8E, 0x0F, 0x80, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0xFE, 0x3C, 0x01, 0xFF, 0x3C, 0x07, 0xFF,
  0xBC, 0x07, 0xE7, 0xB8, 0x0F, 0x81, 0xF8, 0x1F, 0x00, 0xF8, 0x1E, 0x00,
  0xF8, 0x3E, 0x00, 0xF8, 0x3C, 0x00, 0xF0, 0x7C, 0x00, 0xF0, 0x78, 0x00,
  0xF0, 0x78, 0x00, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xE0, 0xF0, 0x01,
  0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xC0, 0xF0, 0x07,
  0xC0, 0xF0, 0x07, 0xC0, 0xF0, 0x0F, 0xC0, 0xF8, 0x1F, 0xC0, 0x7C, 0x3B,
  0x80, 0x7F, 0xF3, 0x80, 0x3F, 0xE7, 0x80, 0x1F, 0xC7, 0x80, 0x00, 0x7F,
  0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xE3, 0xE0, 0xF8, 0x3E, 0x3E, 0x03,
  0xCF, 0x80, 0x79, 0xE0, 0x0E, 0x3C, 0x03, 0xCF, 0x00, 0xF9, 0xE0, 0x7E,
  0x3F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xC0, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x02, 0x1F, 0x01, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x08, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x87, 0x00, 0x7F, 0xCF, 0x01, 0xFF,
  0xEF, 0x01, 0xF9, 0xEE, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x3E, 0x07, 0x80,
  0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x00, 0x3C, 0x1F, 0x00, 0x3C, 0x1E, 0x00,
  0x3C, 0x1E, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x78, 0x3C, 0x00,
  0x78, 0x3C, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x3C, 0x00, 0xF0, 0x3C, 0x01,
  0xF0, 0x3C, 0x03, 0xF0, 0x3C, 0x03, 0xF0, 0x3E, 0x07, 0xF0, 0x3F, 0x1E,
  0xE0, 0x1F, 0xFD, 0xE0, 0x0F, 0xF9, 0xE0, 0x07, 0xF1, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x80, 0x0F, 0x80, 0xE0, 0x3F, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x7E, 0x01, 0xE7, 0xFC, 0x07, 0xBF, 0xF8, 0x1D, 0xE3,
  0xE0, 0xFE, 0x07, 0xC3, 0xF0, 0x1F, 0x0F, 0x80, 0x3C, 0x3E, 0x01, 0xF0,
  0xF0, 0x07, 0x87, 0xC0, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0,
  0x0F, 0x8F, 0x80, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F,
  0x0F, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E,
  0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00,
  0xF0, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x02, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x07, 0xC1, 0xE0, 0x3E, 0x07, 0x81, 0xF0,
  0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x03, 0xC1, 0xE0, 0x0F, 0x0F, 0x00, 0x3C,
  0x7C, 0x00, 0xF3, 0xE0, 0x07, 0x9F, 0x00, 0x1E, 0xF8, 0x00, 0x7F, 0xC0,
  0x01, 0xDF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0x78, 0x00, 0xF8, 0xF0, 0x03,
  0xC3, 0xC0, 0x0F, 0x0F, 0x80, 0x78, 0x1E, 0x01, 0xE0, 0x78, 0x07, 0x81,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x3E, 0x0F, 0x00, 0x78,
  0x3C, 0x01, 0xF0, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x87, 0xE0,
  0x3F, 0x01, 0xC7, 0xFC, 0x3F, 0xE0, 0x73, 0xFF, 0x1F, 0xFC, 0x1D, 0xE7,
  0xEF, 0x1F, 0x0F, 0xE0, 0x7F, 0x03, 0xC3, 0xF0, 0x1F, 0x80, 0xF0, 0xF8,
  0x07, 0xC0, 0x3C, 0x3E, 0x01, 0xF0, 0x0F, 0x0F, 0x00, 0x78, 0x03, 0xC7,
  0xC0, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x00, 0x7C, 0x78, 0x03, 0xC0, 0x1E,
  0x1E, 0x00, 0xF0, 0x07, 0x8F, 0x80, 0x3C, 0x01, 0xE3, 0xC0, 0x1F, 0x00,
  0x78, 0xF0, 0x07, 0x80, 0x3C, 0x3C, 0x01, 0xE0, 0x0F, 0x0F, 0x00, 0x78,
  0x03, 0xC7, 0x80, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x00, 0x3C, 0x78, 0x03,
  0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x01, 0xE3, 0xC0,
  0x0F, 0x00, 0x78, 0xF0, 0x07, 0x80, 0x3E, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x07, 0x87, 0xE0, 0x1E, 0x7F, 0xC0, 0x73, 0xFF, 0x83, 0xDF, 0x7E, 0x0F,
  0xF0, 0x7C, 0x3F, 0x01, 0xF0, 0xFC, 0x07, 0xC3, 0xE0, 0x1F, 0x1F, 0x00,
  0x78, 0x7C, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0xF8,
  0xF8, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x01, 0xF0, 0xF0,
  0x07, 0xC7, 0xC0, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x0F,
  0x8F, 0x80, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x1F, 0x00,
  0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0x7E, 0x7E, 0x0F, 0x81,
  0xF1, 0xF0, 0x0F, 0x3E, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xF7, 0x80,
  0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xCF,
  0x00, 0x3C, 0xF8, 0x07, 0x87, 0x80, 0xF8, 0x7C, 0x1F, 0x03, 0xFF, 0xE0,
  0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0xFC, 0x00, 0x79, 0xFF, 0x00,
  0x39, 0xFF, 0xC0, 0x1D, 0xE3, 0xE0, 0x1F, 0xC0, 0xF8, 0x0F, 0xC0, 0x3C,
  0x07, 0xE0, 0x1E, 0x03, 0xE0, 0x0F, 0x01, 0xE0, 0x07, 0x81, 0xF0, 0x03,
  0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x00,
  0x7C, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x1F, 0x03, 0xC0,
  0x0F, 0x03, 0xE0, 0x07, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0x7E,
  0x07, 0xC0, 0x3B, 0x87, 0xE0, 0x3D, 0xFF, 0xE0, 0x1E, 0x7F, 0xE0, 0x0F,
  0x1F, 0xC0, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x1C, 0x07, 0xFC, 0xF0, 0x7F, 0xFB, 0xC1, 0xF9, 0xEE,
  0x0F, 0x81, 0xF8, 0x7C, 0x03, 0xE1, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3C,
  0x00, 0xF1, 0xF0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0xF8, 0x01,
  0xF3, 0xE0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x03, 0xE3,
  0xC0, 0x0F, 0x0F, 0x00, 0x7C, 0x3C, 0x03, 0xF0, 0xF0, 0x0F, 0xC3, 0xE0,
  0x7F, 0x0F, 0xC3, 0xB8, 0x1F, 0xFD, 0xE0, 0x3F, 0xE7, 0x80, 0x7F, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x8F,
  0xC1, 0xC7, 0xE0, 0x73, 0xF8, 0x1D, 0xFE, 0x0F, 0xF0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0xFF, 0xF0, 0x7F, 0xFC, 0x3E, 0x1E, 0x1F, 0x00, 0x87, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x20, 0x07, 0x8E, 0x07,
  0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xF8, 0x00, 0x01, 0xC0, 0x06, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x01, 0xFF, 0xDF, 0xFF, 0xFF, 0xF8,
  0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xFE,
  0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x07,
  0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87,
  0x80, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00,
  0x3C, 0x7C, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0xF8,
  0x78, 0x03, 0xC3, 0xE0, 0x0F, 0x0F, 0x00, 0x7C, 0x3C, 0x01, 0xF0, 0xF0,
  0x0F, 0xC3, 0xC0, 0x7E, 0x0F, 0x87, 0xB8, 0x1F, 0xFD, 0xE0, 0x7F, 0xE7,
  0x80, 0xFF, 0x1E, 0x00, 0xF8, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x01, 0xE7,
  0x80, 0x1E, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x07, 0x87, 0x80, 0x78,
  0x78, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3C,
  0x03, 0x83, 0xC0, 0x38, 0x78, 0x03, 0x87, 0x80, 0x3C, 0xF0, 0x03, 0xCF,
  0x00, 0x3D, 0xE0, 0x03, 0xDE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0xF0, 0x07, 0x80,
  0x3F, 0xE0, 0x1F, 0x00, 0x7B, 0xC0, 0x3E, 0x01, 0xF7, 0x80, 0xFC, 0x03,
  0xCF, 0x01, 0xF8, 0x07, 0x9E, 0x03, 0xF0, 0x1E, 0x3C, 0x0E, 0xE0, 0x3C,
  0x78, 0x1D, 0xC0, 0xF0, 0xF0, 0x7B, 0x81, 0xE1, 0xE0, 0xE7, 0x07, 0x83,
  0xC3, 0xCF, 0x0F, 0x07, 0x87, 0x1E, 0x1E, 0x0F, 0x1E, 0x3C, 0x78, 0x1E,
  0x38, 0x78, 0xF0, 0x3C, 0x70, 0xF3, 0xC0, 0x79, 0xE1, 0xE7, 0x80, 0xF3,
  0x83, 0xCE, 0x01, 0xEF, 0x07, 0xBC, 0x03, 0xDC, 0x0F, 0x78, 0x07, 0xF8,
  0x1F, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0x03, 0xC0, 0x1F, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x3E, 0x01,
  0xE0, 0x7C, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0xF0, 0x00, 0xF1, 0xE0, 0x00,
  0xF3, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xEF, 0x00, 0x01, 0xEF, 0x00, 0x03, 0xC7, 0x80, 0x07,
  0x87, 0x80, 0x0F, 0x87, 0x80, 0x1F, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x7C, 0x01, 0xE0, 0xF8, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xF0,
  0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x07, 0x80, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0xF0, 0x1E, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x70, 0x3C, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0xF0,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF8, 0x03, 0xFC, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0x50,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF8, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x20, 0x00,
  0x00, 0x3F, 0x00, 0x0B, 0xFF, 0x00, 0xFF, 0xFF, 0x1F, 0xE7, 0xFF, 0xFC,
  0x07, 0xFF, 0x40, 0x07, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Italic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 12, 35, 12, 1, -34 },
  { 54, 14, 12, 18, 5, -34 },
  { 75, 27, 34, 27, 1, -34 },
  { 190, 22, 39, 24, 1, -36 },
  { 298, 30, 35, 35, 3, -35 },
  { 430, 26, 35, 28, 1, -35 },
  { 544, 6, 12, 10, 5, -34 },
  { 553, 15, 42, 13, 2, -34 },
  { 632, 16, 42, 13, -4, -34 },
  { 716, 19, 20, 23, 5, -37 },
  { 764, 21, 23, 25, 3, -28 },
  { 825, 9, 12, 11, -2, -6 },
  { 839, 12, 4, 14, 1, -15 },
  { 845, 5, 7, 11, 1, -6 },
  { 850, 23, 34, 17, -2, -34 },
  { 948, 21, 35, 24, 2, -35 },
  { 1040, 14, 34, 24, 6, -34 },
  { 1100, 23, 35, 24, 0, -35 },
  { 1201, 23, 35, 24, 0, -35 },
  { 1302, 23, 34, 24, 0, -34 },
  { 1400, 22, 34, 24, 1, -34 },
  { 1494, 22, 35, 24, 2, -35 },
  { 1591, 22, 34, 24, 3, -34 },
  { 1685, 23, 35, 24, 1, -35 },
  { 1786, 22, 35, 24, 1, -35 },
  { 1883, 9, 27, 11, 1, -26 },
  { 1914, 12, 32, 11, -2, -26 },
  { 1962, 21, 23, 25, 3, -29 },
  { 2023, 20, 13, 25, 3, -23 },
  { 2056, 21, 23, 25, 3, -29 },
  { 2117, 17, 36, 18, 3, -35 },
  { 2194, 33, 38, 36, 2, -34 },
  { 2351, 25, 34, 24, -3, -34 },
  { 2458, 25, 34, 26, 1, -34 },
  { 2565, 24, 35, 25, 3, -35 },
  { 2670, 26, 34, 28, 1, -34 },
  { 2781, 23, 34, 22, 1, -34 },
  { 2879, 23, 34, 21, 1, -34 },
  { 2977, 26, 35, 29, 3, -35 },
  { 3091, 29, 34, 29, 1, -34 },
  { 3215, 18, 34, 14, -1, -34 },
  { 3292, 20, 43, 12, -7, -34 },
  { 3400, 27, 34, 24, 1, -34 },
  { 3515, 17, 34, 20, 1, -34 },
  { 3588, 36, 34, 37, 1, -34 },
  { 3741, 30, 34, 31, 1, -34 },
  { 3869, 26, 35, 31, 3, -35 },
  { 3983, 24, 34, 24, 1, -34 },
  { 4085, 26, 43, 31, 3, -35 },
  { 4225, 24, 34, 25, 1, -34 },
  { 4327, 23, 35, 22, 0, -35 },
  { 4428, 21, 34, 21, 4, -34 },
  { 4518, 27, 34, 29, 3, -34 },
  { 4633, 24, 34, 24, 4, -34 },
  { 4735, 37, 34, 38, 5, -34 },
  { 4893, 29, 34, 23, -3, -34 },
  { 5017, 22, 34, 22, 4, -34 },
  { 5111, 25, 34, 22, -1, -34 },
  { 5218, 18, 42, 14, -1, -34 },
  { 5313, 9, 34, 17, 5, -34 },
  { 5352, 18, 42, 14, -3, -34 },
  { 5447, 22, 20, 24, 1, -34 },
  { 5502, 18, 3, 17, -4, 4 },
  { 5509, 7, 8, 13, 7, -37 },
  { 5516, 22, 26, 25, 2, -26 },
  { 5588, 22, 36, 25, 1, -36 },
  { 5687, 18, 26, 19, 2, -26 },
  { 5746, 24, 36, 25, 2, -36 },
  { 5854, 19, 26, 22, 2, -26 },
  { 5916, 26, 49, 14, -6, -37 },
  { 6076, 24, 38, 25, 0, -26 },
  { 6190, 22, 36, 25, 1, -36 },
  { 6289, 11, 35, 11, 1, -35 },
  { 6338, 18, 47, 11, -6, -35 },
  { 6444, 22, 36, 21, 1, -36 },
  { 6543, 12, 36, 11, 1, -36 },
  { 6597, 34, 26, 37, 1, -26 },
  { 6708, 22, 26, 25, 1, -26 },
  { 6780, 20, 26, 24, 2, -26 },
  { 6845, 25, 37, 25, -2, -26 },
  { 6961, 22, 38, 25, 2, -26 },
  { 7066, 18, 26, 17, 1, -26 },
  { 7125, 18, 26, 19, 0, -26 },
  { 7184, 14, 32, 14, 2, -32 },
  { 7240, 22, 26, 25, 2, -26 },
  { 7312, 20, 26, 20, 2, -26 },
  { 7377, 31, 26, 32, 3, -26 },
  { 7478, 24, 26, 21, -2, -26 },
  { 7556, 28, 38, 20, -5, -26 },
  { 7689, 20, 26, 19, -1, -26 },
  { 7754, 18, 42, 16, 1, -34 },
  { 7849, 4, 49, 23, 10, -37 },
  { 7874, 18, 42, 16, -2, -34 },
  { 7969, 21, 6, 25, 3, -20 },
};

const GFXfont NotoSans_SemiCondensed_Italic48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic48pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC48PT7B_H_
