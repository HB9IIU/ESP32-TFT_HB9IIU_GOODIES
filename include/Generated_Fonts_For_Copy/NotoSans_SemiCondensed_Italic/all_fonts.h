#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/NotoSans_SemiCondensed_Italic
// Headers: 67

#include "NotoSans_SemiCondensed_Italic6pt7b.h"
#include "NotoSans_SemiCondensed_Italic7pt7b.h"
#include "NotoSans_SemiCondensed_Italic8pt7b.h"
#include "NotoSans_SemiCondensed_Italic9pt7b.h"
#include "NotoSans_SemiCondensed_Italic10pt7b.h"
#include "NotoSans_SemiCondensed_Italic11pt7b.h"
#include "NotoSans_SemiCondensed_Italic12pt7b.h"
#include "NotoSans_SemiCondensed_Italic13pt7b.h"
#include "NotoSans_SemiCondensed_Italic14pt7b.h"
#include "NotoSans_SemiCondensed_Italic15pt7b.h"
#include "NotoSans_SemiCondensed_Italic16pt7b.h"
#include "NotoSans_SemiCondensed_Italic17pt7b.h"
#include "NotoSans_SemiCondensed_Italic18pt7b.h"
#include "NotoSans_SemiCondensed_Italic19pt7b.h"
#include "NotoSans_SemiCondensed_Italic20pt7b.h"
#include "NotoSans_SemiCondensed_Italic21pt7b.h"
#include "NotoSans_SemiCondensed_Italic22pt7b.h"
#include "NotoSans_SemiCondensed_Italic23pt7b.h"
#include "NotoSans_SemiCondensed_Italic24pt7b.h"
#include "NotoSans_SemiCondensed_Italic25pt7b.h"
#include "NotoSans_SemiCondensed_Italic26pt7b.h"
#include "NotoSans_SemiCondensed_Italic27pt7b.h"
#include "NotoSans_SemiCondensed_Italic28pt7b.h"
#include "NotoSans_SemiCondensed_Italic29pt7b.h"
#include "NotoSans_SemiCondensed_Italic30pt7b.h"
#include "NotoSans_SemiCondensed_Italic31pt7b.h"
#include "NotoSans_SemiCondensed_Italic32pt7b.h"
#include "NotoSans_SemiCondensed_Italic33pt7b.h"
#include "NotoSans_SemiCondensed_Italic34pt7b.h"
#include "NotoSans_SemiCondensed_Italic35pt7b.h"
#include "NotoSans_SemiCondensed_Italic36pt7b.h"
#include "NotoSans_SemiCondensed_Italic37pt7b.h"
#include "NotoSans_SemiCondensed_Italic38pt7b.h"
#include "NotoSans_SemiCondensed_Italic39pt7b.h"
#include "NotoSans_SemiCondensed_Italic40pt7b.h"
#include "NotoSans_SemiCondensed_Italic41pt7b.h"
#include "NotoSans_SemiCondensed_Italic42pt7b.h"
#include "NotoSans_SemiCondensed_Italic43pt7b.h"
#include "NotoSans_SemiCondensed_Italic44pt7b.h"
#include "NotoSans_SemiCondensed_Italic45pt7b.h"
#include "NotoSans_SemiCondensed_Italic46pt7b.h"
#include "NotoSans_SemiCondensed_Italic47pt7b.h"
#include "NotoSans_SemiCondensed_Italic48pt7b.h"
#include "NotoSans_SemiCondensed_Italic49pt7b.h"
#include "NotoSans_SemiCondensed_Italic50pt7b.h"
#include "NotoSans_SemiCondensed_Italic51pt7b.h"
#include "NotoSans_SemiCondensed_Italic52pt7b.h"
#include "NotoSans_SemiCondensed_Italic53pt7b.h"
#include "NotoSans_SemiCondensed_Italic54pt7b.h"
#include "NotoSans_SemiCondensed_Italic55pt7b.h"
#include "NotoSans_SemiCondensed_Italic56pt7b.h"
#include "NotoSans_SemiCondensed_Italic57pt7b.h"
#include "NotoSans_SemiCondensed_Italic58pt7b.h"
#include "NotoSans_SemiCondensed_Italic59pt7b.h"
#include "NotoSans_SemiCondensed_Italic60pt7b.h"
#include "NotoSans_SemiCondensed_Italic61pt7b.h"
#include "NotoSans_SemiCondensed_Italic62pt7b.h"
#include "NotoSans_SemiCondensed_Italic63pt7b.h"
#include "NotoSans_SemiCondensed_Italic64pt7b.h"
#include "NotoSans_SemiCondensed_Italic65pt7b.h"
#include "NotoSans_SemiCondensed_Italic66pt7b.h"
#include "NotoSans_SemiCondensed_Italic67pt7b.h"
#include "NotoSans_SemiCondensed_Italic68pt7b.h"
#include "NotoSans_SemiCondensed_Italic69pt7b.h"
#include "NotoSans_SemiCondensed_Italic70pt7b.h"
#include "NotoSans_SemiCondensed_Italic71pt7b.h"
#include "NotoSans_SemiCondensed_Italic72pt7b.h"
