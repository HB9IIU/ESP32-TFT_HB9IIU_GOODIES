#ifndef _NOTOSANS_SEMICONDENSED_ITALIC25PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x18, 0x30, 0x61, 0xC3, 0x06, 0x0C, 0x18, 0x60, 0xC1, 0x83,
  0x00, 0x00, 0x30, 0xE1, 0xC0, 0x67, 0xDF, 0x36, 0x6C, 0xD1, 0xA2, 0x00,
  0x01, 0x88, 0x0C, 0x60, 0x31, 0x80, 0xC4, 0x02, 0x30, 0xFF, 0xF3, 0xFF,
  0xC1, 0x18, 0x0C, 0x60, 0x31, 0x80, 0x84, 0x1F, 0xFE, 0xFF, 0xF8, 0x62,
  0x01, 0x18, 0x0C, 0x60, 0x31, 0x00, 0x8C, 0x00, 0x01, 0x00, 0x20, 0x1F,
  0x0F, 0xF3, 0xA2, 0x64, 0x0D, 0x81, 0xB0, 0x3C, 0x03, 0xC0, 0x1C, 0x07,
  0xC0, 0xD8, 0x13, 0x02, 0x64, 0x5C, 0xFF, 0x0F, 0x80, 0x40, 0x08, 0x00,
  0x3C, 0x0C, 0xFC, 0x11, 0x98, 0x66, 0x31, 0x8C, 0x62, 0x18, 0xCC, 0x31,
  0x30, 0x46, 0x4E, 0x8D, 0xBF, 0xB6, 0xCD, 0xC9, 0x98, 0x32, 0x30, 0xCC,
  0x61, 0x18, 0xC6, 0x31, 0x18, 0x66, 0x20, 0xFC, 0xC0, 0xF0, 0x03, 0xC0,
  0x1F, 0x80, 0xC7, 0x03, 0x0C, 0x0C, 0x60, 0x31, 0x80, 0xCC, 0x01, 0xE0,
  0x0E, 0x00, 0x7C, 0x03, 0x38, 0xD8, 0x66, 0x61, 0xFB, 0x83, 0xCE, 0x0E,
  0x18, 0x78, 0x7F, 0xB0, 0xFC, 0xE0, 0x7F, 0x6D, 0x20, 0x07, 0x06, 0x0C,
  0x18, 0x18, 0x30, 0x30, 0x60, 0x60, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x06, 0x06, 0x02, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x06, 0x06, 0x06, 0x0C, 0x0C,
  0x18, 0x18, 0x30, 0x60, 0xC0, 0x0C, 0x03, 0x08, 0xC3, 0xB0, 0x7F, 0xC7,
  0xF3, 0xC1, 0x90, 0xE6, 0x11, 0x80, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x61, 0xFF, 0xFF, 0xF8, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x39,
  0x9C, 0xC6, 0x60, 0xFF, 0xE0, 0x7F, 0x80, 0x00, 0x70, 0x06, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x01,
  0xC0, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x07, 0x81,
  0xF8, 0x63, 0x9C, 0x33, 0x06, 0xE0, 0xD8, 0x1B, 0x03, 0x60, 0x7C, 0x1F,
  0x03, 0x60, 0x6C, 0x0D, 0x83, 0x30, 0x67, 0x18, 0x7F, 0x07, 0xC0, 0x06,
  0x3C, 0xFF, 0xF4, 0xC1, 0x83, 0x06, 0x1C, 0x30, 0x60, 0xC3, 0x86, 0x0C,
  0x18, 0x30, 0xE0, 0x07, 0xC1, 0xFE, 0x08, 0x70, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x60, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xFF, 0xCF, 0xFC, 0x07, 0xC1, 0xFE, 0x08, 0x70, 0x03,
  0x00, 0x30, 0x07, 0x00, 0x60, 0x1C, 0x0F, 0x80, 0xF8, 0x01, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC8, 0x1C, 0xFF, 0x8F, 0xF0, 0x00, 0x70, 0x0F,
  0x00, 0xE0, 0x1E, 0x03, 0x60, 0x66, 0x06, 0x60, 0xCC, 0x18, 0xC3, 0x0C,
  0x30, 0xC6, 0x0C, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30,
  0x07, 0xF0, 0xFF, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0xF8,
  0x3F, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC8, 0x1C,
  0xFF, 0x87, 0xF0, 0x03, 0xE0, 0xFC, 0x30, 0x0C, 0x03, 0x80, 0x60, 0x1C,
  0x03, 0x7C, 0x7F, 0xCE, 0x1B, 0x83, 0x70, 0x6C, 0x0D, 0x81, 0xB0, 0x73,
  0x0C, 0x7F, 0x07, 0xC0, 0x7F, 0xEF, 0xFC, 0x03, 0x00, 0xE0, 0x18, 0x07,
  0x00, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x1C,
  0x03, 0x00, 0xE0, 0x18, 0x00, 0x07, 0xC3, 0xFC, 0x61, 0x98, 0x33, 0x06,
  0x60, 0xC6, 0x30, 0xFC, 0x0F, 0x07, 0xE1, 0xC6, 0x70, 0xEC, 0x0D, 0x81,
  0xB0, 0x76, 0x0C, 0xFF, 0x8F, 0xC0, 0x0F, 0x83, 0xF8, 0xE3, 0x18, 0x36,
  0x06, 0xC0, 0xD8, 0x1B, 0x07, 0x60, 0xCF, 0x78, 0xFB, 0x00, 0x60, 0x18,
  0x03, 0x00, 0xC0, 0x38, 0xFE, 0x1F, 0x00, 0x08, 0xCE, 0x20, 0x00, 0x00,
  0x00, 0x00, 0xCE, 0x70, 0x04, 0x31, 0xC2, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x31, 0xC6, 0x30, 0xC0, 0x00, 0x20, 0x0C, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x10, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x80, 0x1C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x01, 0xC0, 0x38, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0x40, 0x00,
  0x1F, 0x3F, 0xC8, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C,
  0x06, 0x02, 0x00, 0x00, 0x00, 0xC0, 0xE0, 0x70, 0x00, 0x00, 0xF8, 0x01,
  0xFF, 0x03, 0x80, 0xC3, 0x80, 0x31, 0x80, 0x19, 0x87, 0xCD, 0x87, 0xE2,
  0xC6, 0x31, 0x46, 0x11, 0xE3, 0x18, 0xF3, 0x0C, 0x79, 0x86, 0x2C, 0xC6,
  0x36, 0x77, 0xB3, 0x1E, 0xF1, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0F,
  0x1C, 0x01, 0xFC, 0x00, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x1B,
  0x00, 0xD8, 0x0C, 0xC0, 0x66, 0x06, 0x30, 0x31, 0xC3, 0xFE, 0x1F, 0xF1,
  0xC1, 0x8C, 0x0C, 0xE0, 0x66, 0x03, 0x70, 0x1F, 0x00, 0xC0, 0x1F, 0xC1,
  0xFE, 0x18, 0x71, 0x83, 0x38, 0x33, 0x03, 0x30, 0x73, 0x0E, 0x3F, 0x87,
  0xFC, 0x60, 0xE6, 0x06, 0x60, 0x66, 0x06, 0xE0, 0xEC, 0x1C, 0xFF, 0x8F,
  0xF0, 0x03, 0xF8, 0x3F, 0xC3, 0x82, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01,
  0x80, 0x0E, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0xFF, 0x06, 0x1C,
  0x30, 0x73, 0x81, 0x98, 0x0C, 0xC0, 0x66, 0x03, 0x30, 0x1B, 0x80, 0xD8,
  0x0E, 0xC0, 0x66, 0x07, 0x30, 0x33, 0x83, 0x98, 0x78, 0xFF, 0x87, 0xF0,
  0x00, 0x1F, 0xF1, 0xFE, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03,
  0x04, 0x3F, 0x87, 0xF8, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C,
  0x00, 0xFF, 0x0F, 0xF0, 0x1F, 0xF1, 0xFE, 0x18, 0x01, 0x80, 0x38, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x3F, 0x87, 0xF8, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0xF8, 0x1F, 0xF0, 0xE0,
  0x47, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x83,
  0xEE, 0x01, 0xB8, 0x0E, 0xE0, 0x31, 0x80, 0xC6, 0x03, 0x1C, 0x1C, 0x3F,
  0xE0, 0x7F, 0x80, 0x1C, 0x0C, 0x60, 0x31, 0x80, 0xC6, 0x03, 0x18, 0x1C,
  0xC0, 0x63, 0x01, 0x8C, 0x06, 0x3F, 0xF9, 0xFF, 0xC6, 0x03, 0x18, 0x0C,
  0x60, 0x31, 0x81, 0xCE, 0x06, 0x30, 0x18, 0xC0, 0x63, 0x01, 0x80, 0x0F,
  0xC3, 0xE0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x3A, 0x3F, 0x00, 0x00, 0xE0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38,
  0x06, 0x01, 0xC1, 0xF0, 0x38, 0x00, 0x1C, 0x1C, 0x60, 0xE1, 0x87, 0x06,
  0x38, 0x39, 0xC0, 0xC6, 0x03, 0x30, 0x0D, 0x80, 0x3E, 0x01, 0xF8, 0x07,
  0x70, 0x18, 0xC0, 0x63, 0x01, 0x8E, 0x0E, 0x18, 0x30, 0x60, 0xC1, 0xC3,
  0x03, 0x00, 0x1C, 0x18, 0x18, 0x18, 0x38, 0x30, 0x30, 0x30, 0x30, 0x70,
  0x60, 0x60, 0x60, 0x60, 0xE0, 0xC0, 0xFF, 0xFF, 0x1C, 0x01, 0xE3, 0xC0,
  0x38, 0x78, 0x0F, 0x0F, 0x03, 0xE3, 0x60, 0x7C, 0x6C, 0x1F, 0x0D, 0x83,
  0x61, 0xB0, 0xCC, 0x36, 0x19, 0x8C, 0xC6, 0x71, 0x98, 0xCC, 0x31, 0x31,
  0x86, 0x36, 0x30, 0xC7, 0x86, 0x30, 0xF1, 0x86, 0x1C, 0x30, 0xC3, 0x86,
  0x18, 0x60, 0xC0, 0x1C, 0x06, 0x38, 0x0C, 0x70, 0x18, 0xF0, 0x63, 0x60,
  0xC6, 0xC1, 0x8C, 0xC3, 0x19, 0x86, 0x33, 0x18, 0xC3, 0x31, 0x86, 0x63,
  0x0C, 0xC6, 0x19, 0x8C, 0x1E, 0x30, 0x3C, 0x60, 0x78, 0xC0, 0x71, 0x80,
  0xE0, 0x03, 0xF0, 0x1F, 0xE1, 0xC1, 0xC6, 0x03, 0x38, 0x0C, 0xC0, 0x37,
  0x00, 0xD8, 0x03, 0x60, 0x0D, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x19,
  0x80, 0xE6, 0x03, 0x1C, 0x18, 0x3F, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xFE,
  0x18, 0x61, 0x87, 0x38, 0x33, 0x03, 0x30, 0x73, 0x06, 0x30, 0xE7, 0xFC,
  0x7F, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x03, 0xF0, 0x1F, 0xE1, 0xC1, 0xC6, 0x03, 0x38, 0x0C, 0xC0, 0x37, 0x00,
  0xD8, 0x03, 0x60, 0x0D, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x19, 0x80,
  0xE6, 0x03, 0x1C, 0x18, 0x3F, 0xE0, 0x7E, 0x00, 0x38, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x80, 0x1F, 0x81, 0xFE, 0x18, 0x71, 0x87, 0x38, 0x33, 0x03,
  0x30, 0x73, 0x06, 0x31, 0xC7, 0xF8, 0x7F, 0x06, 0x30, 0x63, 0x06, 0x18,
  0xE1, 0x8C, 0x18, 0xC1, 0xCC, 0x0C, 0x07, 0xE0, 0xFF, 0x1C, 0x21, 0x80,
  0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0x80, 0x1C,
  0x00, 0xC0, 0x0C, 0x01, 0xC8, 0x18, 0xFF, 0x8F, 0xE0, 0xFF, 0xFF, 0xFC,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x00, 0x30, 0x19,
  0x80, 0xCC, 0x06, 0x60, 0x36, 0x03, 0xB0, 0x19, 0x80, 0xCC, 0x06, 0xE0,
  0x36, 0x03, 0x30, 0x19, 0x80, 0xCC, 0x06, 0x60, 0x73, 0x03, 0x18, 0x38,
  0xFF, 0x83, 0xF8, 0x00, 0xC0, 0x3E, 0x01, 0xB8, 0x1D, 0xC0, 0xC6, 0x0E,
  0x30, 0x61, 0x87, 0x0C, 0x30, 0x63, 0x83, 0x18, 0x19, 0xC0, 0xCC, 0x06,
  0xE0, 0x36, 0x01, 0xB0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x00, 0xE0, 0x60,
  0x76, 0x0E, 0x06, 0x60, 0xE0, 0xE6, 0x0E, 0x0C, 0x61, 0xE0, 0xC6, 0x1E,
  0x18, 0x63, 0x61, 0x86, 0x36, 0x30, 0x66, 0x63, 0x06, 0x66, 0x70, 0x6C,
  0x66, 0x06, 0xC2, 0x60, 0x6C, 0x2C, 0x07, 0x82, 0xC0, 0x78, 0x28, 0x07,
  0x03, 0x80, 0x70, 0x38, 0x06, 0x03, 0x00, 0x0C, 0x0E, 0x18, 0x38, 0x38,
  0x60, 0x31, 0x80, 0x67, 0x00, 0xCC, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x1E, 0x00, 0x6C, 0x01, 0xCC, 0x03, 0x18, 0x0C, 0x30, 0x38,
  0x70, 0x60, 0x61, 0x80, 0xC0, 0xC0, 0x76, 0x0E, 0x60, 0xC6, 0x18, 0x61,
  0x86, 0x30, 0x37, 0x03, 0x60, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x0F, 0xFC, 0x3F, 0xE0,
  0x03, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00,
  0x7F, 0xE3, 0xFF, 0x00, 0x0F, 0x87, 0xC3, 0x01, 0x81, 0x80, 0xC0, 0x60,
  0x30, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x30, 0x18, 0x0F, 0x87, 0xC0, 0xCC, 0xCC, 0xCC, 0x46, 0x66, 0x66, 0x66,
  0x33, 0x33, 0x07, 0xC1, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x78, 0x3E, 0x00, 0x06, 0x01, 0xC0, 0x3C, 0x0D, 0x81,
  0xB0, 0x63, 0x0C, 0x63, 0x06, 0x60, 0xD8, 0x0F, 0x01, 0x80, 0xFF, 0xFF,
  0xC0, 0xCE, 0x63, 0x06, 0x11, 0xFA, 0x39, 0xE3, 0x0E, 0x60, 0xE6, 0x0E,
  0xE0, 0xCC, 0x0C, 0xC0, 0xCC, 0x1C, 0xC1, 0x8C, 0x38, 0xFF, 0x87, 0x98,
  0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x88, 0x1B, 0xE1, 0xE7,
  0x1C, 0x33, 0x83, 0x38, 0x33, 0x03, 0x30, 0x33, 0x06, 0x70, 0x67, 0x0E,
  0x70, 0xC7, 0xF8, 0xCF, 0x00, 0x07, 0x0F, 0xCE, 0x26, 0x06, 0x03, 0x03,
  0x81, 0x80, 0xC0, 0x60, 0x30, 0x1C, 0x07, 0xE1, 0xF0, 0x00, 0x18, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x03, 0x38, 0x7F, 0x87, 0x3C, 0x30, 0xE3,
  0x07, 0x18, 0x39, 0xC1, 0x8C, 0x0C, 0x60, 0x63, 0x07, 0x18, 0x30, 0xC3,
  0x87, 0xFC, 0x1E, 0x60, 0x07, 0x07, 0xE3, 0x9C, 0xC3, 0x60, 0xD8, 0x6F,
  0xF3, 0xF8, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0x7F, 0x0F, 0xC0, 0x00, 0x78,
  0x07, 0xC0, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x3F, 0x80, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x1E,
  0x00, 0xE0, 0x00, 0x03, 0x08, 0x7E, 0x87, 0x3C, 0x30, 0xE3, 0x07, 0x18,
  0x39, 0xC1, 0x8C, 0x0C, 0x60, 0x63, 0x07, 0x18, 0x30, 0xC3, 0x87, 0xFC,
  0x1E, 0x60, 0x03, 0x00, 0x30, 0x01, 0x84, 0x1C, 0x3F, 0xC0, 0xF8, 0x00,
  0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x88, 0x1B, 0xE1, 0xE7,
  0x1C, 0x33, 0x83, 0x38, 0x73, 0x06, 0x30, 0x63, 0x06, 0x70, 0x66, 0x0C,
  0x60, 0xC6, 0x0C, 0xE0, 0xC0, 0x0C, 0x30, 0x00, 0x00, 0x61, 0x86, 0x38,
  0xC3, 0x0C, 0x31, 0xC6, 0x18, 0x63, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x00,
  0x00, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x30,
  0x18, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x81, 0xC3, 0xC1, 0xC0, 0x0E, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x81, 0x18, 0x61, 0x8C, 0x19, 0x83,
  0xB0, 0x37, 0x03, 0xE0, 0x3E, 0x03, 0x70, 0x63, 0x06, 0x30, 0x61, 0x86,
  0x18, 0xE1, 0xC0, 0x0E, 0x18, 0x30, 0x61, 0xC3, 0x06, 0x0C, 0x18, 0x70,
  0xC1, 0x83, 0x06, 0x1C, 0x30, 0x60, 0xC3, 0x80, 0x00, 0xC1, 0x06, 0xF9,
  0xF1, 0xE6, 0xCC, 0x71, 0xC3, 0x38, 0x70, 0xCE, 0x18, 0x33, 0x06, 0x0C,
  0xC1, 0x83, 0x30, 0xE1, 0x9C, 0x30, 0x66, 0x0C, 0x19, 0x83, 0x06, 0x60,
  0xC3, 0xB8, 0x70, 0xC0, 0x00, 0xC1, 0xBE, 0x1E, 0x71, 0xC3, 0x38, 0x33,
  0x87, 0x30, 0x63, 0x06, 0x30, 0x67, 0x0E, 0x60, 0xE6, 0x0C, 0x60, 0xCE,
  0x0C, 0x06, 0x03, 0xF0, 0xE7, 0x18, 0x66, 0x0E, 0xC0, 0xF8, 0x3E, 0x06,
  0xC0, 0xD8, 0x1B, 0x06, 0x71, 0xC7, 0xF0, 0x7C, 0x00, 0x00, 0x40, 0x6F,
  0x83, 0xCE, 0x1C, 0x31, 0xC1, 0x8E, 0x0C, 0x60, 0x63, 0x03, 0x18, 0x31,
  0xC1, 0x8E, 0x1C, 0x70, 0xC3, 0xFC, 0x1B, 0xC1, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x38, 0x01, 0x80, 0x00, 0x06, 0x11, 0xFA, 0x39, 0xE3, 0x0E,
  0x60, 0xE6, 0x0E, 0xE0, 0xCC, 0x0C, 0xC0, 0xCC, 0x1C, 0xC1, 0x8C, 0x38,
  0xFF, 0x87, 0x98, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70,
  0x01, 0xC6, 0xF1, 0xF4, 0x70, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x1C,
  0x06, 0x01, 0x80, 0x60, 0x38, 0x00, 0x06, 0x07, 0xF3, 0x88, 0xC0, 0x30,
  0x0C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x32, 0x0C, 0xFE, 0x3F, 0x00,
  0x18, 0x30, 0xC7, 0xF3, 0x06, 0x1C, 0x30, 0x60, 0xC1, 0x87, 0x0C, 0x18,
  0x3E, 0x3C, 0x30, 0x66, 0x0C, 0xC1, 0xB0, 0x36, 0x0C, 0xC1, 0x98, 0x37,
  0x06, 0xC1, 0xD8, 0x33, 0x0E, 0x7E, 0xC7, 0x98, 0xC0, 0xFC, 0x19, 0x86,
  0x30, 0xC6, 0x30, 0xC6, 0x19, 0x83, 0x30, 0x6C, 0x0D, 0x81, 0xE0, 0x3C,
  0x07, 0x00, 0xE1, 0xC3, 0xE3, 0xC7, 0x63, 0xC6, 0x62, 0xC6, 0x66, 0xCC,
  0x64, 0xCC, 0x6C, 0xD8, 0x6C, 0xD8, 0x78, 0xD8, 0x78, 0xF0, 0x50, 0xF0,
  0x70, 0xE0, 0x60, 0xE0, 0x18, 0x38, 0x63, 0x03, 0x30, 0x1B, 0x80, 0x78,
  0x03, 0x80, 0x1C, 0x01, 0xE0, 0x1F, 0x00, 0xCC, 0x0C, 0x60, 0xC3, 0x0E,
  0x0C, 0x00, 0x1C, 0x1C, 0x30, 0x60, 0xC3, 0x03, 0x0C, 0x0C, 0x60, 0x31,
  0x80, 0xCC, 0x03, 0x30, 0x0D, 0x80, 0x36, 0x00, 0xF0, 0x01, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x03, 0xC0, 0x0E, 0x00, 0x00,
  0x1F, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0x60, 0x18,
  0x07, 0x01, 0xC0, 0x3F, 0xCF, 0xF0, 0x01, 0xC0, 0xF0, 0x70, 0x18, 0x06,
  0x01, 0x80, 0xC0, 0x30, 0x0C, 0x06, 0x07, 0x03, 0xC0, 0x38, 0x06, 0x01,
  0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3C, 0x07, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x07, 0x80, 0xC0, 0x60, 0x30, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x00, 0xE0, 0xF0, 0xE0, 0x60, 0x30, 0x30, 0x18,
  0x0C, 0x06, 0x06, 0x0F, 0x07, 0x00, 0x7E, 0x3D, 0xFE, 0x07, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Italic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 7, 18, 6, 0, -18 },
  { 17, 7, 7, 9, 3, -18 },
  { 24, 14, 18, 14, 0, -18 },
  { 56, 11, 20, 12, 1, -19 },
  { 84, 15, 18, 18, 2, -18 },
  { 118, 14, 18, 15, 0, -18 },
  { 150, 3, 7, 5, 3, -18 },
  { 153, 8, 22, 7, 1, -18 },
  { 175, 8, 22, 7, -2, -18 },
  { 197, 10, 10, 12, 3, -19 },
  { 210, 11, 12, 13, 1, -15 },
  { 227, 5, 6, 6, -1, -3 },
  { 231, 6, 2, 7, 1, -8 },
  { 233, 3, 3, 6, 0, -3 },
  { 235, 12, 18, 9, -1, -18 },
  { 262, 11, 18, 12, 1, -18 },
  { 287, 7, 18, 12, 3, -18 },
  { 303, 12, 18, 12, 0, -18 },
  { 330, 12, 18, 12, 0, -18 },
  { 357, 12, 18, 12, 0, -18 },
  { 384, 12, 18, 12, 0, -18 },
  { 411, 11, 18, 12, 1, -18 },
  { 436, 11, 18, 12, 2, -18 },
  { 461, 11, 18, 12, 1, -18 },
  { 486, 11, 18, 12, 1, -18 },
  { 511, 5, 14, 6, 0, -14 },
  { 520, 6, 17, 6, -1, -14 },
  { 533, 11, 12, 13, 1, -15 },
  { 550, 10, 7, 13, 2, -12 },
  { 559, 11, 12, 13, 1, -15 },
  { 576, 9, 18, 9, 1, -18 },
  { 597, 17, 20, 19, 1, -18 },
  { 640, 13, 18, 13, -2, -18 },
  { 670, 12, 18, 13, 1, -18 },
  { 697, 13, 18, 13, 1, -18 },
  { 727, 13, 18, 15, 1, -18 },
  { 757, 12, 18, 12, 1, -18 },
  { 784, 12, 18, 11, 1, -18 },
  { 811, 14, 18, 15, 1, -18 },
  { 843, 14, 18, 15, 1, -18 },
  { 875, 10, 18, 8, -1, -18 },
  { 898, 11, 23, 6, -4, -18 },
  { 930, 14, 18, 13, 1, -18 },
  { 962, 8, 18, 11, 1, -18 },
  { 980, 19, 18, 19, 1, -18 },
  { 1023, 15, 18, 16, 1, -18 },
  { 1057, 14, 18, 16, 1, -18 },
  { 1089, 12, 18, 13, 1, -18 },
  { 1116, 14, 22, 16, 1, -18 },
  { 1155, 12, 18, 13, 1, -18 },
  { 1182, 12, 18, 11, 0, -18 },
  { 1209, 11, 18, 11, 2, -18 },
  { 1234, 13, 18, 15, 2, -18 },
  { 1264, 13, 18, 12, 2, -18 },
  { 1294, 20, 18, 20, 2, -18 },
  { 1339, 15, 18, 12, -1, -18 },
  { 1373, 12, 18, 11, 2, -18 },
  { 1400, 14, 18, 11, -1, -18 },
  { 1432, 9, 22, 7, 0, -18 },
  { 1457, 4, 18, 9, 3, -18 },
  { 1466, 10, 22, 7, -2, -18 },
  { 1494, 11, 11, 13, 1, -18 },
  { 1510, 9, 2, 9, -2, 2 },
  { 1513, 4, 4, 7, 4, -19 },
  { 1515, 12, 14, 13, 1, -14 },
  { 1536, 12, 19, 13, 0, -19 },
  { 1565, 9, 14, 10, 1, -14 },
  { 1581, 13, 19, 13, 1, -19 },
  { 1612, 10, 14, 11, 1, -14 },
  { 1630, 13, 25, 7, -3, -19 },
  { 1671, 13, 20, 13, 0, -14 },
  { 1704, 12, 19, 13, 0, -19 },
  { 1733, 6, 18, 6, 0, -18 },
  { 1747, 9, 24, 6, -3, -18 },
  { 1774, 12, 19, 11, 0, -19 },
  { 1803, 7, 19, 6, 0, -19 },
  { 1820, 18, 14, 19, 0, -14 },
  { 1852, 12, 14, 13, 0, -14 },
  { 1873, 11, 14, 13, 1, -14 },
  { 1893, 13, 20, 13, -1, -14 },
  { 1926, 12, 20, 13, 1, -14 },
  { 1956, 10, 14, 9, 0, -14 },
  { 1974, 10, 14, 10, 0, -14 },
  { 1992, 7, 16, 7, 1, -16 },
  { 2006, 11, 13, 13, 1, -13 },
  { 2024, 11, 13, 10, 1, -13 },
  { 2042, 16, 13, 16, 1, -13 },
  { 2068, 13, 13, 11, -1, -13 },
  { 2090, 14, 19, 11, -2, -13 },
  { 2124, 11, 13, 10, -1, -13 },
  { 2142, 10, 22, 9, 0, -18 },
  { 2170, 2, 25, 12, 5, -19 },
  { 2177, 9, 22, 9, -1, -18 },
  { 2202, 11, 3, 13, 1, -10 },
};

const GFXfont NotoSans_SemiCondensed_Italic25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic25pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC25PT7B_H_
