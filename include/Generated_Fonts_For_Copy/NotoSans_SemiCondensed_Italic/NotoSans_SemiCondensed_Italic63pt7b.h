#ifndef _NOTOSANS_SEMICONDENSED_ITALIC63PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC63PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x30, 0x00, 0x3F, 0x0F, 0xCF,
  0x83, 0xF3, 0xE0, 0xFD, 0xF8, 0x3E, 0x7E, 0x0F, 0x9F, 0x03, 0xE7, 0xC1,
  0xF1, 0xF0, 0x7C, 0x78, 0x1F, 0x1E, 0x07, 0xCF, 0x81, 0xE3, 0xE0, 0x78,
  0xF0, 0x1E, 0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0x80, 0xF0, 0x00, 0x00, 0xF8,
  0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00,
  0xF8, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x87,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00,
  0x3C, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0x9C, 0x7C, 0x03, 0xF1, 0xE0, 0x60, 0x3F, 0x0F,
  0x00, 0x01, 0xF0, 0x78, 0x00, 0x0F, 0x83, 0x80, 0x00, 0x7C, 0x1C, 0x00,
  0x03, 0xE1, 0xE0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0xF8, 0x70, 0x00, 0x07,
  0xE3, 0x80, 0x00, 0x3F, 0x9C, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x77, 0xF0, 0x00,
  0x03, 0x9F, 0xC0, 0x00, 0x3C, 0x7E, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x0F,
  0x0F, 0x80, 0x00, 0x70, 0x7C, 0x00, 0x03, 0x83, 0xE0, 0x00, 0x3C, 0x1F,
  0x00, 0x01, 0xE0, 0xF8, 0x00, 0x0E, 0x0F, 0x81, 0x00, 0x70, 0xFC, 0x1F,
  0x07, 0x8F, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xF0, 0x0F, 0xFE, 0x00,
  0x07, 0xC0, 0x3F, 0xFC, 0x00, 0x0F, 0x00, 0x7C, 0xFC, 0x00, 0x3E, 0x01,
  0xF0, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0xF0, 0x01, 0xE0, 0x0F, 0x01, 0xE0,
  0x07, 0xC0, 0x3E, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x07, 0x80, 0x3C, 0x00,
  0xF0, 0x0F, 0x00, 0xF8, 0x03, 0xE0, 0x1E, 0x03, 0xE0, 0x07, 0xC0, 0x3C,
  0x07, 0x80, 0x0F, 0x00, 0xF8, 0x1F, 0x00, 0x1E, 0x01, 0xF0, 0x7C, 0x00,
  0x3C, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x07, 0x83, 0xE0, 0x01, 0xF0, 0x0F,
  0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x1E, 0x03, 0x07, 0xC0, 0x78, 0x7C, 0x3F,
  0xCF, 0x80, 0xF1, 0xF1, 0xFF, 0xDF, 0x03, 0xE3, 0xC7, 0xFF, 0xBE, 0x0F,
  0x8F, 0x8F, 0xDF, 0xBC, 0x1E, 0x3E, 0x3E, 0x1F, 0x7E, 0xFC, 0x78, 0xF8,
  0x1E, 0xFF, 0xF1, 0xF1, 0xE0, 0x3C, 0xFF, 0xC7, 0xC3, 0xC0, 0x78, 0xFF,
  0x0F, 0x8F, 0x80, 0xF0, 0x60, 0x3E, 0x1E, 0x01, 0xE0, 0x00, 0xF8, 0x3C,
  0x03, 0xC0, 0x01, 0xF0, 0xF8, 0x07, 0x80, 0x07, 0xC1, 0xE0, 0x0F, 0x00,
  0x0F, 0x03, 0xC0, 0x3E, 0x00, 0x3E, 0x07, 0x80, 0x7C, 0x00, 0xF8, 0x0F,
  0x00, 0xF0, 0x01, 0xE0, 0x3E, 0x01, 0xE0, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x1F, 0x00, 0xF8, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x1E, 0x00, 0xF8, 0x03,
  0xE0, 0x7C, 0x03, 0xE0, 0x03, 0xC0, 0xF0, 0x07, 0x80, 0x07, 0x83, 0xE0,
  0x1F, 0x00, 0x0F, 0xDF, 0x80, 0x7C, 0x00, 0x1F, 0xFE, 0x00, 0xF0, 0x00,
  0x1F, 0xF8, 0x03, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x1F, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x7E, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x0F, 0x9F, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01,
  0xFC, 0xFC, 0x01, 0xF0, 0xFE, 0x3F, 0x00, 0xFC, 0x7E, 0x07, 0xE0, 0x3E,
  0x3F, 0x01, 0xF8, 0x1F, 0x8F, 0xC0, 0x3F, 0x07, 0xC7, 0xE0, 0x07, 0xC3,
  0xF1, 0xF0, 0x01, 0xF8, 0xF8, 0x7C, 0x00, 0x3F, 0x7C, 0x3F, 0x00, 0x0F,
  0xFF, 0x0F, 0xC0, 0x01, 0xFF, 0x83, 0xE0, 0x00, 0x7F, 0xC0, 0xF8, 0x00,
  0x0F, 0xF0, 0x3F, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x01, 0xFE, 0x03, 0xF0,
  0x00, 0xFF, 0xC0, 0x7E, 0x00, 0x7F, 0xF0, 0x1F, 0xE0, 0x7F, 0xFE, 0x03,
  0xFF, 0xFF, 0x9F, 0xC0, 0xFF, 0xFF, 0xC3, 0xF0, 0x1F, 0xFF, 0xC0, 0x7E,
  0x01, 0xFF, 0xE0, 0x1F, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x3E, 0x3E,
  0x3E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0xF8, 0xF0, 0xF0, 0xF0,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x03, 0x00, 0xF0, 0x01,
  0xF0, 0x3C, 0x00, 0x7F, 0x0F, 0x00, 0x1F, 0xF3, 0x80, 0x0F, 0xFF, 0xE0,
  0x3C, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07,
  0xE3, 0xFC, 0x03, 0xFC, 0x00, 0x01, 0xF7, 0x00, 0x00, 0xF9, 0xE0, 0x00,
  0x7C, 0x78, 0x00, 0x7E, 0x0F, 0x00, 0x3F, 0x83, 0xC0, 0x0F, 0xC0, 0xF8,
  0x00, 0xE0, 0x3E, 0x00, 0x10, 0x07, 0xC0, 0x04, 0x01, 0xF0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x07,
  0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x3E,
  0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF8, 0x00, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F,
  0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0x08, 0x3E, 0x7E, 0xFF, 0xFE, 0xFE, 0xFE,
  0xFC, 0x30, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x01, 0xFC, 0x3F, 0x80,
  0x7F, 0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0xFC, 0x00,
  0x7C, 0x1F, 0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x3F,
  0x00, 0x07, 0xC7, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x3F, 0x00, 0x03,
  0xE7, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF7, 0xE0,
  0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x3E,
  0xFC, 0x00, 0x07, 0xDF, 0x80, 0x00, 0xFB, 0xF0, 0x00, 0x3F, 0x7C, 0x00,
  0x07, 0xEF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xE7,
  0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xE3, 0xE0, 0x00,
  0xF8, 0x7C, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE1, 0xF0, 0x01, 0xF8, 0x3F,
  0x00, 0x3E, 0x03, 0xE0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0xE1, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x03,
  0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0x7C,
  0x7F, 0x9F, 0x3F, 0xC7, 0xC7, 0xC3, 0xF0, 0xE0, 0xF8, 0x20, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x7F, 0x80,
  0x0F, 0x00, 0x3F, 0x80, 0x1C, 0x00, 0x3F, 0x00, 0x10, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0x80,
  0x1F, 0xC0, 0x18, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF8, 0x20, 0x00, 0x0F, 0xE0, 0xE0, 0x00, 0x7F, 0x03, 0xF0, 0x07, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xBE, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0xF8, 0x07, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0xF8, 0x01,
  0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x8C, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x30, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x08, 0x00, 0x07, 0xF0, 0x38,
  0x00, 0x3F, 0x80, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFE, 0x02, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x0F, 0xF0, 0x03, 0xF3, 0xFF, 0xC0,
  0x3E, 0x7F, 0xFE, 0x03, 0xEF, 0xFF, 0xF0, 0x7F, 0xF0, 0xFF, 0x07, 0xFC,
  0x03, 0xF0, 0x7F, 0x80, 0x1F, 0x87, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x0F,
  0x8F, 0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0xF8, 0xFC,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x01,
  0xF8, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xFC, 0x00, 0x3F, 0x0F,
  0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x01,
  0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0x03, 0xF8, 0x07,
  0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x01, 0xF0, 0x01, 0xF8, 0x1F, 0x80,
  0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x1F,
  0x81, 0xF0, 0x00, 0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0x7E, 0x00, 0x7E, 0x01,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xFC,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xCF, 0xE0, 0x03,
  0xF8, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80,
  0x07, 0xE0, 0xFE, 0x00, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xC1,
  0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xE0,
  0x7C, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x3F, 0x1F, 0x80,
  0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x3F,
  0x1F, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x3F, 0x1F, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x7E, 0x1F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x1F,
  0xE1, 0xFC, 0x03, 0xFE, 0x0F, 0xE0, 0xFF, 0xC0, 0xFF, 0xFF, 0x7C, 0x07,
  0xFF, 0xE7, 0xC0, 0x3F, 0xFC, 0xFC, 0x00, 0xFF, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xE0, 0x0C, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x1F, 0x81, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0x80, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0xFC, 0x07, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x1C, 0x00, 0x00, 0x1F,
  0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0xF8, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xF0, 0x3F, 0x83, 0x80, 0x3F, 0x04, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x7C,
  0x00, 0x3F, 0x00, 0x3E, 0x1F, 0x00, 0x3F, 0xFE, 0x07, 0xC3, 0xC0, 0x0F,
  0xFF, 0xC0, 0x78, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0x1E, 0x00, 0xFC, 0x1F,
  0x01, 0xE7, 0xC0, 0x3E, 0x03, 0xC0, 0x3C, 0xF8, 0x0F, 0x80, 0x78, 0x07,
  0x9E, 0x03, 0xE0, 0x1F, 0x00, 0xF7, 0xC0, 0x78, 0x03, 0xE0, 0x1E, 0xF0,
  0x1F, 0x00, 0x78, 0x07, 0xDE, 0x03, 0xC0, 0x0F, 0x00, 0xFB, 0xC0, 0x78,
  0x03, 0xE0, 0x1E, 0xF8, 0x1F, 0x00, 0x7C, 0x03, 0xDF, 0x03, 0xC0, 0x0F,
  0x00, 0x7B, 0xC0, 0x78, 0x01, 0xE0, 0x1F, 0x78, 0x0F, 0x00, 0x7C, 0x03,
  0xCF, 0x03, 0xE0, 0x0F, 0x80, 0x79, 0xE0, 0x7C, 0x03, 0xE0, 0x1F, 0x3C,
  0x0F, 0x80, 0x7C, 0x03, 0xC7, 0x81, 0xF0, 0x1F, 0x80, 0xF8, 0xF0, 0x1E,
  0x03, 0xF0, 0x3E, 0x1E, 0x03, 0xE0, 0xEF, 0x0F, 0x83, 0xC0, 0x7F, 0xF9,
  0xFF, 0xE0, 0x78, 0x07, 0xFF, 0x1F, 0xFC, 0x0F, 0x80, 0xFF, 0xC3, 0xFE,
  0x01, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x70,
  0x00, 0x01, 0xFF, 0xC1, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x1F,
  0x78, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x7C,
  0x7C, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF8,
  0x7C, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xF0,
  0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x80,
  0x7C, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x00,
  0x3E, 0x03, 0xF0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00,
  0x3E, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x1F, 0x3F, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xF8, 0x01, 0xFE, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0xF8, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF0, 0x00,
  0x3F, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xF0, 0x00,
  0x7E, 0x03, 0xE0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0xFC, 0x03, 0xE0, 0x00,
  0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0x80, 0x1F, 0xC0, 0x0F, 0x80, 0x07,
  0xE0, 0x0F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x01,
  0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x01,
  0xF0, 0x3F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x03,
  0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F,
  0xE0, 0x7C, 0x00, 0x1F, 0xC0, 0x7C, 0x00, 0x7F, 0xC0, 0x7F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x7F, 0xE0, 0x7C, 0x00, 0xFF, 0x80, 0x0C, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x02,
  0x00, 0x1F, 0xF0, 0x3E, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0E, 0x80,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3E,
  0x00, 0xFF, 0x80, 0x0F, 0x80, 0x0F, 0xF0, 0x03, 0xE0, 0x01, 0xFC, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x01, 0xF8,
  0x07, 0xC0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x00,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xFC,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x1F, 0x83,
  0xE0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00,
  0x7F, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x1F, 0xC0, 0x7E, 0x00,
  0x0F, 0xE0, 0x1F, 0x80, 0x07, 0xF8, 0x07, 0xC0, 0x07, 0xFC, 0x01, 0xF0,
  0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFC, 0x0F, 0xE0, 0x0F, 0xF8, 0x00, 0x78, 0x07, 0xF8, 0x00,
  0x04, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x03, 0xFF, 0xF3, 0xF0, 0x00, 0xFF, 0xF8, 0xFC, 0x00, 0x3F,
  0xFE, 0x3F, 0x00, 0x0F, 0xFF, 0x8F, 0xC0, 0x03, 0xFF, 0xE3, 0xE0, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00, 0xF8, 0x3F,
  0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7C, 0x07, 0xF0, 0x00, 0x1F,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x3F, 0xC0, 0x03, 0xF0, 0x07, 0xFC, 0x07,
  0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00,
  0x7C, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x7C,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x7C, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x7C, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x3F, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x3F, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x0F, 0x80, 0x01, 0xF8, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x1F,
  0xC0, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x3F, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x00, 0xF8, 0x3F, 0x80, 0x00, 0x1F, 0x0F, 0xE0, 0x00,
  0x03, 0xE3, 0xF8, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00, 0x7D, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F,
  0xF3, 0xE0, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3E, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0xFB, 0xC0, 0x00, 0x0F, 0xFE, 0x01, 0xF7, 0x80, 0x00, 0x1F, 0xF8, 0x03,
  0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x0F,
  0xBE, 0x00, 0x03, 0xEF, 0xC0, 0x3E, 0x7C, 0x00, 0x07, 0xDF, 0x80, 0x7C,
  0xF8, 0x00, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x00, 0x7E, 0x7C, 0x01, 0xF3,
  0xE0, 0x00, 0xF8, 0xF8, 0x03, 0xE7, 0xC0, 0x03, 0xF3, 0xF0, 0x0F, 0xC7,
  0x80, 0x07, 0xC7, 0xC0, 0x1F, 0x0F, 0x00, 0x1F, 0x8F, 0x80, 0x3E, 0x1E,
  0x00, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x7C,
  0x01, 0xF0, 0xFC, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x07, 0xC1, 0xF0,
  0x0F, 0x83, 0xE0, 0x0F, 0x83, 0xE0, 0x3E, 0x07, 0xC0, 0x1F, 0x07, 0xC0,
  0x7C, 0x1F, 0x80, 0x7E, 0x0F, 0x81, 0xF0, 0x3F, 0x00, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x01, 0xF0, 0x1E, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x3C, 0x1F,
  0x01, 0xF0, 0x07, 0xC0, 0x78, 0x7C, 0x07, 0xE0, 0x1F, 0x80, 0xF8, 0xF8,
  0x0F, 0xC0, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE7, 0xC0,
  0x3E, 0x00, 0xF8, 0x07, 0xDF, 0x00, 0xFC, 0x01, 0xF0, 0x0F, 0xBE, 0x01,
  0xF8, 0x07, 0xC0, 0x1F, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7F, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7F, 0x80, 0x3F,
  0x00, 0x7C, 0x00, 0xFE, 0x00, 0x7E, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0xF8,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0x00, 0xF8, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x07, 0xF8,
  0x00, 0x03, 0xE0, 0x0F, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0xF0, 0x00, 0x1F,
  0x80, 0x3F, 0xE0, 0x00, 0x3E, 0x00, 0xFF, 0xC0, 0x00, 0x7C, 0x01, 0xFF,
  0xC0, 0x00, 0xF8, 0x03, 0xEF, 0x80, 0x01, 0xF0, 0x07, 0xDF, 0x00, 0x07,
  0xE0, 0x0F, 0xBE, 0x00, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x1F, 0x00, 0x7C,
  0x7C, 0x00, 0x3E, 0x00, 0xF8, 0xF8, 0x00, 0xFC, 0x01, 0xF0, 0xF8, 0x01,
  0xF0, 0x03, 0xE1, 0xF0, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x07, 0xC0, 0x1F,
  0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x3F, 0x00, 0x7C, 0x0F, 0x80,
  0x7C, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x07,
  0xC0, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x0F, 0xC0, 0x1F, 0x00, 0x7C,
  0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x7C, 0x01,
  0xF0, 0x03, 0xF0, 0xF8, 0x03, 0xE0, 0x03, 0xE3, 0xF0, 0x07, 0xC0, 0x07,
  0xC7, 0xC0, 0x1F, 0x80, 0x0F, 0x8F, 0x80, 0x3E, 0x00, 0x0F, 0x9F, 0x00,
  0x7C, 0x00, 0x1F, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0xF8, 0x01, 0xF0, 0x00,
  0x7F, 0xF0, 0x07, 0xE0, 0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x00, 0xFF, 0xC0,
  0x1F, 0x00, 0x01, 0xFF, 0x80, 0x3E, 0x00, 0x01, 0xFE, 0x00, 0x7C, 0x00,
  0x03, 0xFC, 0x01, 0xF0, 0x00, 0x07, 0xF8, 0x03, 0xE0, 0x00, 0x07, 0xF0,
  0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0xFE, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x0F,
  0x87, 0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x0F, 0xBF,
  0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00,
  0x0F, 0xCF, 0x80, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x00, 0x3F, 0x3E, 0x00,
  0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x00, 0x7F, 0x1F,
  0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xE0, 0x03, 0xFE,
  0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x1F, 0xE0,
  0x0F, 0x80, 0x1F, 0xC0, 0x3E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x07,
  0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x7C, 0x0F, 0xC0, 0x01, 0xF0, 0x3F, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x3F, 0x03, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F,
  0x81, 0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xF0, 0x1F, 0x00, 0x7F, 0x80,
  0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x3F, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7C, 0x3F,
  0x00, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x00, 0x0F, 0xBF, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x3E,
  0x7E, 0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x00,
  0x3F, 0x3E, 0x00, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x01, 0xF8, 0xF8, 0x00,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x07, 0xF0,
  0x1F, 0x80, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F,
  0xE0, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x0F, 0xE0, 0x0F,
  0x80, 0x1F, 0xC0, 0x3E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0,
  0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x7C, 0x0F, 0xC0, 0x01, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x81,
  0xF0, 0x01, 0xFC, 0x07, 0xC0, 0x0F, 0xE0, 0x1F, 0x01, 0xFF, 0x80, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x80, 0xF8,
  0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00,
  0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xE0, 0x0F,
  0x80, 0x0F, 0x80, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xC0,
  0x03, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0x0F, 0xE0,
  0x0F, 0xE0, 0x03, 0x80, 0x7F, 0x00, 0x04, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x20, 0x00, 0x1F, 0xC0, 0xE0, 0x00, 0xFE, 0x03, 0xF8,
  0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xF0,
  0x1F, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x80,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xB4, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0x0F, 0xCF, 0x80, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF8,
  0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x1F,
  0x00, 0xFC, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC,
  0x0F, 0x80, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE1,
  0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x1F, 0x1F,
  0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xDF,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0xFF, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF1,
  0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xF8,
  0x7E, 0x00, 0x1E, 0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x78, 0x00, 0xFC,
  0x1F, 0x80, 0x0F, 0x3C, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0x9E, 0x00, 0x3E,
  0x03, 0xE0, 0x07, 0xCF, 0x00, 0x3F, 0x01, 0xF0, 0x07, 0xC7, 0x80, 0x1F,
  0x00, 0xF8, 0x03, 0xE3, 0xC0, 0x1F, 0x80, 0x7C, 0x03, 0xE1, 0xE0, 0x0F,
  0x80, 0x3E, 0x01, 0xF0, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF0, 0x78, 0x07,
  0xE0, 0x0F, 0x80, 0xF8, 0x3C, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x1E, 0x03,
  0xF0, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xF0, 0x01, 0xF0, 0x3E, 0x07, 0x81,
  0xF8, 0x00, 0xF8, 0x3E, 0x03, 0xC0, 0xF8, 0x00, 0x7C, 0x1F, 0x01, 0xE0,
  0x7C, 0x00, 0x3E, 0x0F, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x0F, 0x80, 0x7C,
  0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x3E, 0x3F, 0x00, 0x07, 0xC7, 0xC0, 0x1F,
  0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x01, 0xF3, 0xE0, 0x07,
  0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xF0, 0x01,
  0xF7, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x78, 0x00,
  0x7D, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x1E, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x00, 0x1F, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x3E, 0x00, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x00, 0x0F, 0x8F, 0xC0, 0x00,
  0x00, 0x3E, 0x3E, 0x00, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x00,
  0xFC, 0x7C, 0x00, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x00, 0x1F, 0x83, 0xE0,
  0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7E, 0xFC, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0xFC, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF8,
  0x7C, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x03, 0xE0,
  0x07, 0xC0, 0x3E, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x3E, 0x01, 0xF0,
  0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x1F,
  0x0F, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0xF9, 0xF0,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0x78, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF0,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xC0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x01, 0xF0, 0x3E, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0x8F, 0x80,
  0x00, 0xF8, 0x78, 0x00, 0x0F, 0x07, 0xC0, 0x01, 0xF0, 0x3C, 0x00, 0x1E,
  0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0xF8, 0x00, 0xF0, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x00, 0x78, 0x1F,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x3E, 0x7C, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xF0,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFC, 0x1F, 0x87, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8,
  0x1E, 0x07, 0xC0, 0xF0, 0x00, 0x1F, 0xE0, 0xF8, 0x03, 0xFF, 0x87, 0x80,
  0x3F, 0xFE, 0x3C, 0x03, 0xFF, 0xFB, 0xE0, 0x3F, 0xC7, 0xDF, 0x03, 0xF8,
  0x0F, 0xF8, 0x3F, 0x80, 0x3F, 0x81, 0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x0F,
  0xE0, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x0F, 0x87,
  0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x3F, 0x1F, 0x80,
  0x01, 0xF0, 0xFC, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07,
  0xE1, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x83,
  0xE0, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0xE0, 0xF8, 0x00, 0x7F, 0x07, 0xC0,
  0x07, 0xF0, 0x3E, 0x00, 0x3F, 0x81, 0xF8, 0x03, 0xFC, 0x0F, 0xC0, 0x3F,
  0xE0, 0x7F, 0x07, 0xDE, 0x01, 0xFF, 0xFC, 0xF0, 0x0F, 0xFF, 0xC7, 0x80,
  0x3F, 0xFC, 0x7C, 0x00, 0xFF, 0x83, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xC1, 0xFE, 0x00, 0x3E, 0x3F, 0xF8, 0x01, 0xF3, 0xFF,
  0xE0, 0x0F, 0xBF, 0xFF, 0x80, 0xFB, 0xE1, 0xFC, 0x07, 0xDE, 0x03, 0xF0,
  0x3F, 0xC0, 0x1F, 0x81, 0xFE, 0x00, 0x7C, 0x1F, 0xE0, 0x03, 0xE0, 0xFE,
  0x00, 0x1F, 0x07, 0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x07, 0xC1, 0xF8, 0x00,
  0x3E, 0x1F, 0x80, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xFC,
  0x3E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF0, 0xF8,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xE1, 0xF0, 0x00,
  0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF8,
  0x3F, 0x00, 0x1F, 0x83, 0xFC, 0x00, 0xFC, 0x1F, 0xE0, 0x0F, 0xC0, 0xFF,
  0xC1, 0xFC, 0x07, 0xDF, 0xFF, 0xE0, 0x3C, 0x7F, 0xFE, 0x03, 0xE3, 0xFF,
  0xC0, 0x1E, 0x07, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xC1, 0xC0,
  0xFE, 0x00, 0x83, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x04, 0x0F, 0xE0, 0x38, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0xC3, 0xF0, 0x00, 0x7F, 0xF1, 0xF0, 0x00, 0xFF, 0xFC, 0xF8,
  0x00, 0xFF, 0xFF, 0x7C, 0x00, 0x7F, 0x0F, 0xBE, 0x00, 0x7F, 0x01, 0xFF,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x01,
  0xF0, 0x0F, 0xC0, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xE0, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x07, 0xE0, 0x1F, 0x00,
  0x03, 0xE0, 0x0F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xE0,
  0x01, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x7C,
  0x00, 0xFF, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x1F, 0x80, 0xF7, 0xC0, 0x0F,
  0xE0, 0xFB, 0xC0, 0x03, 0xFF, 0xFB, 0xE0, 0x01, 0xFF, 0xF9, 0xF0, 0x00,
  0x7F, 0xF8, 0xF8, 0x00, 0x1F, 0xF0, 0x7C, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x1F, 0xC3, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0x3E, 0x1F,
  0x80, 0x1F, 0x0F, 0xC0, 0x0F, 0x8F, 0xC0, 0x07, 0xC7, 0xC0, 0x07, 0xE7,
  0xE0, 0x03, 0xE3, 0xF0, 0x07, 0xF1, 0xF0, 0x07, 0xF1, 0xF8, 0x3F, 0xF0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x01, 0x81, 0xFC, 0x03, 0xC0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x60,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x37, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x1F, 0x00, 0x0F, 0xFE, 0x1E, 0x00, 0x3F, 0xFF, 0x1E, 0x00,
  0x7F, 0xFF, 0xBE, 0x00, 0x7F, 0x0F, 0xBE, 0x00, 0xFE, 0x03, 0xFE, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xFC, 0x03, 0xF0, 0x01, 0xFC, 0x07,
  0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xC0, 0x01, 0xF8, 0x0F,
  0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0x80, 0x01, 0xF8, 0x1F,
  0x80, 0x01, 0xF0, 0x1F, 0x80, 0x01, 0xF0, 0x1F, 0x80, 0x01, 0xF0, 0x1F,
  0x00, 0x03, 0xF0, 0x1F, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x1F,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xE0, 0x3F,
  0x00, 0x0F, 0xE0, 0x1F, 0x00, 0x1F, 0xC0, 0x1F, 0x00, 0x3F, 0xC0, 0x1F,
  0x80, 0x7F, 0xC0, 0x1F, 0x80, 0xF7, 0xC0, 0x1F, 0xC1, 0xFF, 0x80, 0x0F,
  0xFF, 0xEF, 0x80, 0x0F, 0xFF, 0xCF, 0x80, 0x07, 0xFF, 0x8F, 0x80, 0x03,
  0xFE, 0x1F, 0x80, 0x00, 0x30, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x80,
  0x00, 0xFC, 0x00, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x3F, 0xF8, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC1, 0xFE, 0x00, 0x3E, 0x3F,
  0xFC, 0x01, 0xF3, 0xFF, 0xE0, 0x0F, 0xBF, 0xFF, 0x80, 0xFB, 0xF1, 0xFC,
  0x07, 0xFE, 0x03, 0xF0, 0x3F, 0xC0, 0x1F, 0x81, 0xFC, 0x00, 0xFC, 0x0F,
  0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF0, 0x3F, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x03, 0xE0, 0xFC, 0x00, 0x3F,
  0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x1F,
  0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x3F,
  0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x1F,
  0x80, 0x07, 0xE0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00,
  0x0F, 0x83, 0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0xCF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x3E, 0x00,
  0x7E, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x7E, 0x00, 0xFC, 0x07, 0xE0,
  0x07, 0xC0, 0x7F, 0x00, 0x3E, 0x03, 0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3E, 0x3F,
  0x00, 0x01, 0xF3, 0xF0, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0xFB, 0xF0, 0x00,
  0x07, 0xDF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0x3E, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x3E, 0x0F,
  0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xF8, 0x0F, 0xC0,
  0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0xF8, 0x01, 0xF8, 0x07, 0xC0, 0x0F, 0xC0, 0x3E, 0x00,
  0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x7F,
  0x80, 0x3F, 0xC0, 0x0F, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x78, 0xFF, 0xF8,
  0x7F, 0xFC, 0x03, 0xCF, 0xFF, 0xC7, 0xFF, 0xF0, 0x3E, 0xF8, 0x7E, 0x7C,
  0x3F, 0x81, 0xFF, 0x01, 0xFF, 0x80, 0xFC, 0x0F, 0xF0, 0x0F, 0xF8, 0x03,
  0xE0, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xF8,
  0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xC1, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x87, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x80,
  0x07, 0xC1, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xF0, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC1, 0xF0, 0x00,
  0xFC, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x0F, 0x83, 0xFC, 0x00, 0x7C, 0x7F, 0xF8, 0x03, 0xC7, 0xFF, 0xE0,
  0x3E, 0x7F, 0xFF, 0x01, 0xF7, 0xF3, 0xFC, 0x0F, 0xFC, 0x0F, 0xE0, 0x7F,
  0xC0, 0x3F, 0x03, 0xFC, 0x01, 0xF8, 0x3F, 0xC0, 0x0F, 0xC1, 0xFC, 0x00,
  0x7E, 0x0F, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x07, 0xF0, 0x00, 0xF8,
  0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7C,
  0x00, 0x1F, 0x07, 0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x7E, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF8,
  0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xE0, 0x7C,
  0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0x7E, 0x0F, 0x80, 0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF8,
  0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xF8, 0x7F, 0x81, 0xF8, 0x07, 0xE0,
  0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xCF, 0xC0, 0x01,
  0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x7E, 0x00, 0x07, 0xDF, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F,
  0xBE, 0x00, 0x07, 0xEF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x7C, 0xF8, 0x00,
  0x3F, 0x3E, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF0, 0x7E,
  0x01, 0xF8, 0x1F, 0xC1, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x3E,
  0x0F, 0xF0, 0x00, 0x3E, 0x1F, 0xF8, 0x00, 0x3C, 0x7F, 0xFC, 0x00, 0x3C,
  0xFF, 0xFE, 0x00, 0x7D, 0xF0, 0xFE, 0x00, 0x7D, 0xE0, 0x3F, 0x00, 0x7F,
  0x80, 0x3F, 0x00, 0x7F, 0x80, 0x1F, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0xFE,
  0x00, 0x1F, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0xFC,
  0x00, 0x1F, 0x01, 0xF8, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7E, 0x03, 0xE0,
  0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0xF8, 0x07, 0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xF0,
  0x03, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x0F, 0xFC, 0x1F, 0xC0, 0x0F, 0xBF,
  0xFF, 0xC0, 0x0F, 0x9F, 0xFF, 0x80, 0x1F, 0x9F, 0xFE, 0x00, 0x1F, 0x87,
  0xFC, 0x00, 0x1F, 0x00, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x7C, 0x00, 0xFF, 0xE1, 0xE0, 0x07, 0xFF,
  0xC7, 0x80, 0x3F, 0xFF, 0xBE, 0x01, 0xFC, 0x3E, 0xF8, 0x0F, 0xE0, 0x3F,
  0xE0, 0x7F, 0x00, 0x7F, 0x01, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xF0,
  0x3E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x3F,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x7E, 0x1F, 0x80,
  0x01, 0xF0, 0x7E, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0xFC, 0x1F, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7E,
  0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x81,
  0xF0, 0x01, 0xFC, 0x07, 0xC0, 0x0F, 0xF0, 0x1F, 0x80, 0x7F, 0xC0, 0x7E,
  0x03, 0xDF, 0x01, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0xFB, 0xE0, 0x0F, 0xFF,
  0xCF, 0x80, 0x1F, 0xFE, 0x3E, 0x00, 0x3F, 0xE1, 0xF8, 0x00, 0x0C, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x7F, 0x01, 0xE1, 0xFE,
  0x01, 0xE3, 0xFE, 0x01, 0xE7, 0xFE, 0x03, 0xEF, 0xFC, 0x03, 0xEF, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x07, 0xF0, 0x3E, 0x07, 0xE0, 0x04, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0xC0, 0x07, 0xF0, 0xF0, 0x0F, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x3F, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF8, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x10, 0x3F, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x7C, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0x80,
  0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE1, 0xF8, 0x00, 0x3E,
  0x1F, 0x80, 0x07, 0xE1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x7C, 0x3F, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF8, 0x7C,
  0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0xC0, 0x03,
  0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x7E, 0x0F,
  0x80, 0x0F, 0xE0, 0xF8, 0x01, 0xFE, 0x0F, 0x80, 0x3F, 0xE0, 0xFC, 0x07,
  0xFC, 0x0F, 0xE0, 0xF7, 0xC0, 0xFF, 0xFF, 0x7C, 0x07, 0xFF, 0xE7, 0xC0,
  0x3F, 0xF8, 0x7C, 0x01, 0xFF, 0x07, 0x80, 0x03, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x7E,
  0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0xC7, 0xC0, 0x03, 0xE1, 0xF0, 0x01,
  0xF8, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x3F, 0x07, 0xC0, 0x0F, 0x81, 0xF0,
  0x07, 0xE0, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x1F, 0x80, 0x3E, 0x07, 0xC0, 0x0F, 0x83, 0xF0, 0x03, 0xE0, 0xF8,
  0x00, 0xF8, 0x7E, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xE3,
  0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x00, 0xFE, 0x00, 0x3E,
  0xF8, 0x00, 0xFE, 0x00, 0x3E, 0xF8, 0x01, 0xFE, 0x00, 0x7E, 0xF8, 0x01,
  0xFE, 0x00, 0x7C, 0xF8, 0x03, 0xFE, 0x00, 0xFC, 0xF8, 0x03, 0xDE, 0x00,
  0xF8, 0xF8, 0x03, 0xDE, 0x01, 0xF8, 0xF8, 0x07, 0xDE, 0x01, 0xF0, 0xF8,
  0x07, 0x9E, 0x01, 0xF0, 0xF8, 0x0F, 0xBE, 0x03, 0xF0, 0xF8, 0x0F, 0x3E,
  0x03, 0xE0, 0xF8, 0x1F, 0x1E, 0x07, 0xE0, 0xF8, 0x1E, 0x1E, 0x07, 0xC0,
  0xF8, 0x1E, 0x1E, 0x0F, 0xC0, 0xF8, 0x3E, 0x1E, 0x0F, 0x80, 0xF8, 0x3C,
  0x1E, 0x0F, 0x80, 0xF8, 0x7C, 0x1E, 0x1F, 0x00, 0xF8, 0x78, 0x1E, 0x1F,
  0x00, 0xF8, 0xF8, 0x1E, 0x3F, 0x00, 0xF8, 0xF0, 0x1E, 0x3E, 0x00, 0xF9,
  0xF0, 0x1E, 0x3E, 0x00, 0xF9, 0xF0, 0x1E, 0x7C, 0x00, 0xF9, 0xE0, 0x1E,
  0x7C, 0x00, 0xFB, 0xE0, 0x1E, 0xF8, 0x00, 0xFB, 0xC0, 0x1E, 0xF8, 0x00,
  0xFF, 0xC0, 0x1E, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x3E, 0x03, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0x0F, 0xBF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7E, 0xF8, 0x00,
  0x00, 0xFC, 0x7C, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x03, 0xF0, 0x3E, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x3F, 0x00,
  0x0F, 0xC0, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x0F, 0x80, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00,
  0x0F, 0x1F, 0x00, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x00, 0x0F, 0x3E, 0x00,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xC7, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x2F, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xA0, 0x00, 0xFF, 0xE4, 0x00, 0x03, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Italic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 16, 46, 16, 1, -45 },
  { 93, 18, 16, 23, 7, -45 },
  { 129, 35, 45, 36, 1, -45 },
  { 326, 29, 52, 31, 1, -48 },
  { 515, 39, 47, 46, 4, -46 },
  { 745, 34, 47, 37, 1, -46 },
  { 945, 8, 16, 13, 7, -45 },
  { 961, 20, 55, 18, 2, -45 },
  { 1099, 20, 55, 18, -5, -45 },
  { 1237, 26, 26, 30, 6, -48 },
  { 1322, 27, 30, 33, 4, -37 },
  { 1424, 12, 15, 15, -3, -7 },
  { 1447, 16, 5, 18, 1, -19 },
  { 1457, 8, 9, 15, 1, -8 },
  { 1466, 30, 45, 22, -3, -45 },
  { 1635, 27, 47, 31, 3, -46 },
  { 1794, 18, 45, 31, 8, -45 },
  { 1896, 31, 46, 31, -1, -46 },
  { 2075, 30, 47, 31, 0, -46 },
  { 2252, 30, 45, 31, 0, -45 },
  { 2421, 30, 46, 31, 1, -45 },
  { 2594, 28, 47, 31, 3, -46 },
  { 2759, 28, 45, 31, 4, -45 },
  { 2917, 29, 47, 31, 2, -46 },
  { 3088, 28, 47, 31, 2, -46 },
  { 3253, 13, 35, 15, 1, -34 },
  { 3310, 17, 42, 15, -3, -34 },
  { 3400, 27, 30, 33, 4, -38 },
  { 3502, 27, 17, 33, 4, -31 },
  { 3560, 27, 30, 33, 4, -38 },
  { 3662, 23, 47, 24, 3, -46 },
  { 3798, 43, 51, 47, 3, -45 },
  { 4073, 32, 45, 32, -4, -45 },
  { 4253, 32, 45, 34, 2, -45 },
  { 4433, 32, 47, 32, 4, -46 },
  { 4621, 34, 45, 37, 2, -45 },
  { 4813, 30, 45, 29, 2, -45 },
  { 4982, 30, 45, 27, 2, -45 },
  { 5151, 34, 47, 38, 4, -46 },
  { 5351, 37, 45, 38, 2, -45 },
  { 5560, 25, 45, 19, -2, -45 },
  { 5701, 27, 57, 16, -10, -45 },
  { 5894, 35, 45, 32, 2, -45 },
  { 6091, 21, 45, 27, 2, -45 },
  { 6210, 47, 45, 49, 2, -45 },
  { 6475, 39, 45, 40, 2, -45 },
  { 6695, 35, 47, 40, 4, -46 },
  { 6901, 30, 45, 32, 2, -45 },
  { 7070, 35, 57, 40, 4, -46 },
  { 7320, 30, 45, 33, 2, -45 },
  { 7489, 30, 47, 29, 0, -46 },
  { 7666, 28, 45, 28, 5, -45 },
  { 7824, 35, 46, 38, 4, -45 },
  { 8026, 31, 45, 31, 6, -45 },
  { 8201, 49, 45, 49, 6, -45 },
  { 8477, 38, 45, 30, -3, -45 },
  { 8691, 28, 45, 29, 6, -45 },
  { 8849, 33, 45, 29, -1, -45 },
  { 9035, 24, 55, 18, -1, -45 },
  { 9200, 11, 45, 22, 7, -45 },
  { 9262, 23, 55, 18, -4, -45 },
  { 9421, 28, 27, 32, 2, -45 },
  { 9516, 24, 5, 23, -6, 5 },
  { 9531, 10, 10, 17, 9, -48 },
  { 9544, 29, 35, 32, 3, -34 },
  { 9671, 29, 49, 33, 1, -48 },
  { 9849, 23, 35, 25, 3, -34 },
  { 9950, 33, 49, 33, 2, -48 },
  { 10153, 25, 35, 29, 2, -34 },
  { 10263, 33, 63, 18, -7, -48 },
  { 10523, 32, 49, 33, 0, -34 },
  { 10719, 29, 48, 33, 1, -48 },
  { 10893, 15, 46, 15, 1, -46 },
  { 10980, 24, 61, 15, -8, -46 },
  { 11163, 29, 48, 28, 1, -48 },
  { 11337, 16, 48, 15, 1, -48 },
  { 11433, 45, 34, 49, 1, -34 },
  { 11625, 29, 35, 33, 1, -35 },
  { 11752, 26, 35, 32, 3, -34 },
  { 11866, 32, 49, 33, -2, -34 },
  { 12062, 30, 49, 33, 2, -34 },
  { 12246, 24, 34, 22, 1, -34 },
  { 12348, 24, 35, 25, 0, -34 },
  { 12453, 18, 42, 19, 3, -41 },
  { 12548, 28, 35, 33, 3, -34 },
  { 12671, 26, 34, 26, 3, -34 },
  { 12782, 40, 34, 41, 4, -34 },
  { 12952, 32, 34, 27, -3, -34 },
  { 13088, 36, 49, 26, -6, -34 },
  { 13309, 26, 34, 24, -1, -34 },
  { 13420, 24, 55, 22, 1, -45 },
  { 13585, 4, 63, 30, 14, -48 },
  { 13617, 24, 55, 22, -3, -45 },
  { 13782, 27, 8, 33, 4, -26 },
};

const GFXfont NotoSans_SemiCondensed_Italic63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic63pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC63PT7B_H_
