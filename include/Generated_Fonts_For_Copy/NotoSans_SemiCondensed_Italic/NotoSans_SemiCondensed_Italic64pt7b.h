#ifndef _NOTOSANS_SEMICONDENSED_ITALIC64PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC64PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x30, 0x00, 0x3F,
  0x07, 0xE7, 0xE1, 0xF8, 0xF8, 0x3F, 0x1F, 0x07, 0xE3, 0xE0, 0xF8, 0xFC,
  0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x1F, 0x0F, 0x03, 0xE1, 0xE0,
  0x7C, 0x7C, 0x0F, 0x0F, 0x81, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x81,
  0xE0, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0x3E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x00, 0x78, 0x07, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x7C,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00,
  0x78, 0x07, 0x80, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xBF,
  0x80, 0x7F, 0x1C, 0x1C, 0x01, 0xF0, 0x70, 0x10, 0x0F, 0xC3, 0xC0, 0x00,
  0x3E, 0x0F, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x0F,
  0x83, 0x80, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x03, 0xF1,
  0xC0, 0x00, 0x07, 0xE7, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1E, 0xFE, 0x00,
  0x00, 0x71, 0xF8, 0x00, 0x01, 0xC3, 0xE0, 0x00, 0x0F, 0x0F, 0xC0, 0x00,
  0x3C, 0x3F, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x03, 0x83, 0xF0, 0x00, 0x1E,
  0x0F, 0x80, 0x00, 0x78, 0x3E, 0x08, 0x01, 0xE1, 0xF8, 0x18, 0x07, 0x0F,
  0xC0, 0x78, 0x1C, 0x7F, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0x80, 0x00, 0xF8,
  0x03, 0xFF, 0x80, 0x01, 0xF0, 0x07, 0xFF, 0xC0, 0x01, 0xE0, 0x0F, 0x87,
  0xC0, 0x03, 0xE0, 0x0F, 0x03, 0xC0, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x07,
  0xC0, 0x1E, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0x3C,
  0x03, 0xE0, 0x1F, 0x00, 0x3C, 0x03, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xC0,
  0x3C, 0x00, 0x7C, 0x03, 0xC0, 0x7C, 0x00, 0x78, 0x03, 0xC0, 0xF8, 0x00,
  0x78, 0x07, 0xC0, 0xF0, 0x00, 0x78, 0x07, 0xC1, 0xF0, 0x00, 0x78, 0x07,
  0x83, 0xE0, 0x00, 0xF8, 0x07, 0x83, 0xC0, 0x00, 0xF8, 0x0F, 0x87, 0xC3,
  0xF0, 0xF8, 0x0F, 0x0F, 0x87, 0xFC, 0xF8, 0x0F, 0x0F, 0x1F, 0xFE, 0xF8,
  0x1F, 0x1F, 0x1F, 0xFE, 0x78, 0x3E, 0x3E, 0x3E, 0x3F, 0x7C, 0x7E, 0x3C,
  0x7C, 0x1F, 0x7F, 0xFC, 0x7C, 0x78, 0x0F, 0x3F, 0xF8, 0xF8, 0xF8, 0x0F,
  0x3F, 0xF0, 0xF0, 0xF0, 0x0F, 0x0F, 0xE1, 0xF1, 0xF0, 0x0F, 0x00, 0x03,
  0xE1, 0xF0, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x1F, 0x00, 0x07, 0xC1, 0xE0,
  0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x1F, 0x00, 0x0F, 0x03, 0xE0, 0x1E, 0x00,
  0x1F, 0x03, 0xE0, 0x1E, 0x00, 0x3E, 0x03, 0xC0, 0x3E, 0x00, 0x3C, 0x03,
  0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xC0, 0x3C, 0x00, 0xF8, 0x03, 0xC0, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x78, 0x03, 0xE0,
  0x03, 0xC0, 0xF8, 0x03, 0xC0, 0x03, 0xE1, 0xF0, 0x07, 0xC0, 0x03, 0xF7,
  0xE0, 0x0F, 0x80, 0x01, 0xFF, 0xE0, 0x0F, 0x00, 0x01, 0xFF, 0xC0, 0x1F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x7E, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x3F, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3E, 0x3F, 0x80, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFB, 0xE0, 0x07, 0xE0, 0xFE,
  0x7E, 0x00, 0xF8, 0x3F, 0x07, 0xE0, 0x1F, 0x0F, 0xC0, 0xFC, 0x07, 0xE3,
  0xF0, 0x0F, 0xC0, 0xF8, 0x7C, 0x01, 0xF8, 0x3F, 0x1F, 0x80, 0x1F, 0x87,
  0xC3, 0xE0, 0x01, 0xF1, 0xF8, 0x7C, 0x00, 0x3F, 0x7E, 0x1F, 0x80, 0x03,
  0xFF, 0x83, 0xF0, 0x00, 0x7F, 0xF0, 0x7E, 0x00, 0x07, 0xFC, 0x0F, 0xC0,
  0x00, 0xFF, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xFC, 0x07,
  0xE0, 0x01, 0xFF, 0x80, 0x7E, 0x00, 0x7F, 0xF8, 0x0F, 0xF0, 0x3F, 0xFF,
  0x00, 0xFF, 0xFF, 0xF3, 0xF0, 0x0F, 0xFF, 0xF8, 0x7F, 0x00, 0xFF, 0xFE,
  0x07, 0xE0, 0x0F, 0xFF, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F,
  0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0xF8,
  0xF0, 0xF0, 0xF0, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xE0, 0x02, 0x00, 0xF8, 0x00, 0xE0, 0x3C, 0x00, 0x7E, 0x0F,
  0x00, 0x1F, 0xE3, 0xC0, 0x0F, 0xFE, 0xE0, 0x00, 0xFF, 0xFB, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFC, 0x01,
  0x01, 0xF7, 0x80, 0x00, 0xFD, 0xE0, 0x00, 0x7E, 0x7C, 0x00, 0x3F, 0x0F,
  0x00, 0x1F, 0x83, 0xE0, 0x0F, 0xE0, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x38,
  0x07, 0xC0, 0x04, 0x01, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x3F,
  0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x01, 0xF0,
  0x3E, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF8, 0x00, 0x7F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0x08, 0x3E, 0x7F, 0xFF, 0xFF, 0xFE,
  0xFE, 0x7C, 0x30, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xBF, 0xC0, 0x1F, 0xC0, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x3E,
  0x03, 0xF0, 0x03, 0xE0, 0x7E, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xF0, 0xFC,
  0x00, 0x3F, 0x0F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03,
  0xF1, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x3E,
  0x00, 0x03, 0xE7, 0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x03, 0xE7, 0xE0, 0x00,
  0x3E, 0x7C, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7E, 0x7C, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x7C, 0xFC, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0xFC, 0xF8, 0x00,
  0x0F, 0xCF, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF8,
  0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x3F, 0x0F, 0x80,
  0x03, 0xE0, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC,
  0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x03, 0xFC,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF8, 0x7F, 0xBE, 0x3F,
  0xDF, 0xBF, 0xE7, 0xC7, 0xE1, 0xF1, 0xF0, 0xFC, 0x30, 0x3F, 0x08, 0x0F,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x3E, 0x00,
  0xFE, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0x10, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0x1F, 0xF0,
  0x03, 0xE0, 0x0F, 0xE0, 0x0E, 0x00, 0x1F, 0x80, 0x10, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x20, 0x00, 0x1F, 0xC0, 0xC0,
  0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0xFC, 0x0F, 0x80, 0x01, 0xF0, 0x3F, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x7E, 0x01, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x03,
  0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0xFC,
  0x00, 0x7C, 0x01, 0xF0, 0x01, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00,
  0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x3F, 0xBF, 0xF8, 0x00, 0x40, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF8, 0x20, 0x00, 0x1F, 0xC0, 0xE0, 0x00, 0xFE, 0x03, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0E, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x01, 0xFF, 0xC7, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xF8, 0x1F, 0x00, 0x0F, 0xC7, 0xFE, 0x00, 0x7E, 0x7F, 0xFC, 0x03, 0xE7,
  0xFF, 0xF0, 0x1F, 0x7F, 0xFF, 0x81, 0xFF, 0x80, 0xFE, 0x0F, 0xF8, 0x03,
  0xF0, 0x7F, 0x80, 0x1F, 0x83, 0xF8, 0x00, 0x7C, 0x1F, 0x80, 0x03, 0xF1,
  0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x7C, 0x3E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF0,
  0x7E, 0x00, 0x1F, 0x81, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7F,
  0x01, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xE0,
  0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x1F, 0x80, 0x07,
  0xC0, 0xFC, 0x00, 0x3E, 0x07, 0xE0, 0x01, 0xF0, 0x3F, 0x00, 0x0F, 0x81,
  0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x07, 0xF0,
  0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC7,
  0xC0, 0x00, 0x7E, 0x3E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x1F, 0x8F, 0x80,
  0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x07,
  0xE0, 0x7E, 0x00, 0x7F, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0x3F, 0xE0, 0x1F, 0x80, 0x7E,
  0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0xFC,
  0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x1F, 0x80, 0x01,
  0xF1, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x1F,
  0x00, 0x03, 0xF1, 0xF0, 0x00, 0x3F, 0x1F, 0x00, 0x03, 0xF1, 0xF0, 0x00,
  0x7F, 0x1F, 0x80, 0x07, 0xF1, 0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0xE0,
  0xFC, 0x03, 0xFE, 0x0F, 0xFB, 0xFB, 0xE0, 0x7F, 0xFF, 0x7E, 0x03, 0xFF,
  0xE7, 0xC0, 0x1F, 0xFC, 0x7C, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xF0, 0x0E, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x1F, 0x80, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x07, 0xE0, 0x3F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFE,
  0x7F, 0xC1, 0xE0, 0x1F, 0xC2, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x7C, 0x00, 0x7F, 0xE0, 0x1E, 0x0F, 0x80, 0x1F, 0xFF,
  0x81, 0xF0, 0xF0, 0x03, 0xFF, 0xF8, 0x1F, 0x1F, 0x00, 0xFF, 0x7F, 0x01,
  0xF1, 0xE0, 0x0F, 0x80, 0xF0, 0x1F, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xF3,
  0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x3C, 0x07, 0xC0, 0x1E, 0x01, 0xF7, 0xC0,
  0x7C, 0x01, 0xE0, 0x1F, 0x78, 0x0F, 0x80, 0x3E, 0x01, 0xE7, 0x80, 0xF8,
  0x03, 0xE0, 0x1E, 0x78, 0x0F, 0x00, 0x3C, 0x01, 0xEF, 0x81, 0xF0, 0x07,
  0xC0, 0x3E, 0xF8, 0x1F, 0x00, 0x7C, 0x03, 0xEF, 0x01, 0xE0, 0x07, 0xC0,
  0x3C, 0xF0, 0x1E, 0x00, 0x78, 0x03, 0xCF, 0x01, 0xE0, 0x0F, 0x80, 0x7C,
  0xF0, 0x1E, 0x00, 0xF8, 0x07, 0x8F, 0x01, 0xE0, 0x1F, 0x80, 0xF8, 0xF0,
  0x1E, 0x01, 0xF8, 0x1F, 0x0F, 0x01, 0xF0, 0x3F, 0x81, 0xF0, 0xF0, 0x1F,
  0x07, 0x7C, 0x3E, 0x0F, 0x01, 0xFF, 0xF3, 0xFF, 0xC0, 0xF8, 0x0F, 0xFE,
  0x3F, 0xF8, 0x0F, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0xF8, 0x03, 0xF0, 0x0F,
  0xC0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x40, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xF0,
  0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00,
  0x1F, 0x7C, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x01, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xC0,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x1F,
  0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFE, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF0, 0x7E, 0x00,
  0x00, 0xF8, 0x3F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x3E, 0x1F, 0x80,
  0x00, 0x1F, 0x1F, 0x80, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x07, 0xCF, 0xC0,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x01, 0xFE, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3F, 0x01,
  0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3E, 0x03,
  0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0xFC, 0x07,
  0xE0, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F,
  0xC0, 0xFF, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0x80, 0x07, 0xF0, 0x0F,
  0x80, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F,
  0x00, 0x01, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xF0, 0x3E,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x1F, 0xE0, 0x7C, 0x00, 0x7F, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x7F, 0xC0, 0x0E, 0x00, 0xFF, 0x00, 0x04, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0x00, 0x1F,
  0xF0, 0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x01, 0xFF,
  0x80, 0x0F, 0xC0, 0x0F, 0xF0, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0xF8, 0x00,
  0x3F, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x01, 0xFC, 0x07, 0xC0,
  0x00, 0x3F, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xE0, 0x00,
  0x07, 0xE0, 0xF8, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x03, 0xF0, 0x7C,
  0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0xF8, 0x00, 0x0F, 0xE0, 0x3E, 0x00, 0x03, 0xF8,
  0x1F, 0x80, 0x03, 0xFC, 0x07, 0xE0, 0x01, 0xFE, 0x01, 0xF0, 0x01, 0xFF,
  0x00, 0x7C, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x02, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0x80, 0x0F, 0x00, 0x3F, 0xC0, 0x00, 0x60, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x07, 0xFF, 0xC7, 0xE0, 0x00, 0xFF, 0xF8, 0xFC, 0x00,
  0x3F, 0xFF, 0x1F, 0x80, 0x07, 0xFF, 0xC3, 0xF0, 0x00, 0xFF, 0xF8, 0x7E,
  0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xE0, 0x7E, 0x00,
  0x00, 0x7C, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x1F,
  0xC0, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x3F, 0xC0, 0x01, 0xF0,
  0x03, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x1F, 0xC0,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x00, 0xF8,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00,
  0x1F, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x03, 0xE1,
  0xFC, 0x00, 0x00, 0x3E, 0x3F, 0x80, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x7D, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFB,
  0xE0, 0x00, 0x00, 0xFF, 0x3F, 0x00, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x00,
  0xFC, 0x1F, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0xF7, 0xC0, 0x00, 0x1F, 0xFC, 0x01, 0xF7, 0xC0, 0x00,
  0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x00, 0x3F, 0xFC, 0x01, 0xF7, 0xC0, 0x00,
  0x3E, 0xFC, 0x01, 0xF7, 0xC0, 0x00, 0x7C, 0xF8, 0x03, 0xF7, 0xC0, 0x00,
  0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xC0, 0x00,
  0xF9, 0xF8, 0x03, 0xE3, 0xC0, 0x01, 0xF1, 0xF8, 0x03, 0xE3, 0xE0, 0x01,
  0xF1, 0xF0, 0x07, 0xE3, 0xE0, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x03,
  0xE3, 0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xF0, 0x07, 0xC3, 0xE0, 0x07,
  0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x0F, 0x83, 0xE0, 0x0F, 0xC3, 0xE0, 0x0F,
  0x83, 0xE0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xE0, 0x0F, 0x83, 0xE0, 0x1F,
  0x07, 0xE0, 0x0F, 0x81, 0xE0, 0x3E, 0x07, 0xC0, 0x1F, 0x81, 0xE0, 0x3E,
  0x07, 0xC0, 0x1F, 0x81, 0xF0, 0x7C, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x7C,
  0x0F, 0xC0, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0xC0, 0x1F, 0x01, 0xF0, 0xF8,
  0x0F, 0x80, 0x3F, 0x01, 0xF1, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF1, 0xF0,
  0x1F, 0x80, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x80, 0x3E, 0x01, 0xF3, 0xE0,
  0x1F, 0x80, 0x3E, 0x01, 0xF7, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF7, 0xC0,
  0x1F, 0x00, 0x7C, 0x00, 0xFF, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xFF, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFF, 0x00,
  0x3E, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0xFE, 0x00, 0x00, 0x7C,
  0x01, 0xFC, 0x00, 0x00, 0xF8, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xF8,
  0x00, 0x07, 0xE0, 0x1F, 0xF0, 0x00, 0x0F, 0x80, 0x3F, 0xE0, 0x00, 0x1F,
  0x00, 0x7F, 0xC0, 0x00, 0x3E, 0x00, 0xF7, 0xC0, 0x00, 0xFC, 0x03, 0xEF,
  0x80, 0x01, 0xF0, 0x07, 0xDF, 0x00, 0x03, 0xE0, 0x0F, 0xBF, 0x00, 0x07,
  0xC0, 0x1F, 0x3E, 0x00, 0x0F, 0x80, 0x7E, 0x7C, 0x00, 0x3F, 0x00, 0xF8,
  0xFC, 0x00, 0x7C, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x03, 0xE1, 0xF0, 0x01,
  0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xE0, 0x1F, 0x83, 0xE0, 0x0F, 0xC0, 0x3E,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x1F, 0x80,
  0x7C, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x0F,
  0x80, 0x7E, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x1F, 0x00, 0xFC, 0x01, 0xF0, 0x7E, 0x01, 0xF8, 0x01, 0xF0, 0xF8, 0x03,
  0xE0, 0x03, 0xE1, 0xF0, 0x07, 0xC0, 0x07, 0xC3, 0xE0, 0x0F, 0x80, 0x0F,
  0xC7, 0xC0, 0x3F, 0x00, 0x0F, 0x9F, 0x80, 0x7C, 0x00, 0x1F, 0x3E, 0x00,
  0xF8, 0x00, 0x3F, 0x7C, 0x01, 0xF0, 0x00, 0x3E, 0xF8, 0x03, 0xE0, 0x00,
  0x7D, 0xF0, 0x0F, 0xC0, 0x00, 0xFB, 0xE0, 0x1F, 0x00, 0x01, 0xFF, 0x80,
  0x3E, 0x00, 0x01, 0xFF, 0x00, 0x7C, 0x00, 0x03, 0xFE, 0x00, 0xF8, 0x00,
  0x07, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0xE0,
  0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x03, 0xFF,
  0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0xFF,
  0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x03, 0xF0,
  0x1F, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF8, 0x1F,
  0x80, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x80, 0xF8,
  0x00, 0xFE, 0x01, 0xF0, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xDF, 0x80, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0xC0,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x03,
  0xFF, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0xFF, 0x80, 0x3F, 0x00,
  0x7F, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x03, 0xF0, 0x1F, 0x00, 0x07,
  0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0xFC, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0,
  0x3F, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x7F, 0x00, 0xF8, 0x03, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x01, 0xF8,
  0x0F, 0x80, 0x03, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x0F, 0x80,
  0x7E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x07,
  0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x1F,
  0x80, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E,
  0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F, 0x00, 0x7F, 0x00, 0x06,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x40, 0x00, 0x3F, 0x80, 0xF0, 0x00, 0xFF, 0x01,
  0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x40, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3E, 0x00,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0x7C, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0xFC, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x01, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x1F,
  0x80, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x3F,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x3E,
  0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0xFC, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x07, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF0, 0xFC,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0x7C,
  0x00, 0x1F, 0x80, 0x7C, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x3F, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3E,
  0x07, 0xE0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E,
  0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3E,
  0x7E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xDF, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xF1,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xF8,
  0x7C, 0x00, 0x1F, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0xF8, 0x00, 0x7C,
  0x1F, 0x00, 0x0F, 0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xBE, 0x00, 0x3F,
  0x07, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x03, 0xE0, 0x07, 0xCF, 0x80, 0x1F,
  0x81, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x80, 0xF8, 0x03, 0xE3, 0xE0, 0x0F,
  0xC0, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0xF8, 0x07,
  0xE0, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x3E, 0x01,
  0xF0, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF8, 0x03, 0xE0, 0x3E, 0x0F, 0x80,
  0xF8, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x00, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x00, 0x7C, 0x0F, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0xF8,
  0x3F, 0x00, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x3E,
  0x1F, 0x80, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x03, 0xE3, 0xE0, 0x0F,
  0x8F, 0xC0, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF0, 0x03,
  0xE3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00,
  0x79, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x3C, 0xF8, 0x00, 0x0F, 0xBE, 0x00,
  0x1E, 0xF8, 0x00, 0x07, 0xDE, 0x00, 0x0F, 0x7C, 0x00, 0x03, 0xFF, 0x00,
  0x07, 0xBC, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x1F,
  0x80, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00,
  0x00, 0xFB, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x07, 0xE1, 0xF0, 0x00,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xE1,
  0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x01, 0xF0,
  0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x1F,
  0x80, 0x1F, 0x80, 0xFC, 0x00, 0x7C, 0x0F, 0xC0, 0x03, 0xE0, 0x7C, 0x00,
  0x1F, 0x07, 0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x1F,
  0x3F, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x78,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xE0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xDE, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x1F,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0xF8, 0x1F, 0x00,
  0x0F, 0x80, 0x78, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x01, 0xF0, 0x00,
  0x7C, 0x0F, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C,
  0x7C, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3E, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0x87, 0xE0, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0x83, 0xC0, 0x3F, 0xFE, 0x3E, 0x03,
  0xFF, 0xF9, 0xF0, 0x3F, 0xFF, 0xCF, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0x80,
  0x3F, 0xC1, 0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x3F,
  0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7E, 0x3F,
  0x00, 0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0xFC, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F,
  0x0F, 0x80, 0x01, 0xF8, 0x7C, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7E, 0x1F,
  0x00, 0x07, 0xE0, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xF8, 0x3E, 0x00,
  0x3F, 0xC1, 0xF0, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0xE0, 0x7E, 0x01, 0xFF,
  0x03, 0xF8, 0x3E, 0xF8, 0x0F, 0xFF, 0xE7, 0xC0, 0x3F, 0xFE, 0x3C, 0x01,
  0xFF, 0xE1, 0xE0, 0x03, 0xFC, 0x0F, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x7E, 0x1F, 0xF0, 0x01,
  0xF1, 0xFF, 0xE0, 0x07, 0xCF, 0xFF, 0xC0, 0x1F, 0x7F, 0xFF, 0x80, 0xFB,
  0xE0, 0xFE, 0x03, 0xFE, 0x01, 0xF8, 0x0F, 0xF0, 0x03, 0xE0, 0x3F, 0xC0,
  0x0F, 0xC1, 0xFE, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x03,
  0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC,
  0x3F, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F,
  0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x7C, 0x1F, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x3F,
  0x07, 0xF8, 0x01, 0xF8, 0x1F, 0xF0, 0x0F, 0xE0, 0x7D, 0xE0, 0xFF, 0x01,
  0xF7, 0xFF, 0xF8, 0x07, 0x8F, 0xFF, 0xC0, 0x3E, 0x1F, 0xFE, 0x00, 0xF0,
  0x3F, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xF8,
  0x04, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x20, 0x7F, 0x01, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x3F, 0xF0,
  0xF8, 0x00, 0x7F, 0xFC, 0xFC, 0x00, 0x7F, 0xFF, 0x7E, 0x00, 0x7F, 0xFF,
  0xBE, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x3F, 0x00,
  0x3F, 0xC0, 0x3F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x80,
  0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x7C, 0x03, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xC0, 0x3F,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x01, 0xF8, 0x07,
  0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0xF8, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0x7F, 0x80, 0x3E, 0x00, 0x3F, 0x80,
  0x1F, 0x80, 0x3F, 0xC0, 0x0F, 0xC0, 0x3F, 0xE0, 0x07, 0xF0, 0x7D, 0xF0,
  0x01, 0xFF, 0xFC, 0xF8, 0x00, 0xFF, 0xFC, 0x78, 0x00, 0x3F, 0xFC, 0x3C,
  0x00, 0x07, 0xF8, 0x3E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0xFE, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x1F, 0x80, 0x3F,
  0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0x7C, 0x00,
  0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x1F, 0xC3, 0xE0, 0x1F, 0xE1, 0xF8,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x01,
  0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x06, 0x03,
  0xF8, 0x07, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x11, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x3C, 0x00, 0xFF, 0xF8, 0xF8, 0x03, 0xFF, 0xF9, 0xF0, 0x0F,
  0xFF, 0xF3, 0xC0, 0x3F, 0xC0, 0xFF, 0x80, 0x7E, 0x00, 0xFF, 0x01, 0xF8,
  0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x3E, 0x07, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x3F, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xF8,
  0x1F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0xC0, 0x7C, 0x00, 0x3F, 0x80,
  0xF8, 0x00, 0xFF, 0x01, 0xF0, 0x03, 0xFC, 0x03, 0xF0, 0x07, 0xF8, 0x07,
  0xE0, 0x1F, 0xF0, 0x0F, 0xE0, 0xFB, 0xE0, 0x0F, 0xFF, 0xEF, 0xC0, 0x1F,
  0xFF, 0x9F, 0x00, 0x1F, 0xFE, 0x3E, 0x00, 0x0F, 0xF0, 0x7C, 0x00, 0x03,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x04, 0x00, 0x0F, 0xC0, 0x0C, 0x00, 0x3F,
  0x80, 0x1F, 0x83, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xE0, 0x7C, 0x00, 0x3E, 0x1F, 0xF8, 0x01, 0xF1, 0xFF, 0xE0, 0x0F,
  0x9F, 0xFF, 0x80, 0x7D, 0xFF, 0xFE, 0x07, 0xDF, 0x07, 0xF0, 0x3F, 0xE0,
  0x1F, 0x81, 0xFE, 0x00, 0x7C, 0x0F, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x1F,
  0x07, 0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F,
  0x80, 0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0xF8, 0x3F, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xE0, 0xFC, 0x00, 0x1F,
  0x07, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x7E, 0x0F,
  0x80, 0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0xF8, 0x3E, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0xFC, 0x00, 0x1F,
  0x07, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x7C, 0x1F,
  0x80, 0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x87, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x40, 0x7E, 0x00, 0x7E, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xC0,
  0x1F, 0x80, 0x1F, 0x00, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x3F,
  0x80, 0x0F, 0x80, 0xFC, 0x00, 0x3E, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x7C, 0x7E, 0x00, 0x01,
  0xF3, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3E, 0xFE, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xDF,
  0x00, 0x01, 0xFE, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x7C, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x3E, 0x01, 0xF8, 0x00, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0x80, 0x1F,
  0x80, 0x3F, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF0, 0x01, 0xF8, 0x07, 0xC0,
  0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xC3, 0xFF, 0x01, 0xFF, 0x80,
  0x1F, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x78, 0xFF, 0xF8, 0x7F, 0xFE, 0x01,
  0xE7, 0xFF, 0xF3, 0xFF, 0xF8, 0x0F, 0xBC, 0x0F, 0xDF, 0x07, 0xF0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xC0, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x03, 0xF8,
  0x01, 0xFE, 0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF0, 0x7F, 0x00,
  0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x07, 0xC0, 0x03,
  0xF0, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xFC, 0x00, 0x3E,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x0F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC1, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x83, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x0F, 0x87, 0xFF, 0x00, 0x7C, 0x7F, 0xFC, 0x03, 0xE7, 0xFF,
  0xE0, 0x3E, 0x7F, 0xFF, 0x81, 0xF7, 0xC1, 0xFC, 0x0F, 0xF8, 0x07, 0xE0,
  0x7F, 0x80, 0x1F, 0x03, 0xF8, 0x00, 0xF8, 0x3F, 0xC0, 0x07, 0xC1, 0xFC,
  0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x87, 0xF0, 0x00,
  0xFC, 0x3F, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0,
  0x7C, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xC1, 0xF8,
  0x00, 0x7E, 0x0F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0xF8, 0x3F, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xF0,
  0x7C, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x7E, 0x0F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xF0,
  0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xC3,
  0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0xFD, 0xF0, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0xFC, 0xF8, 0x00, 0x1F, 0x9F, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0xFC,
  0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x07, 0xFC, 0x00, 0x0F, 0x8F, 0xFF, 0x00, 0x07, 0xCF, 0xFF, 0xC0,
  0x03, 0xCF, 0xFF, 0xF0, 0x03, 0xEF, 0x83, 0xF8, 0x01, 0xFF, 0x00, 0xFC,
  0x00, 0xFF, 0x00, 0x3E, 0x00, 0x7F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x0F,
  0xC0, 0x3F, 0x80, 0x07, 0xE0, 0x1F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x3E, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x7F, 0xC0, 0x3F, 0x80, 0x3E,
  0xF0, 0x7F, 0x80, 0x1F, 0x7F, 0xFF, 0x80, 0x0F, 0x9F, 0xFF, 0x80, 0x0F,
  0xC7, 0xFF, 0x80, 0x07, 0xE1, 0xFF, 0x00, 0x03, 0xE0, 0x18, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0xF0, 0x07, 0xFF, 0xC7, 0xC0, 0x3F, 0xFF,
  0x9F, 0x01, 0xFF, 0xFE, 0x78, 0x0F, 0xF0, 0x3F, 0xE0, 0x3F, 0x00, 0x7F,
  0x81, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x7E, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x01,
  0xF0, 0x7C, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xFC,
  0x1F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x81, 0xF0, 0x00, 0xFE, 0x07,
  0xC0, 0x07, 0xF8, 0x1F, 0x00, 0x3F, 0xC0, 0x7E, 0x00, 0xFF, 0x01, 0xF8,
  0x07, 0xFC, 0x07, 0xF0, 0x7D, 0xF0, 0x0F, 0xFF, 0xEF, 0xC0, 0x3F, 0xFF,
  0x3E, 0x00, 0x7F, 0xF8, 0xF8, 0x00, 0x7F, 0x83, 0xE0, 0x00, 0x38, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0xFF,
  0x01, 0xF1, 0xFE, 0x01, 0xE3, 0xFE, 0x01, 0xE7, 0xFE, 0x03, 0xEF, 0xC2,
  0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xF0, 0x0E, 0x07, 0xC0, 0x02,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0xC0, 0x03, 0xF0, 0xF0, 0x0F, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3F, 0x04, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F,
  0xFC, 0x00, 0x30, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x07, 0xC0,
  0x01, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x03,
  0xE0, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0x83,
  0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3F, 0x07, 0xC0,
  0x01, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x07,
  0xE0, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x7F, 0x07, 0xC0,
  0x07, 0xF0, 0x3E, 0x00, 0x3F, 0x81, 0xF0, 0x03, 0xFC, 0x0F, 0xC0, 0x7B,
  0xE0, 0x7F, 0x07, 0xDF, 0x03, 0xFF, 0xFC, 0xF0, 0x0F, 0xFF, 0xCF, 0x80,
  0x3F, 0xFC, 0x7C, 0x00, 0xFF, 0x83, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xF9, 0xF0, 0x00, 0x3F, 0x3E, 0x00, 0x0F,
  0xC7, 0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0xC3, 0xE0,
  0x03, 0xF0, 0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x81, 0xF0, 0x03, 0xF0,
  0x3E, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x80,
  0xFC, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xC0, 0xF8, 0x00,
  0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E,
  0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xBE, 0x00, 0x3F, 0x80, 0x0F, 0xDF, 0x00, 0x3F,
  0xC0, 0x07, 0xCF, 0x80, 0x1F, 0xE0, 0x07, 0xE7, 0xC0, 0x0F, 0xF0, 0x03,
  0xE3, 0xE0, 0x0F, 0x78, 0x03, 0xF1, 0xF0, 0x07, 0xBC, 0x01, 0xF0, 0xF8,
  0x07, 0xDE, 0x01, 0xF8, 0x7C, 0x03, 0xCF, 0x00, 0xF8, 0x3E, 0x03, 0xE7,
  0x80, 0x7C, 0x1F, 0x01, 0xF3, 0xC0, 0x7E, 0x0F, 0x81, 0xF1, 0xE0, 0x3E,
  0x07, 0xC0, 0xF8, 0xF0, 0x3F, 0x03, 0xE0, 0x78, 0x78, 0x1F, 0x01, 0xF0,
  0x7C, 0x3C, 0x1F, 0x80, 0xF8, 0x3C, 0x1E, 0x0F, 0x80, 0x7C, 0x3E, 0x0F,
  0x07, 0xC0, 0x3E, 0x1E, 0x07, 0x87, 0xC0, 0x1F, 0x1F, 0x03, 0xC3, 0xE0,
  0x0F, 0x8F, 0x81, 0xE3, 0xF0, 0x07, 0xC7, 0x80, 0xF1, 0xF0, 0x03, 0xE7,
  0xC0, 0x78, 0xF8, 0x01, 0xF3, 0xC0, 0x3C, 0xF8, 0x00, 0xFB, 0xE0, 0x1E,
  0x7C, 0x00, 0x7D, 0xE0, 0x0F, 0x7C, 0x00, 0x3E, 0xF0, 0x07, 0xBE, 0x00,
  0x1F, 0xF8, 0x03, 0xDF, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xE0, 0x1F, 0x80, 0x01, 0xF0,
  0x1F, 0x80, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x1F,
  0x0F, 0xC0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x01,
  0xF7, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x01, 0xF9, 0xF0, 0x00,
  0x01, 0xF8, 0xF8, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x00,
  0x00, 0xFC, 0x0F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x1F,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x1F, 0x07, 0xE0, 0x00,
  0x00, 0xF0, 0x7C, 0x00, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x00, 0xF8, 0xF8,
  0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x0F,
  0xBF, 0x00, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x83, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F,
  0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x13, 0xFF, 0x80, 0x03, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0xC0, 0x07, 0xFF, 0xC8, 0x00,
  0x1F, 0xF8, 0x80, 0x00, 0x08, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Italic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 16, 47, 16, 1, -46 },
  { 95, 19, 17, 24, 7, -46 },
  { 136, 36, 46, 36, 1, -46 },
  { 343, 30, 53, 31, 1, -49 },
  { 542, 40, 47, 47, 4, -46 },
  { 777, 35, 47, 37, 1, -46 },
  { 983, 8, 17, 13, 7, -46 },
  { 1000, 20, 56, 18, 2, -46 },
  { 1140, 20, 56, 18, -5, -46 },
  { 1280, 26, 27, 31, 6, -49 },
  { 1368, 27, 31, 33, 4, -38 },
  { 1473, 12, 15, 15, -3, -7 },
  { 1496, 16, 5, 19, 1, -20 },
  { 1506, 8, 9, 15, 1, -8 },
  { 1515, 30, 46, 22, -3, -46 },
  { 1688, 28, 47, 31, 3, -46 },
  { 1853, 18, 46, 31, 8, -46 },
  { 1957, 32, 46, 31, -1, -46 },
  { 2141, 30, 47, 31, 1, -46 },
  { 2318, 31, 46, 31, 0, -46 },
  { 2497, 30, 47, 31, 1, -46 },
  { 2674, 29, 47, 31, 3, -46 },
  { 2845, 29, 46, 31, 4, -46 },
  { 3012, 29, 47, 31, 2, -46 },
  { 3183, 28, 47, 31, 2, -46 },
  { 3348, 13, 36, 15, 1, -35 },
  { 3407, 17, 43, 15, -3, -35 },
  { 3499, 28, 30, 33, 4, -38 },
  { 3604, 27, 17, 33, 4, -31 },
  { 3662, 28, 30, 33, 4, -38 },
  { 3767, 23, 47, 24, 3, -46 },
  { 3903, 44, 52, 48, 3, -46 },
  { 4189, 33, 46, 32, -4, -46 },
  { 4379, 32, 46, 34, 2, -46 },
  { 4563, 32, 47, 33, 4, -46 },
  { 4751, 34, 46, 38, 2, -46 },
  { 4947, 30, 46, 29, 2, -46 },
  { 5120, 30, 46, 27, 2, -46 },
  { 5293, 35, 47, 39, 4, -46 },
  { 5499, 38, 46, 39, 2, -46 },
  { 5718, 25, 46, 19, -2, -46 },
  { 5862, 27, 58, 16, -10, -46 },
  { 6058, 36, 46, 32, 2, -46 },
  { 6265, 21, 46, 27, 2, -46 },
  { 6386, 48, 46, 49, 2, -46 },
  { 6662, 39, 46, 41, 2, -46 },
  { 6887, 35, 47, 41, 4, -46 },
  { 7093, 31, 46, 32, 2, -46 },
  { 7272, 35, 57, 41, 4, -46 },
  { 7522, 31, 46, 33, 2, -46 },
  { 7701, 31, 47, 29, 0, -46 },
  { 7884, 29, 46, 28, 5, -46 },
  { 8051, 36, 47, 39, 4, -46 },
  { 8263, 32, 46, 32, 6, -46 },
  { 8447, 49, 46, 50, 6, -46 },
  { 8729, 39, 46, 30, -4, -46 },
  { 8954, 29, 46, 29, 6, -46 },
  { 9121, 34, 46, 29, -1, -46 },
  { 9317, 24, 56, 18, -1, -46 },
  { 9485, 11, 46, 22, 7, -46 },
  { 9549, 24, 56, 18, -4, -46 },
  { 9717, 29, 27, 33, 2, -46 },
  { 9815, 24, 4, 23, -6, 6 },
  { 9827, 10, 10, 17, 9, -49 },
  { 9840, 29, 36, 33, 3, -35 },
  { 9971, 30, 50, 33, 1, -49 },
  { 10159, 24, 36, 26, 3, -35 },
  { 10267, 33, 50, 33, 2, -49 },
  { 10474, 26, 36, 29, 2, -35 },
  { 10591, 33, 64, 18, -7, -49 },
  { 10855, 31, 50, 33, 1, -35 },
  { 11049, 29, 49, 33, 1, -49 },
  { 11227, 15, 47, 15, 1, -47 },
  { 11316, 24, 62, 15, -8, -47 },
  { 11502, 30, 49, 29, 1, -49 },
  { 11686, 16, 49, 15, 1, -49 },
  { 11784, 46, 35, 50, 1, -35 },
  { 11986, 29, 35, 33, 1, -35 },
  { 12113, 27, 36, 32, 3, -35 },
  { 12235, 33, 50, 33, -2, -35 },
  { 12442, 30, 50, 33, 2, -35 },
  { 12630, 24, 35, 23, 1, -35 },
  { 12735, 24, 36, 25, 0, -35 },
  { 12843, 18, 43, 19, 3, -42 },
  { 12940, 29, 35, 33, 3, -34 },
  { 13067, 27, 34, 27, 3, -34 },
  { 13182, 41, 34, 42, 4, -34 },
  { 13357, 33, 34, 28, -3, -34 },
  { 13498, 36, 49, 27, -6, -34 },
  { 13719, 26, 34, 25, -1, -34 },
  { 13830, 24, 56, 22, 1, -46 },
  { 13998, 5, 64, 31, 14, -49 },
  { 14038, 24, 56, 22, -3, -46 },
  { 14206, 28, 9, 33, 4, -27 },
};

const GFXfont NotoSans_SemiCondensed_Italic64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic64pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC64PT7B_H_
