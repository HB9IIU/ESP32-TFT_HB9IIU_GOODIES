#ifndef _NOTOSANS_SEMICONDENSED_ITALIC62PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x03,
  0x00, 0x00, 0x3F, 0x0F, 0xCF, 0x83, 0xE7, 0xE0, 0xF9, 0xF8, 0x7E, 0x7C,
  0x1F, 0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xE0, 0x7C, 0x78, 0x1E, 0x3E, 0x07,
  0x8F, 0x83, 0xE3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x0E, 0x03, 0xC3,
  0x80, 0xE0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF8, 0x0F,
  0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00,
  0x78, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x7E, 0x3C, 0x38, 0x03, 0xE1, 0xE0, 0x40, 0x3E,
  0x0E, 0x00, 0x01, 0xF0, 0x70, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x78, 0x3C,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x1F, 0x0E, 0x00, 0x00, 0xF8, 0x70, 0x00,
  0x07, 0xE7, 0x80, 0x00, 0x3F, 0xBC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xF3, 0xF0,
  0x00, 0x07, 0x8F, 0x80, 0x00, 0x3C, 0x7E, 0x00, 0x01, 0xC1, 0xF0, 0x00,
  0x0E, 0x0F, 0x80, 0x00, 0xF0, 0x7C, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x38,
  0x3E, 0x00, 0x01, 0xC1, 0xF0, 0x20, 0x0E, 0x1F, 0x83, 0xC0, 0xF1, 0xF8,
  0x1F, 0xF7, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xE0, 0x0F, 0xFE, 0x00, 0x07, 0x80, 0x3F,
  0xFC, 0x00, 0x1E, 0x00, 0xF8, 0x78, 0x00, 0x7C, 0x01, 0xE0, 0xF8, 0x00,
  0xF0, 0x07, 0xC0, 0xF0, 0x03, 0xE0, 0x0F, 0x01, 0xE0, 0x0F, 0x80, 0x3E,
  0x03, 0xC0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x7C, 0x00, 0xF0, 0x0F, 0x01,
  0xF0, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x07, 0x80, 0x7C, 0x0F, 0x80, 0x0F,
  0x00, 0xF0, 0x3E, 0x00, 0x1E, 0x01, 0xE0, 0x78, 0x00, 0x7C, 0x03, 0xC1,
  0xF0, 0x00, 0xF8, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0x1E, 0x0F, 0x00, 0x03,
  0xC0, 0x3C, 0x3E, 0x1F, 0x87, 0x80, 0xF8, 0xF8, 0xFF, 0xCF, 0x01, 0xE1,
  0xE3, 0xFF, 0x9F, 0x07, 0xC7, 0xCF, 0xFF, 0xBE, 0x0F, 0x1F, 0x1F, 0x0F,
  0x3E, 0x3E, 0x3C, 0x7C, 0x1F, 0x7F, 0xF8, 0xF8, 0xF0, 0x3E, 0x7F, 0xE3,
  0xE3, 0xE0, 0x7C, 0x7F, 0x87, 0x87, 0x80, 0xF8, 0x7C, 0x1F, 0x1F, 0x01,
  0xF0, 0x00, 0x7C, 0x3E, 0x03, 0xE0, 0x00, 0xF0, 0x78, 0x07, 0x80, 0x03,
  0xE0, 0xF0, 0x0F, 0x00, 0x0F, 0x81, 0xE0, 0x1E, 0x00, 0x1E, 0x07, 0xC0,
  0x3C, 0x00, 0x7C, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x0F, 0x80, 0x78, 0x0F, 0x80, 0x3E, 0x00, 0xF0,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x3C, 0x01, 0xF0, 0x03, 0xC0, 0xF0, 0x07,
  0xC0, 0x07, 0xC3, 0xE0, 0x0F, 0x00, 0x07, 0xCF, 0x80, 0x3E, 0x00, 0x0F,
  0xFF, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x01, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F,
  0x8F, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x01, 0xF0, 0x7E,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x0F, 0xBF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xF7, 0xE0, 0x0F, 0xC3, 0xF8, 0xFC, 0x03, 0xE1, 0xFC, 0x3F, 0x00, 0xF8,
  0x7E, 0x07, 0xE0, 0x7C, 0x3F, 0x00, 0xF8, 0x1F, 0x1F, 0x80, 0x3F, 0x0F,
  0x87, 0xC0, 0x07, 0xC7, 0xE1, 0xF0, 0x01, 0xF9, 0xF0, 0xFC, 0x00, 0x3F,
  0xFC, 0x3E, 0x00, 0x0F, 0xFE, 0x0F, 0x80, 0x01, 0xFF, 0x03, 0xE0, 0x00,
  0x7F, 0x80, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x07, 0xF8, 0x0F, 0xC0,
  0x03, 0xFE, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x7E, 0x03, 0xFF, 0xFF, 0x0F, 0xC0, 0x7F, 0xFF, 0x03, 0xF0,
  0x07, 0xFF, 0x00, 0x7E, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F, 0x3E, 0x3E,
  0x7E, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0xF8, 0xF0, 0xF0, 0xF0, 0xF0,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x02, 0x00,
  0x78, 0x00, 0xC0, 0x3C, 0x00, 0xF8, 0x1C, 0x00, 0x7F, 0x0E, 0x00, 0x7F,
  0xEF, 0x00, 0x0F, 0xFF, 0x9F, 0xE0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x03, 0xF8, 0x06, 0x03, 0xFE, 0x00, 0x03, 0xEF, 0x00,
  0x03, 0xE3, 0xC0, 0x03, 0xE1, 0xE0, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0x3C,
  0x00, 0xF0, 0x1F, 0x00, 0x38, 0x0F, 0x80, 0x08, 0x03, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x07,
  0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x3E,
  0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xC0, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x18,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x3E,
  0x07, 0xE0, 0x07, 0xC0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xC0,
  0x03, 0xF1, 0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF9,
  0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0xFC, 0xF8, 0x00,
  0x1F, 0xBF, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x9F,
  0x00, 0x01, 0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF9, 0xF0,
  0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x3E,
  0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x3E, 0x0F, 0x80,
  0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0x7F, 0x0F, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC,
  0x7F, 0xBE, 0xFF, 0x3F, 0x7F, 0x1F, 0x1E, 0x0F, 0x86, 0x07, 0xC2, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0x00, 0x3F, 0x00, 0x08,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x0F,
  0xE0, 0x07, 0x00, 0x1F, 0x80, 0x10, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x08, 0x00, 0x03, 0xF0, 0x38, 0x00, 0x1F, 0xC0, 0xFC, 0x01, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x0F,
  0x7C, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x3E,
  0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0xF8, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0xF8,
  0x0F, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xF0,
  0x0F, 0x80, 0x07, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xE0, 0xFF, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x40, 0x00, 0x3F, 0x03, 0x00, 0x03,
  0xF8, 0x1F, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x7E, 0x00, 0x3E, 0x1F, 0xF8, 0x03, 0xE7, 0xFF, 0xC0, 0x3E, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0x7F, 0x07, 0xF8, 0x03, 0xF0,
  0x7F, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0xF8, 0xFC, 0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x1F,
  0x8F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8,
  0x00, 0x3F, 0x0F, 0x80, 0x03, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07,
  0xE0, 0x7C, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x03, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x20, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7E, 0x03,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3E, 0x00, 0x3E, 0x03, 0xF0, 0x01, 0xF0,
  0x1F, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x3E,
  0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0x7E, 0x00,
  0xFC, 0x01, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x1F, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x7F, 0x07,
  0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0,
  0x3E, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xF0, 0xF8,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xE1, 0xF0, 0x00,
  0x3F, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0xFC,
  0x1F, 0xC0, 0x0F, 0xC0, 0x7F, 0x01, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1A,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x01, 0xF0, 0x3F, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0x7C,
  0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF1, 0xF8, 0x00, 0x3E, 0x3E, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x1F, 0x8F, 0x80, 0x03, 0xF1, 0xF0, 0x00,
  0xFE, 0x3F, 0x00, 0x3F, 0x87, 0xE0, 0x0F, 0xF0, 0x7E, 0x03, 0xFE, 0x0F,
  0xFF, 0xF7, 0xC0, 0xFF, 0xFD, 0xF8, 0x0F, 0xFF, 0x3E, 0x00, 0xFF, 0x87,
  0xC0, 0x01, 0xC0, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0xC0, 0x3F, 0xC0, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x7E, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x06, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFF,
  0x80, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3C, 0x07, 0xF0,
  0xC0, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0xFF, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x0F, 0xFC, 0x03, 0xC3, 0xE0,
  0x0F, 0xFF, 0xC0, 0xF1, 0xF0, 0x07, 0xFF, 0xF0, 0x3C, 0x78, 0x03, 0xF9,
  0xF8, 0x0F, 0x1E, 0x01, 0xF0, 0x1E, 0x03, 0xCF, 0x80, 0xF8, 0x0F, 0x80,
  0xF3, 0xC0, 0x7C, 0x03, 0xE0, 0x3D, 0xF0, 0x1E, 0x00, 0xF0, 0x0F, 0x78,
  0x0F, 0x80, 0x3C, 0x03, 0xDE, 0x03, 0xC0, 0x1F, 0x00, 0xF7, 0x81, 0xF0,
  0x07, 0xC0, 0x3F, 0xE0, 0x78, 0x01, 0xE0, 0x1F, 0xF0, 0x1E, 0x00, 0xF8,
  0x07, 0xBC, 0x07, 0x80, 0x3E, 0x01, 0xEF, 0x03, 0xE0, 0x0F, 0x00, 0xFB,
  0xC0, 0xF8, 0x07, 0xC0, 0x3C, 0xF0, 0x3E, 0x01, 0xF0, 0x0F, 0x3C, 0x0F,
  0x80, 0x7C, 0x07, 0xCF, 0x03, 0xE0, 0x3F, 0x01, 0xE3, 0xC0, 0xF8, 0x1F,
  0xC0, 0xF0, 0xF0, 0x1E, 0x0F, 0xF0, 0x7C, 0x3C, 0x07, 0xFF, 0x9F, 0xFE,
  0x0F, 0x01, 0xFF, 0xC7, 0xFF, 0x03, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0xF8,
  0x07, 0xF0, 0x1F, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x20, 0x00, 0x0F, 0xE0, 0x00, 0x78, 0x00, 0x01, 0xFF,
  0xC3, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0xF8, 0x78,
  0x00, 0x01, 0xF8, 0x78, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x03, 0xF0, 0x7C,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x80, 0x7C,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x3E,
  0x07, 0xE0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3E,
  0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E,
  0x3F, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0xFF, 0xC0,
  0x1F, 0x00, 0x3F, 0x80, 0x3E, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x3F, 0x01,
  0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0xFC, 0x07, 0xC0, 0x01, 0xF8, 0x1F,
  0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x3F, 0x01, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0,
  0x0F, 0xE0, 0x1F, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x1F,
  0xE0, 0x0F, 0x80, 0x0F, 0xC0, 0x1F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xF0,
  0x7C, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xF8, 0x1F, 0x00, 0x1F, 0xE0, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x07, 0x80, 0x3F, 0xC0, 0x02, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x01, 0x00, 0x3F, 0xE0, 0x3E, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F,
  0x83, 0xFF, 0xC0, 0x07, 0xC0, 0x0F, 0xF0, 0x03, 0xE0, 0x03, 0xF8, 0x03,
  0xF0, 0x00, 0xFE, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x7C, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8,
  0x1F, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F,
  0x07, 0xE0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07,
  0xE0, 0xF8, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00,
  0xFC, 0x3E, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xE0, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF8, 0x3E, 0x00, 0x01, 0xF8, 0x1F, 0x00,
  0x01, 0xFC, 0x0F, 0x80, 0x01, 0xFC, 0x0F, 0xC0, 0x01, 0xFC, 0x07, 0xC0,
  0x01, 0xFC, 0x03, 0xE0, 0x03, 0xFC, 0x01, 0xF0, 0x07, 0xFC, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xC0, 0x0F, 0xF0, 0x00, 0x30, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xE3, 0xF0, 0x00, 0xFF, 0xF8, 0xFC, 0x00,
  0x3F, 0xFC, 0x3E, 0x00, 0x1F, 0xFF, 0x0F, 0x80, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x7E, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xF0, 0x00,
  0x3E, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x1F, 0xF0, 0x1F, 0xE0, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x1F, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0x00,
  0x00, 0x7C, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x1F, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x1F,
  0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0xF8,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x01, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x20, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x0F, 0x80, 0x03, 0xF0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x0F,
  0xC0, 0x01, 0xF0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x07, 0xC1, 0xFC, 0x00, 0x00, 0xF8, 0x7F, 0x00, 0x00, 0x1F, 0x0F, 0xC0,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0x3F,
  0x00, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xBF, 0x00, 0x00,
  0x0F, 0xE3, 0xE0, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0xF8, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x1F, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x0F, 0xBE, 0x01, 0xF7,
  0x80, 0x00, 0x3F, 0xF8, 0x07, 0xDE, 0x00, 0x01, 0xF7, 0xC0, 0x1F, 0x78,
  0x00, 0x07, 0xDF, 0x00, 0xF9, 0xE0, 0x00, 0x3E, 0x7C, 0x03, 0xE7, 0xC0,
  0x00, 0xFB, 0xF0, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x00,
  0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x03,
  0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x80, 0x7C, 0x7C, 0x00, 0x7C,
  0x7C, 0x01, 0xF0, 0xF0, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xC0, 0x0F, 0x87,
  0xC0, 0x3E, 0x0F, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x3C, 0x01, 0xF0, 0xFC,
  0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x80,
  0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x01, 0xF0, 0x3E, 0x07, 0x81, 0xF8, 0x07,
  0xC0, 0xF8, 0x3E, 0x07, 0xE0, 0x1F, 0x03, 0xE0, 0xF0, 0x1F, 0x00, 0x7C,
  0x0F, 0x87, 0xC0, 0x7C, 0x03, 0xE0, 0x1E, 0x1E, 0x01, 0xF0, 0x0F, 0x80,
  0x78, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xE3, 0xC0, 0x3E, 0x00, 0xF8, 0x07,
  0x9F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0x7F,
  0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xFF, 0x00, 0x7E, 0x01, 0xF0, 0x07, 0xFC,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0xE0, 0x07, 0xC0, 0x3F, 0x00, 0x7F, 0x80,
  0x1F, 0x00, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x03, 0xE0, 0x03, 0xF0, 0x03,
  0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x0F,
  0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0xC0, 0x00, 0x3E, 0x00, 0xFF, 0x00, 0x00,
  0xF8, 0x03, 0xFE, 0x00, 0x03, 0xE0, 0x1F, 0xF8, 0x00, 0x0F, 0x80, 0x7F,
  0xE0, 0x00, 0x7C, 0x01, 0xFF, 0x80, 0x01, 0xF0, 0x07, 0xDF, 0x00, 0x07,
  0xC0, 0x1F, 0x7C, 0x00, 0x1F, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0x03, 0xE3,
  0xE0, 0x03, 0xE0, 0x0F, 0x8F, 0x80, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x3E,
  0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0x1F, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x3E, 0x01, 0xF0,
  0x07, 0xC0, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3F, 0x00, 0xF8, 0x07,
  0xC0, 0xF8, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x0F, 0x80,
  0x7E, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x03, 0xE1, 0xF0, 0x07, 0xC0, 0x0F,
  0x87, 0xC0, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x7C, 0x03,
  0xE0, 0x01, 0xF1, 0xF0, 0x0F, 0x80, 0x07, 0xCF, 0x80, 0x3E, 0x00, 0x1F,
  0xBE, 0x00, 0xF8, 0x00, 0x3E, 0xF8, 0x03, 0xE0, 0x00, 0xFB, 0xE0, 0x1F,
  0x00, 0x03, 0xEF, 0x80, 0x7C, 0x00, 0x07, 0xFC, 0x01, 0xF0, 0x00, 0x1F,
  0xF0, 0x07, 0xC0, 0x00, 0x7F, 0xC0, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0xF8,
  0x00, 0x03, 0xFC, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x0F, 0x80, 0x00, 0x3F,
  0x80, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0,
  0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07,
  0xE0, 0xFE, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3E,
  0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x01,
  0xFB, 0xE0, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00,
  0x0F, 0xCF, 0x80, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x01, 0xF8, 0xF8, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x07, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xF8, 0x3F, 0xF0, 0x03, 0xE0, 0x0F, 0xE0, 0x0F, 0x80, 0x1F,
  0x80, 0x7E, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x03, 0xF0,
  0x1F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F,
  0x80, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xE0,
  0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7C, 0x00, 0x3F, 0x01, 0xF0, 0x01,
  0xFC, 0x07, 0xC0, 0x0F, 0xE0, 0x3F, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xE0, 0x07,
  0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x07, 0xE0, 0xFE, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3E, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x07, 0xEF, 0x80, 0x00,
  0x01, 0xFB, 0xE0, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x3F, 0x3E, 0x00,
  0x00, 0x0F, 0xCF, 0x80, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x01, 0xF8, 0xF8,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xF8, 0x3F, 0xF8,
  0x03, 0xE0, 0x0F, 0xE0, 0x0F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x01,
  0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xF0, 0x3E, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x0F,
  0xC0, 0x7C, 0x00, 0x7F, 0x01, 0xF0, 0x03, 0xF8, 0x07, 0xC0, 0x3F, 0xC0,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x07, 0xC0,
  0x7E, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xF0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x03, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0xFC,
  0x00, 0x1F, 0x83, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF8, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFC, 0x07,
  0xC0, 0x1F, 0xC0, 0x03, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x08, 0x00, 0x07, 0xF0, 0x38, 0x00, 0x3F, 0x80, 0xFC, 0x07, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xE0, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0xFC, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x3F, 0x03, 0xE0,
  0x00, 0x0F, 0x81, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0xFC, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x1F, 0x81, 0xF0, 0x00,
  0x07, 0xC0, 0xFC, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0x3F, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x03, 0xE0, 0x7E,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x81,
  0xF0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x7E, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xF3,
  0xE0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x7E, 0x3E, 0x00, 0x01, 0xF8, 0xF8,
  0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x07,
  0xE0, 0x1F, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0x7C, 0x01, 0xF0, 0x01,
  0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x7C,
  0x07, 0xC0, 0x01, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x0F, 0x87,
  0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x0F, 0x9F, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0xF8, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x3F, 0xE0,
  0x01, 0xF0, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0x7F, 0xE0,
  0x03, 0xE0, 0xF8, 0x00, 0x7B, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0xFB, 0xE0,
  0x07, 0xE0, 0xFC, 0x00, 0xF3, 0xE0, 0x07, 0xC0, 0xFC, 0x01, 0xF3, 0xE0,
  0x0F, 0xC0, 0xFC, 0x01, 0xF3, 0xE0, 0x0F, 0x80, 0xFC, 0x03, 0xE3, 0xE0,
  0x1F, 0x80, 0xFC, 0x03, 0xE3, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xC3, 0xE0,
  0x1F, 0x00, 0x7C, 0x07, 0xC3, 0xE0, 0x3F, 0x00, 0x7C, 0x07, 0x83, 0xE0,
  0x3E, 0x00, 0x7C, 0x0F, 0x83, 0xE0, 0x7E, 0x00, 0x7C, 0x0F, 0x03, 0xE0,
  0x7C, 0x00, 0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x1F, 0x03, 0xE0,
  0xF8, 0x00, 0x7C, 0x3E, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x3E, 0x03, 0xE1,
  0xF8, 0x00, 0x7C, 0x3C, 0x01, 0xE1, 0xF0, 0x00, 0x7C, 0x7C, 0x01, 0xE3,
  0xF0, 0x00, 0x7C, 0x78, 0x01, 0xE3, 0xE0, 0x00, 0x7C, 0xF8, 0x01, 0xE3,
  0xE0, 0x00, 0x7C, 0xF8, 0x01, 0xE7, 0xC0, 0x00, 0x7D, 0xF0, 0x01, 0xE7,
  0xC0, 0x00, 0x7D, 0xF0, 0x01, 0xE7, 0xC0, 0x00, 0x7D, 0xE0, 0x01, 0xEF,
  0x80, 0x00, 0x7B, 0xE0, 0x01, 0xEF, 0x80, 0x00, 0x7B, 0xC0, 0x01, 0xEF,
  0x00, 0x00, 0x7B, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x3E, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x00, 0x3E,
  0x3F, 0x00, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00,
  0x00, 0x7D, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00,
  0x03, 0xF1, 0xF0, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x7C, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x0F,
  0xCF, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xF0, 0x7C,
  0x00, 0x3E, 0x07, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0xFC, 0x03, 0xE0, 0x0F,
  0xC0, 0x3E, 0x01, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x03, 0xF0, 0x03,
  0xE0, 0x7E, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x0F,
  0x80, 0x01, 0xF1, 0xF8, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0xF3, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xF0, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xE0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x03, 0xC0, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x07, 0x81,
  0xE0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x03, 0xC0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x1E, 0x07, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x0F, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xE0, 0x7C,
  0x00, 0x3E, 0x03, 0xE0, 0x03, 0xC0, 0x3E, 0x00, 0x7C, 0x01, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0xF8, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0xF8, 0x1E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x03, 0xC7,
  0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1F, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFC, 0x1F,
  0x07, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFF, 0x83, 0xC0, 0x1F, 0xFE, 0x3E, 0x01, 0xFF, 0xF9,
  0xF0, 0x1F, 0xFF, 0xEF, 0x01, 0xFC, 0x0F, 0xF8, 0x1F, 0xC0, 0x3F, 0xC0,
  0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xF0, 0x7C, 0x00, 0x3F, 0x07, 0xE0,
  0x01, 0xF8, 0x3E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03,
  0xE0, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xC3,
  0xF0, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0,
  0x01, 0xF8, 0x3E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x07,
  0xE0, 0xFC, 0x00, 0x3F, 0x03, 0xE0, 0x03, 0xF8, 0x1F, 0x00, 0x3F, 0xC0,
  0xF8, 0x03, 0xFE, 0x07, 0xE0, 0x3D, 0xE0, 0x3F, 0x83, 0xDF, 0x00, 0xFF,
  0xFE, 0xF8, 0x07, 0xFF, 0xE7, 0xC0, 0x1F, 0xFC, 0x3C, 0x00, 0x7F, 0xC1,
  0xE0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC3, 0xFE, 0x00,
  0x3E, 0x3F, 0xF8, 0x03, 0xF7, 0xFF, 0xE0, 0x1F, 0x7F, 0xFF, 0x80, 0xFB,
  0xC0, 0xFC, 0x07, 0xFC, 0x03, 0xE0, 0x3F, 0xC0, 0x1F, 0x83, 0xFC, 0x00,
  0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8,
  0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xF8,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC3, 0xF0, 0x00,
  0x7E, 0x1F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8,
  0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x07, 0xE0, 0xFC,
  0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7F, 0x80, 0x3F, 0x03, 0xFC, 0x03,
  0xF8, 0x1F, 0xF0, 0x3F, 0x80, 0xF3, 0xFF, 0xF8, 0x07, 0x9F, 0xFF, 0x80,
  0x7C, 0x7F, 0xF8, 0x03, 0xC1, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x03, 0xF8, 0x06, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x20, 0x3F, 0x80, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3F, 0xF0, 0xF8, 0x00, 0x7F, 0xF8, 0xF8,
  0x00, 0xFF, 0xFC, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x1F, 0xF0,
  0x07, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x07, 0xE0,
  0x0F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x07, 0xC0,
  0x7E, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x0F, 0xC0,
  0x7C, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0xFF, 0x00,
  0x7C, 0x01, 0xFE, 0x00, 0x7E, 0x03, 0xFE, 0x00, 0x7F, 0x07, 0xBE, 0x00,
  0x3F, 0xFF, 0x3E, 0x00, 0x3F, 0xFE, 0x3E, 0x00, 0x1F, 0xFC, 0x3C, 0x00,
  0x0F, 0xF8, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x1F, 0xC0, 0xF8, 0x1F, 0x80, 0x7E, 0x0F, 0x80, 0x1F, 0x0F, 0xC0, 0x0F,
  0x8F, 0xC0, 0x07, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xF0, 0x03,
  0xF1, 0xF0, 0x07, 0xF0, 0xF8, 0x1F, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x01, 0x01, 0xFC, 0x03, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x1F, 0x82, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x3C, 0x00, 0x7F, 0xF8, 0xF8, 0x01, 0xFF, 0xF9, 0xF0, 0x07, 0xFF,
  0xFB, 0xC0, 0x1F, 0xC0, 0xFF, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFC, 0x00,
  0xFE, 0x03, 0xF0, 0x01, 0xFC, 0x07, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x07,
  0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x03, 0xF0,
  0x3F, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x1F,
  0x80, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x3F, 0x80, 0x7C,
  0x00, 0xFF, 0x00, 0xF8, 0x03, 0xFE, 0x01, 0xF8, 0x0F, 0xF8, 0x03, 0xF8,
  0x3D, 0xF0, 0x03, 0xFF, 0xFB, 0xE0, 0x07, 0xFF, 0xE7, 0xC0, 0x07, 0xFF,
  0x1F, 0x00, 0x07, 0xFC, 0x3E, 0x00, 0x01, 0xC0, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8,
  0x03, 0x00, 0x07, 0xE0, 0x07, 0x80, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0xFF, 0x80, 0x1F, 0x3F, 0xFE,
  0x01, 0xF7, 0xFF, 0xE0, 0x3E, 0xFF, 0xFF, 0x03, 0xEF, 0x03, 0xF0, 0x3F,
  0xE0, 0x1F, 0x03, 0xF8, 0x01, 0xF0, 0x7F, 0x80, 0x1F, 0x07, 0xF0, 0x01,
  0xF0, 0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3F, 0x0F,
  0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00,
  0x3E, 0x0F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0xFC, 0x3F, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF8,
  0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0,
  0x01, 0xF0, 0x7C, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x3E,
  0x00, 0x00, 0x18, 0x00, 0x78, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0x80, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x04, 0x07, 0xC0,
  0x0F, 0xC0, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0xFC,
  0x00, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x7E, 0x00, 0x3E, 0x07, 0xE0, 0x03,
  0xF0, 0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xC7,
  0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x1F, 0x3E, 0x00,
  0x00, 0xFB, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xEF, 0xC0, 0x00, 0xFE, 0x3E, 0x00, 0x07, 0xC1,
  0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xF8,
  0x00, 0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x7E, 0x01, 0xF8, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF8, 0x07, 0xC0,
  0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x07, 0xFC,
  0x07, 0xFE, 0x00, 0x78, 0xFF, 0xF0, 0x7F, 0xF8, 0x03, 0xCF, 0xFF, 0x87,
  0xFF, 0xE0, 0x3E, 0xFF, 0xFE, 0x7F, 0xFF, 0x01, 0xF7, 0x83, 0xF7, 0xC1,
  0xF8, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xC0, 0x7F, 0x00, 0x7F, 0x80, 0x3F,
  0x07, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0x81,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0xFC,
  0x00, 0x3E, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0x00, 0x10, 0x3F, 0x00, 0x1E, 0x0F, 0xFC, 0x01, 0xE3,
  0xFF, 0xE0, 0x3E, 0x7F, 0xFE, 0x03, 0xEF, 0xFF, 0xF0, 0x3F, 0xF0, 0x3F,
  0x03, 0xFE, 0x03, 0xF0, 0x3F, 0xC0, 0x1F, 0x07, 0xF8, 0x01, 0xF0, 0x7F,
  0x00, 0x1F, 0x07, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0xE0, 0x03,
  0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F,
  0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00,
  0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00,
  0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0,
  0x7C, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xF0, 0x3F, 0x01, 0xF8,
  0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xE3, 0xF0, 0x00, 0xFC,
  0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF3, 0xF0, 0x00, 0x3E, 0x7C, 0x00,
  0x07, 0xCF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x07, 0xEF,
  0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0xFD, 0xF8, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0xFC, 0x7C,
  0x00, 0x1F, 0x0F, 0x80, 0x07, 0xE1, 0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x3F,
  0x07, 0xE0, 0x0F, 0xC0, 0x7F, 0x07, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x1F, 0xF0, 0x00, 0x3C, 0x3F,
  0xF8, 0x00, 0x3C, 0x7F, 0xFC, 0x00, 0x7C, 0xFF, 0xFE, 0x00, 0x7D, 0xE0,
  0x7E, 0x00, 0x7F, 0xC0, 0x3E, 0x00, 0x7F, 0x80, 0x3F, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x3F, 0x01, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x3E, 0x03, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7E, 0x03, 0xE0, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0xF8, 0x07, 0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x03,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xF8, 0x1F,
  0xC0, 0x0F, 0xBF, 0xFF, 0x80, 0x0F, 0xBF, 0xFF, 0x00, 0x1F, 0x9F, 0xFE,
  0x00, 0x1F, 0x07, 0xFC, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0x83,
  0xC0, 0x1F, 0xFE, 0x3E, 0x01, 0xFF, 0xF9, 0xF0, 0x1F, 0xFF, 0xEF, 0x01,
  0xFC, 0x0F, 0xF8, 0x1F, 0xC0, 0x3F, 0xC0, 0xFC, 0x00, 0xFE, 0x0F, 0xC0,
  0x07, 0xF0, 0x7C, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3E, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x0F,
  0xC0, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7E, 0x1F, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x7F, 0x07,
  0xE0, 0x03, 0xF8, 0x1F, 0x00, 0x3F, 0xC0, 0xF8, 0x03, 0xFC, 0x07, 0xE0,
  0x3F, 0xE0, 0x3F, 0x83, 0xDF, 0x00, 0xFF, 0xFE, 0xF8, 0x07, 0xFF, 0xE7,
  0xC0, 0x1F, 0xFC, 0x7C, 0x00, 0x7F, 0xC3, 0xE0, 0x00, 0x70, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x03, 0xC1, 0xFC, 0x07, 0x8F, 0xF8,
  0x0F, 0x3F, 0xE0, 0x3E, 0xFF, 0xC0, 0x7D, 0xF0, 0x80, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xE0, 0x0C, 0x0F,
  0xC0, 0x04, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x80, 0x07, 0xE0, 0xF0, 0x0F, 0xE0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0x83, 0xFF,
  0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x01, 0x80, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80,
  0x03, 0xE0, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xC1, 0xF8, 0x00, 0x7C,
  0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F,
  0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C,
  0x00, 0x1F, 0x07, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x03,
  0xE0, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0xFE, 0x0F,
  0x80, 0x1F, 0xC0, 0xF8, 0x03, 0xFC, 0x0F, 0xC0, 0x7F, 0xC0, 0xFC, 0x1F,
  0x7C, 0x0F, 0xFF, 0xE7, 0xC0, 0x7F, 0xFC, 0x78, 0x03, 0xFF, 0x87, 0x80,
  0x1F, 0xF0, 0x78, 0x00, 0x30, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xEF, 0xC0, 0x01, 0xF9, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x3F, 0x1F,
  0x00, 0x0F, 0x87, 0xC0, 0x07, 0xE1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0xFC,
  0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x1F, 0x81, 0xF0, 0x07, 0xC0, 0x7C, 0x03,
  0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x01, 0xF0, 0x1F, 0x00, 0x3C,
  0x0F, 0xC0, 0x0F, 0x83, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0x7C, 0x00,
  0x3E, 0x3F, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE7, 0xE0, 0x00, 0xF9, 0xF0,
  0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xF0, 0x01, 0xF7, 0xC0, 0x0F,
  0xE0, 0x07, 0xEF, 0x80, 0x3F, 0xC0, 0x0F, 0x9F, 0x00, 0x7F, 0x80, 0x3F,
  0x3E, 0x01, 0xFF, 0x00, 0x7C, 0x7C, 0x03, 0xDE, 0x00, 0xF8, 0xF8, 0x07,
  0xBC, 0x03, 0xF1, 0xF0, 0x1F, 0x78, 0x07, 0xC3, 0xE0, 0x3C, 0xF0, 0x1F,
  0x87, 0xC0, 0xF9, 0xE0, 0x3E, 0x0F, 0x81, 0xE3, 0xC0, 0x7C, 0x1F, 0x07,
  0xC7, 0x81, 0xF0, 0x3E, 0x0F, 0x0F, 0x83, 0xE0, 0x7C, 0x1E, 0x1F, 0x0F,
  0x80, 0xF8, 0x7C, 0x3E, 0x1F, 0x01, 0xF0, 0xF0, 0x7C, 0x7E, 0x03, 0xE3,
  0xE0, 0xF8, 0xF8, 0x07, 0xC7, 0x81, 0xF1, 0xF0, 0x0F, 0x9F, 0x03, 0xE7,
  0xC0, 0x1F, 0x3C, 0x07, 0xCF, 0x80, 0x3E, 0x78, 0x0F, 0xBE, 0x00, 0x7D,
  0xF0, 0x1F, 0x7C, 0x00, 0xFB, 0xC0, 0x3E, 0xF0, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0xFE, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x1F, 0x80, 0x07, 0xC0, 0x7E, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x1F, 0x03, 0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F, 0xBE,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xF0, 0xF8,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0,
  0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x0F, 0x80,
  0x3E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x0F, 0xC0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x0F, 0x80, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0xFC, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x01, 0xF1, 0xF8, 0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x03, 0xC7, 0xC0,
  0x00, 0x00, 0x79, 0xF0, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x01, 0xEF,
  0x80, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x01,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x27, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xB0, 0x01, 0xFF, 0xE4, 0x00,
  0x0F, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Italic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 15, 45, 16, 1, -44 },
  { 86, 18, 16, 23, 7, -44 },
  { 122, 35, 44, 35, 1, -44 },
  { 315, 29, 51, 31, 1, -47 },
  { 500, 39, 46, 45, 4, -45 },
  { 725, 34, 46, 36, 1, -45 },
  { 921, 8, 16, 13, 7, -44 },
  { 937, 20, 54, 17, 2, -44 },
  { 1072, 20, 54, 17, -5, -44 },
  { 1207, 25, 25, 30, 6, -47 },
  { 1286, 27, 30, 32, 4, -37 },
  { 1388, 12, 15, 15, -3, -7 },
  { 1411, 15, 5, 18, 1, -19 },
  { 1421, 7, 8, 15, 1, -7 },
  { 1428, 30, 44, 22, -3, -44 },
  { 1593, 27, 46, 31, 3, -45 },
  { 1749, 17, 44, 31, 8, -44 },
  { 1843, 31, 45, 31, -1, -45 },
  { 2018, 30, 46, 31, 0, -45 },
  { 2191, 30, 44, 31, 0, -44 },
  { 2356, 29, 45, 31, 1, -44 },
  { 2520, 28, 46, 31, 3, -45 },
  { 2681, 28, 44, 31, 4, -44 },
  { 2835, 29, 46, 31, 2, -45 },
  { 3002, 27, 46, 31, 2, -45 },
  { 3158, 12, 35, 15, 1, -34 },
  { 3211, 16, 42, 15, -3, -34 },
  { 3295, 27, 29, 32, 4, -37 },
  { 3393, 26, 17, 32, 4, -30 },
  { 3449, 27, 29, 32, 4, -37 },
  { 3547, 22, 46, 23, 3, -45 },
  { 3674, 42, 49, 47, 3, -44 },
  { 3932, 32, 44, 31, -4, -44 },
  { 4108, 31, 44, 33, 2, -44 },
  { 4279, 31, 46, 32, 4, -45 },
  { 4458, 33, 44, 37, 2, -44 },
  { 4640, 29, 44, 29, 2, -44 },
  { 4800, 29, 44, 27, 2, -44 },
  { 4960, 34, 46, 38, 4, -45 },
  { 5156, 36, 44, 38, 2, -44 },
  { 5354, 25, 44, 19, -2, -44 },
  { 5492, 25, 56, 15, -9, -44 },
  { 5667, 35, 44, 31, 2, -44 },
  { 5860, 21, 44, 26, 2, -44 },
  { 5976, 46, 44, 48, 2, -44 },
  { 6229, 38, 44, 39, 2, -44 },
  { 6438, 34, 46, 40, 4, -45 },
  { 6634, 30, 44, 31, 2, -44 },
  { 6799, 34, 56, 40, 4, -45 },
  { 7037, 30, 44, 32, 2, -44 },
  { 7202, 30, 46, 28, 0, -45 },
  { 7375, 28, 44, 27, 5, -44 },
  { 7529, 34, 45, 37, 4, -44 },
  { 7721, 30, 44, 31, 6, -44 },
  { 7886, 48, 44, 48, 6, -44 },
  { 8150, 37, 44, 29, -3, -44 },
  { 8354, 28, 44, 28, 6, -44 },
  { 8508, 33, 44, 28, -1, -44 },
  { 8690, 24, 54, 18, -1, -44 },
  { 8852, 10, 44, 22, 7, -44 },
  { 8907, 23, 54, 18, -4, -44 },
  { 9063, 28, 26, 32, 2, -44 },
  { 9154, 24, 4, 22, -6, 5 },
  { 9166, 10, 9, 17, 9, -47 },
  { 9178, 29, 35, 32, 2, -34 },
  { 9305, 29, 48, 32, 1, -47 },
  { 9479, 24, 35, 25, 2, -34 },
  { 9584, 32, 48, 32, 2, -47 },
  { 9776, 25, 35, 28, 2, -34 },
  { 9886, 32, 62, 18, -7, -47 },
  { 10134, 31, 49, 32, 0, -34 },
  { 10324, 28, 47, 32, 1, -47 },
  { 10489, 15, 46, 15, 1, -46 },
  { 10576, 24, 61, 15, -8, -46 },
  { 10759, 29, 47, 28, 1, -47 },
  { 10930, 15, 47, 14, 1, -47 },
  { 11019, 45, 34, 48, 1, -34 },
  { 11211, 28, 34, 32, 1, -34 },
  { 11330, 27, 35, 31, 2, -34 },
  { 11449, 32, 49, 32, -2, -34 },
  { 11645, 29, 49, 32, 2, -34 },
  { 11823, 23, 34, 22, 1, -34 },
  { 11921, 24, 35, 24, 0, -34 },
  { 12026, 17, 42, 18, 3, -41 },
  { 12116, 28, 34, 32, 3, -33 },
  { 12235, 26, 33, 26, 3, -33 },
  { 12343, 39, 33, 41, 4, -33 },
  { 12504, 31, 33, 27, -2, -33 },
  { 12632, 35, 48, 26, -6, -33 },
  { 12842, 25, 33, 24, -1, -33 },
  { 12946, 24, 54, 21, 1, -44 },
  { 13108, 4, 62, 30, 14, -47 },
  { 13139, 23, 54, 21, -3, -44 },
  { 13295, 27, 8, 32, 4, -26 },
};

const GFXfont NotoSans_SemiCondensed_Italic62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic62pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC62PT7B_H_
