#ifndef _NOTOSANS_SEMICONDENSED_ITALIC40PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x00, 0x38, 0xF3, 0x8F, 0x78, 0xE7, 0x8E, 0x70, 0xE7, 0x0E, 0x71,
  0xC6, 0x1C, 0x61, 0xCE, 0x18, 0xE1, 0x80, 0x00, 0x38, 0x30, 0x00, 0xC1,
  0xC0, 0x07, 0x07, 0x00, 0x1C, 0x18, 0x00, 0x60, 0xE0, 0x03, 0x83, 0x80,
  0x0E, 0x0E, 0x00, 0x38, 0x30, 0x00, 0xC1, 0xC0, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xC0, 0x60, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0C, 0x00, 0x38, 0x70,
  0x01, 0xC1, 0xC0, 0x07, 0x06, 0x00, 0x1C, 0x18, 0x0F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x30, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x06,
  0x00, 0x1C, 0x38, 0x00, 0x60, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x1C, 0x00,
  0x30, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x03, 0xFC,
  0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0xF3, 0x18, 0x38, 0xC0, 0x1E, 0x30, 0x07,
  0x0C, 0x01, 0xC7, 0x00, 0x79, 0x80, 0x0F, 0x60, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0C, 0xE0, 0x07, 0x3C,
  0x01, 0x8F, 0x00, 0x63, 0xC0, 0x18, 0xE2, 0x06, 0x38, 0xC3, 0xBE, 0x3F,
  0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x07, 0x80, 0x0E, 0x0F, 0xE0, 0x0E, 0x07, 0xF8, 0x07,
  0x07, 0x1C, 0x07, 0x07, 0x0E, 0x07, 0x03, 0x87, 0x03, 0x81, 0x83, 0x83,
  0x81, 0xC1, 0xC3, 0x80, 0xE0, 0xE1, 0xC0, 0x70, 0x71, 0xC0, 0x38, 0x31,
  0xC0, 0x18, 0x38, 0xE1, 0x0C, 0x1C, 0xE7, 0xE6, 0x0C, 0xE7, 0xFB, 0x8E,
  0x73, 0x9D, 0xFE, 0x73, 0x86, 0x7E, 0x71, 0x83, 0x9E, 0x39, 0xC1, 0xC0,
  0x38, 0xE0, 0xC0, 0x38, 0x60, 0xE0, 0x1C, 0x70, 0x70, 0x1C, 0x38, 0x38,
  0x1C, 0x1C, 0x1C, 0x0E, 0x0E, 0x0C, 0x0E, 0x07, 0x0E, 0x0E, 0x03, 0x86,
  0x07, 0x01, 0xE7, 0x07, 0x00, 0x7F, 0x07, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x07, 0x87, 0x00, 0x38, 0x3C, 0x03,
  0xC1, 0xE0, 0x1C, 0x0E, 0x00, 0xE0, 0x70, 0x07, 0x07, 0x80, 0x3C, 0x78,
  0x00, 0xE7, 0x80, 0x07, 0x78, 0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x03, 0xFE, 0x07, 0x3E, 0x70, 0x3B, 0xC3, 0xC3, 0xDC, 0x0E, 0x1D,
  0xE0, 0x79, 0xEE, 0x01, 0xFE, 0x70, 0x0F, 0xE3, 0x80, 0x3F, 0x1C, 0x00,
  0xF0, 0xE0, 0x0F, 0x87, 0x81, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xE3, 0xC3,
  0xFC, 0x1F, 0x00, 0x39, 0xDE, 0xF7, 0x39, 0xCC, 0x67, 0x38, 0x00, 0x38,
  0x03, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0,
  0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0xC0, 0x3C, 0x00, 0x01, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0,
  0x41, 0xC0, 0x71, 0xC0, 0xFD, 0xC0, 0x7F, 0xBF, 0x0F, 0xFF, 0x03, 0xFF,
  0x07, 0xC0, 0x0E, 0xC0, 0x3C, 0xE0, 0x78, 0x70, 0x38, 0x70, 0x10, 0x78,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x0F, 0x0F, 0x1E,
  0x1E, 0x1C, 0x3C, 0x38, 0x70, 0x70, 0xE0, 0xFF, 0xFF, 0xEF, 0xF8, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xF1, 0xE0, 0xF0, 0x78, 0xF0, 0x1C,
  0x78, 0x0E, 0x78, 0x07, 0x3C, 0x03, 0x9C, 0x01, 0xDE, 0x00, 0xEF, 0x00,
  0x77, 0x00, 0x3B, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0x70,
  0x03, 0xB8, 0x03, 0xDC, 0x01, 0xEE, 0x00, 0xE7, 0x00, 0xF3, 0x80, 0x71,
  0xC0, 0x78, 0xF0, 0x38, 0x78, 0x3C, 0x1F, 0xFC, 0x07, 0xFC, 0x01, 0xFC,
  0x00, 0x00, 0xE0, 0x3C, 0x1F, 0x87, 0xF1, 0xFE, 0xFB, 0xBE, 0x73, 0x8E,
  0x43, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x07,
  0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x03,
  0x80, 0xF0, 0x1E, 0x03, 0x80, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0xFF,
  0x03, 0xC1, 0xF0, 0x30, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F,
  0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x03, 0xC1, 0xF0,
  0x20, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x07, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x18, 0x03, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x3B, 0x80, 0x07, 0x70, 0x01, 0xDE, 0x00, 0x73, 0x80, 0x1E, 0x70, 0x07,
  0x8E, 0x00, 0xE3, 0xC0, 0x38, 0x78, 0x0E, 0x0E, 0x03, 0xC1, 0xC0, 0x70,
  0x38, 0x1C, 0x0F, 0x07, 0x01, 0xE1, 0xE0, 0x38, 0x38, 0x07, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x79, 0x00, 0x1F,
  0xF8, 0x07, 0xFF, 0x80, 0xC7, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x1E, 0x20, 0x0F, 0x0F, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0x80, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x00, 0xE3, 0xE0, 0x7B, 0xFC, 0x1D, 0xFF, 0x87, 0xE1, 0xE3,
  0xE0, 0x3C, 0xF8, 0x0F, 0x3C, 0x01, 0xCF, 0x00, 0x73, 0x80, 0x3C, 0xE0,
  0x0F, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0xC0, 0x78, 0xF0, 0x1C, 0x1E, 0x0F,
  0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0xDF, 0xFF,
  0xE7, 0xFF, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xC1, 0xE0,
  0x70, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x70, 0x0F, 0x0E, 0x01, 0xC1,
  0xE0, 0x78, 0x1C, 0x1E, 0x03, 0xC7, 0x80, 0x3F, 0xE0, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x7F, 0xE0, 0x1E, 0x1E, 0x07, 0x81, 0xC1, 0xE0, 0x3C, 0x38,
  0x03, 0x8F, 0x00, 0x71, 0xE0, 0x0E, 0x3C, 0x01, 0xC7, 0x80, 0x38, 0xF0,
  0x0F, 0x0F, 0x03, 0xC1, 0xFB, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x00,
  0x7C, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x3E, 0x1E, 0x0F, 0x03, 0x87, 0x80,
  0xF1, 0xC0, 0x3C, 0x70, 0x07, 0x3C, 0x01, 0xCE, 0x00, 0xF3, 0x80, 0x3C,
  0xE0, 0x0F, 0x38, 0x03, 0xCF, 0x01, 0xE3, 0xC0, 0xF8, 0x7D, 0xEE, 0x1F,
  0xFF, 0x81, 0xF9, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x0F, 0xFF, 0x03,
  0xFF, 0x00, 0xFF, 0x80, 0x00, 0x06, 0x1F, 0x1F, 0x1E, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xF0,
  0xF0, 0xF0, 0xF0, 0x00, 0xC0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0,
  0x70, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x0C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xE0, 0x7F, 0xE3, 0xFF,
  0xCE, 0x0F, 0x20, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00,
  0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E,
  0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x7C, 0x07, 0xC0,
  0x3C, 0x00, 0x38, 0x0F, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x70, 0x70, 0x00,
  0x07, 0x1C, 0x07, 0xE0, 0xE7, 0x03, 0xFE, 0x1C, 0xE0, 0xFF, 0xC1, 0xB8,
  0x3C, 0x38, 0x37, 0x07, 0x07, 0x06, 0xE1, 0xC0, 0xC1, 0xF8, 0x30, 0x38,
  0x3F, 0x0E, 0x07, 0x07, 0xE1, 0xC0, 0xE0, 0xFC, 0x30, 0x38, 0x1B, 0x86,
  0x07, 0x07, 0x70, 0xC0, 0xE0, 0xEC, 0x18, 0x3C, 0x39, 0xC3, 0x8D, 0x8E,
  0x38, 0x7F, 0xBF, 0xC7, 0x07, 0xE7, 0xF0, 0xE0, 0x30, 0x38, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3E, 0x03, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x01, 0xDC, 0x00, 0x1D, 0xC0, 0x03, 0x9C, 0x00, 0x39,
  0xC0, 0x07, 0x9C, 0x00, 0x71, 0xC0, 0x0F, 0x1E, 0x00, 0xE1, 0xE0, 0x1E,
  0x0E, 0x01, 0xC0, 0xE0, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0xFF, 0xFE, 0x0E, 0x00, 0xE1, 0xE0, 0x0E, 0x1E, 0x00, 0xE3,
  0xC0, 0x0F, 0x3C, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x78,
  0x7F, 0x07, 0x80, 0xF0, 0x70, 0x0F, 0x07, 0x00, 0x70, 0x70, 0x07, 0x0F,
  0x00, 0x70, 0xF0, 0x0F, 0x0E, 0x00, 0xE0, 0xE0, 0x1E, 0x0E, 0x0F, 0xC1,
  0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1C, 0x07, 0x83, 0xC0, 0x3C,
  0x3C, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x78, 0x03,
  0xC7, 0x80, 0x3C, 0x70, 0x07, 0x87, 0x01, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF,
  0xC0, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xE0, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x10,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xE3, 0xFC, 0x07, 0x81, 0xF0, 0x1C,
  0x01, 0xE0, 0x70, 0x07, 0x81, 0xC0, 0x0E, 0x0F, 0x00, 0x3C, 0x3C, 0x00,
  0xF0, 0xE0, 0x03, 0xC3, 0x80, 0x0F, 0x0E, 0x00, 0x3C, 0x78, 0x00, 0xF1,
  0xE0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0,
  0x07, 0x0E, 0x00, 0x3C, 0x38, 0x00, 0xF0, 0xE0, 0x07, 0x87, 0x80, 0x3E,
  0x1E, 0x01, 0xF0, 0x70, 0x0F, 0x81, 0xC0, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x83, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x83, 0xC0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFC, 0x0F, 0x07, 0xC0,
  0x08, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0xFF, 0x9C, 0x03, 0xFC, 0xF0, 0x0F, 0xF3, 0xC0, 0x03,
  0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x38, 0xF0, 0x00, 0xE1, 0xC0, 0x03, 0x87,
  0x00, 0x1E, 0x1E, 0x00, 0x78, 0x7C, 0x01, 0xC0, 0xF8, 0x07, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x03, 0xC0, 0x0F, 0x03, 0x80,
  0x0F, 0x03, 0x80, 0x0E, 0x07, 0x80, 0x0E, 0x07, 0x80, 0x1E, 0x07, 0x00,
  0x1E, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x0F, 0x00, 0x1C, 0x0F, 0x00,
  0x3C, 0x0E, 0x00, 0x3C, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1C, 0x00, 0x70, 0x1C, 0x00,
  0x70, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x38, 0x00, 0xE0, 0x38, 0x00,
  0xE0, 0x78, 0x00, 0xE0, 0x78, 0x01, 0xE0, 0x70, 0x01, 0xE0, 0x70, 0x01,
  0xC0, 0x70, 0x01, 0xC0, 0xF0, 0x01, 0xC0, 0xF0, 0x03, 0xC0, 0x03, 0xFF,
  0x03, 0xFE, 0x07, 0xFE, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x07, 0x80, 0x6F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x1E, 0x07, 0x00, 0x78, 0x0E, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0x78, 0x1E, 0x00, 0xE0, 0x78, 0x01, 0xC1, 0xE0, 0x03,
  0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x3C, 0x00, 0x38, 0xF0, 0x00, 0x73,
  0xC0, 0x00, 0xEF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1E, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF0, 0xE0, 0x01, 0xE1, 0xE0,
  0x03, 0x83, 0xC0, 0x07, 0x03, 0x80, 0x1E, 0x07, 0x80, 0x3C, 0x0F, 0x00,
  0x70, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x38, 0x0F,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0xFF, 0xFF, 0xFE, 0xFF, 0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80,
  0x03, 0xF0, 0x3E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x01,
  0xF8, 0x1F, 0x80, 0x0F, 0xE0, 0x7E, 0x00, 0x3B, 0x81, 0xF8, 0x01, 0xFE,
  0x0F, 0x70, 0x07, 0x78, 0x39, 0xC0, 0x3D, 0xC0, 0xE7, 0x00, 0xE7, 0x03,
  0x9C, 0x07, 0xBC, 0x1E, 0x70, 0x1C, 0xF0, 0x79, 0xC0, 0xF3, 0x81, 0xC7,
  0x03, 0x8E, 0x07, 0x1C, 0x1C, 0x38, 0x1C, 0x70, 0x71, 0xE0, 0xF1, 0xC3,
  0x87, 0x83, 0x83, 0x0E, 0x1C, 0x0E, 0x0E, 0x70, 0x70, 0x38, 0x39, 0xC1,
  0xC0, 0xE0, 0xEE, 0x0F, 0x07, 0x83, 0xB8, 0x3C, 0x1C, 0x0F, 0xC0, 0xE0,
  0x70, 0x3F, 0x03, 0x81, 0xC0, 0xF8, 0x1E, 0x07, 0x03, 0xE0, 0x78, 0x3C,
  0x0F, 0x01, 0xE0, 0xE0, 0x3C, 0x07, 0x00, 0x03, 0xC0, 0x03, 0x81, 0xE0,
  0x03, 0xC0, 0xF0, 0x01, 0xC0, 0xFC, 0x00, 0xE0, 0x7E, 0x00, 0x70, 0x3F,
  0x00, 0x78, 0x1F, 0xC0, 0x3C, 0x0E, 0xE0, 0x1C, 0x0F, 0x70, 0x0E, 0x07,
  0x3C, 0x07, 0x03, 0x8E, 0x07, 0x81, 0xC7, 0x03, 0xC1, 0xE3, 0x81, 0xC0,
  0xF1, 0xE0, 0xE0, 0x70, 0x70, 0x70, 0x38, 0x38, 0x78, 0x1C, 0x1E, 0x38,
  0x1E, 0x07, 0x1C, 0x0F, 0x03, 0x8E, 0x07, 0x01, 0xE7, 0x03, 0x80, 0x77,
  0x81, 0xC0, 0x3B, 0x81, 0xE0, 0x1D, 0xC0, 0xE0, 0x0F, 0xE0, 0x70, 0x03,
  0xF0, 0x38, 0x01, 0xF8, 0x1C, 0x00, 0xF8, 0x1E, 0x00, 0x3C, 0x0E, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F,
  0x07, 0xC0, 0x7C, 0x07, 0x81, 0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x0F, 0x00,
  0x0E, 0x1C, 0x00, 0x1C, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x7B, 0xC0, 0x00,
  0xE7, 0x80, 0x01, 0xCF, 0x00, 0x03, 0x9C, 0x00, 0x0F, 0x38, 0x00, 0x1E,
  0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0xCF,
  0x00, 0x07, 0x9E, 0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0x78,
  0x03, 0xC0, 0x7C, 0x0F, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x78, 0xFE,
  0x07, 0x81, 0xE0, 0x70, 0x0E, 0x07, 0x00, 0xF0, 0x70, 0x0F, 0x0F, 0x00,
  0xF0, 0xF0, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x1E, 0x0E, 0x01, 0xC1, 0xE0,
  0x7C, 0x1E, 0x1F, 0x81, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x1F, 0x07, 0xC0, 0x7C, 0x07, 0x81, 0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x0F,
  0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x7B, 0xC0,
  0x00, 0xE7, 0x80, 0x01, 0xCF, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x38, 0x00,
  0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xE7, 0x80, 0x03,
  0xCF, 0x00, 0x07, 0x9E, 0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x3C, 0x00, 0xF0,
  0x78, 0x03, 0xC0, 0x7C, 0x0F, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x78, 0xFE, 0x07, 0x81, 0xE0,
  0x70, 0x0E, 0x07, 0x00, 0xF0, 0x70, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0E,
  0x0E, 0x00, 0xE0, 0xE0, 0x1E, 0x0E, 0x03, 0xC1, 0xE0, 0x7C, 0x1F, 0xFF,
  0x81, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xC3, 0x80, 0x3C, 0x3C, 0x03, 0x83,
  0xC0, 0x38, 0x1C, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0xE0, 0x70,
  0x0E, 0x07, 0x00, 0xF0, 0x70, 0x0F, 0x0F, 0x00, 0x70, 0xF0, 0x07, 0x80,
  0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xF0, 0xE0, 0x78, 0x04,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x18,
  0x07, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xDF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x1E, 0x0E, 0x00, 0x3C, 0x3C, 0x00, 0x70,
  0x78, 0x00, 0xE0, 0xE0, 0x03, 0xC1, 0xC0, 0x07, 0x87, 0x80, 0x0E, 0x0F,
  0x00, 0x1C, 0x1E, 0x00, 0x38, 0x38, 0x00, 0xF0, 0x70, 0x01, 0xE1, 0xE0,
  0x03, 0x83, 0xC0, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x3C, 0x1C, 0x00,
  0x78, 0x78, 0x00, 0xE0, 0xF0, 0x01, 0xC1, 0xC0, 0x07, 0x83, 0x80, 0x0F,
  0x07, 0x00, 0x1C, 0x1E, 0x00, 0x38, 0x3C, 0x00, 0xF0, 0x38, 0x01, 0xC0,
  0x78, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0x70, 0x01,
  0xEE, 0x00, 0x39, 0xC0, 0x0F, 0x38, 0x01, 0xC7, 0x00, 0x78, 0xF0, 0x0E,
  0x1E, 0x03, 0xC3, 0xC0, 0x70, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xE0, 0xF0,
  0x1C, 0x1E, 0x03, 0x87, 0x80, 0x70, 0xF0, 0x0E, 0x1C, 0x01, 0xC7, 0x80,
  0x38, 0xE0, 0x07, 0x3C, 0x00, 0xE7, 0x00, 0x1D, 0xE0, 0x03, 0xB8, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x03, 0x80, 0x1F, 0xC0, 0x0F, 0x00, 0x3B, 0x80, 0x1E, 0x00, 0xF7,
  0x00, 0x7C, 0x01, 0xCE, 0x00, 0xF8, 0x07, 0x9C, 0x03, 0xF0, 0x0E, 0x38,
  0x07, 0xE0, 0x3C, 0x70, 0x1F, 0xC0, 0x78, 0xE0, 0x3B, 0x80, 0xE1, 0xC0,
  0x77, 0x03, 0xC3, 0x81, 0xCE, 0x07, 0x07, 0x03, 0x9C, 0x1E, 0x0E, 0x0E,
  0x38, 0x38, 0x1C, 0x1C, 0x70, 0x70, 0x38, 0x78, 0xE1, 0xE0, 0x70, 0xE1,
  0xC3, 0x80, 0xF1, 0xC3, 0x8F, 0x01, 0xE7, 0x07, 0x1C, 0x03, 0xCE, 0x0E,
  0x78, 0x07, 0xB8, 0x1C, 0xE0, 0x0F, 0x70, 0x39, 0xC0, 0x1D, 0xC0, 0x77,
  0x80, 0x3B, 0x80, 0xEE, 0x00, 0x77, 0x01, 0xDC, 0x00, 0xFC, 0x01, 0xF0,
  0x01, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0x80, 0x07, 0xC0, 0x0F, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x01, 0xC0, 0x1E, 0x01,
  0xC0, 0x1C, 0x01, 0xE0, 0x3C, 0x00, 0xE0, 0x78, 0x00, 0xE0, 0x70, 0x00,
  0xF0, 0xF0, 0x00, 0xF1, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0x73, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xEE, 0x00, 0x01,
  0xEE, 0x00, 0x03, 0xCF, 0x00, 0x03, 0x87, 0x00, 0x07, 0x87, 0x00, 0x0F,
  0x07, 0x80, 0x0E, 0x07, 0x80, 0x1E, 0x03, 0x80, 0x3C, 0x03, 0x80, 0x38,
  0x03, 0xC0, 0x78, 0x03, 0xC0, 0xF0, 0x01, 0xC0, 0xE0, 0x03, 0xF8, 0x01,
  0xEE, 0x00, 0x73, 0xC0, 0x3C, 0xF0, 0x1E, 0x1C, 0x07, 0x87, 0x03, 0xC1,
  0xC0, 0xE0, 0x78, 0x78, 0x1E, 0x3C, 0x03, 0x8E, 0x00, 0xE7, 0x80, 0x39,
  0xC0, 0x0E, 0xF0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x01,
  0xFE, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70,
  0x80, 0x7F, 0x00, 0xFF, 0x00, 0xE1, 0xC3, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xF0, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0F, 0x0E, 0x1C, 0x38, 0x70, 0xE0, 0x00, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0xFE, 0x03, 0xFC,
  0x00, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0xEE, 0x00, 0x39, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x03, 0x83, 0x80,
  0xE0, 0xE0, 0x70, 0x1C, 0x1C, 0x07, 0x0E, 0x00, 0xE3, 0x80, 0x39, 0xC0,
  0x0E, 0xF0, 0x01, 0xC0, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0xF3, 0xC7,
  0x1E, 0x38, 0x70, 0xC0, 0x01, 0xE0, 0x01, 0xFE, 0x70, 0xFF, 0xDC, 0x7C,
  0x7F, 0x1E, 0x0F, 0x8F, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x70, 0x07,
  0x3C, 0x01, 0xCF, 0x00, 0x73, 0x80, 0x3C, 0xE0, 0x0F, 0x38, 0x03, 0x8E,
  0x01, 0xE3, 0x80, 0x78, 0xE0, 0x3E, 0x38, 0x0F, 0x8F, 0x07, 0xC3, 0xFF,
  0x70, 0x7F, 0x9C, 0x0F, 0xC7, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0F, 0x1E, 0x03, 0x9F, 0xC0, 0xEF, 0xF8, 0x3F, 0x1F, 0x1F, 0x83, 0xC7,
  0xC0, 0x71, 0xE0, 0x1C, 0x78, 0x07, 0x1C, 0x01, 0xCF, 0x00, 0x73, 0xC0,
  0x3C, 0xE0, 0x0F, 0x38, 0x03, 0xDE, 0x00, 0xE7, 0x80, 0x79, 0xE0, 0x1E,
  0x78, 0x0F, 0x1E, 0x03, 0xCF, 0xC1, 0xE3, 0xBD, 0xF0, 0xEF, 0xF8, 0x31,
  0xFC, 0x00, 0x00, 0xF8, 0x07, 0xFC, 0x3F, 0xF0, 0xF8, 0x21, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x43, 0xEF, 0x07, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x01, 0xE1, 0xC0, 0x7F, 0x9C, 0x0F, 0xFF, 0xC1,
  0xF0, 0xF8, 0x1E, 0x0F, 0x83, 0xC0, 0x78, 0x78, 0x07, 0x87, 0x80, 0x78,
  0x70, 0x07, 0x0F, 0x00, 0x70, 0xF0, 0x07, 0x0E, 0x00, 0xF0, 0xE0, 0x0F,
  0x0E, 0x00, 0xE0, 0xE0, 0x1E, 0x0E, 0x01, 0xE0, 0xE0, 0x3E, 0x0E, 0x07,
  0xC0, 0xF0, 0xFC, 0x0F, 0xFD, 0xC0, 0x7F, 0x9C, 0x03, 0xF1, 0xC0, 0x01,
  0xF0, 0x0F, 0xF8, 0x3F, 0xF8, 0xF8, 0xF3, 0xC0, 0xE7, 0x81, 0xDE, 0x03,
  0xB8, 0x0F, 0x70, 0x3D, 0xE1, 0xF3, 0xFF, 0xC7, 0xFE, 0x0F, 0x80, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x43, 0xF7,
  0x87, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x60, 0x00, 0x1F, 0xC0, 0x01,
  0xFE, 0x00, 0x1F, 0x20, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x80, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x4F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xE7, 0x03, 0xFF,
  0x70, 0x7C, 0x3F, 0x07, 0x83, 0xE0, 0xF0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0,
  0x1E, 0x1C, 0x01, 0xC3, 0xC0, 0x1C, 0x3C, 0x01, 0xC3, 0x80, 0x3C, 0x38,
  0x03, 0xC3, 0x80, 0x38, 0x38, 0x07, 0x83, 0x80, 0x78, 0x38, 0x0F, 0x83,
  0x81, 0xF8, 0x3C, 0x3F, 0x03, 0xFF, 0x70, 0x1F, 0xE7, 0x00, 0xFC, 0xF0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x08, 0x03, 0xC0, 0xF0, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x60,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x1E, 0x03, 0x9F, 0xE0,
  0xEF, 0xF8, 0x3F, 0x0F, 0x1F, 0x83, 0xC7, 0xC0, 0xF1, 0xE0, 0x3C, 0x78,
  0x0F, 0x1C, 0x03, 0x8F, 0x00, 0xE3, 0xC0, 0x38, 0xE0, 0x1E, 0x38, 0x07,
  0x8E, 0x01, 0xC7, 0x80, 0x71, 0xC0, 0x1C, 0x70, 0x0F, 0x1C, 0x03, 0x8F,
  0x00, 0xE3, 0xC0, 0x38, 0xE0, 0x0E, 0x38, 0x07, 0x80, 0x03, 0x83, 0xC1,
  0xE0, 0x60, 0x00, 0x00, 0x00, 0x02, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xE0,
  0xE0, 0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xC0, 0xE0,
  0x70, 0x78, 0x3C, 0x1C, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x04,
  0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x43, 0x80, 0xE0, 0xE0, 0x70, 0x38, 0x3C, 0x1E,
  0x1E, 0x07, 0x8F, 0x01, 0xC7, 0x80, 0x73, 0xC0, 0x1D, 0xE0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3E, 0xE0, 0x1F, 0x38, 0x07, 0x8F, 0x01,
  0xC1, 0xC0, 0x70, 0x78, 0x1C, 0x1E, 0x0F, 0x03, 0x83, 0xC0, 0xF0, 0xE0,
  0x3C, 0x38, 0x07, 0x80, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0,
  0x70, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xC0, 0x70,
  0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x1C,
  0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0xE7, 0xF0,
  0xFE, 0x0E, 0xFF, 0x9F, 0xF0, 0xFC, 0x7B, 0x8F, 0x1F, 0x83, 0xF0, 0x71,
  0xF0, 0x3E, 0x07, 0x1E, 0x03, 0xC0, 0x71, 0xE0, 0x3C, 0x07, 0x1C, 0x03,
  0x80, 0x73, 0xC0, 0x78, 0x0F, 0x3C, 0x07, 0x80, 0xE3, 0x80, 0x70, 0x0E,
  0x38, 0x07, 0x00, 0xE7, 0x80, 0xF0, 0x1E, 0x78, 0x0F, 0x01, 0xE7, 0x00,
  0xE0, 0x1C, 0x70, 0x0E, 0x01, 0xC7, 0x00, 0xE0, 0x1C, 0xF0, 0x1E, 0x03,
  0xCF, 0x01, 0xE0, 0x3C, 0xE0, 0x1C, 0x03, 0x8E, 0x01, 0xC0, 0x38, 0x0E,
  0x1E, 0x03, 0x9F, 0xE0, 0xEF, 0xF8, 0x3F, 0x1F, 0x1F, 0x83, 0xC7, 0xC0,
  0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x3C, 0x03, 0x8F, 0x00, 0xE3, 0xC0, 0x78,
  0xE0, 0x1E, 0x38, 0x07, 0x9E, 0x01, 0xC7, 0x80, 0x71, 0xE0, 0x3C, 0x70,
  0x0F, 0x1C, 0x03, 0xCF, 0x00, 0xE3, 0xC0, 0x38, 0xE0, 0x1E, 0x38, 0x07,
  0x80, 0x00, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xE3, 0xE3, 0xC0, 0xF1,
  0xE0, 0x39, 0xE0, 0x1E, 0xE0, 0x0F, 0x70, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xDC, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x7B, 0x80, 0x3D, 0xC0, 0x1C, 0xE0,
  0x1E, 0x70, 0x1E, 0x3C, 0x1F, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0x80, 0x39, 0xFC, 0x03, 0xBF, 0xE0, 0x3F, 0x0F, 0x07, 0xE0,
  0xF0, 0x7C, 0x07, 0x07, 0x80, 0x70, 0x78, 0x07, 0x07, 0x00, 0x70, 0xF0,
  0x07, 0x0F, 0x00, 0xF0, 0xE0, 0x0F, 0x0E, 0x00, 0xF0, 0xE0, 0x0E, 0x1E,
  0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x03, 0xC1, 0xE0, 0x3C, 0x3F, 0x07, 0x83,
  0xBD, 0xF0, 0x39, 0xFE, 0x03, 0x8F, 0xC0, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xFE, 0x70, 0xFF,
  0xDC, 0x7C, 0x7E, 0x1E, 0x0F, 0x8F, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E,
  0x70, 0x07, 0x3C, 0x01, 0xCF, 0x00, 0x73, 0x80, 0x3C, 0xE0, 0x0F, 0x38,
  0x03, 0x8E, 0x01, 0xE3, 0x80, 0x78, 0xE0, 0x3E, 0x38, 0x1F, 0x8F, 0x0F,
  0xC3, 0xFF, 0x70, 0x7F, 0x9C, 0x0F, 0xCF, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x1C, 0xF8, 0x3B, 0xF0,
  0x7F, 0x21, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xF0, 0x0F, 0xFC, 0x3F, 0xF8, 0xF0, 0x61, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF2, 0x01, 0xE7,
  0x9F, 0x8F, 0xFE, 0x0F, 0xF8, 0x00, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x01,
  0xE1, 0xFF, 0xFF, 0xF8, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80,
  0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0xD0, 0xFE, 0x0F, 0xC0, 0x1C, 0x03, 0xC7, 0x00, 0xF3, 0xC0,
  0x38, 0xF0, 0x0E, 0x38, 0x03, 0x8E, 0x01, 0xE3, 0x80, 0x71, 0xE0, 0x1C,
  0x78, 0x07, 0x1C, 0x03, 0xC7, 0x00, 0xF1, 0xC0, 0x38, 0xF0, 0x0E, 0x3C,
  0x07, 0x8E, 0x01, 0xE3, 0x80, 0xF8, 0xE0, 0x7C, 0x3C, 0x3F, 0x0F, 0xBD,
  0xC1, 0xFE, 0x70, 0x7F, 0x18, 0x00, 0xF0, 0x07, 0xF8, 0x07, 0xBC, 0x03,
  0x9E, 0x03, 0xCF, 0x01, 0xC3, 0x81, 0xE1, 0xC0, 0xE0, 0xE0, 0xF0, 0x70,
  0x70, 0x38, 0x78, 0x1C, 0x38, 0x0E, 0x3C, 0x07, 0x1C, 0x03, 0x9E, 0x01,
  0xCE, 0x00, 0xEF, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x03, 0xFC, 0x0F, 0x80, 0xEF, 0x03, 0xE0,
  0x7B, 0xC1, 0xF8, 0x1C, 0xF0, 0x7E, 0x0F, 0x3C, 0x1B, 0x83, 0x8F, 0x0E,
  0xE0, 0xE1, 0xC3, 0xB8, 0x70, 0x71, 0xCE, 0x1C, 0x1C, 0x73, 0x8F, 0x07,
  0x38, 0xE3, 0x81, 0xCE, 0x39, 0xE0, 0x73, 0x0E, 0x70, 0x1D, 0xC3, 0x9C,
  0x07, 0x70, 0xEE, 0x01, 0xF8, 0x3B, 0x80, 0x7E, 0x0E, 0xE0, 0x1F, 0x03,
  0xF0, 0x07, 0xC0, 0xFC, 0x01, 0xE0, 0x3E, 0x00, 0x78, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0xF8, 0x1C, 0x0F, 0x00, 0xF0, 0x70, 0x03, 0x87, 0x80, 0x1C,
  0x78, 0x00, 0xF7, 0x80, 0x03, 0xB8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFE,
  0x00, 0x1E, 0x70, 0x00, 0xE3, 0x80, 0x0E, 0x1E, 0x00, 0xF0, 0x70, 0x0F,
  0x03, 0x80, 0x70, 0x1E, 0x0F, 0x80, 0x70, 0x00, 0x03, 0xC0, 0x1E, 0x07,
  0x80, 0x78, 0x0F, 0x00, 0xE0, 0x0E, 0x03, 0xC0, 0x1C, 0x07, 0x00, 0x38,
  0x1E, 0x00, 0x70, 0x38, 0x00, 0xE0, 0xF0, 0x01, 0xC1, 0xC0, 0x03, 0x87,
  0x80, 0x07, 0x0E, 0x00, 0x0F, 0x3C, 0x00, 0x0E, 0x70, 0x00, 0x1D, 0xE0,
  0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x04, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x1F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x00,
  0x06, 0x00, 0x7C, 0x03, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x80, 0xFE, 0x01, 0xF0, 0x03, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x00, 0x03, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x1E, 0x00,
  0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0xFE, 0x01, 0xF8, 0x03,
  0xE0, 0x00, 0x1C, 0x00, 0x5F, 0xE0, 0x3F, 0xFF, 0x3F, 0x87, 0xFF, 0x80,
  0x7F, 0xA0, 0x00, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Italic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 10, 29, 10, 1, -29 },
  { 38, 12, 11, 15, 4, -29 },
  { 55, 22, 29, 23, 1, -29 },
  { 135, 18, 32, 20, 1, -30 },
  { 207, 25, 29, 29, 3, -29 },
  { 298, 21, 29, 23, 1, -29 },
  { 375, 5, 11, 8, 4, -29 },
  { 382, 13, 35, 11, 1, -29 },
  { 439, 13, 35, 11, -3, -29 },
  { 496, 16, 17, 19, 4, -31 },
  { 530, 18, 19, 21, 2, -24 },
  { 573, 8, 10, 9, -2, -5 },
  { 583, 10, 3, 12, 1, -12 },
  { 587, 4, 5, 9, 1, -5 },
  { 590, 19, 29, 14, -2, -29 },
  { 659, 17, 29, 20, 2, -29 },
  { 721, 11, 29, 20, 5, -29 },
  { 761, 19, 29, 20, 0, -29 },
  { 830, 19, 29, 20, 0, -29 },
  { 899, 19, 29, 20, 0, -29 },
  { 968, 18, 29, 20, 1, -29 },
  { 1034, 18, 29, 20, 2, -29 },
  { 1100, 18, 29, 20, 3, -29 },
  { 1166, 19, 29, 20, 1, -29 },
  { 1235, 18, 29, 20, 1, -29 },
  { 1301, 8, 22, 9, 1, -22 },
  { 1323, 11, 27, 9, -2, -22 },
  { 1361, 18, 19, 21, 2, -24 },
  { 1404, 17, 11, 21, 3, -20 },
  { 1428, 18, 19, 21, 2, -24 },
  { 1471, 14, 29, 15, 2, -29 },
  { 1522, 27, 33, 30, 2, -29 },
  { 1634, 20, 29, 20, -2, -29 },
  { 1707, 20, 29, 22, 1, -29 },
  { 1780, 21, 29, 21, 2, -29 },
  { 1857, 22, 29, 24, 1, -29 },
  { 1937, 19, 29, 18, 1, -29 },
  { 2006, 19, 29, 17, 1, -29 },
  { 2075, 22, 29, 24, 2, -29 },
  { 2155, 24, 29, 24, 1, -29 },
  { 2242, 16, 29, 12, -1, -29 },
  { 2300, 17, 37, 10, -6, -29 },
  { 2379, 23, 29, 20, 1, -29 },
  { 2463, 14, 29, 17, 1, -29 },
  { 2514, 30, 29, 31, 1, -29 },
  { 2623, 25, 29, 25, 1, -29 },
  { 2714, 23, 29, 26, 2, -29 },
  { 2798, 20, 29, 20, 1, -29 },
  { 2871, 23, 36, 26, 2, -29 },
  { 2975, 20, 29, 21, 1, -29 },
  { 3048, 19, 29, 18, 0, -29 },
  { 3117, 18, 29, 18, 3, -29 },
  { 3183, 23, 29, 24, 2, -29 },
  { 3267, 19, 29, 20, 4, -29 },
  { 3336, 31, 29, 31, 4, -29 },
  { 3449, 24, 29, 19, -2, -29 },
  { 3536, 18, 29, 18, 4, -29 },
  { 3602, 21, 29, 18, -1, -29 },
  { 3679, 16, 35, 11, -1, -29 },
  { 3749, 7, 29, 14, 4, -29 },
  { 3775, 15, 35, 11, -3, -29 },
  { 3841, 18, 17, 20, 1, -29 },
  { 3880, 15, 3, 14, -4, 3 },
  { 3886, 6, 7, 11, 6, -31 },
  { 3892, 18, 22, 21, 2, -22 },
  { 3942, 18, 30, 21, 1, -30 },
  { 4010, 15, 22, 16, 2, -22 },
  { 4052, 20, 30, 21, 2, -30 },
  { 4127, 15, 22, 18, 2, -22 },
  { 4169, 21, 41, 11, -5, -31 },
  { 4277, 20, 32, 21, 0, -22 },
  { 4357, 18, 30, 21, 1, -30 },
  { 4425, 9, 29, 9, 1, -29 },
  { 4458, 15, 39, 9, -5, -29 },
  { 4532, 18, 30, 18, 1, -30 },
  { 4600, 10, 30, 9, 1, -30 },
  { 4638, 28, 22, 31, 1, -22 },
  { 4715, 18, 22, 21, 1, -22 },
  { 4765, 17, 22, 20, 2, -22 },
  { 4812, 20, 31, 21, -1, -22 },
  { 4890, 18, 32, 21, 2, -22 },
  { 4962, 15, 22, 14, 1, -22 },
  { 5004, 15, 22, 16, 0, -22 },
  { 5046, 11, 26, 12, 2, -26 },
  { 5082, 18, 21, 21, 2, -21 },
  { 5130, 17, 21, 17, 2, -21 },
  { 5175, 26, 21, 26, 2, -21 },
  { 5244, 21, 21, 17, -2, -21 },
  { 5300, 23, 31, 17, -4, -21 },
  { 5390, 17, 21, 15, -1, -21 },
  { 5435, 15, 35, 14, 1, -29 },
  { 5501, 3, 40, 19, 9, -30 },
  { 5516, 15, 35, 14, -2, -29 },
  { 5582, 18, 6, 21, 2, -17 },
};

const GFXfont NotoSans_SemiCondensed_Italic40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic40pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC40PT7B_H_
