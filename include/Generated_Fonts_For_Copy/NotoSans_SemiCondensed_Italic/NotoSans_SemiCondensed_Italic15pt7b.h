#ifndef _NOTOSANS_SEMICONDENSED_ITALIC15PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x22, 0x22, 0x44, 0x04, 0xC0, 0xDB, 0xAA, 0x09, 0x04, 0x84,
  0x8F, 0xF1, 0x20, 0xA0, 0x91, 0xFE, 0x24, 0x24, 0x12, 0x00, 0x0C, 0x3C,
  0xA1, 0x42, 0x83, 0x07, 0x0A, 0x15, 0xF0, 0x81, 0x00, 0x30, 0xA8, 0xA4,
  0x92, 0x49, 0x55, 0x55, 0xAA, 0x29, 0x24, 0x92, 0x51, 0xC0, 0x0C, 0x12,
  0x32, 0x36, 0x1C, 0x38, 0x69, 0xCF, 0xC6, 0xCE, 0x7B, 0xEA, 0x08, 0x8C,
  0x46, 0x21, 0x08, 0x46, 0x10, 0x84, 0x00, 0x10, 0x84, 0x31, 0x8C, 0x42,
  0x11, 0x88, 0xCC, 0x00, 0x32, 0x87, 0xD8, 0x90, 0x40, 0x10, 0x41, 0x3F,
  0x10, 0x41, 0x00, 0x2D, 0x60, 0x7F, 0x70, 0x02, 0x04, 0x10, 0x60, 0x83,
  0x04, 0x10, 0x20, 0x83, 0x00, 0x19, 0xB4, 0x71, 0x86, 0x18, 0x63, 0x8A,
  0x6F, 0x00, 0x17, 0xF2, 0x22, 0x26, 0x44, 0x40, 0x1C, 0x4C, 0x08, 0x10,
  0x61, 0x82, 0x08, 0x20, 0x83, 0xF0, 0x1C, 0x4C, 0x08, 0x10, 0x47, 0x03,
  0x02, 0x05, 0x1B, 0xE0, 0x02, 0x0C, 0x28, 0xA3, 0x44, 0x91, 0x7F, 0xFE,
  0x10, 0x20, 0x1E, 0x60, 0x81, 0x03, 0x8D, 0x81, 0x03, 0x05, 0x1B, 0xE0,
  0x1C, 0xC6, 0x10, 0xFB, 0x28, 0xE3, 0x8A, 0x27, 0x00, 0x7E, 0x08, 0x10,
  0x40, 0x82, 0x0C, 0x10, 0x60, 0x83, 0x00, 0x1C, 0x64, 0x89, 0x13, 0x43,
  0x19, 0x22, 0xC6, 0x89, 0xE0, 0x1C, 0x6D, 0x8A, 0x14, 0x2C, 0xCF, 0x82,
  0x04, 0x13, 0xC0, 0x2C, 0x00, 0x16, 0x13, 0x00, 0x00, 0x26, 0x48, 0x04,
  0x33, 0x30, 0x60, 0x60, 0x40, 0xFC, 0x00, 0x3F, 0x83, 0x81, 0x81, 0x1D,
  0x88, 0x00, 0x76, 0xC2, 0x11, 0x11, 0x08, 0x04, 0x30, 0x0F, 0x0C, 0x66,
  0x05, 0x39, 0x92, 0x64, 0x9A, 0x26, 0x92, 0xBB, 0xA0, 0x0C, 0x01, 0xF8,
  0x06, 0x06, 0x0E, 0x0A, 0x1A, 0x12, 0x3E, 0x3E, 0x63, 0x43, 0xC3, 0x1E,
  0x33, 0x21, 0x21, 0x22, 0x3C, 0x62, 0x42, 0x42, 0x46, 0xFC, 0x1F, 0x32,
  0x60, 0x40, 0xC0, 0x80, 0x80, 0x80, 0x80, 0xC0, 0x78, 0x1C, 0x1B, 0x88,
  0x44, 0x22, 0x19, 0x09, 0x84, 0x86, 0x42, 0x27, 0x3E, 0x00, 0x1F, 0x30,
  0x20, 0x20, 0x20, 0x3C, 0x60, 0x40, 0x40, 0x40, 0xF8, 0x1F, 0x30, 0x20,
  0x20, 0x20, 0x3C, 0x60, 0x40, 0x40, 0x40, 0xC0, 0x0E, 0x31, 0x60, 0x40,
  0xC0, 0x8E, 0x82, 0x82, 0x82, 0xC6, 0x7C, 0x10, 0x98, 0x48, 0x24, 0x32,
  0x11, 0xF9, 0x84, 0x86, 0x43, 0x21, 0x30, 0x80, 0x38, 0x84, 0x62, 0x10,
  0x8C, 0x62, 0x38, 0x04, 0x30, 0x82, 0x08, 0x21, 0x84, 0x10, 0x41, 0x0C,
  0x23, 0x00, 0x11, 0x99, 0x89, 0x84, 0x82, 0x81, 0xC1, 0xA0, 0x98, 0x4C,
  0x22, 0x31, 0x80, 0x11, 0x88, 0x42, 0x11, 0x88, 0x42, 0x3E, 0x10, 0x33,
  0x86, 0x28, 0x62, 0x8A, 0x28, 0xA2, 0x96, 0x69, 0x44, 0xA4, 0x4A, 0x44,
  0xCC, 0xCC, 0xC0, 0x10, 0xCC, 0x23, 0x88, 0xA2, 0x28, 0x8B, 0x66, 0x51,
  0x14, 0x47, 0x10, 0xCC, 0x30, 0x1E, 0x33, 0x61, 0x41, 0xC1, 0x81, 0x83,
  0x83, 0x82, 0xC4, 0x78, 0x1C, 0x36, 0x23, 0x23, 0x22, 0x26, 0x78, 0x40,
  0x40, 0x40, 0xC0, 0x1E, 0x33, 0x61, 0x41, 0xC1, 0x81, 0x81, 0x83, 0x82,
  0xC4, 0x78, 0x08, 0x0C, 0x04, 0x1C, 0x36, 0x23, 0x23, 0x22, 0x3E, 0x78,
  0x4C, 0x44, 0x44, 0xC6, 0x1E, 0x65, 0x83, 0x02, 0x03, 0x03, 0x02, 0x05,
  0x1B, 0xE0, 0xFE, 0x20, 0x41, 0x82, 0x04, 0x08, 0x10, 0x60, 0x81, 0x00,
  0x21, 0x61, 0x41, 0x43, 0x42, 0xC2, 0xC2, 0x86, 0x84, 0xCC, 0x78, 0xC3,
  0xC2, 0xC6, 0x44, 0x4C, 0x48, 0x58, 0x50, 0x70, 0x60, 0x60, 0xC2, 0x14,
  0x62, 0x46, 0x24, 0xA6, 0x4A, 0x45, 0x2C, 0x52, 0x87, 0x28, 0x63, 0x06,
  0x30, 0x43, 0x00, 0x10, 0x88, 0x86, 0xC1, 0x40, 0xC0, 0x60, 0x70, 0x28,
  0x24, 0x33, 0x30, 0x80, 0xC2, 0x89, 0x32, 0x45, 0x8E, 0x08, 0x10, 0x60,
  0x81, 0x00, 0x3F, 0x02, 0x06, 0x0C, 0x08, 0x10, 0x30, 0x20, 0x40, 0xC0,
  0xFC, 0x19, 0x08, 0x42, 0x31, 0x08, 0x42, 0x31, 0x0E, 0x00, 0xAA, 0xAD,
  0x54, 0x1C, 0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0xC2, 0x08, 0xE0, 0x08,
  0x30, 0x61, 0x22, 0x48, 0x70, 0x80, 0xF8, 0xCC, 0x3E, 0x9B, 0x14, 0x28,
  0xD1, 0x26, 0x74, 0x30, 0x60, 0x81, 0x73, 0x2C, 0x58, 0xA1, 0x46, 0x8A,
  0xE0, 0x3A, 0x21, 0x08, 0x42, 0x1E, 0x02, 0x04, 0x1B, 0xE4, 0xD8, 0xA1,
  0x46, 0x89, 0x33, 0xA0, 0x3A, 0x63, 0xF8, 0x42, 0x1E, 0x07, 0x0C, 0x08,
  0x1E, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x10, 0x30, 0x20, 0xE0, 0xC0,
  0x1F, 0x26, 0x62, 0x42, 0x46, 0x44, 0x4C, 0x74, 0x0C, 0x08, 0xD8, 0x60,
  0x30, 0x60, 0x81, 0x73, 0x2C, 0x58, 0xA3, 0x44, 0x8B, 0x10, 0x32, 0x02,
  0x26, 0x44, 0x44, 0xC0, 0x0C, 0x20, 0x02, 0x08, 0x61, 0x04, 0x10, 0x43,
  0x08, 0x23, 0x8C, 0x00, 0x30, 0x60, 0x81, 0x32, 0xCF, 0x14, 0x3C, 0x48,
  0x93, 0x30, 0x33, 0x22, 0x26, 0x44, 0x44, 0xC0, 0x2E, 0xE6, 0x65, 0x88,
  0xB3, 0x34, 0x44, 0x88, 0x91, 0x16, 0x66, 0x2E, 0x65, 0x8B, 0x34, 0x68,
  0x91, 0x62, 0x39, 0x38, 0x61, 0x8E, 0x29, 0xBC, 0x2E, 0x65, 0x8B, 0x14,
  0x28, 0xD1, 0x7C, 0x81, 0x02, 0x04, 0x00, 0x3E, 0x9B, 0x14, 0x28, 0xD1,
  0x26, 0x74, 0x18, 0x30, 0x40, 0x80, 0x2C, 0xC6, 0x18, 0x41, 0x04, 0x30,
  0x3D, 0x04, 0x18, 0x18, 0x29, 0xBC, 0x24, 0xF4, 0xC8, 0x88, 0x8E, 0x45,
  0x1C, 0x63, 0x8E, 0x29, 0xBA, 0x8E, 0x29, 0xA4, 0xB2, 0x8A, 0x30, 0x88,
  0xCC, 0x66, 0x55, 0x2A, 0xA5, 0x53, 0x29, 0x98, 0x33, 0x16, 0x14, 0x18,
  0x18, 0x38, 0x24, 0xC4, 0x23, 0x22, 0x26, 0x24, 0x2C, 0x28, 0x38, 0x10,
  0x30, 0x20, 0xE0, 0x80, 0x7C, 0x21, 0x8C, 0x21, 0x0C, 0x3E, 0x0C, 0x61,
  0x04, 0x10, 0x8E, 0x18, 0x21, 0x84, 0x10, 0x60, 0xFF, 0xFE, 0x10, 0x20,
  0x82, 0x18, 0x60, 0xC6, 0x10, 0xC2, 0x08, 0xE0, 0xF6, 0x30,
};

const GFXglyph NotoSans_SemiCondensed_Italic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 11, 4, 0, -11 },
  { 7, 4, 4, 6, 2, -11 },
  { 9, 9, 11, 8, 0, -11 },
  { 22, 7, 12, 7, 0, -11 },
  { 33, 9, 11, 11, 1, -11 },
  { 46, 8, 11, 9, 0, -11 },
  { 57, 2, 4, 3, 2, -11 },
  { 58, 5, 13, 4, 0, -11 },
  { 67, 5, 13, 4, -1, -11 },
  { 76, 6, 6, 7, 2, -11 },
  { 81, 6, 7, 8, 1, -9 },
  { 87, 3, 4, 4, -1, -2 },
  { 89, 4, 2, 4, 0, -5 },
  { 90, 2, 2, 4, 0, -2 },
  { 91, 7, 11, 5, -1, -11 },
  { 101, 6, 11, 7, 1, -11 },
  { 110, 4, 11, 7, 2, -11 },
  { 116, 7, 11, 7, 0, -11 },
  { 126, 7, 11, 7, 0, -11 },
  { 136, 7, 11, 7, 0, -11 },
  { 146, 7, 11, 7, 0, -11 },
  { 156, 6, 11, 7, 1, -11 },
  { 165, 7, 11, 7, 1, -11 },
  { 175, 7, 11, 7, 0, -11 },
  { 185, 7, 11, 7, 0, -11 },
  { 195, 3, 8, 4, 0, -8 },
  { 198, 4, 10, 4, -1, -8 },
  { 203, 6, 7, 8, 1, -9 },
  { 209, 6, 4, 8, 1, -7 },
  { 212, 6, 7, 8, 1, -9 },
  { 218, 5, 11, 6, 1, -11 },
  { 225, 10, 12, 11, 1, -11 },
  { 240, 8, 11, 8, -1, -11 },
  { 251, 8, 11, 8, 0, -11 },
  { 262, 8, 11, 8, 1, -11 },
  { 273, 9, 11, 9, 0, -11 },
  { 286, 8, 11, 7, 0, -11 },
  { 297, 8, 11, 6, 0, -11 },
  { 308, 8, 11, 9, 1, -11 },
  { 319, 9, 11, 9, 0, -11 },
  { 332, 5, 11, 5, 0, -11 },
  { 339, 6, 14, 4, -2, -11 },
  { 350, 9, 11, 8, 0, -11 },
  { 363, 5, 11, 6, 0, -11 },
  { 370, 12, 11, 12, 0, -11 },
  { 387, 10, 11, 10, 0, -11 },
  { 401, 8, 11, 10, 1, -11 },
  { 412, 8, 11, 8, 0, -11 },
  { 423, 8, 14, 10, 1, -11 },
  { 437, 8, 11, 8, 0, -11 },
  { 448, 7, 11, 7, 0, -11 },
  { 458, 7, 11, 7, 1, -11 },
  { 468, 8, 11, 9, 1, -11 },
  { 479, 8, 11, 7, 1, -11 },
  { 490, 12, 11, 12, 1, -11 },
  { 507, 9, 11, 7, -1, -11 },
  { 520, 7, 11, 7, 1, -11 },
  { 530, 8, 11, 7, 0, -11 },
  { 541, 5, 13, 4, 0, -11 },
  { 550, 2, 11, 5, 2, -11 },
  { 553, 6, 13, 4, -1, -11 },
  { 563, 7, 7, 8, 0, -11 },
  { 570, 5, 1, 5, -1, 1 },
  { 571, 3, 2, 4, 2, -11 },
  { 572, 7, 8, 8, 1, -8 },
  { 579, 7, 11, 8, 0, -11 },
  { 589, 5, 8, 6, 1, -8 },
  { 594, 7, 11, 8, 1, -11 },
  { 604, 5, 8, 7, 1, -8 },
  { 609, 8, 15, 4, -2, -11 },
  { 624, 8, 12, 8, 0, -8 },
  { 636, 7, 11, 8, 0, -11 },
  { 646, 4, 11, 4, 0, -11 },
  { 652, 6, 15, 4, -2, -11 },
  { 664, 7, 11, 7, 0, -11 },
  { 674, 4, 11, 4, 0, -11 },
  { 680, 11, 8, 12, 0, -8 },
  { 691, 7, 8, 8, 0, -8 },
  { 698, 6, 8, 8, 1, -8 },
  { 704, 7, 12, 8, 0, -8 },
  { 715, 7, 12, 8, 1, -8 },
  { 726, 6, 8, 5, 0, -8 },
  { 732, 6, 8, 6, 0, -8 },
  { 738, 4, 10, 4, 1, -10 },
  { 743, 6, 8, 8, 1, -8 },
  { 749, 6, 8, 6, 1, -8 },
  { 755, 9, 8, 10, 1, -8 },
  { 764, 8, 8, 6, -1, -8 },
  { 772, 8, 12, 6, -1, -8 },
  { 784, 6, 8, 6, 0, -8 },
  { 790, 6, 13, 5, 0, -11 },
  { 800, 1, 15, 7, 3, -11 },
  { 802, 6, 13, 5, -1, -11 },
  { 812, 6, 2, 8, 1, -6 },
};

const GFXfont NotoSans_SemiCondensed_Italic15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic15pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC15PT7B_H_
