#ifndef _NOTOSANS_SEMICONDENSED_ITALIC13PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0xB4, 0x82, 0xC0, 0x55, 0xA0, 0x12, 0x14, 0x7F, 0x24, 0x24,
  0xFE, 0x48, 0x48, 0x50, 0x08, 0x73, 0x54, 0x30, 0x61, 0x8A, 0xF8, 0x82,
  0x00, 0x72, 0x94, 0x94, 0xAA, 0xF5, 0x19, 0x29, 0x4A, 0xCE, 0x3C, 0x48,
  0x91, 0xC3, 0x0B, 0x63, 0x46, 0x76, 0x58, 0x19, 0x08, 0x84, 0x23, 0x10,
  0xC2, 0x10, 0x31, 0x11, 0x11, 0x12, 0x24, 0x80, 0x12, 0x47, 0xCC, 0x50,
  0x21, 0x09, 0xF2, 0x10, 0x80, 0x2D, 0x40, 0xE0, 0x70, 0x06, 0x08, 0x20,
  0xC1, 0x04, 0x08, 0x20, 0xC0, 0x7A, 0x63, 0x18, 0xC6, 0x52, 0xE0, 0x74,
  0xB4, 0x92, 0x80, 0x3C, 0x10, 0x43, 0x08, 0x42, 0x10, 0xF8, 0x3C, 0x10,
  0x42, 0x38, 0x20, 0x82, 0xF0, 0x0C, 0x31, 0x4A, 0x4B, 0x2F, 0xC6, 0x10,
  0x3C, 0x82, 0x1C, 0x08, 0x30, 0xC2, 0xF0, 0x3A, 0x31, 0x6D, 0xC6, 0x32,
  0xF0, 0xFC, 0x21, 0x04, 0x20, 0x84, 0x10, 0x80, 0x3C, 0x92, 0x4A, 0x39,
  0x28, 0x72, 0x78, 0x3D, 0x14, 0x51, 0x6C, 0xD0, 0x86, 0xF0, 0x68, 0x00,
  0xB0, 0x32, 0x00, 0x02, 0x44, 0x80, 0x08, 0xD9, 0x06, 0x0C, 0xF8, 0x3E,
  0x86, 0x0C, 0x13, 0x60, 0xF1, 0x12, 0x44, 0x88, 0x80, 0x3E, 0x20, 0x93,
  0x52, 0x9A, 0x55, 0x2A, 0xB5, 0x2C, 0x80, 0x3E, 0x00, 0x0C, 0x18, 0x70,
  0xA3, 0x47, 0xD8, 0xA1, 0xC2, 0x3E, 0x44, 0x89, 0x27, 0xC8, 0x91, 0x22,
  0xF8, 0x3D, 0x0C, 0x20, 0x82, 0x08, 0x20, 0x78, 0x3E, 0x44, 0x89, 0x14,
  0x28, 0x51, 0xA6, 0xF8, 0x3E, 0x40, 0x81, 0x07, 0x88, 0x10, 0x20, 0xF8,
  0x3E, 0x40, 0x81, 0x07, 0x88, 0x10, 0x20, 0xC0, 0x3E, 0x83, 0x04, 0x09,
  0xD0, 0xA1, 0x46, 0x78, 0x21, 0x21, 0x22, 0x22, 0x7E, 0x42, 0x46, 0x44,
  0xC4, 0x79, 0x08, 0x42, 0x21, 0x08, 0xE0, 0x08, 0x42, 0x11, 0x08, 0x42,
  0x31, 0x38, 0x23, 0x24, 0x28, 0x30, 0x70, 0x58, 0x48, 0x48, 0xCC, 0x21,
  0x08, 0x44, 0x21, 0x08, 0xF8, 0x30, 0xCC, 0x33, 0x1D, 0xC6, 0x52, 0x95,
  0xA5, 0x49, 0x26, 0x89, 0x00, 0x31, 0x31, 0x31, 0x69, 0x4A, 0x4A, 0x4E,
  0x46, 0x86, 0x3C, 0x87, 0x0C, 0x18, 0x30, 0xE1, 0x46, 0x78, 0x3C, 0x4C,
  0x89, 0x27, 0xC8, 0x10, 0x20, 0xC0, 0x3C, 0x87, 0x0C, 0x18, 0x30, 0xE1,
  0x46, 0x78, 0x20, 0x20, 0x3C, 0x4C, 0x99, 0x27, 0x89, 0x12, 0x24, 0xCC,
  0x3D, 0x84, 0x08, 0x10, 0x20, 0x82, 0xF0, 0xFC, 0x82, 0x08, 0x21, 0x04,
  0x10, 0x40, 0x42, 0x85, 0x16, 0x28, 0x50, 0xA3, 0x44, 0xF0, 0x87, 0x0A,
  0x26, 0x45, 0x0A, 0x18, 0x30, 0x40, 0x8C, 0x63, 0x29, 0x4A, 0x52, 0x95,
  0x29, 0x4A, 0x63, 0x18, 0xC4, 0x00, 0x33, 0x12, 0x14, 0x08, 0x18, 0x18,
  0x24, 0x64, 0xC4, 0x8D, 0x25, 0x14, 0x61, 0x04, 0x10, 0x40, 0x3E, 0x08,
  0x20, 0x83, 0x04, 0x10, 0x60, 0xF8, 0x39, 0x08, 0x84, 0x21, 0x08, 0x84,
  0x30, 0x89, 0x24, 0x92, 0x20, 0x38, 0x44, 0x21, 0x08, 0x44, 0x21, 0x38,
  0x10, 0xA2, 0x91, 0xC4, 0xF8, 0x90, 0x7F, 0x28, 0xA2, 0x9A, 0x4F, 0x00,
  0x20, 0x82, 0x0F, 0x65, 0x14, 0x51, 0x4A, 0xE0, 0x7C, 0x88, 0x88, 0xE0,
  0x02, 0x04, 0x09, 0xE6, 0x48, 0x91, 0x66, 0x48, 0xF0, 0x39, 0x94, 0x9C,
  0xC1, 0x07, 0x80, 0x06, 0x10, 0x20, 0xE0, 0x82, 0x04, 0x08, 0x10, 0x60,
  0x81, 0x0E, 0x00, 0x3E, 0xC9, 0x12, 0x2C, 0xC9, 0x1E, 0x04, 0x19, 0xE0,
  0x20, 0x82, 0x0F, 0x65, 0x14, 0x53, 0x4A, 0x20, 0x24, 0x14, 0x92, 0x50,
  0x08, 0x40, 0x11, 0x08, 0x42, 0x11, 0x08, 0x4C, 0x00, 0x20, 0x82, 0x09,
  0x49, 0x47, 0x14, 0x5A, 0x20, 0x24, 0x94, 0x92, 0x50, 0x3D, 0x99, 0xB4,
  0x49, 0x12, 0x48, 0x92, 0x28, 0x98, 0x3D, 0x94, 0x51, 0x4D, 0x28, 0x80,
  0x76, 0x63, 0x18, 0xCB, 0x80, 0x3D, 0x94, 0x51, 0x45, 0x2B, 0xA0, 0x82,
  0x00, 0x3E, 0xC9, 0x12, 0x2C, 0xC9, 0x1E, 0x04, 0x08, 0x30, 0x3B, 0x10,
  0x84, 0x22, 0x00, 0x7A, 0x10, 0x41, 0x0B, 0xC0, 0x4B, 0xE9, 0x24, 0xC0,
  0x4C, 0x63, 0x19, 0xCB, 0xC0, 0x8C, 0xA5, 0x4A, 0x63, 0x00, 0x91, 0x9A,
  0xAA, 0xAE, 0xCC, 0xCC, 0x88, 0x26, 0x28, 0x60, 0x83, 0x85, 0x33, 0x00,
  0x22, 0x48, 0x91, 0x42, 0x86, 0x0C, 0x10, 0x21, 0x80, 0x78, 0x84, 0x44,
  0x63, 0xC0, 0x18, 0x88, 0x42, 0x61, 0x08, 0x42, 0x18, 0xFF, 0xF8, 0x30,
  0x44, 0x21, 0x04, 0x44, 0x21, 0x30, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_Italic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 4, 3, 5, 1, -9 },
  { 7, 8, 9, 7, 0, -9 },
  { 16, 6, 11, 6, 0, -10 },
  { 25, 8, 9, 9, 1, -9 },
  { 34, 7, 9, 8, 0, -9 },
  { 42, 2, 3, 3, 1, -9 },
  { 43, 5, 11, 4, 0, -9 },
  { 50, 4, 11, 4, -1, -9 },
  { 56, 6, 5, 6, 1, -10 },
  { 60, 5, 7, 7, 1, -8 },
  { 65, 3, 4, 3, -1, -2 },
  { 67, 3, 1, 4, 0, -4 },
  { 68, 2, 2, 3, 0, -2 },
  { 69, 7, 9, 5, -1, -9 },
  { 77, 5, 9, 6, 1, -9 },
  { 83, 3, 9, 6, 2, -9 },
  { 87, 6, 9, 6, 0, -9 },
  { 94, 6, 9, 6, 0, -9 },
  { 101, 6, 9, 6, 0, -9 },
  { 108, 6, 9, 6, 0, -9 },
  { 115, 5, 9, 6, 1, -9 },
  { 121, 6, 9, 6, 1, -9 },
  { 128, 6, 9, 6, 0, -9 },
  { 135, 6, 9, 6, 0, -9 },
  { 142, 3, 7, 3, 0, -7 },
  { 145, 4, 9, 3, -1, -7 },
  { 150, 5, 6, 7, 1, -8 },
  { 154, 5, 3, 7, 1, -6 },
  { 156, 5, 6, 7, 1, -8 },
  { 160, 4, 9, 5, 1, -9 },
  { 165, 9, 10, 10, 1, -9 },
  { 177, 7, 9, 7, -1, -9 },
  { 185, 7, 9, 7, 0, -9 },
  { 193, 6, 9, 7, 1, -9 },
  { 200, 7, 9, 8, 0, -9 },
  { 208, 7, 9, 6, 0, -9 },
  { 216, 7, 9, 6, 0, -9 },
  { 224, 7, 9, 8, 1, -9 },
  { 232, 8, 9, 8, 0, -9 },
  { 241, 5, 9, 4, 0, -9 },
  { 247, 5, 11, 3, -2, -9 },
  { 254, 8, 9, 7, 0, -9 },
  { 263, 5, 9, 6, 0, -9 },
  { 269, 10, 9, 10, 0, -9 },
  { 281, 8, 9, 8, 0, -9 },
  { 290, 7, 9, 8, 1, -9 },
  { 298, 7, 9, 7, 0, -9 },
  { 306, 7, 11, 8, 1, -9 },
  { 316, 7, 9, 7, 0, -9 },
  { 324, 6, 9, 6, 0, -9 },
  { 331, 6, 9, 6, 1, -9 },
  { 338, 7, 9, 8, 1, -9 },
  { 346, 7, 9, 6, 1, -9 },
  { 354, 10, 9, 10, 1, -9 },
  { 366, 8, 9, 6, -1, -9 },
  { 375, 6, 9, 6, 1, -9 },
  { 382, 7, 9, 6, 0, -9 },
  { 390, 5, 11, 4, 0, -9 },
  { 397, 3, 9, 5, 1, -9 },
  { 401, 5, 11, 4, -1, -9 },
  { 408, 6, 5, 7, 0, -9 },
  { 412, 5, 1, 5, -1, 1 },
  { 413, 2, 2, 3, 2, -10 },
  { 414, 6, 7, 7, 1, -7 },
  { 420, 6, 10, 7, 0, -10 },
  { 428, 4, 7, 5, 1, -7 },
  { 432, 7, 10, 7, 0, -10 },
  { 441, 6, 7, 6, 0, -7 },
  { 447, 7, 13, 4, -2, -10 },
  { 459, 7, 10, 7, 0, -7 },
  { 468, 6, 10, 7, 0, -10 },
  { 476, 3, 10, 3, 0, -10 },
  { 480, 5, 13, 3, -2, -10 },
  { 489, 6, 10, 6, 0, -10 },
  { 497, 3, 10, 3, 0, -10 },
  { 501, 10, 7, 10, 0, -7 },
  { 510, 6, 7, 7, 0, -7 },
  { 516, 5, 7, 7, 1, -7 },
  { 521, 6, 10, 7, 0, -7 },
  { 529, 7, 10, 7, 0, -7 },
  { 538, 5, 7, 5, 0, -7 },
  { 543, 5, 7, 5, 0, -7 },
  { 548, 3, 9, 4, 1, -9 },
  { 552, 5, 7, 7, 1, -7 },
  { 557, 5, 7, 5, 1, -7 },
  { 562, 8, 7, 9, 1, -7 },
  { 569, 7, 7, 6, -1, -7 },
  { 576, 7, 10, 5, -1, -7 },
  { 585, 5, 7, 5, 0, -7 },
  { 590, 5, 11, 4, 0, -9 },
  { 597, 1, 13, 6, 3, -10 },
  { 599, 5, 11, 4, -1, -9 },
  { 606, 5, 1, 7, 1, -5 },
};

const GFXfont NotoSans_SemiCondensed_Italic13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic13pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC13PT7B_H_
