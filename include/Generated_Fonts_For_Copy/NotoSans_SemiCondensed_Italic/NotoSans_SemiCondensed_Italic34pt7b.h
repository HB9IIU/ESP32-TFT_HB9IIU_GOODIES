#ifndef _NOTOSANS_SEMICONDENSED_ITALIC34PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x18,
  0x38, 0x38, 0x38, 0x30, 0x30, 0x70, 0x00, 0x00, 0x00, 0xE0, 0xF0, 0xE0,
  0xE0, 0x73, 0xDC, 0xEE, 0x3B, 0x8E, 0xE3, 0x30, 0xCC, 0x73, 0x18, 0xC6,
  0x00, 0x00, 0xE1, 0x80, 0x18, 0x70, 0x07, 0x0C, 0x00, 0xE1, 0x80, 0x18,
  0x70, 0x03, 0x0C, 0x00, 0xE1, 0x81, 0xFF, 0xFF, 0x3F, 0xFF, 0xC0, 0xE1,
  0x80, 0x18, 0x30, 0x03, 0x0E, 0x00, 0x61, 0x80, 0x1C, 0x30, 0x03, 0x0E,
  0x27, 0xFF, 0xF8, 0xFF, 0xFF, 0x03, 0x06, 0x00, 0x61, 0x80, 0x1C, 0x30,
  0x03, 0x06, 0x00, 0x61, 0xC0, 0x0C, 0x30, 0x03, 0x86, 0x00, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x80, 0x0F, 0xC0, 0x7F, 0xE1, 0xFB, 0xC7, 0x30, 0x8E,
  0x60, 0x18, 0xC0, 0x31, 0x80, 0x72, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0x01, 0xBC, 0x03, 0x38, 0x06, 0x70, 0x0C, 0xE0, 0x19, 0xC8,
  0x63, 0x98, 0xDE, 0x3F, 0xF8, 0x7F, 0xE0, 0x04, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x7C, 0x03, 0x87, 0xF0, 0x38, 0x71,
  0x81, 0x83, 0x0C, 0x1C, 0x38, 0x61, 0xC1, 0x83, 0x0C, 0x0C, 0x38, 0xE0,
  0x61, 0xCE, 0x07, 0x0C, 0x60, 0x38, 0x67, 0x3D, 0xC7, 0x73, 0xFE, 0x33,
  0x3B, 0xBF, 0xBB, 0x8D, 0xFB, 0x98, 0x63, 0x19, 0xC3, 0x01, 0xCE, 0x18,
  0x0C, 0x60, 0xC0, 0xC3, 0x06, 0x0E, 0x18, 0x70, 0x60, 0xC3, 0x06, 0x06,
  0x38, 0x70, 0x31, 0x83, 0x01, 0xFC, 0x30, 0x07, 0xC0, 0x00, 0x70, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x1C, 0x38, 0x06, 0x0E, 0x03, 0x83, 0x80, 0xE0,
  0xE0, 0x38, 0x70, 0x0E, 0x3C, 0x01, 0xDE, 0x00, 0x7E, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0xF0, 0x03, 0x9C, 0x1D, 0xC3, 0x8E, 0xE0, 0xF3, 0xB8,
  0x1D, 0xCE, 0x03, 0xF3, 0x00, 0xF8, 0xE0, 0x3C, 0x38, 0x1F, 0x0F, 0x0F,
  0xE1, 0xFF, 0xBC, 0x3F, 0x87, 0x80, 0x77, 0xEE, 0xEC, 0xCC, 0xC0, 0x00,
  0xE0, 0x30, 0x0E, 0x03, 0x80, 0x60, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07,
  0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x60, 0x0C, 0x01, 0xC0,
  0x38, 0x03, 0x80, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x30,
  0x0E, 0x03, 0x80, 0x60, 0x1C, 0x0F, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x18,
  0x10, 0x60, 0x71, 0x83, 0xF4, 0x01, 0xFF, 0xC1, 0xFF, 0x0F, 0x80, 0x76,
  0x03, 0x9C, 0x1E, 0x30, 0x30, 0xE0, 0x03, 0x00, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFE, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x0E, 0x3C, 0x70, 0xE3, 0x86, 0x1C, 0x70, 0xFF, 0xFF, 0xEF,
  0xEE, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0x00, 0x60, 0x03, 0xF0, 0x1F, 0xF0, 0x38, 0xF0,
  0xE0, 0xE3, 0x81, 0xC7, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x1D, 0xC0,
  0x3B, 0x80, 0x77, 0x00, 0xEE, 0x01, 0xDC, 0x03, 0xB8, 0x0E, 0x60, 0x1D,
  0xC0, 0x39, 0x80, 0xE3, 0x01, 0xC7, 0x07, 0x0E, 0x0E, 0x1E, 0x78, 0x1F,
  0xE0, 0x1F, 0x80, 0x03, 0xC1, 0xF1, 0xF8, 0xFE, 0xFB, 0x9C, 0xE4, 0x38,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x03,
  0xFC, 0x0F, 0xFE, 0x07, 0x0F, 0x04, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0x00,
  0x70, 0x03, 0xFC, 0x0F, 0xFE, 0x06, 0x0F, 0x04, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x07, 0xF8, 0x07,
  0xC0, 0x07, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x80, 0x38, 0xE0, 0xF8, 0xFF, 0xF0, 0x7F,
  0xC0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x76, 0x00,
  0xEE, 0x00, 0xEE, 0x01, 0xCE, 0x03, 0x8C, 0x07, 0x1C, 0x06, 0x1C, 0x0E,
  0x1C, 0x1C, 0x1C, 0x38, 0x18, 0x30, 0x38, 0x70, 0x38, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00,
  0xE0, 0x07, 0xFF, 0x07, 0xFE, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1F, 0xC0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x38, 0x80, 0x70, 0xC1, 0xF0, 0xFF, 0xE0, 0xFF,
  0x80, 0x00, 0x3C, 0x03, 0xFC, 0x0F, 0xF8, 0x3C, 0x00, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xDF, 0x83, 0x7F, 0x8F,
  0xC7, 0x9E, 0x07, 0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x39, 0xC0, 0x73, 0x00,
  0xE7, 0x01, 0xCE, 0x07, 0x1C, 0x1E, 0x3C, 0x78, 0x3F, 0xE0, 0x3F, 0x80,
  0x3F, 0xFF, 0x3F, 0xFE, 0x40, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0x0E, 0x0E, 0x07, 0x1C, 0x07,
  0x1C, 0x07, 0x1C, 0x0E, 0x0C, 0x0E, 0x0E, 0x1C, 0x07, 0x78, 0x07, 0xF0,
  0x07, 0xC0, 0x1F, 0xF0, 0x3C, 0x78, 0x70, 0x38, 0x70, 0x38, 0xE0, 0x1C,
  0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0x38, 0x78, 0xF0, 0x7F, 0xF0,
  0x1F, 0xC0, 0x00, 0x40, 0x07, 0xF0, 0x3F, 0xF0, 0x70, 0xE1, 0xC0, 0xE7,
  0x01, 0xCE, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x60, 0x1C, 0xC0, 0x39, 0xC0,
  0xF3, 0x83, 0xE7, 0xDD, 0x87, 0xF7, 0x07, 0xCE, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x20, 0xF0, 0x7F, 0xC0, 0xFE,
  0x00, 0x04, 0x1C, 0x78, 0xF0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x71, 0xE1, 0xC0, 0x01, 0x01, 0xC1, 0xE0, 0xF0, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x03, 0x83, 0x80, 0x00, 0x06, 0x00, 0x3C,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x01, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1E, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x38,
  0x00, 0x40, 0x00, 0x02, 0x03, 0xFC, 0x7F, 0xE3, 0x0F, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x1C, 0x03, 0x80, 0x30, 0x03, 0x00, 0x40, 0x00, 0x00, 0x00, 0x06, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01,
  0xE0, 0x3C, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x06, 0x1C,
  0x0F, 0x07, 0x18, 0x3F, 0xC7, 0x38, 0x79, 0xC3, 0x30, 0xE1, 0xC3, 0x70,
  0xC1, 0x87, 0x71, 0xC1, 0x87, 0x61, 0x83, 0x86, 0x61, 0x83, 0x86, 0x63,
  0x83, 0x06, 0xE3, 0x87, 0x0E, 0xE3, 0x87, 0x0C, 0xE3, 0x8F, 0x1C, 0xE1,
  0xFB, 0xF8, 0x61, 0xF1, 0xF0, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x03, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x03,
  0x70, 0x03, 0xB8, 0x01, 0x9C, 0x01, 0xCE, 0x00, 0xC7, 0x00, 0xE3, 0x80,
  0x71, 0xC0, 0x70, 0x60, 0x38, 0x30, 0x38, 0x18, 0x1F, 0xFE, 0x1F, 0xFF,
  0x0E, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x3B, 0x80,
  0x1D, 0xC0, 0x0F, 0xC0, 0x07, 0x07, 0xFE, 0x03, 0xFF, 0x83, 0x83, 0xE1,
  0xC0, 0x70, 0xE0, 0x38, 0x70, 0x1C, 0x38, 0x0E, 0x38, 0x07, 0x1C, 0x07,
  0x0E, 0x07, 0x07, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0xC1, 0xC0, 0xF0, 0xE0,
  0x38, 0x70, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x03, 0xC7,
  0x03, 0xC7, 0xFF, 0xE3, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x18, 0x00, 0xFF,
  0xC0, 0xFF, 0xE0, 0xF8, 0x20, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0xE0, 0x7F, 0xF0, 0x0F,
  0xF0, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0xE1, 0xF8, 0x38, 0x1E, 0x0E,
  0x03, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00,
  0x71, 0xC0, 0x1C, 0x60, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x38,
  0xE0, 0x0E, 0x70, 0x07, 0x9C, 0x01, 0xC7, 0x00, 0xF1, 0xC0, 0x78, 0x70,
  0x7C, 0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x07, 0xFF,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x1F,
  0xF8, 0x0F, 0xFF, 0x83, 0xE0, 0xE0, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0x03, 0xF9, 0xC0, 0x7F, 0x38, 0x0F, 0xE7, 0x00, 0x1C, 0xE0, 0x07,
  0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x78, 0x03, 0x87, 0x00, 0xE0, 0xF0, 0x1C,
  0x0F, 0x87, 0x80, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x07, 0x00, 0x70, 0x70,
  0x07, 0x0E, 0x00, 0x60, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x0E,
  0x00, 0xE1, 0xC0, 0x1C, 0x1C, 0x01, 0xC1, 0xC0, 0x1C, 0x1F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0x80, 0x38, 0x38, 0x03, 0x83, 0x80, 0x38,
  0x70, 0x03, 0x07, 0x00, 0x70, 0x70, 0x07, 0x07, 0x00, 0x70, 0x70, 0x07,
  0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0x07, 0xF8, 0x3F, 0x80,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x03, 0xFE, 0x1F, 0xE0, 0x00,
  0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0,
  0xFE, 0x03, 0xF0, 0x02, 0x00, 0x00, 0x07, 0x01, 0xE0, 0xE0, 0x78, 0x38,
  0x1E, 0x07, 0x07, 0x80, 0xE1, 0xE0, 0x1C, 0x38, 0x03, 0x0E, 0x00, 0xE3,
  0x80, 0x1C, 0xE0, 0x03, 0xBC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC,
  0x00, 0x79, 0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x70, 0x70, 0x0E, 0x0E,
  0x01, 0xC1, 0xC0, 0x38, 0x1C, 0x07, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x07,
  0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0x80, 0x07, 0xC1, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00,
  0x7E, 0x0F, 0xC0, 0x1B, 0x83, 0x70, 0x0F, 0xC0, 0xDC, 0x03, 0x70, 0x77,
  0x01, 0xDC, 0x1D, 0xC0, 0x67, 0x07, 0x70, 0x39, 0x81, 0x8C, 0x0C, 0xE0,
  0xE3, 0x07, 0x38, 0x38, 0xC1, 0x8E, 0x0E, 0x30, 0xE3, 0x83, 0x8C, 0x30,
  0xC0, 0xC3, 0x9C, 0x70, 0x70, 0xE6, 0x1C, 0x1C, 0x3B, 0x87, 0x07, 0x0F,
  0xC1, 0xC1, 0xC3, 0xF0, 0xE0, 0x60, 0xF8, 0x38, 0x38, 0x1E, 0x0E, 0x0E,
  0x07, 0x03, 0x83, 0x81, 0xC1, 0xE0, 0x07, 0x00, 0x38, 0x3C, 0x01, 0xC3,
  0xE0, 0x0C, 0x1F, 0x00, 0xE0, 0xFC, 0x07, 0x06, 0xE0, 0x38, 0x37, 0x01,
  0xC3, 0x9C, 0x0C, 0x1C, 0xE0, 0xE0, 0xE7, 0x07, 0x06, 0x18, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x1C, 0x1C, 0x18, 0xE0, 0xE0, 0xE7, 0x06, 0x07, 0x38,
  0x70, 0x39, 0x83, 0x80, 0xDC, 0x1C, 0x07, 0xE0, 0xE0, 0x3F, 0x06, 0x00,
  0xF8, 0x70, 0x07, 0x83, 0x80, 0x3C, 0x1C, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xC3, 0xE0, 0xE0, 0x1C, 0x38, 0x03, 0x8F,
  0x00, 0x39, 0xC0, 0x07, 0x78, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x03, 0xB8,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0E, 0xE0,
  0x03, 0xDC, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x03, 0x8F, 0x00, 0xF0, 0xF0,
  0x3C, 0x1F, 0x1F, 0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x07,
  0xFE, 0x0E, 0x1F, 0x0E, 0x07, 0x0E, 0x07, 0x0E, 0x07, 0x0E, 0x07, 0x1C,
  0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x0E, 0x18, 0x3E, 0x3F, 0xFC, 0x3F,
  0xF0, 0x3F, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xC3, 0xE0, 0xE0, 0x1C, 0x38, 0x03, 0x8F,
  0x00, 0x39, 0xC0, 0x07, 0x78, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x03, 0xB8,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0E, 0xE0,
  0x03, 0xDC, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x03, 0x8F, 0x00, 0xF0, 0xF0,
  0x3C, 0x1F, 0x1F, 0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x07,
  0xFC, 0x03, 0xFF, 0x03, 0x87, 0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x3C,
  0x38, 0x1C, 0x38, 0x0E, 0x1C, 0x07, 0x0E, 0x07, 0x87, 0x07, 0x83, 0xFF,
  0x83, 0xFF, 0x81, 0xFF, 0x00, 0xE3, 0x80, 0x70, 0xE0, 0x70, 0x70, 0x38,
  0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x07, 0x03, 0x87, 0x01, 0xC3, 0x80, 0x71,
  0xC0, 0x38, 0x00, 0x78, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0x86, 0x0E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x80, 0x78, 0xF1, 0xF0,
  0xFF, 0xE0, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x0E, 0x00, 0xE1, 0xC0,
  0x1C, 0x30, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00,
  0x71, 0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x01,
  0xC7, 0x00, 0x38, 0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x0E,
  0x0F, 0x03, 0xC0, 0xF0, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0xE0, 0x07,
  0xF0, 0x03, 0xB8, 0x03, 0xDC, 0x01, 0xCE, 0x01, 0xE7, 0x00, 0xE1, 0x80,
  0xF0, 0xC0, 0x70, 0x70, 0x38, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x1C, 0x07,
  0x0E, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x3B, 0x80,
  0x1D, 0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0xE0, 0x0E, 0x01, 0xF8, 0x07, 0x80, 0x7E, 0x01, 0xE0, 0x3B, 0x80,
  0xF8, 0x0E, 0xE0, 0x36, 0x07, 0x38, 0x1F, 0x81, 0xC6, 0x07, 0xE0, 0x71,
  0x81, 0xB8, 0x38, 0x60, 0xE6, 0x0E, 0x18, 0x31, 0x87, 0x06, 0x1C, 0x61,
  0xC1, 0x86, 0x18, 0xE0, 0x63, 0x86, 0x38, 0x18, 0xE1, 0x8C, 0x06, 0x70,
  0x67, 0x01, 0x9C, 0x19, 0xC0, 0x66, 0x06, 0xE0, 0x1B, 0x81, 0xB8, 0x06,
  0xC0, 0x6C, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x07, 0x80, 0x1E, 0x01, 0xE0,
  0x07, 0x80, 0x78, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x78, 0x1C, 0x07,
  0x00, 0x60, 0x38, 0x03, 0x83, 0x80, 0x1C, 0x38, 0x00, 0xE3, 0xC0, 0x03,
  0x9C, 0x00, 0x1D, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x73,
  0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x03, 0x87, 0x00, 0x38, 0x1C, 0x01,
  0xC0, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x38, 0x1E, 0x00, 0xE0, 0xE0, 0x0F,
  0xC0, 0x39, 0x80, 0x73, 0x81, 0xC7, 0x07, 0x8E, 0x0E, 0x1C, 0x38, 0x18,
  0x70, 0x39, 0xC0, 0x77, 0x00, 0xEE, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xF0,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF,
  0xF0, 0x01, 0xF8, 0x1F, 0xC0, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0xC3, 0x0E, 0x38, 0xE3, 0x86, 0x18, 0x61, 0xC7, 0x1C, 0x71, 0xC3,
  0x0C, 0x38, 0xE3, 0x8E, 0x38, 0x61, 0x87, 0x03, 0xF0, 0x7F, 0x00, 0x70,
  0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00,
  0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x0F,
  0xE0, 0xFC, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3F, 0x00, 0x66,
  0x01, 0xCE, 0x03, 0x0C, 0x0E, 0x1C, 0x18, 0x38, 0x70, 0x30, 0xC0, 0x73,
  0x80, 0x66, 0x00, 0xFC, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xE3, 0x9C,
  0x61, 0x80, 0x00, 0x80, 0x07, 0xE3, 0x0F, 0xF7, 0x1E, 0x1F, 0x1C, 0x1E,
  0x38, 0x0E, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x70, 0x1C, 0x70, 0x1C,
  0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0x38, 0xE0, 0x78, 0x70, 0x78, 0x71, 0xF8,
  0x7F, 0xB8, 0x3F, 0x30, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x18, 0x1C, 0xFC, 0x3B, 0xFC, 0x7C,
  0x38, 0xF0, 0x73, 0xC0, 0xE7, 0x81, 0xCE, 0x03, 0x9C, 0x07, 0x30, 0x0E,
  0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0xE7, 0x01, 0xCE, 0x07, 0xBC, 0x0E, 0x7C,
  0x78, 0xCF, 0xE1, 0x9F, 0x80, 0x00, 0x40, 0x1F, 0xC3, 0xFE, 0x3C, 0x11,
  0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x41, 0xFE, 0x07, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x70, 0x02, 0x1C, 0x07, 0xE7, 0x03, 0xFD, 0xC1, 0xE1,
  0xE0, 0x70, 0x78, 0x38, 0x0E, 0x0E, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x30,
  0x70, 0x1C, 0x1C, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0xF0, 0xE0, 0x38, 0x38,
  0x1E, 0x0F, 0x0F, 0x81, 0xC7, 0xE0, 0x7F, 0xB8, 0x0F, 0x8C, 0x00, 0x00,
  0x40, 0x1F, 0xC0, 0xFF, 0x87, 0x8F, 0x1C, 0x1C, 0xE0, 0x73, 0x83, 0x9C,
  0x1E, 0x73, 0xF1, 0xFF, 0x8F, 0xF0, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x78, 0x60, 0xFF, 0x81, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x07, 0xF0, 0x03, 0xE8, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x02, 0x70, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x40, 0x01, 0xFC, 0xC1, 0xFE, 0xE1, 0xE1, 0xF0, 0xE0,
  0xF0, 0xE0, 0x38, 0x70, 0x1C, 0x70, 0x0E, 0x38, 0x06, 0x1C, 0x07, 0x0E,
  0x03, 0x8E, 0x01, 0xC7, 0x01, 0xE3, 0x80, 0xE1, 0xC0, 0xF0, 0xF0, 0xF8,
  0x38, 0xFC, 0x1F, 0xEE, 0x07, 0xEE, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xC1, 0x01, 0xE0, 0xE1, 0xE0, 0x7F, 0xE0, 0x1F, 0xE0, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x06, 0x10, 0x1C, 0xFC, 0x3B, 0xFC, 0x7C, 0x38, 0xF0, 0x73, 0xC0,
  0xE7, 0x81, 0xCE, 0x03, 0x9C, 0x06, 0x30, 0x1C, 0xE0, 0x39, 0xC0, 0x73,
  0x80, 0xE7, 0x01, 0x8C, 0x07, 0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x39, 0xC0,
  0xE0, 0x06, 0x0F, 0x0E, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x1C, 0x1C, 0x1C,
  0x38, 0x38, 0x38, 0x38, 0x30, 0x70, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0,
  0xE0, 0xE0, 0x00, 0x30, 0x03, 0xC0, 0x1C, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x0E, 0x02, 0xF0, 0x1F, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C,
  0x1E, 0x38, 0x38, 0x70, 0xE0, 0xE3, 0x83, 0x8E, 0x07, 0x38, 0x0E, 0xE0,
  0x1F, 0x80, 0x3F, 0x80, 0xFF, 0x01, 0xEE, 0x03, 0x8E, 0x07, 0x1C, 0x0C,
  0x1C, 0x38, 0x38, 0x70, 0x70, 0xE0, 0x71, 0xC0, 0xE0, 0x07, 0x07, 0x06,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38,
  0x38, 0x30, 0x70, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0x00,
  0x20, 0x08, 0x1C, 0xF8, 0x7E, 0x1D, 0xFC, 0xFF, 0x1B, 0x1D, 0x87, 0x1E,
  0x0F, 0x07, 0x3C, 0x0E, 0x07, 0x3C, 0x0E, 0x07, 0x38, 0x1C, 0x07, 0x38,
  0x1C, 0x0E, 0x30, 0x1C, 0x0E, 0x70, 0x1C, 0x0E, 0x70, 0x18, 0x0E, 0x70,
  0x38, 0x0E, 0x70, 0x38, 0x1C, 0x60, 0x38, 0x1C, 0xE0, 0x38, 0x1C, 0xE0,
  0x70, 0x1C, 0xE0, 0x70, 0x18, 0xE0, 0x70, 0x38, 0x00, 0x30, 0x39, 0xF8,
  0x77, 0xF8, 0xF8, 0x71, 0xE0, 0xE7, 0x81, 0xCF, 0x03, 0x9C, 0x07, 0x38,
  0x1E, 0x70, 0x39, 0xC0, 0x73, 0x80, 0xE7, 0x01, 0xCE, 0x07, 0x38, 0x0E,
  0x70, 0x1C, 0xE0, 0x39, 0xC0, 0x73, 0x81, 0xC0, 0x00, 0x80, 0x0F, 0xE0,
  0x3F, 0xF0, 0xF0, 0xE1, 0xC1, 0xE7, 0x01, 0xCE, 0x03, 0xB8, 0x07, 0x70,
  0x0E, 0xE0, 0x1D, 0x80, 0x3F, 0x00, 0xEE, 0x01, 0xDC, 0x03, 0xB8, 0x0E,
  0x38, 0x3C, 0x78, 0xF0, 0x7F, 0xC0, 0x7E, 0x00, 0x00, 0x0C, 0x03, 0x9F,
  0x81, 0xDF, 0xE0, 0xF8, 0x70, 0x78, 0x38, 0x78, 0x1C, 0x3C, 0x0E, 0x1C,
  0x07, 0x0E, 0x03, 0x87, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x70,
  0xE0, 0x38, 0x70, 0x38, 0x78, 0x1C, 0x3E, 0x3C, 0x1D, 0xFC, 0x0E, 0xFC,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x00, 0x00, 0x80, 0x07, 0xF3, 0x0F, 0xF7,
  0x1E, 0x1E, 0x1C, 0x1E, 0x38, 0x0E, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x0C,
  0x70, 0x1C, 0x70, 0x1C, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0x38, 0xE0, 0x78,
  0xF0, 0xF8, 0x71, 0xF8, 0x7F, 0xB8, 0x3F, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x31, 0xCF, 0x1D, 0xF1, 0xB8, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0x80,
  0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x01, 0x00, 0x7F, 0xC7, 0xFE, 0x38, 0x23,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x03,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0xC1, 0xC7, 0xFE, 0x3F, 0xC0,
  0x0C, 0x06, 0x07, 0x03, 0x0F, 0xFF, 0xFC, 0xE0, 0x70, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x1C, 0x0F, 0xC3,
  0xE0, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x06, 0x18, 0x0E, 0x38, 0x0E, 0x38,
  0x0E, 0x38, 0x0E, 0x38, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70,
  0x38, 0x70, 0x38, 0xE0, 0x78, 0xE0, 0xF8, 0x71, 0xF8, 0x7F, 0xB0, 0x3E,
  0x30, 0xE0, 0x1F, 0x80, 0xEE, 0x03, 0xB8, 0x1C, 0xE0, 0x73, 0x83, 0x8E,
  0x0E, 0x38, 0x70, 0xE1, 0xC1, 0x8E, 0x06, 0x38, 0x19, 0xC0, 0x67, 0x01,
  0xB8, 0x06, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0xE0, 0x70, 0x3F,
  0x83, 0xC0, 0xEE, 0x0F, 0x03, 0xB8, 0x3C, 0x1C, 0xE1, 0xF0, 0x73, 0x86,
  0xC3, 0x8E, 0x3B, 0x8E, 0x38, 0xCE, 0x30, 0xE7, 0x39, 0xC3, 0x98, 0xE7,
  0x0E, 0xE3, 0xB8, 0x3B, 0x8E, 0xE0, 0xEC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F,
  0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF0, 0x3C, 0x03, 0xC0, 0xF0, 0x00, 0x0E,
  0x07, 0x87, 0x07, 0x01, 0x83, 0x80, 0xE3, 0x80, 0x73, 0x80, 0x1B, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0xEE, 0x00, 0xE3, 0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x70, 0x38, 0x70,
  0x1C, 0x00, 0x07, 0x00, 0xE0, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0x81, 0xC0,
  0x70, 0x38, 0x0E, 0x0E, 0x00, 0xC1, 0xC0, 0x18, 0x70, 0x03, 0x0E, 0x00,
  0x63, 0x80, 0x0E, 0x70, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x04, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x03, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0x7F, 0xE3, 0xFF, 0x80,
  0x00, 0xF0, 0x1F, 0x03, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x1C, 0x0F, 0x80, 0xE0, 0x0F, 0x80,
  0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00,
  0x70, 0x07, 0x00, 0x78, 0x03, 0xE0, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x1F,
  0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x7C, 0x00, 0xE0, 0x1F, 0x01,
  0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0,
  0x0E, 0x00, 0x70, 0x07, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x7E, 0x03, 0xFF,
  0x1F, 0x1F, 0xFC, 0x07, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Italic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 8, 24, 9, 1, -24 },
  { 25, 10, 9, 13, 4, -24 },
  { 37, 19, 24, 19, 1, -24 },
  { 94, 15, 28, 17, 1, -26 },
  { 147, 21, 25, 25, 2, -25 },
  { 213, 18, 25, 20, 1, -25 },
  { 270, 4, 9, 7, 4, -24 },
  { 275, 11, 29, 9, 1, -24 },
  { 315, 11, 29, 9, -3, -24 },
  { 355, 14, 14, 16, 3, -26 },
  { 380, 15, 16, 18, 2, -20 },
  { 410, 7, 8, 8, -2, -4 },
  { 417, 8, 2, 10, 1, -10 },
  { 419, 4, 4, 8, 1, -4 },
  { 421, 17, 24, 12, -2, -24 },
  { 472, 15, 25, 17, 1, -25 },
  { 519, 10, 24, 17, 4, -24 },
  { 549, 16, 25, 17, 0, -25 },
  { 599, 16, 25, 17, 0, -25 },
  { 649, 16, 24, 17, 0, -24 },
  { 697, 16, 24, 17, 1, -24 },
  { 745, 15, 25, 17, 2, -25 },
  { 792, 16, 24, 17, 2, -24 },
  { 840, 16, 25, 17, 1, -25 },
  { 890, 15, 25, 17, 1, -25 },
  { 937, 7, 19, 8, 0, -19 },
  { 954, 9, 23, 8, -2, -19 },
  { 980, 15, 16, 18, 2, -20 },
  { 1010, 15, 10, 18, 2, -17 },
  { 1029, 15, 16, 18, 2, -20 },
  { 1059, 12, 25, 13, 2, -25 },
  { 1097, 24, 27, 26, 1, -24 },
  { 1178, 17, 24, 17, -2, -24 },
  { 1229, 17, 24, 18, 1, -24 },
  { 1280, 17, 25, 17, 2, -25 },
  { 1334, 18, 24, 20, 1, -24 },
  { 1388, 16, 24, 16, 1, -24 },
  { 1436, 16, 24, 15, 1, -24 },
  { 1484, 19, 25, 21, 2, -25 },
  { 1544, 20, 24, 21, 1, -24 },
  { 1604, 13, 24, 10, -1, -24 },
  { 1643, 14, 31, 8, -5, -24 },
  { 1698, 19, 24, 17, 1, -24 },
  { 1755, 11, 24, 14, 1, -24 },
  { 1788, 26, 24, 26, 1, -24 },
  { 1866, 21, 24, 22, 1, -24 },
  { 1929, 19, 25, 22, 2, -25 },
  { 1989, 16, 24, 17, 1, -24 },
  { 2037, 19, 31, 22, 2, -25 },
  { 2111, 17, 24, 18, 1, -24 },
  { 2162, 16, 25, 16, 0, -25 },
  { 2212, 15, 24, 15, 3, -24 },
  { 2257, 19, 24, 20, 2, -24 },
  { 2314, 17, 24, 17, 3, -24 },
  { 2365, 26, 24, 27, 3, -24 },
  { 2443, 21, 24, 16, -2, -24 },
  { 2506, 15, 24, 15, 3, -24 },
  { 2551, 18, 24, 16, -1, -24 },
  { 2605, 13, 29, 10, -1, -24 },
  { 2653, 6, 24, 12, 4, -24 },
  { 2671, 12, 29, 10, -2, -24 },
  { 2715, 15, 14, 17, 1, -24 },
  { 2742, 13, 2, 12, -3, 3 },
  { 2746, 5, 5, 9, 5, -26 },
  { 2750, 16, 19, 18, 1, -19 },
  { 2788, 15, 26, 18, 1, -26 },
  { 2837, 13, 19, 14, 1, -19 },
  { 2868, 18, 26, 18, 1, -26 },
  { 2927, 14, 19, 16, 1, -19 },
  { 2961, 18, 34, 10, -4, -26 },
  { 3038, 17, 27, 18, 0, -19 },
  { 3096, 15, 26, 18, 1, -26 },
  { 3145, 8, 25, 8, 1, -25 },
  { 3170, 13, 33, 8, -4, -25 },
  { 3224, 15, 26, 15, 1, -26 },
  { 3273, 8, 26, 8, 1, -26 },
  { 3299, 24, 19, 26, 1, -19 },
  { 3356, 15, 19, 18, 1, -19 },
  { 3392, 15, 19, 17, 1, -19 },
  { 3428, 17, 27, 18, -1, -19 },
  { 3486, 16, 27, 18, 1, -19 },
  { 3540, 12, 19, 12, 1, -19 },
  { 3569, 13, 19, 13, 0, -19 },
  { 3600, 9, 22, 10, 2, -22 },
  { 3625, 16, 18, 18, 1, -18 },
  { 3661, 14, 18, 14, 2, -18 },
  { 3693, 22, 18, 22, 2, -18 },
  { 3743, 17, 18, 15, -1, -18 },
  { 3782, 19, 26, 14, -3, -18 },
  { 3844, 14, 18, 13, -1, -18 },
  { 3876, 12, 29, 12, 1, -24 },
  { 3920, 3, 34, 16, 7, -26 },
  { 3933, 13, 29, 12, -2, -24 },
  { 3981, 15, 4, 18, 2, -14 },
};

const GFXfont NotoSans_SemiCondensed_Italic34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic34pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC34PT7B_H_
