#ifndef _NOTOSANS_SEMICONDENSED_ITALIC42PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x0F,
  0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0xE0, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x0F, 0x83, 0xE0,
  0xF0, 0x3C, 0x04, 0x00, 0x3C, 0x79, 0xC3, 0x8E, 0x1C, 0xF1, 0xE7, 0x8F,
  0x38, 0x71, 0xC3, 0x8E, 0x1C, 0x60, 0xC3, 0x06, 0x38, 0x70, 0x00, 0x38,
  0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x03, 0x81, 0x80, 0x07, 0x07,
  0x00, 0x0E, 0x0E, 0x00, 0x18, 0x18, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0,
  0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF9, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00,
  0x30, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x03, 0x00, 0x0E,
  0x0E, 0x03, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x01, 0xC1,
  0xC0, 0x03, 0x83, 0x80, 0x06, 0x06, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38,
  0x00, 0x60, 0x60, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x0F,
  0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x78, 0xC2, 0x0E, 0x38, 0x01, 0xC7,
  0x00, 0x38, 0xC0, 0x0F, 0x18, 0x00, 0xE3, 0x00, 0x1E, 0xE0, 0x03, 0xFC,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x67,
  0x80, 0x0C, 0x70, 0x01, 0x8E, 0x00, 0x71, 0xE0, 0x0E, 0x38, 0x01, 0x87,
  0x10, 0x31, 0xE3, 0x86, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0x3F, 0x80,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xC0,
  0x07, 0x07, 0xF8, 0x03, 0x81, 0xCF, 0x00, 0xE0, 0xE1, 0xC0, 0x70, 0x78,
  0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x07, 0x07, 0x01, 0x81, 0xC3, 0x80,
  0xE0, 0x70, 0xE0, 0x38, 0x38, 0x70, 0x0E, 0x0E, 0x38, 0x03, 0x83, 0x8E,
  0x00, 0xE0, 0xC7, 0x1F, 0x38, 0x73, 0x9F, 0xEE, 0x3C, 0xE7, 0x3F, 0xDE,
  0x73, 0x87, 0x7F, 0x38, 0xE1, 0xDF, 0x8E, 0x70, 0x70, 0x07, 0x1C, 0x1C,
  0x03, 0x87, 0x07, 0x00, 0xE3, 0x81, 0xC0, 0x70, 0xE0, 0xE0, 0x38, 0x38,
  0x38, 0x0E, 0x0E, 0x0E, 0x07, 0x03, 0x83, 0x83, 0xC0, 0xE1, 0xC0, 0xE0,
  0x38, 0x70, 0x70, 0x0F, 0x38, 0x3C, 0x01, 0xFC, 0x1E, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xDF, 0x00, 0x1E, 0x0E, 0x00,
  0x38, 0x1E, 0x00, 0x70, 0x3C, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x03,
  0x83, 0xC0, 0x07, 0x0F, 0x00, 0x0E, 0x3C, 0x00, 0x1E, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x01, 0x1E, 0x78,
  0x1C, 0x78, 0xF0, 0x79, 0xE0, 0xF0, 0xE3, 0x80, 0xF3, 0xCF, 0x01, 0xE7,
  0x1C, 0x01, 0xFE, 0x38, 0x03, 0xF8, 0x70, 0x03, 0xE0, 0xE0, 0x07, 0x81,
  0xE0, 0x1F, 0x83, 0xE0, 0x7F, 0x83, 0xFF, 0xEF, 0x07, 0xFF, 0x8F, 0x03,
  0xFC, 0x1F, 0x00, 0x3C, 0xF3, 0x8E, 0x79, 0xC7, 0x1C, 0x71, 0x8E, 0x00,
  0x00, 0x3C, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x78,
  0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00,
  0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x1C, 0x06, 0x0E, 0x03, 0xC6, 0x03, 0xFB, 0x00, 0x7F, 0xFF, 0x07,
  0xFF, 0x81, 0xFF, 0xC1, 0xF8, 0x01, 0xCC, 0x01, 0xE7, 0x03, 0xE3, 0x80,
  0xE1, 0xE0, 0x20, 0x70, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x0F, 0x1E, 0x1E, 0x1C,
  0x3C, 0x38, 0x78, 0x70, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x77, 0xFF, 0xEF,
  0x20, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1E,
  0x1E, 0x0F, 0x03, 0xC3, 0x80, 0xF1, 0xE0, 0x1C, 0x70, 0x07, 0x3C, 0x01,
  0xCF, 0x00, 0x77, 0x80, 0x1D, 0xE0, 0x0F, 0x78, 0x03, 0xDC, 0x00, 0xF7,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xC0,
  0x1E, 0xE0, 0x07, 0x38, 0x03, 0xCE, 0x00, 0xF3, 0xC0, 0x78, 0xF0, 0x1E,
  0x3C, 0x0F, 0x07, 0x87, 0x81, 0xFF, 0xE0, 0x3F, 0xE0, 0x07, 0xF0, 0x00,
  0x00, 0xF0, 0x1F, 0x03, 0xF0, 0xFF, 0x1F, 0xE7, 0xEE, 0xF9, 0xE7, 0x1E,
  0x21, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x00, 0x7F, 0x80,
  0x1F, 0xFC, 0x07, 0xFF, 0xE0, 0x38, 0x1F, 0x03, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0x38, 0x1F, 0x02, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x1F, 0xF0, 0x03,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x88, 0x00, 0xF8, 0xE0, 0x1F, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xEE, 0x00, 0x1D, 0xE0, 0x03, 0xDC, 0x00,
  0x79, 0xC0, 0x07, 0x1C, 0x00, 0xE3, 0xC0, 0x1E, 0x3C, 0x03, 0xC3, 0x80,
  0x38, 0x38, 0x07, 0x03, 0x80, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70,
  0x38, 0x07, 0x07, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x81, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xFF,
  0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x10, 0x03, 0xE3, 0x00, 0xF8, 0x7F, 0xFE,
  0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x07,
  0xFF, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x7C, 0x07, 0x9F,
  0xE0, 0xFF, 0xFE, 0x1F, 0xC7, 0xC3, 0xE0, 0x38, 0xF8, 0x07, 0x9E, 0x00,
  0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0E, 0x3C, 0x01,
  0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x0E, 0x03, 0xC1, 0xE0, 0xF0, 0x3F, 0xFE,
  0x03, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF,
  0xFF, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x03,
  0xFF, 0xE0, 0x7C, 0x1E, 0x07, 0x80, 0xF0, 0x70, 0x0F, 0x0F, 0x00, 0xF0,
  0xF0, 0x0E, 0x0F, 0x00, 0xE0, 0x70, 0x1E, 0x07, 0x83, 0xC0, 0x78, 0x78,
  0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0x1E,
  0x03, 0xE0, 0xF0, 0x7C, 0x07, 0x87, 0x80, 0x78, 0xF0, 0x07, 0x8F, 0x00,
  0x38, 0xF0, 0x03, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0xF0, 0x78,
  0x1F, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x7F, 0xF0, 0x1F, 0xFF, 0x03, 0xC1, 0xE0, 0xF0, 0x1C, 0x3C, 0x03, 0xC7,
  0x80, 0x78, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x9E,
  0x00, 0xF3, 0xC0, 0x3E, 0x78, 0x07, 0x87, 0x01, 0xF0, 0xF8, 0xFE, 0x1F,
  0xFF, 0xC1, 0xFF, 0x78, 0x0F, 0x8E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x06, 0x0F, 0x1F,
  0x1F, 0x1E, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0xF0, 0xF8, 0xF0, 0xF0, 0x40, 0x00, 0xE0, 0x3C,
  0x0F, 0x81, 0xF0, 0x3C, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x0F,
  0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0x80, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x03, 0x80, 0x00,
  0x40, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF8, 0xC0, 0xF0, 0x01,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xE0, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x70,
  0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x1C, 0x03, 0xF0, 0x30, 0xE0,
  0x7F, 0xE1, 0xCE, 0x07, 0xFE, 0x0E, 0x70, 0x78, 0x70, 0x77, 0x07, 0x83,
  0x83, 0xB8, 0x38, 0x1C, 0x1D, 0xC3, 0x81, 0xC0, 0xDC, 0x1C, 0x0E, 0x0E,
  0xE1, 0xC0, 0x70, 0x77, 0x0E, 0x07, 0x03, 0xB8, 0x70, 0x38, 0x19, 0xC3,
  0x81, 0xC1, 0xCE, 0x1C, 0x1E, 0x0E, 0x70, 0xE0, 0xF0, 0xE3, 0x87, 0x9D,
  0x8E, 0x1C, 0x1F, 0xCF, 0xF0, 0xE0, 0x7C, 0x3E, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x08, 0x00, 0x7C, 0x03, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0, 0x00,
  0xE7, 0x00, 0x03, 0x9C, 0x00, 0x1E, 0x70, 0x00, 0x71, 0xC0, 0x03, 0xC7,
  0x00, 0x0E, 0x1C, 0x00, 0x78, 0x70, 0x01, 0xC1, 0xE0, 0x0F, 0x07, 0x80,
  0x38, 0x1E, 0x01, 0xE0, 0x78, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x1E, 0x00, 0xE0, 0xF0, 0x03, 0x83, 0xC0, 0x0E,
  0x1E, 0x00, 0x38, 0x78, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x78,
  0x00, 0x3F, 0xE0, 0x00, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF,
  0xFC, 0x07, 0x03, 0xF0, 0x78, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x00, 0xE0,
  0xE0, 0x07, 0x07, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1C, 0x1E, 0x01,
  0xE0, 0xE0, 0x3E, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x1E,
  0x03, 0xC0, 0xE0, 0x0F, 0x07, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E,
  0x1C, 0x00, 0xF0, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x03, 0xC3, 0xC0,
  0x3E, 0x1C, 0x07, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFC, 0x06, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x10, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1C, 0x1F, 0xC0, 0x78,
  0x07, 0xC0, 0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x03, 0x80, 0x0F, 0x07, 0x00,
  0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xE0, 0x01,
  0xE1, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0E, 0x1E, 0x00, 0x3C,
  0x38, 0x00, 0x78, 0x70, 0x00, 0xF1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87,
  0x00, 0x1E, 0x0E, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0x78, 0x03, 0xE0, 0xF0,
  0x1F, 0x81, 0xC0, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xFF,
  0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0xFF, 0xC0,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF,
  0xF0, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xF0, 0x0E, 0x07, 0xE0, 0x02, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x07, 0xFC, 0x78, 0x07, 0xF8, 0x70, 0x07, 0xF8, 0x70,
  0x08, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x70, 0x70,
  0x00, 0x70, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x3C,
  0x00, 0xE0, 0x3F, 0x01, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xC0,
  0x70, 0x00, 0xE0, 0x38, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3C,
  0x0E, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07,
  0x81, 0xE0, 0x03, 0xC0, 0xE0, 0x01, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF8, 0x1E, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x07, 0x00,
  0x1E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0x80, 0xE0,
  0x01, 0xC0, 0x70, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1C,
  0x00, 0x38, 0x0E, 0x00, 0x1C, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x00,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFC, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x3F, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xE0,
  0x23, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x03, 0xC0, 0x1F,
  0x03, 0xC0, 0x3E, 0x03, 0xC0, 0x7C, 0x03, 0x80, 0x78, 0x07, 0x80, 0xF0,
  0x07, 0x81, 0xE0, 0x07, 0x83, 0xC0, 0x07, 0x07, 0x80, 0x07, 0x0F, 0x00,
  0x0F, 0x1F, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x3C, 0x00, 0x0E, 0x78, 0x00,
  0x0E, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00,
  0x1E, 0x3C, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x1E, 0x00,
  0x3C, 0x1E, 0x00, 0x38, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x78, 0x0F, 0x00,
  0x78, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x70, 0x07, 0x80, 0xF0, 0x07, 0x80,
  0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0xFE, 0x07, 0x70, 0x01, 0xFE, 0x07, 0x70, 0x01, 0xDC,
  0x07, 0x70, 0x03, 0xDC, 0x07, 0x70, 0x03, 0xBC, 0x0F, 0x70, 0x07, 0xBC,
  0x0F, 0x70, 0x07, 0x3C, 0x0E, 0x70, 0x0F, 0x38, 0x0E, 0x78, 0x0E, 0x38,
  0x0E, 0x38, 0x1E, 0x78, 0x1E, 0x38, 0x1C, 0x78, 0x1E, 0x38, 0x3C, 0x78,
  0x1C, 0x38, 0x38, 0x70, 0x1C, 0x38, 0x78, 0xF0, 0x3C, 0x38, 0x70, 0xF0,
  0x3C, 0x38, 0xF0, 0xF0, 0x38, 0x38, 0xE0, 0xE0, 0x38, 0x39, 0xE0, 0xE0,
  0x38, 0x39, 0xC1, 0xE0, 0x78, 0x3F, 0xC1, 0xE0, 0x78, 0x1F, 0x81, 0xE0,
  0x70, 0x1F, 0x81, 0xC0, 0x70, 0x1F, 0x01, 0xC0, 0x70, 0x1F, 0x03, 0xC0,
  0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1C, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xC0,
  0xF8, 0x00, 0xF0, 0x3E, 0x00, 0x3C, 0x0F, 0x80, 0x0E, 0x07, 0xF0, 0x03,
  0x81, 0xDC, 0x00, 0xE0, 0x77, 0x00, 0x78, 0x1D, 0xE0, 0x1E, 0x07, 0x78,
  0x07, 0x03, 0xCE, 0x01, 0xC0, 0xF3, 0x80, 0xF0, 0x38, 0xF0, 0x3C, 0x0E,
  0x1C, 0x0F, 0x03, 0x87, 0x03, 0x81, 0xE1, 0xE0, 0xE0, 0x78, 0x38, 0x78,
  0x1C, 0x0E, 0x1E, 0x07, 0x03, 0xC7, 0x03, 0xC0, 0xF1, 0xC0, 0xF0, 0x1C,
  0x70, 0x3C, 0x07, 0x3C, 0x0E, 0x01, 0xEF, 0x03, 0x80, 0x3B, 0x81, 0xE0,
  0x0E, 0xE0, 0x78, 0x03, 0xF8, 0x1C, 0x00, 0x7E, 0x07, 0x00, 0x1F, 0x81,
  0xC0, 0x07, 0xC0, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xE0, 0x7C, 0x07, 0xC0,
  0x3E, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x1E, 0x00,
  0x0F, 0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x78, 0x00,
  0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0x70, 0x00,
  0x1E, 0x70, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3C, 0xF0, 0x00,
  0x3C, 0x70, 0x00, 0x7C, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF8, 0x78, 0x01,
  0xF0, 0x3C, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF8,
  0x07, 0x07, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x38, 0x1E, 0x01, 0xE0, 0xE0,
  0x0F, 0x07, 0x00, 0x78, 0x78, 0x03, 0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xE0,
  0xE0, 0x1F, 0x07, 0x01, 0xF0, 0x78, 0x1F, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x00, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xE0, 0x7C, 0x07,
  0xC0, 0x3E, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x1E,
  0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x78,
  0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0x70,
  0x00, 0x1E, 0x70, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3C, 0xF0,
  0x00, 0x3C, 0x70, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF8, 0x78,
  0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0x07,
  0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x38, 0x1E, 0x01, 0xE0, 0xE0, 0x0F, 0x07,
  0x00, 0x78, 0x78, 0x03, 0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0xE0, 0x1E,
  0x07, 0x01, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0x07, 0x00, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x1C, 0x0F, 0x00,
  0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x38, 0x1C, 0x01,
  0xE0, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x01, 0xE0, 0x00, 0x7F, 0xC0,
  0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7C, 0x06, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x08,
  0x00, 0xF0, 0xE0, 0x3E, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x1E, 0x1C,
  0x00, 0x3C, 0x38, 0x00, 0x70, 0xF0, 0x00, 0xE1, 0xE0, 0x03, 0xC3, 0xC0,
  0x07, 0x87, 0x00, 0x0F, 0x0E, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0x78, 0x00,
  0xF0, 0xF0, 0x01, 0xE1, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x0F, 0x00, 0x1E,
  0x1E, 0x00, 0x3C, 0x38, 0x00, 0x78, 0x70, 0x00, 0xE1, 0xE0, 0x01, 0xC3,
  0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x38, 0x38,
  0x00, 0xF0, 0x70, 0x01, 0xE0, 0xE0, 0x07, 0x81, 0xE0, 0x0F, 0x03, 0xE0,
  0x7C, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xBC, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x1C,
  0x78, 0x01, 0xE3, 0xC0, 0x0E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x07, 0x80,
  0x78, 0x1C, 0x03, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xC0, 0x38, 0x1E, 0x01,
  0xC0, 0xE0, 0x0E, 0x0F, 0x00, 0x70, 0x78, 0x03, 0x87, 0x80, 0x1E, 0x3C,
  0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x0F,
  0x70, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03,
  0xC0, 0x0F, 0xF0, 0x07, 0xC0, 0x0E, 0xF0, 0x07, 0xC0, 0x1E, 0xF0, 0x07,
  0xC0, 0x1C, 0xF0, 0x0F, 0xC0, 0x3C, 0xF0, 0x0F, 0xC0, 0x3C, 0xF0, 0x1D,
  0xC0, 0x78, 0xF0, 0x1D, 0xC0, 0x78, 0xF0, 0x3D, 0xC0, 0x70, 0xF0, 0x39,
  0xC0, 0xF0, 0xF0, 0x79, 0xC0, 0xE0, 0xF0, 0x71, 0xC1, 0xE0, 0xF0, 0x71,
  0xC1, 0xE0, 0xF0, 0xE1, 0xC1, 0xC0, 0xF0, 0xE1, 0xC3, 0xC0, 0xF1, 0xC1,
  0xC3, 0x80, 0xF1, 0xC1, 0xC7, 0x80, 0x73, 0xC1, 0xC7, 0x00, 0x73, 0x81,
  0xCF, 0x00, 0x73, 0x81, 0xCF, 0x00, 0x77, 0x01, 0xCE, 0x00, 0x77, 0x01,
  0xDE, 0x00, 0x7E, 0x01, 0xDC, 0x00, 0x7E, 0x01, 0xDC, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x78, 0x01,
  0xF0, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x01, 0xC0, 0x07, 0x80, 0xF0, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x1C, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x07, 0x83,
  0xC0, 0x01, 0xC1, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0x79, 0xE0, 0x00, 0x3C,
  0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x3C, 0x78, 0x00,
  0x1C, 0x3C, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x07, 0x00, 0x0E, 0x03, 0xC0,
  0x0F, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x38, 0x07, 0x80, 0x1E,
  0x07, 0x80, 0x0F, 0x00, 0xE0, 0x01, 0xFE, 0x00, 0x7B, 0xC0, 0x1E, 0x78,
  0x03, 0xC7, 0x00, 0xF0, 0xE0, 0x1C, 0x1E, 0x07, 0x83, 0xC1, 0xE0, 0x78,
  0x3C, 0x07, 0x0F, 0x00, 0xE3, 0xC0, 0x1C, 0x78, 0x03, 0xDE, 0x00, 0x3B,
  0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0xFF, 0x00, 0xF0, 0x70, 0x70, 0x70, 0x70, 0x70, 0x78,
  0x78, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3C, 0x3C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1E, 0x1E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0F, 0x07, 0x00,
  0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF,
  0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0xC0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x38, 0x70, 0x07, 0x0E, 0x01, 0xE0,
  0xE0, 0x38, 0x1C, 0x0F, 0x03, 0xC1, 0xC0, 0x38, 0x78, 0x07, 0x0E, 0x00,
  0x73, 0xC0, 0x0E, 0x70, 0x00, 0xFE, 0x00, 0x1C, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF1, 0xE1, 0xC1, 0xC3, 0x83, 0x80, 0x00, 0xF0, 0xE0, 0x7F, 0x9C,
  0x1F, 0xF3, 0x87, 0xC7, 0xF1, 0xE0, 0x7C, 0x78, 0x07, 0x8F, 0x00, 0xF3,
  0xC0, 0x1E, 0x78, 0x03, 0x8E, 0x00, 0x73, 0xC0, 0x1E, 0x78, 0x03, 0xCF,
  0x00, 0x79, 0xC0, 0x0E, 0x38, 0x03, 0xC7, 0x00, 0x78, 0xE0, 0x1F, 0x1C,
  0x03, 0xE3, 0xC0, 0xF8, 0x78, 0x3F, 0x0F, 0xFE, 0xE0, 0xFF, 0x9C, 0x0F,
  0xC3, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xE1, 0xE0, 0x3C, 0xFE, 0x07, 0xBF, 0xE0, 0xEE, 0x3E, 0x1F, 0x83, 0xC7,
  0xE0, 0x78, 0xF8, 0x07, 0x1E, 0x00, 0xE3, 0xC0, 0x1C, 0x70, 0x07, 0x9E,
  0x00, 0xF3, 0xC0, 0x1E, 0x70, 0x03, 0xCE, 0x00, 0x71, 0xC0, 0x1E, 0x78,
  0x03, 0xCF, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x07, 0x8F, 0xC1, 0xF1, 0xDF,
  0xFC, 0x39, 0xFF, 0x07, 0x1F, 0xC0, 0x00, 0xFC, 0x03, 0xFF, 0x07, 0xFE,
  0x0F, 0x86, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x10, 0x7F, 0xF0,
  0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x07, 0x87, 0x00, 0xFF, 0x78, 0x1F, 0xFB, 0xC0,
  0xF8, 0xFC, 0x0F, 0x03, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x78, 0x03,
  0xC3, 0xC0, 0x1C, 0x1C, 0x00, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78,
  0x03, 0xC3, 0x80, 0x1C, 0x1C, 0x01, 0xE0, 0xE0, 0x0F, 0x07, 0x00, 0xF8,
  0x38, 0x07, 0x81, 0xE0, 0x7C, 0x0F, 0x06, 0xE0, 0x7F, 0xF7, 0x01, 0xFF,
  0x38, 0x07, 0xE3, 0x80, 0x00, 0xF8, 0x03, 0xFE, 0x07, 0xFF, 0x0F, 0x0F,
  0x1E, 0x07, 0x3C, 0x07, 0x38, 0x07, 0x78, 0x0F, 0x70, 0x1E, 0xF0, 0x7E,
  0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0x80, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x08, 0x7F, 0xF8, 0x3F, 0xF8,
  0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x38, 0x07, 0xF9, 0xC0, 0xFF, 0xCE, 0x07, 0xC7, 0xF0, 0x78, 0x1F, 0x07,
  0x80, 0x78, 0x3C, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xE0, 0xE0, 0x07,
  0x0F, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1C, 0x00, 0xE0, 0xE0,
  0x0F, 0x07, 0x00, 0x78, 0x38, 0x07, 0xC1, 0xC0, 0x3E, 0x0F, 0x03, 0xE0,
  0x78, 0x3F, 0x03, 0xFF, 0xF8, 0x0F, 0xFB, 0xC0, 0x3F, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x08,
  0x01, 0xE0, 0x70, 0x3E, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE1,
  0xE0, 0x3C, 0xFF, 0x07, 0x3F, 0xE0, 0xEE, 0x3E, 0x1F, 0x03, 0xC7, 0xC0,
  0x78, 0xF8, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x38, 0x70, 0x07, 0x1E, 0x01,
  0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8E, 0x00, 0xE1, 0xC0, 0x1C, 0x78, 0x07,
  0x8F, 0x00, 0xF1, 0xC0, 0x1C, 0x38, 0x03, 0x8F, 0x00, 0x71, 0xE0, 0x1E,
  0x3C, 0x03, 0xC7, 0x00, 0x70, 0x01, 0x80, 0xF0, 0x7C, 0x0E, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xE0,
  0x78, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78,
  0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x3C, 0x3C, 0x0F, 0x07, 0x83, 0xC0, 0xE0,
  0xF0, 0x1C, 0x1E, 0x07, 0x87, 0x80, 0xF1, 0xE0, 0x1C, 0x78, 0x03, 0x9E,
  0x00, 0x77, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xBC,
  0x01, 0xC7, 0x80, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xC0, 0xE0, 0x38, 0x1E,
  0x0F, 0x03, 0xC1, 0xE0, 0x38, 0x3C, 0x07, 0x87, 0x00, 0xF0, 0x03, 0xC0,
  0xF0, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xF0,
  0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x3C,
  0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0x80, 0x0E, 0x1F, 0x01, 0xE0, 0x38, 0xFE, 0x1F, 0xE0, 0xEF, 0xFC,
  0xFF, 0x83, 0xB8, 0xF7, 0x1F, 0x0F, 0x81, 0xF8, 0x3C, 0x7C, 0x07, 0xC0,
  0xF1, 0xF0, 0x1E, 0x03, 0xC7, 0x80, 0x78, 0x0F, 0x1E, 0x03, 0xC0, 0x38,
  0x70, 0x0F, 0x00, 0xE3, 0xC0, 0x38, 0x07, 0x8F, 0x00, 0xE0, 0x1E, 0x38,
  0x03, 0x80, 0x78, 0xE0, 0x1E, 0x01, 0xC3, 0x80, 0x78, 0x07, 0x1E, 0x01,
  0xC0, 0x3C, 0x78, 0x07, 0x00, 0xF1, 0xC0, 0x3C, 0x03, 0xC7, 0x00, 0xF0,
  0x0E, 0x3C, 0x03, 0xC0, 0x38, 0xF0, 0x0E, 0x01, 0xE3, 0xC0, 0x38, 0x07,
  0x8E, 0x01, 0xE0, 0x1C, 0x00, 0x0E, 0x1F, 0x01, 0xC7, 0xF8, 0x3B, 0xFF,
  0x07, 0x71, 0xF0, 0xFC, 0x1E, 0x3F, 0x03, 0xC7, 0xC0, 0x78, 0xF0, 0x0F,
  0x1E, 0x01, 0xC7, 0x80, 0x38, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C,
  0x70, 0x07, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF1,
  0xC0, 0x1C, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x38, 0x03, 0x80,
  0x00, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x3C, 0x3E, 0x1E, 0x07, 0x8F,
  0x00, 0xE3, 0x80, 0x39, 0xE0, 0x0F, 0x70, 0x03, 0xDC, 0x00, 0xFF, 0x00,
  0x3B, 0xC0, 0x0E, 0xE0, 0x07, 0xB8, 0x01, 0xEE, 0x00, 0x7B, 0x80, 0x1C,
  0xE0, 0x0F, 0x38, 0x03, 0x8F, 0x01, 0xE3, 0xE0, 0xF0, 0x7F, 0xF8, 0x0F,
  0xFC, 0x01, 0xFE, 0x00, 0x01, 0x83, 0xC0, 0x1C, 0x7F, 0x00, 0xE7, 0xFC,
  0x07, 0x71, 0xF0, 0x3E, 0x07, 0x83, 0xF0, 0x3C, 0x1F, 0x00, 0xE0, 0xF0,
  0x07, 0x07, 0x80, 0x38, 0x38, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0,
  0xE0, 0x07, 0x87, 0x00, 0x38, 0x38, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x01,
  0xE0, 0xF0, 0x0F, 0x07, 0x80, 0xF0, 0x7E, 0x0F, 0x83, 0xFF, 0xF8, 0x1E,
  0xFF, 0x80, 0xE3, 0xF8, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0xE0, 0x7F, 0x9C,
  0x3F, 0xF3, 0x87, 0xC7, 0xE1, 0xE0, 0x7C, 0x78, 0x07, 0x8F, 0x00, 0xF3,
  0xC0, 0x1E, 0x78, 0x03, 0x8E, 0x00, 0x73, 0xC0, 0x1E, 0x78, 0x03, 0xCF,
  0x00, 0x79, 0xC0, 0x0E, 0x38, 0x03, 0xC7, 0x00, 0x78, 0xE0, 0x1F, 0x1C,
  0x03, 0xE3, 0xC0, 0xF8, 0x78, 0x3F, 0x0F, 0xFF, 0xE0, 0xFF, 0xBC, 0x0F,
  0xC7, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x1E, 0x1C, 0xFC, 0x39, 0xF8, 0x77, 0x90, 0xFC, 0x03,
  0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x00, 0x01, 0xF8,
  0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0x06, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38,
  0x80, 0x78, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xC0, 0x03, 0x00, 0x70, 0x07,
  0x00, 0xE0, 0x0E, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x1C, 0x01, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70,
  0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xF0, 0x0F, 0xF0, 0xFF,
  0x07, 0xF0, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x70, 0x07, 0x8E, 0x00, 0xE3,
  0xC0, 0x1C, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xC0, 0x1C, 0x38, 0x03, 0x8F,
  0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x00, 0x70, 0xE0, 0x0E, 0x3C,
  0x03, 0xC7, 0x80, 0x78, 0xF0, 0x1F, 0x1C, 0x03, 0xC3, 0xC0, 0xF8, 0x78,
  0x37, 0x0F, 0xFE, 0xE0, 0xFF, 0xB8, 0x0F, 0xC7, 0x00, 0xF0, 0x03, 0xFC,
  0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x3C, 0xF0, 0x0F, 0x1C, 0x07, 0x87, 0x01,
  0xE1, 0xC0, 0xF0, 0x70, 0x3C, 0x1C, 0x1E, 0x07, 0x07, 0x81, 0xC1, 0xC0,
  0x70, 0xF0, 0x1E, 0x38, 0x07, 0x9E, 0x01, 0xE7, 0x00, 0x7B, 0xC0, 0x0E,
  0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x0F, 0x00, 0xFE, 0x03, 0xE0, 0x3D, 0xC0, 0x7C, 0x07, 0x38,
  0x0F, 0x81, 0xE7, 0x03, 0xF0, 0x3C, 0xE0, 0x7E, 0x07, 0x1C, 0x1D, 0xC1,
  0xE3, 0x83, 0xB8, 0x38, 0x70, 0xE7, 0x0F, 0x0E, 0x1C, 0xE1, 0xC1, 0xC7,
  0x1C, 0x78, 0x38, 0xE3, 0x8F, 0x07, 0x1C, 0x71, 0xC0, 0xE7, 0x0E, 0x78,
  0x1C, 0xE1, 0xCE, 0x03, 0xB8, 0x3B, 0xC0, 0x77, 0x07, 0x70, 0x0F, 0xC0,
  0xEE, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xC0, 0x7E, 0x00,
  0xF8, 0x0F, 0x80, 0x1E, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x1C, 0x03,
  0xC0, 0xF0, 0x3C, 0x07, 0x83, 0xC0, 0x1C, 0x1C, 0x00, 0xF1, 0xE0, 0x07,
  0x9E, 0x00, 0x1D, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0x70, 0x00, 0x7B,
  0x80, 0x07, 0x9E, 0x00, 0x78, 0x70, 0x03, 0xC3, 0x80, 0x3C, 0x1E, 0x03,
  0xC0, 0x70, 0x3C, 0x03, 0xC3, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x03,
  0xC0, 0x1E, 0x03, 0xC0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x01,
  0xC0, 0x38, 0x01, 0xC0, 0x78, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0xF0, 0x01,
  0xE0, 0xE0, 0x01, 0xE1, 0xE0, 0x01, 0xE1, 0xC0, 0x00, 0xE3, 0xC0, 0x00,
  0xE3, 0x80, 0x00, 0xE7, 0x80, 0x00, 0xE7, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x7F, 0xFC, 0x3F, 0xFF,
  0x0F, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xF0, 0x00,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x3E,
  0x00, 0xFC, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x7E, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x3E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xE0, 0x00, 0x04,
  0x00, 0x27, 0xF8, 0x05, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x07, 0xFD, 0x00,
  0x3E, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Italic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 10, 31, 11, 1, -30 },
  { 40, 13, 11, 16, 4, -30 },
  { 58, 23, 30, 24, 1, -30 },
  { 145, 19, 34, 21, 1, -32 },
  { 226, 26, 30, 31, 3, -30 },
  { 324, 23, 30, 24, 1, -30 },
  { 411, 6, 11, 9, 4, -30 },
  { 420, 14, 37, 12, 1, -30 },
  { 485, 13, 37, 12, -3, -30 },
  { 546, 17, 17, 20, 4, -32 },
  { 583, 19, 20, 22, 2, -25 },
  { 631, 8, 10, 10, -2, -5 },
  { 641, 10, 3, 12, 1, -13 },
  { 645, 5, 6, 10, 1, -5 },
  { 649, 20, 30, 15, -2, -30 },
  { 724, 18, 30, 21, 2, -30 },
  { 792, 12, 30, 21, 5, -30 },
  { 837, 20, 30, 21, 0, -30 },
  { 912, 20, 30, 21, 0, -30 },
  { 987, 20, 30, 21, 0, -30 },
  { 1062, 19, 30, 21, 1, -30 },
  { 1134, 19, 30, 21, 2, -30 },
  { 1206, 19, 30, 21, 3, -30 },
  { 1278, 20, 30, 21, 1, -30 },
  { 1353, 19, 30, 21, 1, -30 },
  { 1425, 8, 24, 10, 1, -23 },
  { 1449, 11, 28, 10, -2, -23 },
  { 1488, 19, 20, 22, 2, -25 },
  { 1536, 18, 12, 22, 3, -21 },
  { 1563, 19, 20, 22, 2, -25 },
  { 1611, 15, 31, 16, 2, -30 },
  { 1670, 29, 34, 32, 2, -30 },
  { 1794, 22, 30, 21, -3, -30 },
  { 1877, 21, 30, 23, 1, -30 },
  { 1956, 22, 30, 22, 2, -30 },
  { 2039, 23, 30, 25, 1, -30 },
  { 2126, 20, 30, 19, 1, -30 },
  { 2201, 20, 30, 18, 1, -30 },
  { 2276, 24, 30, 26, 2, -30 },
  { 2366, 25, 30, 26, 1, -30 },
  { 2460, 16, 30, 13, -1, -30 },
  { 2520, 17, 38, 10, -6, -30 },
  { 2601, 24, 30, 21, 1, -30 },
  { 2691, 14, 30, 18, 1, -30 },
  { 2744, 32, 30, 32, 1, -30 },
  { 2864, 26, 30, 27, 1, -30 },
  { 2962, 24, 30, 27, 2, -30 },
  { 3052, 21, 30, 21, 1, -30 },
  { 3131, 24, 37, 27, 2, -30 },
  { 3242, 21, 30, 22, 1, -30 },
  { 3321, 20, 30, 19, 0, -30 },
  { 3396, 18, 30, 19, 4, -30 },
  { 3464, 23, 30, 25, 3, -30 },
  { 3551, 21, 30, 21, 4, -30 },
  { 3630, 32, 30, 33, 4, -30 },
  { 3750, 25, 30, 20, -2, -30 },
  { 3844, 19, 30, 19, 4, -30 },
  { 3916, 22, 30, 19, -1, -30 },
  { 3999, 16, 37, 12, -1, -30 },
  { 4073, 8, 30, 15, 4, -30 },
  { 4103, 16, 37, 12, -3, -30 },
  { 4177, 19, 18, 21, 1, -30 },
  { 4220, 16, 2, 15, -4, 4 },
  { 4224, 7, 7, 11, 6, -32 },
  { 4231, 19, 23, 22, 2, -23 },
  { 4286, 19, 32, 22, 1, -32 },
  { 4362, 16, 23, 17, 2, -23 },
  { 4408, 21, 32, 22, 2, -32 },
  { 4492, 16, 23, 19, 2, -23 },
  { 4538, 22, 42, 12, -5, -32 },
  { 4654, 21, 33, 22, 0, -23 },
  { 4741, 19, 32, 22, 1, -32 },
  { 4817, 10, 31, 10, 1, -31 },
  { 4856, 16, 41, 10, -5, -31 },
  { 4938, 19, 32, 19, 1, -32 },
  { 5014, 10, 32, 10, 1, -32 },
  { 5054, 30, 23, 33, 1, -23 },
  { 5141, 19, 23, 22, 1, -23 },
  { 5196, 18, 23, 21, 2, -23 },
  { 5248, 21, 33, 22, -1, -23 },
  { 5335, 19, 33, 22, 2, -23 },
  { 5414, 15, 23, 15, 1, -23 },
  { 5458, 16, 23, 16, 0, -23 },
  { 5504, 12, 28, 13, 2, -28 },
  { 5546, 19, 23, 22, 2, -23 },
  { 5601, 18, 23, 18, 2, -23 },
  { 5653, 27, 23, 28, 2, -23 },
  { 5731, 21, 23, 18, -2, -23 },
  { 5792, 24, 33, 18, -4, -23 },
  { 5891, 18, 23, 16, -1, -23 },
  { 5943, 16, 37, 14, 1, -30 },
  { 6017, 3, 42, 20, 9, -32 },
  { 6033, 16, 37, 14, -2, -30 },
  { 6107, 19, 6, 22, 2, -18 },
};

const GFXfont NotoSans_SemiCondensed_Italic42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic42pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC42PT7B_H_
