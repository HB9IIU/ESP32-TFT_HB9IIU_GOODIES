#ifndef _NOTOSANS_SEMICONDENSED_ITALIC68PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1C, 0x00, 0x00,
  0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x3F, 0x03, 0xF3, 0xF0, 0x7E, 0x3F, 0x07,
  0xE3, 0xF0, 0x7E, 0x3E, 0x07, 0xE3, 0xE0, 0x7C, 0x3E, 0x07, 0xC7, 0xC0,
  0x7C, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0x80, 0xF8, 0x78,
  0x0F, 0x0F, 0x80, 0xF0, 0xF0, 0x0F, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x01, 0xE0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0x3C, 0x7C, 0x00, 0xFC, 0x3C, 0x0C, 0x01, 0xF8, 0x38, 0x00, 0x01, 0xF0,
  0x78, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x03, 0xF0, 0x78, 0x00, 0x03, 0xF0,
  0x78, 0x00, 0x03, 0xF0, 0x70, 0x00, 0x03, 0xF0, 0xF0, 0x00, 0x03, 0xF0,
  0xF0, 0x00, 0x01, 0xF8, 0xF0, 0x00, 0x01, 0xFC, 0xF0, 0x00, 0x01, 0xFE,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xDF, 0xC0, 0x00, 0x03,
  0x8F, 0xE0, 0x00, 0x07, 0x87, 0xE0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x07,
  0x83, 0xE0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x07, 0x03, 0xE0, 0x00, 0x0F,
  0x03, 0xE0, 0x00, 0x0F, 0x07, 0xE0, 0x00, 0x0F, 0x07, 0xE0, 0x40, 0x0F,
  0x0F, 0xC0, 0x70, 0x1E, 0x1F, 0xC0, 0x7F, 0x1E, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3E, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0x80, 0x3F, 0xFC, 0x00,
  0x07, 0xC0, 0x1F, 0xFF, 0x00, 0x03, 0xE0, 0x0F, 0xC7, 0xE0, 0x00, 0xF8,
  0x07, 0xE0, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x00, 0xF8,
  0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x00, 0x78, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x0F,
  0x80, 0x3C, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x03, 0xE0, 0x00, 0xF8, 0x07,
  0xC0, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x00, 0x7C, 0x3E,
  0x00, 0x03, 0xC0, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x0F, 0x87, 0xC3, 0xFE,
  0x3C, 0x03, 0xC3, 0xE1, 0xFF, 0xCF, 0x01, 0xF0, 0xF8, 0xFF, 0xFB, 0xC0,
  0x7C, 0x7C, 0x7F, 0x7E, 0xF8, 0x3E, 0x3E, 0x3F, 0x0F, 0xBF, 0x1F, 0x0F,
  0x8F, 0x81, 0xF7, 0xFF, 0xC7, 0xC7, 0xC0, 0x7D, 0xFF, 0xE3, 0xE1, 0xF0,
  0x1F, 0x3F, 0xF0, 0xF8, 0x78, 0x07, 0xC7, 0xF0, 0x7C, 0x3E, 0x01, 0xF0,
  0x00, 0x3E, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x83, 0xC0, 0x1F, 0x00, 0x07,
  0xC1, 0xF0, 0x07, 0x80, 0x03, 0xE0, 0x7C, 0x01, 0xE0, 0x00, 0xF8, 0x1F,
  0x00, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x01, 0xE0, 0x0F,
  0x80, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x1E, 0x00, 0x7C, 0x00,
  0xF8, 0x0F, 0x80, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0x81,
  0xF0, 0x07, 0xC0, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x07, 0xC7, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x7E,
  0x00, 0x7E, 0x0F, 0xE3, 0xF8, 0x03, 0xF0, 0xFE, 0x0F, 0xC0, 0x3F, 0x0F,
  0xE0, 0x7F, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x1F, 0x87, 0xE0, 0x0F, 0xE0,
  0xFC, 0x7E, 0x00, 0x3F, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x7E, 0x1F, 0x00,
  0x07, 0xF7, 0xE1, 0xF8, 0x00, 0x1F, 0xFE, 0x0F, 0xC0, 0x00, 0xFF, 0xF0,
  0x7E, 0x00, 0x03, 0xFF, 0x03, 0xF0, 0x00, 0x1F, 0xF0, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0xE0, 0x1F,
  0x80, 0x07, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFC, 0x1F, 0xF7,
  0xE0, 0x1F, 0xFF, 0xFF, 0x3F, 0x80, 0x7F, 0xFF, 0xE0, 0xFE, 0x01, 0xFF,
  0xFE, 0x03, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xC0, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x8F, 0xCF, 0xC7, 0xE3, 0xF1, 0xF8, 0xF8, 0x7C, 0x3E, 0x3F,
  0x1F, 0x0F, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0xF8, 0x78, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x00, 0x10, 0x01, 0xE0, 0x03, 0x80, 0x7C, 0x00,
  0x7C, 0x0F, 0x80, 0x0F, 0xE1, 0xE0, 0x03, 0xFF, 0x3C, 0x00, 0x7F, 0xFF,
  0x80, 0x71, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x20, 0x3E, 0xF0, 0x00, 0x0F, 0xDE,
  0x00, 0x03, 0xF1, 0xE0, 0x00, 0xFC, 0x3C, 0x00, 0x3F, 0x07, 0xC0, 0x0F,
  0xE0, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x1E, 0x01, 0xF0, 0x01, 0x80, 0x3F,
  0x00, 0x10, 0x03, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E,
  0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03,
  0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xBF, 0xFF,
  0xDF, 0xFF, 0xEF, 0xFF, 0xEF, 0xFF, 0xF0, 0x1E, 0x7F, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7E, 0x38, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F,
  0x00, 0x7E, 0x03, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0x7F, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFC,
  0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3E, 0x3F,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x7E, 0x7E, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xE7, 0xC0, 0x00,
  0x1F, 0x1F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x7F, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F,
  0xEF, 0x8F, 0xFB, 0xF3, 0xFC, 0x7E, 0x7F, 0x0F, 0xC7, 0x81, 0xF0, 0x60,
  0x7E, 0x08, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F,
  0xE0, 0x1F, 0xE0, 0x01, 0xE0, 0x03, 0xF8, 0x00, 0x70, 0x00, 0x7E, 0x00,
  0x08, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x1E, 0x00, 0x3F, 0x80, 0x30, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x82, 0x00, 0x00, 0xFE, 0x07, 0x80, 0x07, 0xFC, 0x0F, 0xF0, 0x7F, 0xF0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x0F,
  0xBF, 0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x07,
  0xE1, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x01,
  0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x01,
  0xF8, 0x03, 0xE0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xF3, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0xC0, 0x00, 0x3F, 0x80, 0xF0,
  0x00, 0xFF, 0x80, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x03,
  0xFE, 0x00, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7E, 0x03, 0x80, 0x00, 0xFC, 0x3F, 0xE0, 0x01, 0xF1, 0xFF, 0xF0,
  0x07, 0xE7, 0xFF, 0xF0, 0x0F, 0xDF, 0xFF, 0xF0, 0x1F, 0x7E, 0x3F, 0xE0,
  0x3F, 0xE0, 0x0F, 0xE0, 0xFF, 0x80, 0x0F, 0xC1, 0xFE, 0x00, 0x1F, 0x83,
  0xF8, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x7C, 0x1F,
  0x80, 0x00, 0xF8, 0x7E, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xE1, 0xF8,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x3E, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xFE, 0x3F, 0xE0, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xF8, 0x0F, 0x80,
  0x01, 0xF0, 0x1F, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x03, 0xF0, 0x1F, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xF3, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFB, 0xFC, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF8, 0x0F,
  0xC0, 0x03, 0xF0, 0x3F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7C, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x83, 0xF8, 0x00,
  0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xFE, 0x0F, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0xFE, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xF8, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7F, 0x1F, 0x80, 0x01, 0xFC,
  0x7E, 0x00, 0x0F, 0xF1, 0xF8, 0x00, 0x3F, 0x83, 0xF0, 0x01, 0xFE, 0x0F,
  0xE0, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0xE0, 0x7F, 0xFF, 0xDF, 0x81, 0xFF,
  0xFE, 0x7C, 0x03, 0xFF, 0xF3, 0xF0, 0x07, 0xFF, 0x8F, 0xC0, 0x03, 0xF8,
  0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x20, 0x01,
  0xFE, 0x00, 0xFC, 0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFC, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0x80, 0xFC, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F, 0x00, 0xFE,
  0x0C, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0xFF, 0xE0, 0x0F, 0x03, 0xE0, 0x07, 0xFF, 0xF0, 0x1E, 0x0F, 0x80,
  0x1F, 0xFF, 0xE0, 0x3E, 0x1F, 0x00, 0x7F, 0xFF, 0xC0, 0x7C, 0x7C, 0x01,
  0xF8, 0x0F, 0x00, 0xF8, 0xF8, 0x07, 0xE0, 0x3E, 0x01, 0xF3, 0xE0, 0x1F,
  0x80, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xCF, 0x00, 0xF8,
  0x01, 0xE0, 0x0F, 0xBE, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x7C, 0x07, 0xC0,
  0x0F, 0x80, 0x3C, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0xF9, 0xE0, 0x3E, 0x00,
  0x7C, 0x01, 0xF7, 0xC0, 0x7C, 0x00, 0xF8, 0x03, 0xEF, 0x80, 0xF8, 0x01,
  0xF0, 0x07, 0x9F, 0x01, 0xE0, 0x03, 0xE0, 0x1F, 0x3E, 0x03, 0xC0, 0x0F,
  0x80, 0x3E, 0x7C, 0x07, 0x80, 0x1F, 0x00, 0x78, 0xF8, 0x1F, 0x00, 0x7E,
  0x01, 0xF1, 0xF0, 0x3E, 0x00, 0xFC, 0x03, 0xC3, 0xE0, 0x3C, 0x03, 0xF8,
  0x0F, 0x87, 0xC0, 0x7C, 0x07, 0xF0, 0x3E, 0x0F, 0x80, 0xF8, 0x1D, 0xE0,
  0xFC, 0x1F, 0x01, 0xFF, 0xFB, 0xF7, 0xF0, 0x3E, 0x01, 0xFF, 0xE3, 0xFF,
  0xC0, 0x7C, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0xF8, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0xF8, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x00, 0x7C,
  0x7E, 0x00, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00,
  0xFC, 0x1F, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x7C, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00,
  0x01, 0xF3, 0xF0, 0x00, 0x00, 0x3E, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0x83, 0xFF,
  0xE0, 0x07, 0xE0, 0x07, 0xF8, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7F, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x03, 0xF8,
  0x03, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x0F, 0xC0,
  0x01, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFE,
  0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07,
  0xF0, 0x3E, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xFE, 0x07, 0xE0, 0x00,
  0xFF, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0x00, 0x1F, 0xF0, 0x00, 0x40, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x01, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01,
  0xF8, 0x03, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x1F,
  0xE0, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7F, 0x01, 0xF0, 0x00,
  0x03, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0xFE, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x81, 0xF0, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x01, 0xFC,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x3E, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0x80,
  0x00, 0x7F, 0x80, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xE0, 0x00, 0x7F, 0x80,
  0x3E, 0x00, 0x07, 0xF8, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0x80, 0x0F,
  0xF8, 0x00, 0xFC, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0x03, 0xC0, 0x1F,
  0xF0, 0x00, 0x04, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x01, 0xFF, 0xF8, 0x7E, 0x00, 0x0F, 0xFF, 0xC7, 0xF0, 0x00,
  0x7F, 0xFE, 0x3F, 0x00, 0x03, 0xFF, 0xF1, 0xF8, 0x00, 0x3F, 0xFF, 0x8F,
  0xC0, 0x01, 0xFF, 0xF8, 0x7E, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x7E,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x1F, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x7E, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0xE0, 0x01,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0xC3, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x3F, 0x80, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0x7E, 0x0F,
  0xE0, 0x00, 0x01, 0xF0, 0x7F, 0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x03, 0xF3, 0xF8,
  0x00, 0x00, 0x0F, 0x9F, 0xC0, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xDF, 0x80, 0x00, 0x03, 0xFE, 0x7E, 0x00, 0x00, 0x0F,
  0xE1, 0xF8, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0x7C,
  0x00, 0x00, 0xFD, 0xF0, 0x03, 0xEF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x7D,
  0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x1F, 0xBE, 0x00, 0x00, 0xF9, 0xF8, 0x03,
  0xF7, 0xC0, 0x00, 0x3F, 0x3E, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xCF, 0xC0,
  0x0F, 0x9F, 0x80, 0x01, 0xF9, 0xF8, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x3F,
  0x00, 0x7E, 0x3E, 0x00, 0x0F, 0xC7, 0xC0, 0x0F, 0xC7, 0xC0, 0x01, 0xF1,
  0xF8, 0x01, 0xF0, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x3E, 0x1F, 0x00, 0x0F,
  0x87, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7C, 0x00,
  0x7C, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xC1, 0xF0,
  0x03, 0xE0, 0xFC, 0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07,
  0xE0, 0x1F, 0x03, 0xF0, 0x07, 0xE0, 0x7C, 0x07, 0xE0, 0x7C, 0x00, 0xFC,
  0x0F, 0x80, 0xF8, 0x1F, 0x80, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x03,
  0xE0, 0x3E, 0x07, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xC1, 0xF8, 0x0F, 0xC0,
  0x1F, 0x80, 0xF8, 0x3E, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x0F, 0xC0, 0x7E,
  0x00, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x7C, 0x7E, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x00, 0x7E, 0x01, 0xF3, 0xF0,
  0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x7C, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xFF,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F,
  0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x3F, 0xC0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xF8, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0x80, 0x1F, 0xF0, 0x00, 0x07, 0xE0, 0x07, 0xFC, 0x00,
  0x01, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xC0, 0x0F, 0xBE, 0x00, 0x03, 0xF0, 0x03,
  0xEF, 0xC0, 0x00, 0xFC, 0x01, 0xFB, 0xF0, 0x00, 0x3E, 0x00, 0x7E, 0x7C,
  0x00, 0x0F, 0x80, 0x1F, 0x1F, 0x80, 0x07, 0xE0, 0x07, 0xC7, 0xE0, 0x01,
  0xF8, 0x01, 0xF0, 0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x00,
  0x3F, 0x0F, 0xC0, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xF0, 0x03, 0xE0,
  0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x07, 0xE0,
  0x0F, 0x80, 0x1F, 0x80, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x3F, 0x01, 0xF8,
  0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x1F, 0x80, 0x3F,
  0x00, 0x7C, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x0F,
  0x80, 0x1F, 0x80, 0x0F, 0xC3, 0xE0, 0x07, 0xE0, 0x01, 0xF1, 0xF8, 0x01,
  0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x00, 0x1F, 0x9F, 0x80, 0x3F, 0x00,
  0x03, 0xE7, 0xC0, 0x0F, 0xC0, 0x00, 0xF9, 0xF0, 0x03, 0xF0, 0x00, 0x3F,
  0x7C, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xC0,
  0x1F, 0x80, 0x00, 0x7F, 0xE0, 0x07, 0xE0, 0x00, 0x1F, 0xF8, 0x01, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0x00, 0x00,
  0x3F, 0xC0, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x1F, 0x81,
  0xFC, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0x07, 0xEF, 0xE0,
  0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x7F, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x3F,
  0x8F, 0xC0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0xFC, 0x00,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x03, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x03, 0xFC, 0x00, 0xF8,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x3F,
  0x00, 0x07, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x01,
  0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x07, 0xF0,
  0x1F, 0x80, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0xF8, 0x07, 0xE0, 0x3F, 0xF8,
  0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0xFE, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00, 0x1F, 0x83,
  0xF8, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x03, 0xFC, 0x00,
  0xF8, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x1F, 0xC0,
  0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F,
  0x01, 0xF0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x0F, 0xE0, 0x1F, 0x00, 0x0F,
  0xF0, 0x1F, 0x80, 0x0F, 0xF0, 0x0F, 0xC0, 0x3F, 0xF0, 0x07, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x1F,
  0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF0, 0x03, 0xFE, 0x03, 0xF0, 0x03, 0xFC, 0x00, 0x38, 0x01, 0xFC,
  0x00, 0x04, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x30, 0x00,
  0x0F, 0xE0, 0x1F, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x3E, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x7E,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x03, 0xFB, 0xF0,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x1F, 0x87,
  0xC0, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x07, 0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x03, 0xE0, 0x07, 0xE0, 0x00,
  0xF8, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x3F, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xF1,
  0xF8, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x07,
  0xCF, 0xC0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00,
  0x1F, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0x0F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1E, 0xF8,
  0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3E,
  0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0xC0, 0xFC, 0x00,
  0x7C, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xCF, 0x80, 0x1F, 0x80, 0xFC,
  0x00, 0xF8, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x8F, 0x80, 0x1F, 0x80,
  0xFC, 0x01, 0xF0, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x3F,
  0x00, 0xFC, 0x03, 0xE0, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3E, 0x0F, 0x80,
  0x7E, 0x00, 0xFC, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0x0F, 0xC0, 0x7C, 0x0F,
  0x80, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0xF8,
  0x0F, 0x81, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0xF8, 0x1F, 0x80, 0x0F, 0xC1,
  0xF0, 0x0F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x00, 0xF8, 0x3F, 0x00, 0x0F,
  0xC3, 0xE0, 0x0F, 0x83, 0xE0, 0x00, 0xFC, 0x3E, 0x00, 0xF8, 0x7E, 0x00,
  0x0F, 0xC7, 0xE0, 0x0F, 0x87, 0xC0, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0xFC,
  0x00, 0x0F, 0xC7, 0xC0, 0x0F, 0x8F, 0xC0, 0x00, 0xFC, 0xF8, 0x00, 0xF8,
  0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x0F, 0x9F, 0x80, 0x00, 0xFD, 0xF0, 0x00,
  0xF9, 0xF0, 0x00, 0x0F, 0xDF, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xFD, 0xF0,
  0x00, 0xFB, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x03,
  0xE1, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xF3, 0xF0, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0x80, 0x01,
  0xF8, 0x3F, 0x00, 0x07, 0xF0, 0x3E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x07, 0xE0,
  0x03, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0xFE, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x3E, 0x0F, 0xC0, 0x00,
  0x7C, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x01,
  0xF7, 0xE0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF0,
  0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x00, 0xF0, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0x81, 0xF0, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x03,
  0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0xFC, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xE0,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x01, 0xF1, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0x07, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFE, 0xFC, 0x3F, 0x87, 0xE1, 0xF8, 0x3F, 0x07, 0xC1, 0xF8,
  0x3E, 0x07, 0xC0, 0xF0, 0x1C, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x7C, 0x01, 0xFF, 0xF0, 0xF8, 0x07, 0xFF, 0xF1, 0xF0, 0x1F, 0xFF, 0xF7,
  0xC0, 0x7F, 0x81, 0xEF, 0x81, 0xFE, 0x01, 0xFF, 0x03, 0xF8, 0x01, 0xFE,
  0x0F, 0xE0, 0x03, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x7E, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x1F,
  0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF8, 0x7E, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x83, 0xF0, 0x00,
  0x7F, 0x07, 0xE0, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xF8, 0x1F, 0x80, 0x1F,
  0xF0, 0x3F, 0x00, 0x3F, 0xE0, 0x7F, 0x01, 0xFF, 0xC0, 0x7F, 0x8F, 0xDF,
  0x00, 0xFF, 0xFF, 0x3E, 0x00, 0xFF, 0xFC, 0x7C, 0x00, 0xFF, 0xF0, 0xF8,
  0x00, 0xFF, 0x81, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0xF8, 0x7F, 0xF0, 0x01, 0xF8, 0xFF, 0xF8, 0x01, 0xF9, 0xFF,
  0xFC, 0x01, 0xFB, 0xFF, 0xFC, 0x01, 0xF7, 0xC0, 0xFE, 0x01, 0xFF, 0x80,
  0x7E, 0x03, 0xFF, 0x00, 0x7E, 0x03, 0xFE, 0x00, 0x3E, 0x03, 0xFC, 0x00,
  0x3F, 0x03, 0xF8, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x3E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x01,
  0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03,
  0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0xC0, 0x0F,
  0xE0, 0x7F, 0xE0, 0x3F, 0xC0, 0x7D, 0xF8, 0x7F, 0x80, 0x7C, 0xFF, 0xFF,
  0x00, 0x7C, 0xFF, 0xFE, 0x00, 0xF8, 0x7F, 0xFC, 0x00, 0xF8, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xE0, 0x18,
  0x1F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x60, 0x7F, 0xC1, 0xF0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xC1, 0xF8,
  0x00, 0x3F, 0xF8, 0x7E, 0x00, 0x1F, 0xFF, 0x1F, 0x80, 0x0F, 0xFF, 0xE7,
  0xC0, 0x07, 0xFF, 0xFD, 0xF0, 0x03, 0xFC, 0x0F, 0x7C, 0x01, 0xFC, 0x01,
  0xFF, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0,
  0x03, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x00,
  0x0F, 0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0xFC,
  0x00, 0xFF, 0x80, 0x3F, 0x00, 0x7F, 0xE0, 0x0F, 0xE0, 0x3F, 0xF8, 0x01,
  0xFE, 0x3F, 0x7C, 0x00, 0x7F, 0xFF, 0x9F, 0x00, 0x0F, 0xFF, 0xC7, 0xC0,
  0x01, 0xFF, 0xE1, 0xF0, 0x00, 0x3F, 0xE0, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x00,
  0xFC, 0x3F, 0x80, 0x1F, 0x0F, 0xC0, 0x07, 0xC7, 0xF0, 0x01, 0xF1, 0xF8,
  0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x8F, 0x80, 0x0F, 0xE7,
  0xE0, 0x07, 0xF1, 0xF8, 0x0F, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x41, 0xFC, 0x00, 0x60, 0x7F, 0xC0,
  0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x04, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x87, 0xC0, 0x07, 0xFF, 0xE3,
  0xE0, 0x07, 0xFF, 0xF1, 0xF0, 0x07, 0xFF, 0xFD, 0xF0, 0x07, 0xF8, 0x1E,
  0xF8, 0x07, 0xF0, 0x07, 0xFC, 0x03, 0xF0, 0x01, 0xFE, 0x03, 0xF8, 0x00,
  0xFF, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x7F, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x03, 0xF8, 0x0F,
  0xC0, 0x03, 0xFC, 0x07, 0xE0, 0x01, 0xFC, 0x03, 0xF0, 0x01, 0xFE, 0x01,
  0xF8, 0x01, 0xFF, 0x00, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0x01, 0xFF, 0xC0,
  0x1F, 0xE3, 0xF7, 0xC0, 0x0F, 0xFF, 0xF3, 0xE0, 0x03, 0xFF, 0xF3, 0xF0,
  0x00, 0xFF, 0xF1, 0xF8, 0x00, 0x3F, 0xE0, 0xFC, 0x00, 0x07, 0x80, 0x7C,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x02, 0x00, 0x07,
  0xF0, 0x01, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0xF8, 0x7F, 0xF0, 0x01, 0xF1, 0xFF,
  0xF0, 0x07, 0xE7, 0xFF, 0xF0, 0x0F, 0xDF, 0xFF, 0xE0, 0x1F, 0x7C, 0x0F,
  0xE0, 0x3F, 0xE0, 0x0F, 0xC0, 0xFF, 0x80, 0x1F, 0x81, 0xFE, 0x00, 0x3F,
  0x03, 0xFC, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8,
  0x3F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F,
  0x80, 0x01, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7C, 0x0F, 0xC0,
  0x01, 0xF8, 0x1F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x0F, 0x81, 0xF8, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xC0, 0x00,
  0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x0F,
  0xC0, 0xF8, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x00, 0x0E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0x00, 0xF8, 0x00, 0xFE,
  0x01, 0xF8, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x03, 0xF0,
  0x01, 0xF8, 0x07, 0xE0, 0x01, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80,
  0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x03, 0xE0, 0xFE, 0x00,
  0x03, 0xE1, 0xFC, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x07, 0xC7, 0xE0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x0F, 0xDF, 0xC0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xE3, 0xF0, 0x00, 0x1F, 0xC3, 0xF0, 0x00,
  0x1F, 0x83, 0xF8, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x1F, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x08, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0x78, 0x3F, 0xF8, 0x0F, 0xFE, 0x00,
  0x7C, 0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0x3E, 0x3F, 0xFF, 0x0F, 0xFF, 0xE0,
  0x1F, 0x3F, 0xFF, 0x8F, 0xFF, 0xF0, 0x0F, 0xBE, 0x0F, 0xEF, 0x81, 0xFC,
  0x07, 0xFC, 0x03, 0xFF, 0x80, 0x7E, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0x81, 0xFE, 0x00, 0x7F, 0x80, 0x0F,
  0xC0, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x3F, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x1F, 0xE0, 0x01, 0xF0, 0xFF, 0xF0, 0x07, 0xC3, 0xFF, 0xF0, 0x0F, 0x8F,
  0xFF, 0xE0, 0x1F, 0x3F, 0xFF, 0xE0, 0x3E, 0xFC, 0x1F, 0xC0, 0xFF, 0xE0,
  0x1F, 0x81, 0xFF, 0x80, 0x3F, 0x03, 0xFE, 0x00, 0x7E, 0x07, 0xF8, 0x00,
  0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x07,
  0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E,
  0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x7E,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC1,
  0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0x87, 0xE0,
  0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x81, 0xF8,
  0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC3, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x28, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0xFF,
  0xC0, 0x00, 0x78, 0x7F, 0xFC, 0x00, 0x1F, 0x1F, 0xFF, 0xC0, 0x03, 0xE7,
  0xFF, 0xF8, 0x00, 0x7D, 0xF0, 0x3F, 0x80, 0x0F, 0xFC, 0x03, 0xF0, 0x03,
  0xFF, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x07, 0xC0, 0x0F, 0xF0, 0x00, 0xFC,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x03, 0xF0, 0x0F, 0xE0, 0x00,
  0x7E, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0xFC,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x1F, 0xC0,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x0F,
  0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0xE0, 0x3F, 0xC0,
  0x0F, 0xFF, 0x0F, 0xF0, 0x01, 0xF3, 0xFF, 0xFC, 0x00, 0x3E, 0x7F, 0xFF,
  0x00, 0x07, 0xC7, 0xFF, 0xC0, 0x01, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0x01,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x7C, 0x01, 0xFF, 0xF8, 0xF8, 0x07, 0xFF, 0xF1, 0xF0,
  0x1F, 0xFF, 0xF7, 0xC0, 0x7F, 0x81, 0xEF, 0x81, 0xFC, 0x01, 0xFF, 0x03,
  0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7E,
  0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x3F, 0x87, 0xE0,
  0x00, 0x7E, 0x1F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0x87, 0xE0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x03,
  0xF8, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F,
  0x83, 0xF0, 0x00, 0xFF, 0x07, 0xE0, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xF8,
  0x1F, 0x80, 0x1F, 0xF0, 0x3F, 0x00, 0x7F, 0xE0, 0x7F, 0x01, 0xFF, 0xC0,
  0x7F, 0x8F, 0xDF, 0x00, 0xFF, 0xFF, 0x3E, 0x00, 0xFF, 0xFC, 0xFC, 0x00,
  0xFF, 0xF1, 0xF8, 0x00, 0xFF, 0x83, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x08,
  0x1F, 0xC0, 0x3C, 0x1F, 0xE0, 0x1F, 0x0F, 0xF8, 0x07, 0xC7, 0xFE, 0x01,
  0xF3, 0xFF, 0x00, 0x7D, 0xFC, 0x40, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x81, 0xFC, 0x01, 0xE0, 0x7E, 0x00, 0x10, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x08, 0x00, 0x1F, 0x83, 0x80, 0x0F, 0xE0, 0xFC, 0x0F, 0xF8, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x03, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x08, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x01,
  0xFF, 0x80, 0x07, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0xF8, 0x1F, 0x80, 0x01, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x7C,
  0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF0, 0x3F, 0x00, 0x03, 0xE0, 0x7E,
  0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x7C, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3E, 0x00,
  0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0xFE, 0x07, 0xE0, 0x03, 0xFC, 0x0F, 0xC0, 0x0F, 0xF8, 0x1F, 0x80, 0x3F,
  0xF0, 0x3F, 0x80, 0xF7, 0xC0, 0x7F, 0x8F, 0xEF, 0x80, 0x7F, 0xFF, 0x9F,
  0x00, 0xFF, 0xFE, 0x3E, 0x00, 0xFF, 0xF8, 0x78, 0x00, 0xFF, 0xC1, 0xF0,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7E,
  0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x8F, 0xC0,
  0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7E,
  0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0x7C,
  0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x07, 0xC0, 0x3F,
  0x00, 0x7C, 0x07, 0xE0, 0x07, 0xC0, 0x7E, 0x00, 0x7C, 0x07, 0xC0, 0x07,
  0xC0, 0xFC, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x03, 0xE7, 0xE0, 0x00,
  0x3E, 0x7C, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xFF, 0x80,
  0x1F, 0x0F, 0xC0, 0x1F, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xEF, 0x80, 0x3F,
  0x0F, 0xC0, 0x3E, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xCF, 0x80, 0x7E, 0x0F,
  0xC0, 0x7C, 0xF8, 0x07, 0xC0, 0xFC, 0x07, 0xCF, 0x80, 0xFC, 0x0F, 0xC0,
  0xF8, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0x8F, 0x81, 0xF8, 0x0F, 0xC1, 0xF0,
  0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0x0F, 0x83, 0xF0, 0x0F, 0xC1, 0xE0, 0xF8,
  0x3F, 0x00, 0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0x0F, 0xC3, 0xE0, 0xF8, 0x7E,
  0x00, 0xFC, 0x7C, 0x0F, 0x87, 0xC0, 0x0F, 0xC7, 0xC0, 0xF8, 0xFC, 0x00,
  0xFC, 0xF8, 0x0F, 0x8F, 0x80, 0x0F, 0xCF, 0x80, 0xF8, 0xF8, 0x00, 0xFC,
  0xF0, 0x0F, 0x9F, 0x80, 0x0F, 0xDF, 0x00, 0x79, 0xF0, 0x00, 0x7D, 0xF0,
  0x07, 0xBF, 0x00, 0x07, 0xFE, 0x00, 0x7B, 0xE0, 0x00, 0x7B, 0xE0, 0x07,
  0xBE, 0x00, 0x07, 0xBC, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0x80,
  0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xE1, 0xF8, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x07, 0xDF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00,
  0x7E, 0x3E, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0xC3, 0xF0, 0x00,
  0x07, 0xE0, 0x7C, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x0F, 0xE0, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x7E, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x00,
  0x3E, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0xFC,
  0x00, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x01,
  0xE7, 0xC0, 0x00, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x00, 0x1E, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x40, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x70, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x04, 0xFF, 0xF8, 0x00, 0x77, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xEC, 0x00, 0x3F, 0xFF, 0x20, 0x00, 0x1F, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Italic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 17, 50, 17, 1, -49 },
  { 108, 20, 18, 25, 7, -49 },
  { 153, 38, 49, 38, 1, -49 },
  { 386, 32, 56, 33, 1, -52 },
  { 610, 42, 50, 50, 5, -49 },
  { 873, 37, 50, 40, 1, -49 },
  { 1105, 9, 18, 14, 7, -49 },
  { 1126, 22, 60, 19, 2, -49 },
  { 1291, 21, 60, 19, -5, -49 },
  { 1449, 27, 28, 33, 7, -52 },
  { 1544, 29, 32, 35, 4, -40 },
  { 1660, 13, 17, 16, -3, -8 },
  { 1688, 17, 5, 20, 1, -21 },
  { 1699, 8, 9, 16, 1, -8 },
  { 1708, 32, 49, 24, -3, -49 },
  { 1904, 30, 50, 33, 3, -49 },
  { 2092, 19, 49, 33, 9, -49 },
  { 2209, 34, 49, 33, -1, -49 },
  { 2418, 31, 50, 33, 1, -49 },
  { 2612, 33, 49, 33, 0, -49 },
  { 2815, 32, 50, 33, 1, -49 },
  { 3015, 31, 50, 33, 3, -49 },
  { 3209, 31, 49, 33, 4, -49 },
  { 3399, 31, 50, 33, 2, -49 },
  { 3593, 30, 50, 33, 2, -49 },
  { 3781, 14, 38, 16, 1, -37 },
  { 3848, 18, 46, 16, -3, -37 },
  { 3952, 30, 33, 35, 4, -41 },
  { 4076, 29, 18, 35, 4, -33 },
  { 4142, 30, 33, 35, 4, -41 },
  { 4266, 24, 50, 26, 4, -49 },
  { 4416, 47, 55, 51, 3, -49 },
  { 4740, 35, 49, 34, -4, -49 },
  { 4955, 34, 49, 37, 2, -49 },
  { 5164, 35, 50, 35, 4, -49 },
  { 5383, 37, 49, 40, 2, -49 },
  { 5610, 32, 49, 31, 2, -49 },
  { 5806, 32, 49, 29, 2, -49 },
  { 6002, 37, 50, 41, 4, -49 },
  { 6234, 40, 49, 41, 2, -49 },
  { 6479, 27, 49, 20, -2, -49 },
  { 6645, 28, 62, 17, -10, -49 },
  { 6862, 38, 49, 34, 2, -49 },
  { 7095, 23, 49, 29, 2, -49 },
  { 7236, 51, 49, 52, 2, -49 },
  { 7549, 42, 49, 43, 2, -49 },
  { 7807, 38, 50, 43, 4, -49 },
  { 8045, 33, 49, 34, 2, -49 },
  { 8248, 38, 61, 43, 4, -49 },
  { 8538, 33, 49, 35, 2, -49 },
  { 8741, 33, 50, 31, 0, -49 },
  { 8948, 30, 49, 30, 6, -49 },
  { 9132, 38, 50, 41, 4, -49 },
  { 9370, 34, 49, 34, 6, -49 },
  { 9579, 52, 49, 53, 7, -49 },
  { 9898, 41, 49, 32, -4, -49 },
  { 10150, 31, 49, 31, 6, -49 },
  { 10340, 36, 49, 31, -1, -49 },
  { 10561, 26, 60, 20, -1, -49 },
  { 10756, 12, 49, 24, 7, -49 },
  { 10830, 26, 60, 20, -5, -49 },
  { 11025, 31, 29, 35, 2, -49 },
  { 11138, 26, 4, 25, -6, 6 },
  { 11151, 10, 11, 18, 10, -52 },
  { 11165, 31, 38, 35, 3, -37 },
  { 11313, 32, 53, 35, 1, -52 },
  { 11525, 25, 38, 27, 3, -37 },
  { 11644, 34, 53, 35, 3, -52 },
  { 11870, 26, 38, 31, 3, -37 },
  { 11994, 36, 68, 19, -8, -52 },
  { 12300, 33, 53, 36, 1, -37 },
  { 12519, 31, 52, 35, 1, -52 },
  { 12721, 16, 50, 16, 1, -50 },
  { 12821, 26, 66, 16, -9, -50 },
  { 13036, 32, 52, 30, 1, -52 },
  { 13244, 17, 52, 16, 1, -52 },
  { 13355, 49, 37, 53, 1, -37 },
  { 13582, 31, 37, 35, 1, -37 },
  { 13726, 29, 38, 34, 3, -37 },
  { 13864, 35, 53, 35, -2, -37 },
  { 14096, 31, 53, 35, 3, -37 },
  { 14302, 26, 37, 24, 1, -37 },
  { 14423, 26, 38, 26, 0, -37 },
  { 14547, 19, 46, 20, 3, -45 },
  { 14657, 31, 37, 35, 3, -36 },
  { 14801, 28, 36, 28, 4, -36 },
  { 14927, 44, 36, 45, 4, -36 },
  { 15125, 34, 36, 29, -3, -36 },
  { 15278, 38, 52, 29, -6, -36 },
  { 15525, 29, 36, 26, -2, -36 },
  { 15656, 26, 60, 23, 1, -49 },
  { 15851, 5, 68, 33, 15, -52 },
  { 15894, 25, 60, 23, -3, -49 },
  { 16082, 30, 8, 35, 4, -28 },
};

const GFXfont NotoSans_SemiCondensed_Italic68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic68pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC68PT7B_H_
