#ifndef _NOTOSANS_SEMICONDENSED_ITALIC43PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x03, 0xE0,
  0xF8, 0x3E, 0x0F, 0x01, 0x00, 0x78, 0xF7, 0x8F, 0x70, 0xF7, 0x0E, 0x70,
  0xEF, 0x1E, 0xE1, 0xCE, 0x1C, 0xE1, 0xCE, 0x1C, 0xC1, 0x80, 0x00, 0x1C,
  0x1C, 0x00, 0x38, 0x18, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x30,
  0x38, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0xE0,
  0x60, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x01, 0xC1,
  0xC0, 0x01, 0xC1, 0xC0, 0x01, 0x81, 0xC0, 0x03, 0x83, 0x80, 0x03, 0x83,
  0x80, 0x03, 0x83, 0x80, 0x07, 0x03, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0C, 0x0E,
  0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x18,
  0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0x03, 0xFF,
  0xE0, 0x7D, 0x8E, 0x0F, 0x18, 0x20, 0xE1, 0x80, 0x0E, 0x38, 0x00, 0xE3,
  0x80, 0x0E, 0x30, 0x00, 0xF3, 0x00, 0x0F, 0xB0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0xEF, 0x80,
  0x0C, 0x78, 0x00, 0xC7, 0x80, 0x0C, 0x78, 0x01, 0xC7, 0x80, 0x1C, 0x78,
  0x81, 0x8F, 0x0F, 0x1B, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x1F, 0xE0,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x07, 0xC0, 0x03, 0x81, 0xFC, 0x00, 0xE0, 0x7F, 0xC0, 0x3C, 0x1E,
  0x38, 0x07, 0x03, 0x87, 0x01, 0xC0, 0xE0, 0xE0, 0x78, 0x1C, 0x1C, 0x0E,
  0x03, 0x83, 0x83, 0x80, 0xE0, 0x70, 0xF0, 0x1C, 0x0E, 0x1C, 0x03, 0x81,
  0xC7, 0x00, 0x70, 0x71, 0xE0, 0x0E, 0x0E, 0x38, 0xF1, 0xC1, 0xCE, 0x3F,
  0x38, 0x73, 0xCF, 0xF7, 0x1E, 0x73, 0x8E, 0xFF, 0x9C, 0xE0, 0xEF, 0xE7,
  0x9C, 0x1C, 0xF8, 0xE7, 0x83, 0x80, 0x38, 0xE0, 0x70, 0x0F, 0x1C, 0x1C,
  0x01, 0xC3, 0x83, 0x80, 0x70, 0x70, 0x70, 0x1E, 0x1C, 0x0E, 0x03, 0x83,
  0x83, 0x80, 0xE0, 0x70, 0x70, 0x3C, 0x0E, 0x0E, 0x07, 0x01, 0xE3, 0x81,
  0xC0, 0x1C, 0xF0, 0x78, 0x03, 0xFC, 0x0E, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0x0F, 0x00, 0x3C, 0x1E,
  0x00, 0x70, 0x1C, 0x00, 0xE0, 0x78, 0x01, 0xC0, 0xF0, 0x03, 0x81, 0xC0,
  0x07, 0x07, 0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x78, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x1E, 0x3C,
  0xF0, 0x3C, 0xF0, 0xF0, 0x73, 0xC1, 0xE1, 0xE7, 0x01, 0xE3, 0x9E, 0x01,
  0xEF, 0x3C, 0x03, 0xFC, 0x70, 0x03, 0xF0, 0xE0, 0x07, 0xE1, 0xE0, 0x0F,
  0x83, 0xC0, 0x3F, 0x87, 0xC0, 0xFF, 0x07, 0xFF, 0xCF, 0x07, 0xFF, 0x1E,
  0x07, 0xF8, 0x1E, 0x00, 0x7B, 0xDE, 0xE7, 0x7B, 0x9C, 0xE7, 0x30, 0x00,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03,
  0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F,
  0x00, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0E, 0x00,
  0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x40, 0xE0, 0x1C, 0x38, 0x07, 0xCE, 0x03,
  0xFF, 0x0F, 0x0F, 0xFF, 0xC0, 0x7F, 0xF0, 0x3E, 0x04, 0x1D, 0x80, 0x0E,
  0x70, 0x07, 0x9C, 0x07, 0xC3, 0x80, 0xE0, 0xE0, 0x10, 0x3C, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x0F, 0x0F,
  0x1E, 0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x70, 0x70, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x77, 0xFF, 0xFF, 0x20, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xE3, 0xE0, 0x78, 0x3C, 0x1E,
  0x03, 0x87, 0x80, 0x78, 0xF0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xF0,
  0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1C, 0xF0, 0x03, 0x9C, 0x00, 0x73, 0x80,
  0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x03, 0xCF, 0x00,
  0x79, 0xE0, 0x0F, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0E, 0x1E, 0x03,
  0xC3, 0xC0, 0xF0, 0x3C, 0x3E, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xF0,
  0x00, 0x00, 0xF0, 0x1E, 0x07, 0xE0, 0xFE, 0x1F, 0xE7, 0xDE, 0xF9, 0xCF,
  0x3C, 0x43, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x00,
  0x00, 0x3F, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0x83, 0xE0, 0x30,
  0x0F, 0x01, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0x83, 0xE0, 0x30, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x1F, 0xC0, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x20, 0x03, 0xE1, 0xC0, 0x3E, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x3B, 0x80, 0x03, 0x9C, 0x00, 0x3D, 0xE0, 0x03, 0xCF, 0x00, 0x1C,
  0x70, 0x01, 0xC3, 0x80, 0x1E, 0x3C, 0x01, 0xE1, 0xE0, 0x1E, 0x0F, 0x00,
  0xE0, 0x70, 0x0E, 0x03, 0x80, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0x70, 0x0F,
  0x07, 0x00, 0x70, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xC1, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x80,
  0x1F, 0x0C, 0x03, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xFC, 0x10, 0x3E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0x8F, 0xC0, 0xF7, 0xFE, 0x1F, 0xFF, 0xC3,
  0xF0, 0x7C, 0x7C, 0x07, 0x8F, 0x00, 0xF3, 0xC0, 0x0E, 0x78, 0x01, 0xCF,
  0x00, 0x39, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x1E,
  0x01, 0xE1, 0xE0, 0x78, 0x3C, 0x1F, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x07,
  0xF8, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0xE0,
  0x3C, 0x1F, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x00, 0xF0, 0xF0, 0x0F,
  0x07, 0x00, 0xF0, 0x70, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x03, 0xC7,
  0x80, 0x1F, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xFE, 0x01, 0xF1,
  0xF0, 0x3E, 0x0F, 0x87, 0x80, 0x78, 0x78, 0x03, 0x8F, 0x00, 0x3C, 0xF0,
  0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0x8F, 0x00, 0x78, 0xF8, 0x07, 0x87,
  0x80, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xE1, 0xE0, 0xF0, 0x1E, 0x1E, 0x03,
  0xC7, 0x80, 0x38, 0xF0, 0x07, 0x1C, 0x00, 0xE7, 0x80, 0x1C, 0xF0, 0x03,
  0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x07, 0xCF, 0x00, 0xF8, 0xF0, 0x3F,
  0x1F, 0xBF, 0xC1, 0xFF, 0xB8, 0x1F, 0xCF, 0x00, 0xC1, 0xE0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x40, 0x7C, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x00,
  0x0F, 0x1F, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0xF8, 0xF8, 0xF0, 0xF0, 0x40,
  0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01,
  0xC0, 0x70, 0x0E, 0x00, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x3C, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7C, 0x00,
  0x03, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x0F,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x0F,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x3F,
  0xFE, 0x1C, 0x3E, 0x10, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x20, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x38, 0x1E, 0x00, 0x01,
  0xC1, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0xE0, 0x3F, 0xE1, 0xC7,
  0x03, 0xFF, 0x0E, 0x70, 0x3C, 0x38, 0x33, 0x83, 0x83, 0x81, 0xB8, 0x3C,
  0x1C, 0x1D, 0xC1, 0xC0, 0xE0, 0xEE, 0x1C, 0x07, 0x07, 0xE0, 0xE0, 0x70,
  0x3F, 0x07, 0x03, 0x81, 0xF8, 0x70, 0x1C, 0x1D, 0xC3, 0x81, 0xE0, 0xEE,
  0x1C, 0x0E, 0x07, 0x70, 0xE0, 0xF0, 0x73, 0x87, 0x07, 0x87, 0x9C, 0x1C,
  0xEE, 0x78, 0xE0, 0xFE, 0x7F, 0x87, 0x03, 0xE1, 0xF8, 0x3C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x40, 0x03, 0xE0, 0x0E, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1D, 0xC0, 0x00,
  0x77, 0x00, 0x03, 0xDC, 0x00, 0x0E, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xC7,
  0x80, 0x0F, 0x1E, 0x00, 0x38, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x03, 0x80,
  0x3C, 0x0E, 0x00, 0xE0, 0x38, 0x07, 0x80, 0xE0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC3, 0xC0, 0x0F,
  0x0F, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xCF, 0x00, 0x0F, 0x3C,
  0x00, 0x3D, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xC0, 0x01, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xF1, 0xFE, 0x03, 0x80, 0x7C, 0x1E, 0x00,
  0xF0, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1C, 0x00, 0xF0,
  0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x01, 0xF0, 0x3F, 0xFF, 0x80, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x78, 0x0F, 0x81, 0xC0, 0x1E,
  0x07, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0E,
  0x00, 0x3C, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x3C, 0x1E, 0x07,
  0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xE0, 0xE0, 0x7C, 0x01, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFC, 0x04, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x38, 0x0F, 0xC0, 0xF0,
  0x07, 0x81, 0xE0, 0x0F, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0E, 0x00,
  0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03,
  0xC3, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C,
  0x70, 0x00, 0xF0, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x0F,
  0x00, 0x1E, 0x1C, 0x00, 0x78, 0x78, 0x01, 0xF0, 0xF0, 0x07, 0xC1, 0xE0,
  0x3F, 0x03, 0xC3, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xC1, 0xE0, 0x7C, 0x00,
  0x41, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x07, 0xFC, 0xF0, 0x0F, 0xF9, 0xE0,
  0x1F, 0xF3, 0x80, 0x01, 0xE7, 0x00, 0x03, 0x8E, 0x00, 0x0F, 0x1E, 0x00,
  0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x70, 0xF0, 0x00, 0xE1, 0xF0, 0x03,
  0xC1, 0xE0, 0x07, 0x83, 0xF0, 0x0F, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xE0, 0x3C,
  0x00, 0x78, 0x0F, 0x00, 0x1E, 0x03, 0x80, 0x07, 0x80, 0xE0, 0x01, 0xC0,
  0x78, 0x00, 0x70, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x01, 0xC0, 0x03,
  0xC0, 0xF0, 0x00, 0xE0, 0x3C, 0x00, 0x38, 0x0F, 0x00, 0x1E, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07,
  0x80, 0x0F, 0x01, 0xC0, 0x03, 0xC0, 0x70, 0x00, 0xF0, 0x3C, 0x00, 0x38,
  0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0xE0, 0x01, 0xE0, 0x38, 0x00,
  0x70, 0x1E, 0x00, 0x1C, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x70,
  0x00, 0xF0, 0x3C, 0x00, 0x38, 0x0F, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0x81,
  0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0xFA, 0x07, 0xFE,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x02, 0x1F, 0x00,
  0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x01, 0xC0, 0x0F, 0x03, 0xC0,
  0x1E, 0x03, 0xC0, 0x3E, 0x03, 0xC0, 0x7C, 0x03, 0x80, 0xF8, 0x07, 0x81,
  0xF0, 0x07, 0x81, 0xE0, 0x07, 0x83, 0xC0, 0x07, 0x87, 0x80, 0x07, 0x0F,
  0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x7C, 0x00, 0x0E, 0x78,
  0x00, 0x0E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x3C,
  0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E,
  0x00, 0x3C, 0x1E, 0x00, 0x38, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x78, 0x0F,
  0x00, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x80, 0xF0, 0x03,
  0xC0, 0xF0, 0x03, 0xC0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xB8, 0x0E, 0xE0, 0x03, 0xFC,
  0x07, 0x70, 0x01, 0xDE, 0x03, 0xBC, 0x01, 0xEF, 0x03, 0xDE, 0x00, 0xE7,
  0x01, 0xE7, 0x00, 0xF3, 0x80, 0xE3, 0x80, 0x73, 0xC0, 0x71, 0xC0, 0x79,
  0xE0, 0x38, 0xE0, 0x38, 0xF0, 0x3C, 0x70, 0x3C, 0x70, 0x1E, 0x38, 0x1C,
  0x78, 0x0E, 0x1C, 0x1E, 0x3C, 0x07, 0x0E, 0x0E, 0x1E, 0x07, 0x87, 0x0F,
  0x0F, 0x03, 0xC3, 0xC7, 0x07, 0x01, 0xE1, 0xE7, 0x07, 0x80, 0xE0, 0x73,
  0x83, 0xC0, 0x70, 0x3B, 0x81, 0xE0, 0x78, 0x1D, 0xC0, 0xE0, 0x3C, 0x0F,
  0xC0, 0x70, 0x1E, 0x07, 0xE0, 0x78, 0x0E, 0x03, 0xE0, 0x3C, 0x07, 0x01,
  0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0x01,
  0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x3C, 0x0F, 0x80, 0x07, 0x01, 0xF8, 0x00,
  0xE0, 0x3F, 0x00, 0x3C, 0x0F, 0xE0, 0x07, 0x81, 0xFE, 0x00, 0xF0, 0x3B,
  0xC0, 0x1C, 0x07, 0x38, 0x03, 0x80, 0xE7, 0x00, 0xF0, 0x3C, 0xF0, 0x1E,
  0x07, 0x9E, 0x03, 0x80, 0xE1, 0xC0, 0x70, 0x1C, 0x3C, 0x1E, 0x03, 0x87,
  0x83, 0xC0, 0xF0, 0x70, 0x78, 0x1E, 0x0E, 0x0E, 0x03, 0x81, 0xE1, 0xC0,
  0x70, 0x1C, 0x78, 0x1E, 0x03, 0x8F, 0x03, 0xC0, 0x79, 0xE0, 0x78, 0x0F,
  0x38, 0x0E, 0x00, 0xE7, 0x01, 0xC0, 0x1F, 0xE0, 0x78, 0x03, 0xFC, 0x0F,
  0x00, 0x3F, 0x81, 0xE0, 0x07, 0xE0, 0x38, 0x00, 0xFC, 0x07, 0x00, 0x0F,
  0x81, 0xE0, 0x01, 0xF0, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xF8, 0xFE, 0x03, 0xE0, 0x3E, 0x07,
  0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E,
  0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x78,
  0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78,
  0x00, 0x0F, 0x70, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0x70,
  0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x7C, 0x78, 0x00, 0x78, 0x7C,
  0x00, 0xF0, 0x3C, 0x01, 0xF0, 0x3F, 0x07, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x38, 0x0F, 0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xE0,
  0xF0, 0x0F, 0x07, 0x80, 0x78, 0x38, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00,
  0xF0, 0xF0, 0x0F, 0x07, 0x80, 0xF8, 0x38, 0x0F, 0x83, 0xC1, 0xF8, 0x1F,
  0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC,
  0x01, 0xF8, 0xFE, 0x03, 0xE0, 0x3E, 0x07, 0x80, 0x1F, 0x0F, 0x80, 0x0F,
  0x0F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x3C, 0x00, 0x0F,
  0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x70, 0x00, 0x1E,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0x70, 0x00, 0x3C, 0x78, 0x00, 0x3C,
  0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x7C, 0x00, 0xF0, 0x3C, 0x01, 0xF0,
  0x3F, 0x07, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x01, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x38, 0x0F, 0x83, 0xC0,
  0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x38, 0x03, 0xC3,
  0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x0F, 0x07, 0x80, 0xF8, 0x38, 0x1F,
  0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0x07, 0x00, 0x38,
  0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x3C, 0x07, 0x01, 0xE0,
  0x78, 0x0F, 0x03, 0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x00,
  0x78, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF,
  0xC0, 0xFF, 0xFC, 0x07, 0xE3, 0xE0, 0x7C, 0x02, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x20, 0x03, 0xC1, 0xC0, 0x7E, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFE, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0x7F, 0xFF, 0xE0, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x0F, 0x00,
  0x0E, 0x0F, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00,
  0x1C, 0x1E, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x1C, 0x00, 0x3C, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x38, 0x3C, 0x00, 0x38, 0x38, 0x00, 0x78, 0x78, 0x00,
  0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x70, 0x78, 0x00, 0xF0, 0x70, 0x00,
  0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xE0, 0xF0, 0x00, 0xE0, 0xF0, 0x01,
  0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x03, 0xC0, 0xF0, 0x03,
  0xC0, 0xF0, 0x07, 0x80, 0xF8, 0x1F, 0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3D,
  0xE0, 0x01, 0xEF, 0x00, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x0F, 0x1E, 0x00,
  0x78, 0xF0, 0x07, 0x83, 0x80, 0x3C, 0x1C, 0x03, 0xC0, 0xE0, 0x1E, 0x07,
  0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0xF0, 0x0E, 0x07, 0x80, 0x78, 0x78,
  0x03, 0xC3, 0xC0, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8E, 0x00, 0x3C,
  0xF0, 0x01, 0xE7, 0x00, 0x0F, 0x78, 0x00, 0x3B, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xF8, 0x01, 0xF0, 0x03, 0xFC, 0x00,
  0xF8, 0x03, 0xDE, 0x00, 0x7C, 0x01, 0xEF, 0x00, 0x7E, 0x00, 0xE7, 0x80,
  0x3F, 0x00, 0xF3, 0xC0, 0x3B, 0x80, 0x79, 0xE0, 0x1D, 0xC0, 0x78, 0xF0,
  0x1E, 0xE0, 0x3C, 0x78, 0x0E, 0x70, 0x3C, 0x3C, 0x0F, 0x38, 0x1E, 0x1E,
  0x07, 0x1C, 0x0E, 0x0F, 0x03, 0x8E, 0x0F, 0x03, 0x83, 0x87, 0x07, 0x81,
  0xC1, 0xC3, 0x87, 0x80, 0xE1, 0xE1, 0xC3, 0xC0, 0x70, 0xE0, 0xE1, 0xC0,
  0x38, 0xF0, 0x71, 0xE0, 0x1C, 0x70, 0x38, 0xE0, 0x0E, 0x38, 0x1C, 0xF0,
  0x07, 0x38, 0x0E, 0x78, 0x03, 0x9C, 0x07, 0x38, 0x01, 0xDE, 0x03, 0xBC,
  0x00, 0xEE, 0x01, 0xDC, 0x00, 0x77, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x07, 0xC0, 0x0F,
  0x80, 0x03, 0xC0, 0x07, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x07, 0xC0, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x78, 0x00,
  0xF0, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x07, 0x80, 0x01, 0xC1, 0xC0,
  0x00, 0x78, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x70, 0x00,
  0x03, 0xDC, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x38, 0x38,
  0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x01, 0xE0,
  0x1C, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x0F,
  0x00, 0x0F, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0x78, 0x03,
  0xC7, 0x00, 0x78, 0xF0, 0x1E, 0x1E, 0x03, 0x83, 0xC0, 0xF0, 0x38, 0x3C,
  0x07, 0x07, 0x80, 0xE1, 0xE0, 0x1E, 0x38, 0x03, 0xCF, 0x00, 0x3B, 0xC0,
  0x07, 0x70, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0xE1, 0xC3, 0x87, 0x0E,
  0x1E, 0x3C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x8F, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xE3, 0xC7, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xF1, 0xE1, 0xC3, 0x80,
  0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xFC, 0x00, 0x1D, 0xC0, 0x03, 0x9E, 0x00, 0x38, 0xE0,
  0x07, 0x0E, 0x00, 0x70, 0x70, 0x0E, 0x07, 0x00, 0xE0, 0x38, 0x1E, 0x03,
  0x81, 0xC0, 0x3C, 0x3C, 0x01, 0xC3, 0x80, 0x1C, 0x78, 0x00, 0xE7, 0x00,
  0x0E, 0xF0, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF1,
  0xE1, 0xE1, 0xC3, 0x83, 0x80, 0x01, 0xF8, 0x70, 0x7F, 0xCE, 0x0F, 0xFE,
  0xE1, 0xF0, 0x7E, 0x1E, 0x03, 0xE3, 0xC0, 0x3C, 0x3C, 0x03, 0xC7, 0x80,
  0x3C, 0x78, 0x03, 0xC7, 0x00, 0x3C, 0xF0, 0x03, 0x8F, 0x00, 0x38, 0xF0,
  0x07, 0x8F, 0x00, 0x78, 0xE0, 0x07, 0x8E, 0x00, 0xF0, 0xE0, 0x0F, 0x0F,
  0x01, 0xF0, 0xF0, 0x3F, 0x0F, 0x07, 0xE0, 0x7F, 0xEE, 0x07, 0xFC, 0xE0,
  0x3F, 0x8E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x0F, 0x1F, 0x80, 0xF7, 0xFC, 0x0F, 0xFF, 0xE0,
  0xEC, 0x1E, 0x0F, 0x80, 0xE1, 0xF8, 0x0F, 0x1F, 0x00, 0xF1, 0xE0, 0x0F,
  0x1E, 0x00, 0xF1, 0xC0, 0x0F, 0x3C, 0x00, 0xE3, 0xC0, 0x1E, 0x3C, 0x01,
  0xE3, 0x80, 0x1E, 0x38, 0x01, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80,
  0x78, 0x7C, 0x0F, 0x8F, 0xC1, 0xF0, 0xFF, 0xFE, 0x0E, 0x7F, 0xC0, 0xE3,
  0xF8, 0x00, 0x01, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0x02, 0x1E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x10, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x1F, 0x8E, 0x01, 0xFF, 0x38, 0x0F, 0xFE, 0xE0,
  0x7C, 0x1F, 0x81, 0xE0, 0x3E, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC1, 0xE0,
  0x0F, 0x07, 0x80, 0x3C, 0x1C, 0x00, 0xF0, 0xF0, 0x03, 0x83, 0xC0, 0x1E,
  0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0xE0, 0x0F, 0x03, 0x80, 0x3C, 0x0E,
  0x01, 0xF0, 0x3C, 0x07, 0xC0, 0xF0, 0x3F, 0x03, 0xC1, 0xF8, 0x07, 0xFE,
  0xE0, 0x1F, 0xF3, 0x80, 0x3F, 0x8E, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0x83,
  0xFF, 0xC3, 0xE0, 0xE1, 0xE0, 0x79, 0xE0, 0x3C, 0xE0, 0x1C, 0xF0, 0x1E,
  0x78, 0x1E, 0x78, 0x3F, 0x3F, 0xFF, 0x1F, 0xFE, 0x0F, 0xF0, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F,
  0x01, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x00, 0xFA, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x20, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x1C, 0x07, 0xFC, 0xE0, 0x3F, 0xFB, 0x81, 0xF0, 0x7E, 0x07,
  0x80, 0xF8, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x00,
  0xF0, 0x70, 0x03, 0xC3, 0xC0, 0x0E, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0,
  0xF0, 0x07, 0x83, 0x80, 0x3E, 0x0E, 0x00, 0xF0, 0x38, 0x07, 0xC0, 0xF0,
  0x1F, 0x03, 0xC0, 0xFC, 0x0F, 0x07, 0xE0, 0x3F, 0xFB, 0x80, 0x7F, 0xDE,
  0x00, 0xFE, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x80, 0x1E, 0x03, 0x00, 0xF0, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x7E, 0x07, 0xBF, 0xE0,
  0xFF, 0xFE, 0x1D, 0x83, 0xC3, 0xE0, 0x38, 0xF8, 0x07, 0x1F, 0x01, 0xE3,
  0xC0, 0x3C, 0x78, 0x07, 0x8E, 0x00, 0xF3, 0xC0, 0x1C, 0x78, 0x03, 0x8F,
  0x00, 0xF1, 0xC0, 0x1E, 0x38, 0x03, 0xCF, 0x00, 0x71, 0xE0, 0x1E, 0x3C,
  0x03, 0xC7, 0x00, 0x78, 0xE0, 0x0E, 0x3C, 0x01, 0xC7, 0x80, 0x78, 0xF0,
  0x0F, 0x00, 0x00, 0x80, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0x00, 0x02, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x01, 0xF0, 0xF0, 0x3C,
  0x0F, 0x07, 0x80, 0xE0, 0xF0, 0x0E, 0x1F, 0x01, 0xE1, 0xE0, 0x1E, 0x3C,
  0x01, 0xE7, 0x80, 0x1C, 0xF0, 0x01, 0xDE, 0x00, 0x3F, 0xE0, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xCF, 0x00, 0x38, 0x78, 0x07, 0x87, 0x80, 0x78,
  0x78, 0x07, 0x83, 0xC0, 0x70, 0x3C, 0x0F, 0x01, 0xC0, 0xF0, 0x1E, 0x0F,
  0x01, 0xE0, 0xF0, 0x0F, 0x00, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x38,
  0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x00, 0x07,
  0x3F, 0x83, 0xF8, 0x1C, 0xFF, 0x8F, 0xF8, 0x3B, 0xFF, 0x3F, 0xF0, 0x7E,
  0x0F, 0xE1, 0xE0, 0xF8, 0x1F, 0x81, 0xE3, 0xE0, 0x3E, 0x03, 0xC7, 0xC0,
  0x78, 0x07, 0x0F, 0x00, 0xF0, 0x0E, 0x1E, 0x01, 0xC0, 0x3C, 0x38, 0x07,
  0x80, 0x78, 0xF0, 0x0F, 0x00, 0xF1, 0xE0, 0x1E, 0x01, 0xC3, 0xC0, 0x38,
  0x03, 0x87, 0x00, 0x70, 0x0F, 0x0E, 0x01, 0xE0, 0x1E, 0x3C, 0x03, 0xC0,
  0x3C, 0x78, 0x07, 0x80, 0x70, 0xF0, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x03,
  0xC7, 0x80, 0x78, 0x07, 0x8F, 0x00, 0xF0, 0x0F, 0x1E, 0x01, 0xE0, 0x1C,
  0x3C, 0x03, 0x80, 0x78, 0x00, 0x00, 0x06, 0x01, 0xE7, 0xF8, 0x3D, 0xFF,
  0x87, 0x7F, 0xF0, 0xFE, 0x1E, 0x1F, 0x03, 0xC7, 0xC0, 0x38, 0xF8, 0x0F,
  0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xE3, 0xC0, 0x3C,
  0x78, 0x07, 0x8E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0x8F, 0x00, 0xF1,
  0xE0, 0x1E, 0x38, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x1E, 0x3C, 0x03, 0xC7,
  0x80, 0x78, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7C, 0x1E, 0x1E,
  0x03, 0xCF, 0x00, 0xF3, 0x80, 0x3D, 0xE0, 0x0F, 0x78, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xEE, 0x00, 0x7B,
  0x80, 0x1E, 0xE0, 0x0F, 0x3C, 0x03, 0xCF, 0x01, 0xE1, 0xE0, 0xF0, 0x7F,
  0xFC, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x01, 0xC7, 0xE0, 0x0E, 0x7F, 0xC0,
  0x3B, 0xFF, 0x80, 0xEC, 0x1E, 0x03, 0xE0, 0x38, 0x1F, 0x80, 0xF0, 0x7C,
  0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1C, 0x00, 0xF0, 0xF0, 0x03,
  0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x38, 0x01, 0xE0, 0xE0, 0x07, 0x07,
  0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC1,
  0xF0, 0x3F, 0xFF, 0x80, 0xF7, 0xFC, 0x03, 0x8F, 0xE0, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x70, 0x7F, 0xCE, 0x0F, 0xFE, 0xE1, 0xF0, 0x7E, 0x1E,
  0x03, 0xE3, 0xC0, 0x3C, 0x3C, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7,
  0x00, 0x3C, 0xF0, 0x03, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x78,
  0xE0, 0x0F, 0x8E, 0x00, 0xF0, 0xE0, 0x1F, 0x0F, 0x01, 0xF0, 0xF0, 0x3F,
  0x0F, 0x07, 0xE0, 0xFF, 0xEE, 0x07, 0xFD, 0xE0, 0x3F, 0x9E, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x3F, 0x0E, 0x7E, 0x0E, 0xFE, 0x0E, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xFE,
  0x07, 0xFF, 0x0F, 0xFF, 0x1E, 0x02, 0x1E, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0xC0, 0x78, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xC0, 0x03, 0x00, 0x70, 0x07,
  0x00, 0xF0, 0x0E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x01, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70,
  0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xF0, 0x7F,
  0x07, 0xF0, 0x1E, 0x00, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8E, 0x00, 0xF3,
  0xC0, 0x1C, 0x78, 0x03, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x38, 0x03, 0xCF,
  0x00, 0x71, 0xE0, 0x0E, 0x3C, 0x03, 0xC7, 0x00, 0x78, 0xE0, 0x0F, 0x3C,
  0x03, 0xC7, 0x80, 0x78, 0xF0, 0x1F, 0x1E, 0x03, 0xE3, 0xC0, 0xF8, 0x78,
  0x3F, 0x0F, 0xFE, 0xE0, 0xFF, 0x9C, 0x0F, 0xC3, 0x80, 0xF0, 0x03, 0xFC,
  0x00, 0xEF, 0x00, 0x79, 0xC0, 0x1C, 0x70, 0x0F, 0x1C, 0x03, 0x87, 0x01,
  0xE1, 0xC0, 0x70, 0x70, 0x3C, 0x1C, 0x0E, 0x07, 0x07, 0x81, 0xE1, 0xC0,
  0x78, 0xF0, 0x1E, 0x38, 0x07, 0x9E, 0x01, 0xE7, 0x00, 0x3B, 0xC0, 0x0E,
  0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xE0, 0x1E, 0x01, 0xFC, 0x03, 0xC0, 0x3B, 0x80, 0xF8, 0x0F, 0x70,
  0x1F, 0x01, 0xEE, 0x07, 0xE0, 0x79, 0xC0, 0xFC, 0x0F, 0x38, 0x3B, 0x81,
  0xC7, 0x07, 0x70, 0x78, 0xE1, 0xEE, 0x0E, 0x1C, 0x39, 0xC3, 0xC3, 0x87,
  0x38, 0x70, 0x71, 0xC7, 0x1E, 0x0E, 0x38, 0xE3, 0xC1, 0xCE, 0x1C, 0x70,
  0x39, 0xC3, 0x9E, 0x07, 0x70, 0x73, 0x80, 0xEE, 0x0E, 0xF0, 0x1D, 0xC0,
  0xDC, 0x03, 0xF0, 0x1B, 0x80, 0x7E, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01,
  0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x7C, 0x0F, 0x01,
  0xE0, 0x3C, 0x0F, 0x00, 0x70, 0x78, 0x01, 0xE1, 0xC0, 0x07, 0x8F, 0x00,
  0x0E, 0x78, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1D, 0xC0,
  0x00, 0xF7, 0x80, 0x07, 0x8E, 0x00, 0x3C, 0x38, 0x00, 0xF0, 0xF0, 0x07,
  0x81, 0xC0, 0x3C, 0x07, 0x81, 0xE0, 0x1E, 0x0F, 0x80, 0x38, 0x00, 0x03,
  0xC0, 0x0F, 0x03, 0xC0, 0x0E, 0x01, 0xC0, 0x1E, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x3C, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x78, 0x01, 0xE0, 0x70, 0x01,
  0xE0, 0xF0, 0x01, 0xE0, 0xE0, 0x01, 0xE1, 0xE0, 0x00, 0xE1, 0xC0, 0x00,
  0xE3, 0xC0, 0x00, 0xE3, 0x80, 0x00, 0xE7, 0x80, 0x00, 0xE7, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x7F,
  0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0xFC, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x80, 0x0F, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0xF0, 0x01,
  0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x3E,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x7F, 0xF0, 0x1F,
  0xFF, 0xBF, 0x0F, 0xFF, 0x80, 0x7F, 0xA0, 0x01, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Italic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 10, 32, 11, 1, -31 },
  { 41, 12, 11, 16, 5, -31 },
  { 58, 24, 31, 24, 1, -31 },
  { 151, 20, 36, 21, 1, -33 },
  { 241, 27, 31, 31, 3, -31 },
  { 346, 23, 31, 25, 1, -31 },
  { 436, 5, 11, 9, 5, -31 },
  { 443, 14, 38, 12, 1, -31 },
  { 510, 13, 38, 12, -3, -31 },
  { 572, 18, 18, 21, 4, -33 },
  { 613, 18, 20, 22, 3, -25 },
  { 658, 8, 11, 10, -2, -5 },
  { 669, 10, 3, 13, 1, -13 },
  { 673, 5, 6, 10, 1, -5 },
  { 677, 20, 31, 15, -2, -31 },
  { 755, 19, 31, 21, 2, -31 },
  { 829, 12, 31, 21, 6, -31 },
  { 876, 21, 31, 21, 0, -31 },
  { 958, 21, 31, 21, 0, -31 },
  { 1040, 21, 31, 21, 0, -31 },
  { 1122, 20, 31, 21, 1, -31 },
  { 1200, 19, 31, 21, 2, -31 },
  { 1274, 19, 31, 21, 3, -31 },
  { 1348, 20, 31, 21, 1, -31 },
  { 1426, 19, 31, 21, 1, -31 },
  { 1500, 8, 24, 10, 1, -23 },
  { 1524, 11, 29, 10, -2, -23 },
  { 1564, 18, 21, 22, 3, -26 },
  { 1612, 18, 12, 22, 3, -21 },
  { 1639, 18, 21, 22, 3, -26 },
  { 1687, 16, 32, 16, 2, -31 },
  { 1751, 29, 35, 32, 2, -31 },
  { 1878, 22, 31, 22, -3, -31 },
  { 1964, 22, 31, 23, 1, -31 },
  { 2050, 21, 31, 22, 3, -31 },
  { 2132, 23, 31, 26, 1, -31 },
  { 2222, 21, 31, 20, 1, -31 },
  { 2304, 21, 31, 18, 1, -31 },
  { 2386, 23, 31, 26, 3, -31 },
  { 2476, 26, 31, 26, 1, -31 },
  { 2577, 17, 31, 13, -1, -31 },
  { 2643, 18, 39, 11, -7, -31 },
  { 2731, 24, 31, 22, 1, -31 },
  { 2824, 15, 31, 18, 1, -31 },
  { 2883, 33, 31, 33, 1, -31 },
  { 3011, 27, 31, 27, 1, -31 },
  { 3116, 24, 31, 27, 2, -31 },
  { 3209, 21, 31, 22, 1, -31 },
  { 3291, 24, 38, 27, 2, -31 },
  { 3405, 21, 31, 22, 1, -31 },
  { 3487, 21, 31, 20, 0, -31 },
  { 3569, 19, 31, 19, 4, -31 },
  { 3643, 24, 31, 26, 3, -31 },
  { 3736, 21, 31, 21, 4, -31 },
  { 3818, 33, 31, 34, 4, -31 },
  { 3946, 26, 31, 20, -2, -31 },
  { 4047, 19, 31, 19, 4, -31 },
  { 4121, 23, 31, 20, -1, -31 },
  { 4211, 17, 38, 12, -1, -31 },
  { 4292, 7, 31, 15, 5, -31 },
  { 4320, 16, 38, 12, -3, -31 },
  { 4396, 20, 19, 22, 1, -31 },
  { 4444, 16, 3, 16, -4, 4 },
  { 4450, 7, 7, 11, 6, -33 },
  { 4457, 20, 23, 22, 2, -23 },
  { 4515, 20, 33, 22, 1, -33 },
  { 4598, 16, 23, 17, 2, -23 },
  { 4644, 22, 33, 22, 2, -33 },
  { 4735, 17, 23, 20, 2, -23 },
  { 4784, 23, 43, 12, -5, -33 },
  { 4908, 22, 33, 22, 0, -23 },
  { 4999, 19, 33, 22, 1, -33 },
  { 5078, 10, 32, 10, 1, -32 },
  { 5118, 16, 42, 10, -5, -32 },
  { 5202, 20, 33, 19, 1, -33 },
  { 5285, 10, 33, 10, 1, -33 },
  { 5327, 31, 23, 34, 1, -23 },
  { 5417, 19, 24, 22, 1, -24 },
  { 5474, 18, 23, 22, 2, -23 },
  { 5526, 22, 33, 22, -1, -23 },
  { 5617, 20, 33, 22, 2, -23 },
  { 5700, 16, 23, 15, 1, -23 },
  { 5746, 16, 23, 17, 0, -23 },
  { 5792, 12, 28, 13, 2, -28 },
  { 5834, 19, 23, 22, 2, -23 },
  { 5889, 18, 23, 18, 2, -23 },
  { 5941, 27, 23, 28, 3, -23 },
  { 6019, 22, 23, 19, -2, -23 },
  { 6083, 24, 33, 18, -4, -23 },
  { 6182, 18, 23, 17, -1, -23 },
  { 6234, 16, 38, 15, 1, -31 },
  { 6310, 3, 43, 21, 9, -33 },
  { 6327, 16, 38, 15, -2, -31 },
  { 6403, 18, 6, 22, 3, -18 },
};

const GFXfont NotoSans_SemiCondensed_Italic43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic43pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC43PT7B_H_
