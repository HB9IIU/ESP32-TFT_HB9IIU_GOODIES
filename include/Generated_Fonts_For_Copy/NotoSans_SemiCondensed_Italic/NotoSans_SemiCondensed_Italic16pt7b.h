#ifndef _NOTOSANS_SEMICONDENSED_ITALIC16PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x32, 0x22, 0x64, 0x04, 0xC0, 0xD9, 0xBA, 0x09, 0x84, 0x82,
  0x4F, 0xF1, 0x20, 0x90, 0x91, 0xFE, 0x24, 0x36, 0x12, 0x00, 0x04, 0x1F,
  0x3A, 0x28, 0x28, 0x38, 0x1C, 0x16, 0x16, 0x94, 0xFC, 0x10, 0x20, 0x30,
  0x1E, 0x24, 0x92, 0x68, 0x92, 0x25, 0x7F, 0xA5, 0x29, 0x12, 0x4D, 0x92,
  0x69, 0x0E, 0x0C, 0x0F, 0x04, 0x86, 0x41, 0x60, 0xC0, 0xE0, 0x9B, 0xC5,
  0x63, 0x31, 0x8F, 0x60, 0xEA, 0x19, 0x18, 0x8C, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x20, 0x10, 0xC2, 0x10, 0x8C, 0x62, 0x11, 0x88, 0xC4, 0x40, 0x12,
  0x4E, 0x4F, 0x52, 0x60, 0x10, 0x20, 0x47, 0xF1, 0x02, 0x04, 0x00, 0x2D,
  0x60, 0xF0, 0x70, 0x03, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20,
  0x40, 0xC0, 0x18, 0x79, 0x9A, 0x3C, 0x70, 0xE1, 0x42, 0x85, 0x1A, 0x63,
  0x80, 0x3B, 0xA4, 0x63, 0x10, 0x84, 0x62, 0x10, 0x0C, 0x3E, 0x23, 0x03,
  0x02, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0xFC, 0x0C, 0x3E, 0x03, 0x03,
  0x02, 0x0C, 0x3C, 0x06, 0x06, 0x06, 0x8C, 0xF8, 0x07, 0x06, 0x0A, 0x12,
  0x36, 0x24, 0x44, 0xFF, 0x0C, 0x0C, 0x08, 0x1F, 0x30, 0x20, 0x20, 0x7C,
  0x06, 0x06, 0x06, 0x06, 0x8C, 0xF8, 0x06, 0x3C, 0x82, 0x04, 0x1F, 0xB1,
  0x42, 0x85, 0x1B, 0x23, 0x80, 0x7E, 0x0C, 0x10, 0x40, 0x82, 0x0C, 0x10,
  0x60, 0x83, 0x00, 0x0C, 0x1F, 0x33, 0x23, 0x32, 0x1C, 0x3C, 0x66, 0x42,
  0xC2, 0x46, 0x7C, 0x0C, 0x3E, 0x22, 0x63, 0x63, 0x62, 0x66, 0x3A, 0x06,
  0x04, 0x08, 0xF0, 0x24, 0x00, 0x06, 0xC0, 0x11, 0x00, 0x00, 0x02, 0x64,
  0xC0, 0x02, 0x0C, 0x63, 0x0C, 0x0E, 0x03, 0x01, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x81, 0x80, 0xC0, 0x60, 0x63, 0x18, 0x40, 0x33, 0xE0, 0xC2, 0x08,
  0x42, 0x10, 0x40, 0x0C, 0x30, 0x1F, 0x84, 0x09, 0x01, 0xA7, 0x99, 0x13,
  0x24, 0xEC, 0x95, 0xB2, 0x9F, 0x90, 0x03, 0x00, 0x3F, 0x00, 0x06, 0x06,
  0x0F, 0x0B, 0x1B, 0x13, 0x3F, 0x21, 0x61, 0x41, 0xC1, 0x1F, 0x18, 0x8C,
  0x64, 0x23, 0xE1, 0xF1, 0x8C, 0xC6, 0x43, 0x23, 0x3F, 0x00, 0x06, 0x1F,
  0x20, 0x60, 0x40, 0xC0, 0xC0, 0x80, 0x80, 0xC0, 0xC4, 0x7C, 0x1F, 0x18,
  0xCC, 0x64, 0x12, 0x09, 0x0D, 0x86, 0xC2, 0x43, 0x23, 0x3E, 0x00, 0x1F,
  0x30, 0x30, 0x20, 0x3E, 0x3E, 0x60, 0x60, 0x40, 0x40, 0xFC, 0x1F, 0x30,
  0x30, 0x20, 0x20, 0x3E, 0x60, 0x60, 0x40, 0x40, 0xC0, 0x06, 0x0F, 0xCC,
  0x0C, 0x04, 0x06, 0x03, 0x1D, 0x16, 0x83, 0x61, 0x30, 0x8F, 0xC0, 0x10,
  0xCC, 0x23, 0x08, 0x82, 0x3F, 0x8F, 0xE6, 0x11, 0x84, 0x41, 0x10, 0xCC,
  0x30, 0x1E, 0x10, 0x20, 0xC1, 0x02, 0x04, 0x18, 0x30, 0x43, 0xE0, 0x04,
  0x30, 0xC2, 0x08, 0x21, 0x86, 0x10, 0x41, 0x0C, 0x23, 0x80, 0x11, 0x99,
  0x8D, 0x85, 0x82, 0x81, 0xC1, 0xB0, 0xC8, 0x44, 0x23, 0x30, 0x80, 0x10,
  0xC3, 0x08, 0x20, 0x86, 0x18, 0x41, 0x0F, 0xC0, 0x18, 0x33, 0x87, 0x28,
  0x52, 0x8F, 0x28, 0xA2, 0x9A, 0x69, 0x24, 0xB6, 0x4E, 0x64, 0xE4, 0xC4,
  0x40, 0x18, 0x4E, 0x12, 0x8C, 0xB3, 0x2C, 0x89, 0x26, 0x49, 0x1E, 0x43,
  0x10, 0xCC, 0x30, 0x0C, 0x1F, 0x88, 0x6C, 0x34, 0x1E, 0x0F, 0x07, 0x02,
  0x81, 0x61, 0xB1, 0x8F, 0x80, 0x1F, 0x31, 0x31, 0x21, 0x23, 0x3E, 0x70,
  0x60, 0x40, 0x40, 0xC0, 0x0C, 0x1F, 0x88, 0x6C, 0x34, 0x1E, 0x0F, 0x07,
  0x02, 0x81, 0x61, 0xB1, 0x8F, 0x80, 0x80, 0x60, 0x18, 0x1F, 0x31, 0x31,
  0x21, 0x23, 0x3E, 0x6C, 0x64, 0x44, 0x46, 0xC6, 0x0C, 0x3F, 0x20, 0x60,
  0x20, 0x30, 0x18, 0x0C, 0x04, 0x04, 0x8C, 0xF8, 0xFE, 0x20, 0x40, 0x83,
  0x04, 0x08, 0x10, 0x60, 0xC1, 0x00, 0x21, 0xB0, 0x90, 0x48, 0x24, 0x36,
  0x1B, 0x09, 0x04, 0x86, 0x62, 0x1E, 0x00, 0xC3, 0x42, 0x46, 0x44, 0x44,
  0x48, 0x48, 0x50, 0x50, 0x60, 0x60, 0x84, 0x38, 0xC2, 0x8C, 0x69, 0xC4,
  0x94, 0xCB, 0x68, 0xA6, 0x8A, 0x70, 0xC7, 0x0C, 0x70, 0x86, 0x00, 0x10,
  0xC6, 0x40, 0xB0, 0x28, 0x0C, 0x03, 0x01, 0xC0, 0x58, 0x26, 0x18, 0x8C,
  0x30, 0xC3, 0x44, 0x4C, 0x68, 0x78, 0x30, 0x20, 0x20, 0x60, 0x60, 0x40,
  0x3F, 0x02, 0x06, 0x0C, 0x08, 0x18, 0x30, 0x20, 0x40, 0xC0, 0xFC, 0x1C,
  0xC2, 0x08, 0x21, 0x86, 0x10, 0x41, 0x0C, 0x20, 0xE3, 0x80, 0x92, 0x4C,
  0x92, 0x49, 0x80, 0x1C, 0x20, 0x82, 0x08, 0x61, 0x04, 0x10, 0x43, 0x08,
  0xE3, 0x80, 0x18, 0x1C, 0x34, 0x24, 0x62, 0xC3, 0xFC, 0xCC, 0x3A, 0xD5,
  0x1E, 0x28, 0x50, 0xA3, 0x4E, 0xE8, 0x10, 0x30, 0x30, 0x26, 0x3A, 0x33,
  0x63, 0x63, 0x42, 0x42, 0x64, 0xFC, 0x1D, 0xA4, 0x30, 0x82, 0x08, 0x20,
  0xF0, 0x03, 0x02, 0x02, 0x3A, 0x6A, 0x46, 0xC4, 0x84, 0x84, 0x8C, 0x9C,
  0xE8, 0x19, 0xBC, 0x63, 0xFA, 0x08, 0x22, 0xF8, 0x07, 0x82, 0x01, 0x01,
  0xC1, 0xE0, 0x40, 0x20, 0x30, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01, 0x00,
  0x81, 0x80, 0x1D, 0x35, 0x23, 0x62, 0x42, 0x42, 0x46, 0x4E, 0x74, 0x04,
  0x0C, 0x98, 0x70, 0x10, 0x10, 0x30, 0x26, 0x3A, 0x23, 0x62, 0x62, 0x42,
  0x46, 0x46, 0xC4, 0x13, 0x02, 0x22, 0x66, 0x44, 0x4C, 0x04, 0x30, 0x02,
  0x08, 0x21, 0x86, 0x10, 0x41, 0x0C, 0x30, 0x86, 0x30, 0x10, 0x30, 0x30,
  0x23, 0x26, 0x2C, 0x78, 0x58, 0x68, 0x48, 0x4C, 0xC4, 0x11, 0x32, 0x22,
  0x66, 0x44, 0x4C, 0x26, 0x63, 0xEB, 0x23, 0x36, 0x23, 0x62, 0x24, 0x62,
  0x46, 0x24, 0x46, 0xC4, 0x60, 0x26, 0x3E, 0x33, 0x62, 0x62, 0x42, 0x46,
  0x46, 0xC4, 0x19, 0xBC, 0x61, 0x86, 0x18, 0xE2, 0x70, 0x13, 0x0E, 0x86,
  0x66, 0x33, 0x19, 0x08, 0x84, 0x64, 0x7E, 0x30, 0x10, 0x08, 0x0C, 0x00,
  0x3A, 0xD5, 0x1E, 0x28, 0x50, 0xA3, 0x4E, 0xE8, 0x10, 0x20, 0xC1, 0x00,
  0x2C, 0xF3, 0x18, 0x61, 0x04, 0x10, 0xC0, 0x39, 0x94, 0x18, 0x30, 0x60,
  0xA2, 0xF0, 0x22, 0x7F, 0x4C, 0xC8, 0x88, 0xE0, 0x42, 0x8D, 0x1E, 0x2C,
  0x51, 0xA3, 0x4C, 0xE8, 0x86, 0x18, 0xA2, 0x92, 0x4E, 0x38, 0xC0, 0x8C,
  0x63, 0x39, 0x4A, 0x56, 0x95, 0x29, 0x4A, 0x73, 0x18, 0xC6, 0x00, 0x31,
  0x13, 0x16, 0x1C, 0x08, 0x18, 0x34, 0x64, 0xC6, 0x10, 0xC4, 0x21, 0x10,
  0x44, 0x1A, 0x06, 0x81, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x00, 0xC0, 0xE0,
  0x00, 0x3D, 0x10, 0x86, 0x30, 0x84, 0x30, 0xF8, 0x0C, 0x61, 0x04, 0x10,
  0x8C, 0x08, 0x20, 0x86, 0x10, 0x70, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0x18,
  0x20, 0x82, 0x08, 0x60, 0x46, 0x10, 0xC3, 0x08, 0xE2, 0x00, 0x63, 0x7C,
};

const GFXglyph NotoSans_SemiCondensed_Italic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 11, 4, 0, -11 },
  { 7, 4, 4, 6, 2, -11 },
  { 9, 9, 11, 9, 0, -11 },
  { 22, 8, 13, 8, 0, -12 },
  { 35, 10, 12, 12, 1, -12 },
  { 50, 9, 12, 9, 0, -12 },
  { 64, 2, 4, 3, 2, -11 },
  { 65, 5, 14, 4, 1, -11 },
  { 74, 5, 14, 4, -1, -11 },
  { 83, 6, 6, 8, 2, -12 },
  { 88, 7, 7, 8, 1, -9 },
  { 95, 3, 4, 4, -1, -2 },
  { 97, 4, 1, 5, 0, -5 },
  { 98, 2, 2, 4, 0, -2 },
  { 99, 8, 11, 6, -1, -11 },
  { 110, 7, 12, 8, 1, -12 },
  { 121, 5, 11, 8, 2, -11 },
  { 128, 8, 12, 8, 0, -12 },
  { 140, 8, 12, 8, 0, -12 },
  { 152, 8, 11, 8, 0, -11 },
  { 163, 8, 11, 8, 0, -11 },
  { 174, 7, 12, 8, 1, -12 },
  { 185, 7, 11, 8, 1, -11 },
  { 195, 8, 12, 8, 0, -12 },
  { 207, 8, 12, 8, 0, -12 },
  { 219, 3, 9, 4, 0, -9 },
  { 223, 4, 11, 4, -1, -9 },
  { 229, 7, 8, 8, 1, -10 },
  { 236, 7, 5, 8, 1, -8 },
  { 241, 7, 8, 8, 1, -10 },
  { 248, 6, 12, 6, 1, -12 },
  { 257, 11, 12, 12, 1, -11 },
  { 274, 8, 11, 8, -1, -11 },
  { 285, 9, 11, 9, 0, -11 },
  { 298, 8, 12, 8, 1, -12 },
  { 310, 9, 11, 9, 0, -11 },
  { 323, 8, 11, 7, 0, -11 },
  { 334, 8, 11, 7, 0, -11 },
  { 345, 9, 12, 10, 1, -12 },
  { 359, 10, 11, 10, 0, -11 },
  { 373, 7, 11, 5, -1, -11 },
  { 383, 6, 14, 4, -2, -11 },
  { 394, 9, 11, 8, 0, -11 },
  { 407, 6, 11, 7, 0, -11 },
  { 416, 12, 11, 12, 0, -11 },
  { 433, 10, 11, 10, 0, -11 },
  { 447, 9, 12, 10, 1, -12 },
  { 461, 8, 11, 8, 0, -11 },
  { 472, 9, 15, 10, 1, -12 },
  { 489, 8, 11, 8, 0, -11 },
  { 500, 8, 12, 7, 0, -12 },
  { 512, 7, 11, 7, 1, -11 },
  { 522, 9, 11, 10, 1, -11 },
  { 535, 8, 11, 8, 1, -11 },
  { 546, 12, 11, 13, 2, -11 },
  { 563, 10, 11, 8, -1, -11 },
  { 577, 8, 11, 7, 1, -11 },
  { 588, 8, 11, 7, 0, -11 },
  { 599, 6, 14, 5, 0, -11 },
  { 610, 3, 11, 6, 2, -11 },
  { 615, 6, 14, 5, -1, -11 },
  { 626, 8, 6, 8, 0, -11 },
  { 632, 6, 1, 6, -1, 1 },
  { 633, 3, 2, 4, 2, -12 },
  { 634, 7, 9, 8, 1, -9 },
  { 642, 8, 12, 8, 0, -12 },
  { 654, 6, 9, 6, 1, -9 },
  { 661, 8, 12, 8, 1, -12 },
  { 673, 6, 9, 7, 1, -9 },
  { 680, 9, 16, 5, -2, -12 },
  { 698, 8, 13, 8, 0, -9 },
  { 711, 8, 12, 8, 0, -12 },
  { 723, 4, 12, 4, 0, -12 },
  { 729, 6, 16, 4, -2, -12 },
  { 741, 8, 12, 7, 0, -12 },
  { 753, 4, 12, 4, 0, -12 },
  { 759, 12, 9, 12, 0, -9 },
  { 773, 8, 9, 8, 0, -9 },
  { 782, 6, 9, 8, 1, -9 },
  { 789, 9, 13, 8, -1, -9 },
  { 804, 7, 13, 8, 1, -9 },
  { 816, 6, 9, 6, 0, -9 },
  { 823, 6, 9, 6, 0, -9 },
  { 830, 4, 11, 5, 1, -11 },
  { 836, 7, 9, 8, 1, -9 },
  { 844, 6, 9, 7, 1, -9 },
  { 851, 10, 9, 11, 1, -9 },
  { 863, 8, 9, 7, -1, -9 },
  { 872, 10, 13, 7, -2, -9 },
  { 889, 6, 9, 6, 0, -9 },
  { 896, 6, 14, 5, 0, -11 },
  { 907, 2, 16, 8, 3, -12 },
  { 911, 6, 14, 5, -1, -11 },
  { 922, 7, 2, 8, 1, -7 },
};

const GFXfont NotoSans_SemiCondensed_Italic16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic16pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC16PT7B_H_
