#ifndef _NOTOSANS_SEMICONDENSED_ITALIC18PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0x84, 0x63, 0x10, 0x84, 0x60, 0x01, 0x8C, 0x00, 0x5E, 0xF7,
  0x29, 0x00, 0x04, 0xC1, 0x20, 0x88, 0x26, 0x7F, 0xC6, 0x41, 0x30, 0x48,
  0xFF, 0x88, 0x82, 0x40, 0x90, 0x44, 0x00, 0x02, 0x02, 0x07, 0xE6, 0xA2,
  0x41, 0x20, 0xE0, 0x38, 0x0E, 0x05, 0x82, 0x92, 0xCF, 0xC0, 0x80, 0x40,
  0x38, 0x6D, 0x19, 0x22, 0x64, 0x8C, 0x91, 0x15, 0xF5, 0xEB, 0x29, 0x09,
  0x23, 0x64, 0x48, 0x91, 0xA6, 0x1C, 0x0F, 0x06, 0x41, 0x10, 0x44, 0x13,
  0x07, 0x01, 0x81, 0xB3, 0x46, 0xB0, 0xEC, 0x31, 0x1C, 0x7D, 0x80, 0x7E,
  0x80, 0x08, 0x8C, 0xC4, 0x23, 0x10, 0x84, 0x21, 0x08, 0x42, 0x08, 0x10,
  0xC2, 0x10, 0x84, 0x21, 0x08, 0xC4, 0x62, 0x31, 0x10, 0x18, 0x32, 0x43,
  0xF3, 0x2F, 0x32, 0x06, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x18, 0x18, 0x18,
  0x18, 0x36, 0x4C, 0x7F, 0xC0, 0x70, 0x01, 0x81, 0x80, 0x80, 0xC0, 0x40,
  0x60, 0x20, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x0C, 0x00, 0x1E, 0x36, 0x63,
  0x63, 0x43, 0xC3, 0xC2, 0x82, 0x86, 0x86, 0x84, 0xCC, 0x78, 0x09, 0xFE,
  0xB1, 0x08, 0xC6, 0x31, 0x08, 0xC6, 0x00, 0x1F, 0x19, 0x80, 0x60, 0x30,
  0x10, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x0F, 0xE0, 0x1F, 0x19,
  0x80, 0x60, 0x30, 0x10, 0x30, 0x70, 0x0C, 0x02, 0x01, 0x80, 0x90, 0xCF,
  0xC0, 0x01, 0x81, 0x81, 0x41, 0xE0, 0xB0, 0x90, 0x88, 0xC4, 0xC6, 0x7F,
  0x81, 0x00, 0x80, 0xC0, 0x1F, 0x8F, 0x84, 0x06, 0x03, 0x01, 0xE0, 0x98,
  0x06, 0x03, 0x01, 0x80, 0x90, 0xCF, 0xC0, 0x0F, 0x19, 0x30, 0x60, 0x40,
  0xDC, 0xE6, 0xC6, 0x82, 0x86, 0x86, 0xCC, 0x78, 0x7F, 0x7F, 0x02, 0x06,
  0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x60, 0xC0, 0x0F, 0x0C, 0xCC,
  0x66, 0x33, 0x10, 0xF0, 0x70, 0x6C, 0x43, 0x21, 0xB0, 0xCC, 0xC3, 0xC0,
  0x1C, 0x76, 0x42, 0x43, 0xC2, 0xC2, 0x46, 0x7E, 0x06, 0x04, 0x0C, 0x98,
  0xF0, 0x33, 0x20, 0x00, 0x00, 0xCC, 0x18, 0xC4, 0x00, 0x00, 0x00, 0x33,
  0x11, 0x80, 0x01, 0x07, 0x1C, 0x30, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x0E, 0x38, 0xE0,
  0x80, 0x79, 0x30, 0x41, 0x0C, 0x63, 0x18, 0x40, 0x00, 0x30, 0xC0, 0x07,
  0xC1, 0xC6, 0x30, 0x36, 0x01, 0x47, 0x9C, 0x99, 0x99, 0x99, 0x11, 0x91,
  0x29, 0x32, 0x9D, 0xC8, 0x00, 0x40, 0x07, 0xF0, 0x0C, 0x00, 0x03, 0x01,
  0x81, 0xC0, 0xA0, 0xD0, 0x48, 0x66, 0x23, 0x3F, 0x90, 0xD8, 0x68, 0x3C,
  0x18, 0x1F, 0x04, 0xE1, 0x0C, 0xC3, 0x30, 0x8C, 0xE3, 0xE0, 0x84, 0x61,
  0x98, 0x66, 0x11, 0x1C, 0xFE, 0x00, 0x0F, 0x8C, 0x4C, 0x0C, 0x06, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x0C, 0x43, 0xE0, 0x1F, 0x07, 0xE1,
  0x0C, 0xC3, 0x30, 0x4C, 0x12, 0x0C, 0x83, 0x60, 0xD8, 0x66, 0x31, 0x1C,
  0xFC, 0x00, 0x1F, 0x8F, 0xC4, 0x06, 0x03, 0x01, 0x88, 0xF8, 0x40, 0x60,
  0x30, 0x18, 0x08, 0x4F, 0xC0, 0x1F, 0x8F, 0xC4, 0x06, 0x03, 0x01, 0x80,
  0xF8, 0x7C, 0x60, 0x30, 0x18, 0x08, 0x0C, 0x00, 0x0F, 0x86, 0x33, 0x01,
  0x80, 0x60, 0x30, 0x0C, 0x7B, 0x1E, 0xC1, 0xB0, 0x4C, 0x11, 0x8C, 0x3F,
  0x00, 0x18, 0x22, 0x0C, 0x41, 0x98, 0x23, 0x04, 0x61, 0x8F, 0xF1, 0x06,
  0x60, 0x8C, 0x11, 0x86, 0x20, 0xCC, 0x18, 0x1F, 0x0C, 0x0C, 0x08, 0x08,
  0x18, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0xF8, 0x03, 0x02, 0x02, 0x06,
  0x06, 0x06, 0x04, 0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0xF0,
  0x18, 0x62, 0x10, 0x46, 0x19, 0x83, 0x60, 0x78, 0x0F, 0x01, 0xA0, 0x66,
  0x0C, 0xC1, 0x88, 0x21, 0x8C, 0x30, 0x18, 0x20, 0x41, 0x83, 0x06, 0x08,
  0x10, 0x60, 0xC1, 0x82, 0x1F, 0xC0, 0x18, 0x0C, 0x60, 0x71, 0xC3, 0xCF,
  0x0A, 0x3C, 0x68, 0xB1, 0x62, 0x4D, 0x89, 0x26, 0x65, 0x91, 0x94, 0x44,
  0x73, 0x11, 0x8C, 0xC6, 0x20, 0x18, 0x31, 0x82, 0x1C, 0x23, 0xC6, 0x34,
  0x63, 0x46, 0x26, 0x42, 0x24, 0x62, 0xC6, 0x3C, 0x43, 0x84, 0x18, 0xC1,
  0x80, 0x0F, 0x06, 0x63, 0x0D, 0x83, 0x40, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xB0, 0x6C, 0x11, 0x9C, 0x3E, 0x00, 0x1F, 0x0F, 0xC4, 0x26, 0x13, 0x09,
  0x8C, 0x9C, 0x7C, 0x60, 0x30, 0x18, 0x08, 0x0C, 0x00, 0x0F, 0x06, 0x63,
  0x0D, 0x83, 0x40, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xB0, 0x6C, 0x11, 0x9C,
  0x3E, 0x03, 0x00, 0x60, 0x0C, 0x1F, 0x0F, 0xC4, 0x26, 0x13, 0x09, 0x8C,
  0xFC, 0x78, 0x66, 0x33, 0x18, 0x88, 0x6C, 0x30, 0x1F, 0x9C, 0x8C, 0x04,
  0x03, 0x01, 0x80, 0x70, 0x0C, 0x06, 0x01, 0x01, 0x91, 0xCF, 0xC0, 0xFF,
  0xFC, 0xC1, 0x83, 0x04, 0x08, 0x30, 0x60, 0x81, 0x06, 0x0C, 0x00, 0x30,
  0x48, 0x32, 0x0D, 0x82, 0x60, 0x90, 0x64, 0x1B, 0x06, 0xC1, 0x30, 0x4C,
  0x33, 0x18, 0x7C, 0x00, 0x81, 0xC1, 0xA0, 0x90, 0xC8, 0x44, 0x63, 0x21,
  0xB0, 0xD0, 0x78, 0x38, 0x1C, 0x0C, 0x00, 0x82, 0x0E, 0x18, 0x68, 0x61,
  0xA3, 0xC4, 0x8B, 0x32, 0x2C, 0x89, 0xB6, 0x24, 0xD0, 0xB3, 0xC2, 0x8F,
  0x0E, 0x38, 0x30, 0xE0, 0xC3, 0x00, 0x18, 0x63, 0x18, 0x22, 0x04, 0xC0,
  0xF0, 0x0C, 0x01, 0x80, 0x70, 0x1A, 0x06, 0x40, 0x8C, 0x31, 0x8C, 0x10,
  0x83, 0x86, 0xC4, 0xCC, 0xD8, 0x50, 0x70, 0x60, 0x60, 0x40, 0x40, 0x40,
  0xC0, 0x3F, 0x9F, 0xC0, 0xC0, 0x40, 0x60, 0x60, 0x20, 0x30, 0x30, 0x30,
  0x18, 0x18, 0x0F, 0xE0, 0x1E, 0x20, 0x41, 0x83, 0x04, 0x08, 0x10, 0x60,
  0x81, 0x02, 0x0C, 0x18, 0x20, 0x70, 0x93, 0x64, 0x92, 0x4D, 0xB2, 0x1E,
  0x08, 0x10, 0x60, 0xC1, 0x02, 0x04, 0x18, 0x30, 0x40, 0x83, 0x06, 0x08,
  0x70, 0x0C, 0x06, 0x05, 0x02, 0xC2, 0x21, 0x19, 0x85, 0x83, 0xFE, 0xB4,
  0x19, 0x37, 0x63, 0xC2, 0xC2, 0x86, 0x86, 0x86, 0xCC, 0xF4, 0x18, 0x08,
  0x04, 0x02, 0x03, 0x61, 0xF8, 0xC6, 0x43, 0x61, 0xB0, 0x98, 0x4C, 0x66,
  0x66, 0xE0, 0x1E, 0x69, 0x86, 0x0C, 0x10, 0x20, 0x40, 0xC8, 0xF0, 0x01,
  0x80, 0xC0, 0x40, 0x21, 0x93, 0xB9, 0x8D, 0x84, 0xC2, 0x43, 0x21, 0x91,
  0xCC, 0xC7, 0xA0, 0x1C, 0x6D, 0x1E, 0x3D, 0xDE, 0x20, 0x40, 0xC4, 0xF0,
  0x03, 0x83, 0xC1, 0x80, 0x80, 0xF0, 0xF8, 0x30, 0x10, 0x08, 0x0C, 0x06,
  0x03, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x70, 0x00, 0x0C, 0x8D, 0xCC,
  0x6C, 0x26, 0x12, 0x19, 0x0C, 0x8E, 0x66, 0x3D, 0x01, 0x80, 0xC8, 0xC7,
  0xC0, 0x18, 0x08, 0x04, 0x02, 0x03, 0x71, 0xF8, 0xC6, 0x42, 0x61, 0x31,
  0x98, 0xC8, 0x64, 0x26, 0x30, 0x18, 0x80, 0x63, 0x10, 0x8C, 0x63, 0x10,
  0x8C, 0x00, 0x06, 0x08, 0x00, 0x60, 0xC1, 0x02, 0x0C, 0x18, 0x30, 0x40,
  0x83, 0x06, 0x0C, 0x10, 0xE0, 0x18, 0x08, 0x04, 0x02, 0x03, 0x19, 0x98,
  0x98, 0x58, 0x78, 0x3C, 0x1B, 0x09, 0x84, 0x46, 0x30, 0x18, 0x84, 0x23,
  0x18, 0x84, 0x63, 0x18, 0x84, 0x60, 0x36, 0x31, 0x7B, 0xCC, 0x62, 0x42,
  0x16, 0x31, 0xB1, 0x8D, 0x8C, 0x48, 0x42, 0x42, 0x16, 0x31, 0x80, 0x37,
  0x17, 0x8C, 0x64, 0x26, 0x13, 0x19, 0x8C, 0x86, 0x42, 0x63, 0x00, 0x1C,
  0xFD, 0x0E, 0x1C, 0x30, 0x61, 0xC3, 0xCC, 0xF0, 0x1B, 0x85, 0x61, 0x8C,
  0x43, 0x30, 0xCC, 0x23, 0x08, 0xC6, 0x33, 0x1B, 0x86, 0x01, 0x80, 0x40,
  0x30, 0x00, 0x19, 0x37, 0x63, 0xC2, 0xC2, 0x86, 0x86, 0x8E, 0xCC, 0xF4,
  0x0C, 0x0C, 0x08, 0x08, 0x36, 0x5C, 0xC1, 0x06, 0x0C, 0x18, 0x20, 0x41,
  0x80, 0x1C, 0x6D, 0x83, 0x03, 0x03, 0x03, 0x06, 0x8D, 0xF0, 0x21, 0x1F,
  0xF4, 0x23, 0x18, 0xC4, 0x21, 0xC0, 0x63, 0x63, 0x43, 0x42, 0xC2, 0xC6,
  0x86, 0x84, 0xCC, 0xF4, 0x83, 0x8F, 0x16, 0x6C, 0x9B, 0x34, 0x78, 0x60,
  0xC0, 0xC6, 0x3C, 0xE2, 0xCE, 0x6C, 0xE4, 0xD6, 0xCD, 0x68, 0xF7, 0x8E,
  0x70, 0xE3, 0x0C, 0x30, 0x30, 0x88, 0x86, 0xC1, 0xC0, 0xC0, 0x60, 0x50,
  0x6C, 0x66, 0x61, 0x00, 0x10, 0x46, 0x31, 0x88, 0x66, 0x19, 0x02, 0xC0,
  0xA0, 0x38, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x10, 0x3C, 0x00, 0x3E, 0x7C,
  0x30, 0x41, 0x86, 0x08, 0x20, 0xC1, 0xF0, 0x06, 0x18, 0x20, 0xC1, 0x82,
  0x04, 0x30, 0xE0, 0x40, 0x81, 0x06, 0x0C, 0x18, 0x18, 0xFF, 0xFF, 0xC0,
  0x18, 0x18, 0x10, 0x60, 0xC1, 0x02, 0x07, 0x0E, 0x30, 0x40, 0x83, 0x06,
  0x18, 0x60, 0x21, 0xFF, 0x8E,
};

const GFXglyph NotoSans_SemiCondensed_Italic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 13, 5, 0, -13 },
  { 10, 5, 5, 7, 2, -13 },
  { 14, 10, 13, 10, 0, -13 },
  { 31, 9, 15, 9, 0, -14 },
  { 48, 11, 13, 13, 1, -13 },
  { 66, 10, 13, 11, 0, -13 },
  { 83, 2, 5, 4, 2, -13 },
  { 85, 5, 16, 5, 1, -13 },
  { 95, 5, 16, 5, -1, -13 },
  { 105, 7, 8, 9, 2, -14 },
  { 112, 8, 9, 9, 1, -11 },
  { 121, 4, 4, 4, -1, -2 },
  { 123, 5, 2, 5, 0, -6 },
  { 125, 2, 2, 4, 0, -2 },
  { 126, 9, 13, 6, -1, -13 },
  { 141, 8, 13, 9, 1, -13 },
  { 154, 5, 13, 9, 2, -13 },
  { 163, 9, 13, 9, 0, -13 },
  { 178, 9, 13, 9, 0, -13 },
  { 193, 9, 13, 9, 0, -13 },
  { 208, 9, 13, 9, 0, -13 },
  { 223, 8, 13, 9, 1, -13 },
  { 236, 8, 13, 9, 1, -13 },
  { 249, 9, 13, 9, 0, -13 },
  { 264, 8, 13, 9, 1, -13 },
  { 277, 4, 10, 4, 0, -10 },
  { 282, 5, 12, 4, -1, -10 },
  { 290, 8, 9, 9, 1, -11 },
  { 299, 8, 5, 9, 1, -9 },
  { 304, 8, 9, 9, 1, -11 },
  { 313, 6, 13, 7, 1, -13 },
  { 323, 12, 15, 14, 1, -13 },
  { 346, 9, 13, 9, -1, -13 },
  { 361, 10, 13, 10, 0, -13 },
  { 378, 9, 13, 9, 1, -13 },
  { 393, 10, 13, 11, 0, -13 },
  { 410, 9, 13, 8, 0, -13 },
  { 425, 9, 13, 8, 0, -13 },
  { 440, 10, 13, 11, 1, -13 },
  { 457, 11, 13, 11, 0, -13 },
  { 475, 8, 13, 5, -1, -13 },
  { 488, 8, 16, 4, -3, -13 },
  { 504, 11, 13, 9, 0, -13 },
  { 522, 7, 13, 8, 0, -13 },
  { 534, 14, 13, 14, 0, -13 },
  { 557, 12, 13, 11, 0, -13 },
  { 577, 10, 13, 12, 1, -13 },
  { 594, 9, 13, 9, 0, -13 },
  { 609, 10, 16, 12, 1, -13 },
  { 629, 9, 13, 9, 0, -13 },
  { 644, 9, 13, 8, 0, -13 },
  { 659, 7, 13, 8, 2, -13 },
  { 671, 10, 13, 11, 1, -13 },
  { 688, 9, 13, 9, 2, -13 },
  { 703, 14, 13, 14, 2, -13 },
  { 726, 11, 13, 8, -1, -13 },
  { 744, 8, 13, 8, 2, -13 },
  { 757, 9, 13, 8, 0, -13 },
  { 772, 7, 16, 5, 0, -13 },
  { 786, 3, 13, 6, 2, -13 },
  { 791, 7, 16, 5, -1, -13 },
  { 805, 9, 8, 9, 0, -13 },
  { 814, 7, 1, 7, -2, 2 },
  { 815, 2, 3, 5, 3, -14 },
  { 816, 8, 10, 9, 1, -10 },
  { 826, 9, 14, 9, 0, -14 },
  { 842, 7, 10, 7, 1, -10 },
  { 851, 9, 14, 9, 1, -14 },
  { 867, 7, 10, 8, 1, -10 },
  { 876, 9, 18, 5, -2, -14 },
  { 897, 9, 14, 9, 0, -10 },
  { 913, 9, 14, 9, 0, -14 },
  { 929, 5, 13, 4, 0, -13 },
  { 938, 7, 17, 4, -2, -13 },
  { 953, 9, 14, 8, 0, -14 },
  { 969, 5, 14, 4, 0, -14 },
  { 978, 13, 10, 14, 0, -10 },
  { 995, 9, 10, 9, 0, -10 },
  { 1007, 7, 10, 9, 1, -10 },
  { 1016, 10, 14, 9, -1, -10 },
  { 1034, 8, 14, 9, 1, -10 },
  { 1048, 7, 10, 6, 0, -10 },
  { 1057, 7, 10, 7, 0, -10 },
  { 1066, 5, 12, 5, 1, -12 },
  { 1074, 8, 10, 9, 1, -10 },
  { 1084, 7, 10, 8, 1, -10 },
  { 1093, 12, 10, 12, 1, -10 },
  { 1108, 9, 10, 8, -1, -10 },
  { 1120, 10, 14, 8, -2, -10 },
  { 1138, 7, 10, 7, 0, -10 },
  { 1147, 7, 16, 6, 0, -13 },
  { 1161, 1, 18, 9, 4, -14 },
  { 1164, 7, 16, 6, -1, -13 },
  { 1178, 8, 3, 9, 1, -8 },
};

const GFXfont NotoSans_SemiCondensed_Italic18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic18pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC18PT7B_H_
