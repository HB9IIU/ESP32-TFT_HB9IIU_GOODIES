#ifndef _NOTOSANS_SEMICONDENSED_ITALIC39PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x1E, 0x0E, 0x07,
  0x03, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x0E, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0xF0, 0x78, 0x3C, 0x1E, 0x00, 0x38, 0xF7, 0x8E,
  0x78, 0xE7, 0x1E, 0x71, 0xC7, 0x1C, 0x61, 0xCE, 0x1C, 0xE1, 0x8E, 0x18,
  0x00, 0x30, 0x70, 0x01, 0xC1, 0x80, 0x07, 0x0E, 0x00, 0x18, 0x38, 0x00,
  0xE0, 0xC0, 0x03, 0x83, 0x00, 0x0C, 0x1C, 0x00, 0x30, 0x70, 0x3F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x80, 0xE0, 0xC0, 0x03, 0x87, 0x00,
  0x0C, 0x1C, 0x00, 0x70, 0x60, 0x01, 0xC1, 0x80, 0x06, 0x0E, 0x03, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x0C, 0x1C, 0x00, 0x70, 0x60,
  0x01, 0xC3, 0x80, 0x06, 0x0E, 0x00, 0x38, 0x30, 0x00, 0xE0, 0xC0, 0x03,
  0x07, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0x38, 0xC2, 0x1E,
  0x30, 0x07, 0x1C, 0x01, 0xC6, 0x00, 0x71, 0x80, 0x1E, 0x60, 0x03, 0xD8,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1D, 0xE0,
  0x06, 0x38, 0x01, 0x8E, 0x00, 0x63, 0x80, 0x18, 0xE0, 0x0E, 0x78, 0xC3,
  0x3C, 0x3F, 0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x1C, 0x1F, 0xC0, 0x18, 0x39,
  0xE0, 0x38, 0x30, 0xE0, 0x70, 0x70, 0xE0, 0x60, 0x60, 0xE0, 0xE0, 0xE0,
  0xE1, 0xC0, 0xE0, 0xE1, 0xC0, 0xE0, 0xC3, 0x80, 0xE1, 0xC7, 0x00, 0xC1,
  0xC7, 0x00, 0xC1, 0xCE, 0x7C, 0xC3, 0x9C, 0xFE, 0xC3, 0x9D, 0xEF, 0xE7,
  0x39, 0xC7, 0xFE, 0x73, 0x87, 0x7C, 0x73, 0x87, 0x00, 0xE3, 0x07, 0x01,
  0xC7, 0x07, 0x01, 0xC7, 0x06, 0x03, 0x87, 0x06, 0x07, 0x06, 0x0E, 0x07,
  0x06, 0x0E, 0x0E, 0x06, 0x0C, 0x1C, 0x07, 0x1C, 0x1C, 0x07, 0x38, 0x38,
  0x07, 0xF8, 0x70, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFB,
  0xE0, 0x07, 0x07, 0x00, 0x78, 0x38, 0x03, 0x81, 0xC0, 0x1C, 0x0E, 0x00,
  0xE0, 0xF0, 0x07, 0x07, 0x00, 0x3C, 0xF0, 0x00, 0xEF, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xDE, 0x0F, 0x3C,
  0x70, 0x73, 0xC3, 0xC7, 0xBC, 0x0F, 0x39, 0xC0, 0x7B, 0xCE, 0x01, 0xFC,
  0x70, 0x07, 0xC3, 0x80, 0x3C, 0x1C, 0x03, 0xE0, 0xF0, 0x3F, 0x87, 0xEF,
  0xDE, 0x1F, 0xFC, 0xF0, 0x7F, 0x83, 0xC0, 0x3B, 0xDE, 0xE7, 0x39, 0x8C,
  0xE7, 0x00, 0x00, 0x78, 0x07, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xC0,
  0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0,
  0x38, 0x07, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F,
  0x00, 0x01, 0x80, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x41, 0xC0, 0xF1,
  0x80, 0xFD, 0x80, 0x3F, 0xFF, 0x03, 0xFF, 0x07, 0x83, 0x0E, 0xC0, 0x1C,
  0xC0, 0x38, 0xE0, 0x78, 0xE0, 0x30, 0x70, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x0F, 0x1E, 0x1E, 0x1C, 0x38, 0x38, 0x70, 0x70, 0xE0, 0xFF,
  0xFF, 0xFF, 0xE0, 0x6F, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xE1, 0xE0, 0xE0, 0x70,
  0xF0, 0x3C, 0x70, 0x1E, 0x78, 0x0F, 0x38, 0x07, 0xBC, 0x03, 0xDE, 0x01,
  0xEE, 0x00, 0xF7, 0x00, 0x77, 0x80, 0x3B, 0xC0, 0x1D, 0xC0, 0x0E, 0xE0,
  0x0F, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x03, 0xCE, 0x01, 0xC7, 0x00, 0xE3,
  0x80, 0xF1, 0xC0, 0xF0, 0xF0, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x03, 0xF0,
  0x00, 0x00, 0xE0, 0x7C, 0x1F, 0x8F, 0xE3, 0xFC, 0xF3, 0xBC, 0xF3, 0x1C,
  0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0F,
  0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07,
  0x80, 0xE0, 0x1C, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x03,
  0x81, 0xE0, 0x20, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x03, 0x81, 0xE0, 0x20, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x3F, 0xE0, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0xC0, 0x1E, 0x1F, 0xBF,
  0x83, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xDC, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03,
  0x9C, 0x00, 0xF3, 0x80, 0x1C, 0xF0, 0x07, 0x1C, 0x01, 0xC3, 0x80, 0x78,
  0x70, 0x0E, 0x0E, 0x03, 0x83, 0xC0, 0xE0, 0x70, 0x38, 0x0E, 0x0F, 0x01,
  0xC1, 0xC0, 0x38, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x80, 0x3C, 0x3E, 0xFE, 0x0F,
  0xFF, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x0E, 0x10, 0x0F, 0x7F, 0x07, 0x7F, 0xC3, 0xF1, 0xF3, 0xE0, 0x79,
  0xF0, 0x1C, 0xF0, 0x0E, 0x78, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xCE, 0x00,
  0xE7, 0x00, 0xF3, 0x80, 0x71, 0xE0, 0x78, 0x70, 0x78, 0x3F, 0xFC, 0x0F,
  0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xE0,
  0x7F, 0xF8, 0x1E, 0x0F, 0x0F, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x38,
  0x07, 0x0E, 0x03, 0xC3, 0xC0, 0xE0, 0x70, 0xF0, 0x1E, 0x78, 0x03, 0xFC,
  0x00, 0xFC, 0x00, 0xFF, 0x80, 0x7C, 0xF0, 0x3C, 0x1E, 0x1E, 0x03, 0x87,
  0x00, 0xF3, 0xC0, 0x3C, 0xE0, 0x07, 0x38, 0x03, 0xCE, 0x00, 0xF3, 0xC0,
  0x38, 0xF0, 0x1E, 0x1F, 0x9F, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xFC,
  0x01, 0xFF, 0x81, 0xFF, 0xC1, 0xE0, 0xF1, 0xE0, 0x38, 0xE0, 0x1C, 0x70,
  0x0E, 0x78, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0xF3,
  0x80, 0x79, 0xE0, 0x7C, 0x78, 0x7E, 0x3F, 0xFE, 0x0F, 0xE7, 0x01, 0xC3,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0x07, 0x0F,
  0x0F, 0x0F, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x78, 0x78, 0xF8, 0x70, 0x01, 0xC0, 0xF0, 0x3C, 0x0F,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0E, 0x03, 0x81,
  0xC0, 0x70, 0x38, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x03, 0x80, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0x78, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xE0,
  0xFF, 0xE3, 0xFF, 0x8C, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xF0, 0x07,
  0x80, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0xE0,
  0x00, 0x0E, 0x1C, 0x0F, 0xE0, 0xC7, 0x07, 0xFE, 0x18, 0xC1, 0xE1, 0x83,
  0xB8, 0x38, 0x70, 0x77, 0x0E, 0x0E, 0x0D, 0xC3, 0x81, 0xC1, 0xB8, 0x70,
  0x30, 0x77, 0x0C, 0x0E, 0x0E, 0xE3, 0x81, 0xC1, 0xD8, 0x70, 0x38, 0x33,
  0x0E, 0x0E, 0x0E, 0x61, 0xC1, 0xC1, 0x8C, 0x38, 0x7C, 0x71, 0x83, 0xFB,
  0xFC, 0x38, 0x7E, 0x3F, 0x07, 0x03, 0x83, 0x80, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x1C,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x1D, 0xC0, 0x01, 0xDC, 0x00,
  0x39, 0xC0, 0x03, 0x9C, 0x00, 0x79, 0xC0, 0x07, 0x1C, 0x00, 0xF1, 0xC0,
  0x0E, 0x1C, 0x01, 0xE1, 0xC0, 0x1C, 0x1C, 0x03, 0xC1, 0xC0, 0x38, 0x1E,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xE0, 0x0E, 0x1E, 0x00,
  0xE1, 0xC0, 0x0E, 0x3C, 0x00, 0xE3, 0xC0, 0x0E, 0x78, 0x00, 0xE7, 0x80,
  0x0E, 0xF0, 0x00, 0xEF, 0x00, 0x0F, 0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x07,
  0xFF, 0xE0, 0x78, 0x3E, 0x07, 0x00, 0xF0, 0x70, 0x0F, 0x07, 0x00, 0xF0,
  0xF0, 0x0F, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x01, 0xE1, 0xE0, 0x7C,
  0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x01, 0xC0, 0x78, 0x3C, 0x03,
  0x83, 0xC0, 0x3C, 0x38, 0x03, 0xC3, 0x80, 0x3C, 0x38, 0x03, 0xC7, 0x80,
  0x3C, 0x78, 0x07, 0x87, 0x00, 0x78, 0x70, 0x1F, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0,
  0x3E, 0x02, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x02, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0x07,
  0xC0, 0x70, 0x0F, 0x03, 0x80, 0x78, 0x1C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F,
  0x00, 0x78, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x3C, 0x00, 0x71, 0xE0, 0x07,
  0x8E, 0x00, 0x3C, 0x70, 0x01, 0xE3, 0x80, 0x0F, 0x3C, 0x00, 0x71, 0xE0,
  0x07, 0x8E, 0x00, 0x3C, 0x70, 0x03, 0xC3, 0x80, 0x1E, 0x3C, 0x01, 0xE1,
  0xE0, 0x1E, 0x0E, 0x01, 0xF0, 0x70, 0x3F, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFF, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFF, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xF8, 0x0E, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x3F, 0xC7, 0x00, 0xFF, 0x3C,
  0x07, 0xFC, 0xF0, 0x00, 0xE3, 0xC0, 0x03, 0x8F, 0x00, 0x0E, 0x3C, 0x00,
  0x78, 0xF0, 0x01, 0xE1, 0xC0, 0x07, 0x07, 0x80, 0x1C, 0x1E, 0x00, 0xF0,
  0x3C, 0x03, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x03,
  0x80, 0x0E, 0x07, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xE0, 0x70,
  0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00,
  0x38, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x70, 0x03, 0xC1, 0xFF, 0xFF,
  0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0E, 0x00, 0x38, 0x3C, 0x00, 0xF0,
  0x78, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x1E, 0x0F,
  0x00, 0x3C, 0x1E, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xE0,
  0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1C, 0x00, 0x03, 0xFE, 0x0F, 0xFC,
  0x07, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x03, 0xFF, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0xC0, 0x07, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0x03,
  0x80, 0x3C, 0x0E, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x07, 0x03,
  0xC0, 0x1C, 0x1E, 0x00, 0x70, 0x78, 0x03, 0xC3, 0xC0, 0x0E, 0x1E, 0x00,
  0x38, 0xF0, 0x00, 0xE7, 0x80, 0x07, 0xBC, 0x00, 0x1F, 0xE0, 0x00, 0x77,
  0x80, 0x01, 0xFF, 0x00, 0x07, 0xDC, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0,
  0x03, 0x83, 0x80, 0x0E, 0x0F, 0x00, 0x38, 0x3C, 0x01, 0xE0, 0x70, 0x07,
  0x81, 0xE0, 0x1C, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x0F, 0x00,
  0xF0, 0x38, 0x01, 0xE0, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01,
  0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC1, 0xF8, 0x00,
  0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x83, 0xF0, 0x01, 0xF8,
  0x1F, 0x80, 0x1D, 0xC1, 0xDC, 0x00, 0xEE, 0x0E, 0xE0, 0x0E, 0xF0, 0x77,
  0x00, 0x77, 0x03, 0x9C, 0x07, 0x38, 0x3C, 0xE0, 0x39, 0xC1, 0xC7, 0x03,
  0x8E, 0x0E, 0x38, 0x1C, 0xF0, 0x71, 0xC1, 0xC7, 0x03, 0x8E, 0x1E, 0x38,
  0x3C, 0x70, 0xE1, 0xC1, 0xC3, 0x8F, 0x1E, 0x0E, 0x1C, 0x70, 0xF0, 0x70,
  0xE7, 0x87, 0x03, 0x87, 0x38, 0x38, 0x3C, 0x1B, 0x81, 0xC1, 0xC0, 0xFC,
  0x1E, 0x0E, 0x07, 0xC0, 0xF0, 0x70, 0x3E, 0x07, 0x07, 0x81, 0xE0, 0x38,
  0x38, 0x0F, 0x01, 0xC1, 0xC0, 0x70, 0x1E, 0x00, 0x03, 0xC0, 0x07, 0x03,
  0xC0, 0x07, 0x07, 0xC0, 0x07, 0x07, 0xE0, 0x0F, 0x07, 0xE0, 0x0E, 0x07,
  0xE0, 0x0E, 0x07, 0xE0, 0x0E, 0x0E, 0x70, 0x1E, 0x0E, 0x70, 0x1C, 0x0E,
  0x70, 0x1C, 0x0E, 0x78, 0x1C, 0x1E, 0x38, 0x1C, 0x1C, 0x38, 0x3C, 0x1C,
  0x3C, 0x38, 0x1C, 0x1C, 0x38, 0x1C, 0x1C, 0x38, 0x3C, 0x1C, 0x38, 0x38,
  0x0E, 0x78, 0x38, 0x0E, 0x70, 0x38, 0x0E, 0x70, 0x38, 0x0F, 0x70, 0x78,
  0x07, 0x70, 0x70, 0x07, 0xF0, 0x70, 0x07, 0xE0, 0x70, 0x03, 0xE0, 0xF0,
  0x03, 0xE0, 0xF0, 0x03, 0xE0, 0xE0, 0x01, 0xC0, 0x00, 0x7F, 0x80, 0x03,
  0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xF0, 0x3E, 0x0F, 0x80, 0x78, 0x3C, 0x00,
  0xE1, 0xE0, 0x03, 0xC7, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF7,
  0x80, 0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xC0, 0x00, 0xF7, 0x00,
  0x03, 0xBC, 0x00, 0x0E, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x07,
  0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF1, 0xC0, 0x07, 0x87, 0x80, 0x1E, 0x1E,
  0x00, 0xF0, 0x3C, 0x0F, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x03, 0xC3, 0xE0, 0x70,
  0x1E, 0x0E, 0x03, 0xC1, 0xC0, 0x78, 0x78, 0x07, 0x0E, 0x00, 0xE1, 0xC0,
  0x3C, 0x38, 0x07, 0x8F, 0x01, 0xE1, 0xE0, 0x3C, 0x38, 0x1F, 0x07, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xF0, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x03,
  0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xF0, 0x3E, 0x0F, 0x80, 0x78, 0x3C, 0x00,
  0xE1, 0xE0, 0x03, 0xC7, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF7,
  0x80, 0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xC0, 0x00, 0xF7, 0x00,
  0x03, 0xBC, 0x00, 0x0E, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x07,
  0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF1, 0xC0, 0x07, 0x87, 0x80, 0x1E, 0x1E,
  0x00, 0xF0, 0x3C, 0x0F, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x01, 0xFE,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFC, 0x00,
  0x7F, 0xF0, 0x1F, 0xFF, 0x03, 0xC3, 0xE0, 0x70, 0x1E, 0x0E, 0x03, 0xC1,
  0xC0, 0x38, 0x78, 0x07, 0x0E, 0x01, 0xE1, 0xC0, 0x3C, 0x38, 0x07, 0x0F,
  0x01, 0xE1, 0xE0, 0x78, 0x38, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x3C,
  0x78, 0x07, 0x87, 0x00, 0xE0, 0xE0, 0x1C, 0x1E, 0x03, 0x81, 0xC0, 0xF0,
  0x38, 0x1E, 0x07, 0x83, 0x80, 0xF0, 0x70, 0x0E, 0x0E, 0x01, 0xE3, 0xC0,
  0x3C, 0x70, 0x03, 0x80, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xC0, 0x60, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0xC0, 0x3C, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x7F,
  0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF8, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x1C, 0x3C, 0x00, 0xF0, 0xE0, 0x03, 0xC3, 0x80,
  0x0E, 0x0E, 0x00, 0x38, 0x78, 0x00, 0xE1, 0xE0, 0x07, 0x87, 0x00, 0x1E,
  0x1C, 0x00, 0x70, 0x70, 0x01, 0xC3, 0xC0, 0x07, 0x0F, 0x00, 0x3C, 0x38,
  0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x1E, 0x00, 0x78, 0x70, 0x01,
  0xE1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0xF0, 0x03, 0xC3,
  0xC0, 0x0E, 0x0F, 0x00, 0x78, 0x1C, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0xE0, 0x01, 0xFC, 0x00, 0x3B,
  0x80, 0x0F, 0x70, 0x01, 0xCE, 0x00, 0x79, 0xC0, 0x0E, 0x38, 0x03, 0xC7,
  0x00, 0x70, 0xE0, 0x1E, 0x1C, 0x03, 0x83, 0x80, 0xF0, 0x78, 0x1C, 0x0F,
  0x07, 0x81, 0xE0, 0xE0, 0x1C, 0x3C, 0x03, 0x87, 0x00, 0x71, 0xE0, 0x0E,
  0x38, 0x01, 0xCF, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0xEE, 0x00, 0x1D,
  0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0x80, 0x1C, 0x00, 0xEE, 0x00, 0xF8,
  0x07, 0xB8, 0x03, 0xE0, 0x1C, 0xE0, 0x1F, 0x80, 0xF3, 0x80, 0x7E, 0x03,
  0x8E, 0x03, 0xB8, 0x0E, 0x38, 0x0E, 0xE0, 0x78, 0xE0, 0x73, 0x81, 0xC3,
  0x81, 0xCE, 0x0F, 0x0E, 0x07, 0x38, 0x38, 0x38, 0x38, 0xE1, 0xE0, 0xE0,
  0xE3, 0x87, 0x03, 0x87, 0x0E, 0x1C, 0x0E, 0x1C, 0x38, 0xF0, 0x38, 0xE0,
  0xE3, 0x80, 0xE3, 0x83, 0x9E, 0x03, 0x8E, 0x0E, 0x70, 0x0E, 0x70, 0x39,
  0xC0, 0x39, 0xC0, 0xEE, 0x00, 0xEE, 0x03, 0xB8, 0x03, 0xB8, 0x0F, 0xE0,
  0x0E, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xE0, 0x03,
  0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x3C, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x1E, 0x03, 0x80, 0x38, 0x07, 0x00, 0xF0, 0x0F, 0x03, 0xC0, 0x0E,
  0x07, 0x00, 0x1C, 0x1E, 0x00, 0x38, 0x78, 0x00, 0x78, 0xE0, 0x00, 0x73,
  0x80, 0x00, 0xEF, 0x00, 0x01, 0xDC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xEE, 0x00,
  0x03, 0xDC, 0x00, 0x0F, 0x38, 0x00, 0x1C, 0x78, 0x00, 0x78, 0x70, 0x01,
  0xE0, 0xE0, 0x03, 0x81, 0xC0, 0x0F, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x70,
  0x07, 0x01, 0xE0, 0x0F, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xDC, 0x00,
  0xE7, 0x00, 0x79, 0xC0, 0x3C, 0x78, 0x0E, 0x0E, 0x07, 0x83, 0x81, 0xC0,
  0xE0, 0xF0, 0x38, 0x78, 0x0F, 0x1C, 0x01, 0xCF, 0x00, 0x73, 0x80, 0x1D,
  0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC,
  0x00, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x7F, 0x01, 0xFE, 0x00, 0xE1, 0xC3, 0x83, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE0, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x0C, 0x1C, 0x38, 0x70, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x7F, 0x01, 0xFE, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xB8, 0x00, 0xEE, 0x00,
  0x71, 0x80, 0x1C, 0x70, 0x0E, 0x1C, 0x03, 0x83, 0x81, 0xC0, 0xE0, 0x70,
  0x1C, 0x38, 0x07, 0x0E, 0x00, 0xC7, 0x00, 0x39, 0xC0, 0x0E, 0xE0, 0x01,
  0xC0, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0xE3, 0xC7, 0x1E, 0x38, 0x70,
  0x03, 0xF1, 0xC1, 0xFE, 0xE0, 0xFF, 0xB8, 0x78, 0x3E, 0x3C, 0x0F, 0x8E,
  0x01, 0xC7, 0x80, 0x71, 0xC0, 0x1C, 0xF0, 0x0F, 0x3C, 0x03, 0xCE, 0x00,
  0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x07, 0x8E, 0x01, 0xE3, 0x80, 0xF0,
  0xE0, 0x7C, 0x3C, 0x3F, 0x0F, 0xBD, 0xC1, 0xFE, 0x60, 0x3F, 0x18, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x8F, 0x80, 0xEF,
  0xF0, 0x3F, 0xFE, 0x1D, 0x83, 0x87, 0xC0, 0xF1, 0xE0, 0x3C, 0x78, 0x0F,
  0x1C, 0x03, 0xCF, 0x00, 0xF3, 0x80, 0x3C, 0xE0, 0x0E, 0x38, 0x03, 0x9E,
  0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1C, 0x78, 0x0F, 0x1E, 0x07, 0x8F, 0x81,
  0xE3, 0xB9, 0xF0, 0xEF, 0xF8, 0x31, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xF0,
  0xFF, 0xC7, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0xC0, 0x87, 0xCE, 0x1F, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x7E, 0x70, 0x3F, 0xEE, 0x0F,
  0xFD, 0xC1, 0xE0, 0xF8, 0x78, 0x1F, 0x0E, 0x01, 0xC3, 0xC0, 0x38, 0x70,
  0x07, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0,
  0x3C, 0x38, 0x07, 0x87, 0x00, 0xF0, 0xE0, 0x3C, 0x1C, 0x0F, 0x83, 0xC3,
  0xF0, 0x7C, 0xEE, 0x07, 0xF9, 0x80, 0x7E, 0x70, 0x00, 0x03, 0xF8, 0x0F,
  0xF8, 0x3E, 0xF8, 0xF0, 0xF3, 0xC0, 0xEF, 0x01, 0xDC, 0x07, 0x38, 0x1E,
  0xF0, 0xF9, 0xFF, 0xE3, 0xFF, 0x87, 0xF8, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x21, 0xF3, 0xC3, 0xFF, 0x81, 0xFE,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x0D,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x70, 0x1F,
  0xEE, 0x03, 0xFE, 0xE0, 0x78, 0x3E, 0x0F, 0x03, 0xE0, 0xE0, 0x1C, 0x1E,
  0x01, 0xC1, 0xC0, 0x1C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x38, 0x03, 0x83,
  0x80, 0x38, 0x38, 0x07, 0x83, 0x80, 0x78, 0x38, 0x0F, 0x83, 0x80, 0xF0,
  0x38, 0x1F, 0x03, 0xC3, 0xF0, 0x3E, 0x77, 0x01, 0xFE, 0xE0, 0x0F, 0xCE,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x80, 0x78, 0x0F, 0xBF, 0x80, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x1F, 0x83, 0xBF, 0xE1, 0xFF,
  0xF1, 0xD8, 0x38, 0xF8, 0x1C, 0x78, 0x0E, 0x3C, 0x07, 0x1C, 0x03, 0x9E,
  0x01, 0xCE, 0x01, 0xE7, 0x00, 0xE3, 0x80, 0x73, 0xC0, 0x39, 0xE0, 0x3C,
  0xE0, 0x1E, 0x70, 0x0E, 0x38, 0x07, 0x3C, 0x03, 0x9E, 0x03, 0xCE, 0x01,
  0xC7, 0x00, 0xE0, 0x01, 0x03, 0xC1, 0xE0, 0xF0, 0x20, 0x00, 0x00, 0x00,
  0x0E, 0x07, 0x03, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x3C, 0x1C, 0x0E,
  0x07, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x0E, 0x00,
  0x00, 0x04, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x3C, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0xF0, 0xE0,
  0x70, 0x38, 0x3C, 0x1E, 0x1E, 0x07, 0x0F, 0x01, 0xC7, 0x80, 0x73, 0xC0,
  0x1D, 0xE0, 0x0E, 0xF0, 0x03, 0xBC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x1F,
  0x38, 0x07, 0x8E, 0x01, 0xC3, 0xC0, 0x70, 0x70, 0x1C, 0x1E, 0x0F, 0x07,
  0x83, 0xC0, 0xE0, 0xE0, 0x3C, 0x38, 0x0F, 0x00, 0x03, 0x81, 0xC0, 0xE0,
  0xF0, 0x70, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xE0,
  0x70, 0x38, 0x1C, 0x1E, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x70,
  0x38, 0x3C, 0x1C, 0x0E, 0x07, 0x00, 0x0E, 0x3E, 0x0F, 0xC0, 0xEF, 0xF1,
  0xFE, 0x0F, 0xFF, 0x3F, 0xE1, 0xD8, 0x7F, 0x0F, 0x1F, 0x03, 0xE0, 0xF1,
  0xE0, 0x3C, 0x0F, 0x1E, 0x07, 0x80, 0xE1, 0xC0, 0x78, 0x0E, 0x3C, 0x07,
  0x00, 0xE3, 0x80, 0x70, 0x0E, 0x38, 0x07, 0x01, 0xE3, 0x80, 0xF0, 0x1C,
  0x78, 0x0F, 0x01, 0xC7, 0x80, 0xE0, 0x1C, 0x70, 0x0E, 0x03, 0xC7, 0x00,
  0xE0, 0x3C, 0x70, 0x1E, 0x03, 0x8F, 0x01, 0xC0, 0x38, 0xF0, 0x1C, 0x03,
  0x8E, 0x01, 0xC0, 0x78, 0xE0, 0x3C, 0x07, 0x80, 0x0E, 0x3F, 0x07, 0x7F,
  0xC7, 0xFF, 0xE3, 0xF0, 0x71, 0xF0, 0x38, 0xF0, 0x1C, 0x78, 0x0E, 0x78,
  0x07, 0x3C, 0x07, 0x9E, 0x03, 0xCE, 0x01, 0xC7, 0x00, 0xE7, 0x80, 0x73,
  0xC0, 0x79, 0xC0, 0x3C, 0xE0, 0x1C, 0x70, 0x0E, 0x78, 0x07, 0x3C, 0x07,
  0x9C, 0x03, 0xCE, 0x01, 0xC0, 0x03, 0xF8, 0x07, 0xFC, 0x1F, 0xFE, 0x1E,
  0x0F, 0x3C, 0x0F, 0x78, 0x07, 0x70, 0x07, 0x70, 0x07, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1E, 0xE0,
  0x1C, 0xE0, 0x3C, 0xF0, 0x78, 0x7D, 0xF0, 0x7F, 0xE0, 0x1F, 0xC0, 0x03,
  0x8F, 0x80, 0x3B, 0xFC, 0x03, 0xFB, 0xE0, 0x76, 0x0E, 0x07, 0xC0, 0xF0,
  0x78, 0x0F, 0x07, 0x80, 0xF0, 0x70, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F,
  0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x01,
  0xC1, 0xE0, 0x3C, 0x1E, 0x07, 0x83, 0xE0, 0x78, 0x3B, 0x9F, 0x03, 0xBF,
  0xE0, 0x39, 0xFC, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xF1, 0xC1, 0xFE, 0xE0, 0xFF, 0xB8, 0x78, 0x3E, 0x3C,
  0x0F, 0x8E, 0x01, 0xC7, 0x80, 0x71, 0xC0, 0x1C, 0xF0, 0x0F, 0x3C, 0x03,
  0xCE, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x1E, 0x38, 0x07, 0x8E, 0x01, 0xE3,
  0x80, 0xF0, 0xE0, 0x7C, 0x3C, 0x3F, 0x0F, 0x9D, 0xC1, 0xFE, 0xF0, 0x3F,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x7C,
  0x3B, 0xF0, 0xDF, 0xC7, 0x60, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00,
  0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x03,
  0xF8, 0x1F, 0xFC, 0x7F, 0xF0, 0xE0, 0x21, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x79, 0x01, 0xE3, 0xCF, 0xC7, 0xFF,
  0x07, 0xFC, 0x00, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFE, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x90,
  0xFE, 0x0F, 0xC0, 0x1C, 0x03, 0x8E, 0x01, 0xCF, 0x00, 0xE7, 0x80, 0xF3,
  0x80, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0xF0, 0x0E, 0x70, 0x0F, 0x38, 0x07,
  0x1C, 0x03, 0x9E, 0x01, 0xCF, 0x01, 0xE7, 0x00, 0xF3, 0x80, 0x71, 0xC0,
  0x78, 0xE0, 0x7C, 0x70, 0x7E, 0x3E, 0xF7, 0x1F, 0xF7, 0x07, 0xF3, 0x80,
  0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0xF0, 0x1E, 0xF0, 0x1C, 0xF0, 0x3C,
  0x70, 0x38, 0x70, 0x78, 0x70, 0x70, 0x70, 0xF0, 0x70, 0xE0, 0x71, 0xE0,
  0x71, 0xC0, 0x73, 0xC0, 0x73, 0x80, 0x77, 0x80, 0x77, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0xF0, 0x1C, 0x03, 0xF8, 0x1E, 0x03,
  0xFC, 0x0F, 0x81, 0xDE, 0x0F, 0xC1, 0xEF, 0x07, 0xE0, 0xE7, 0x87, 0x70,
  0x73, 0xC3, 0xB8, 0x71, 0xE1, 0x9C, 0x38, 0xF1, 0xCE, 0x3C, 0x78, 0xE7,
  0x1C, 0x3C, 0xE3, 0x9E, 0x0E, 0x71, 0xCE, 0x07, 0x70, 0xE7, 0x03, 0xB8,
  0x77, 0x01, 0xD8, 0x3B, 0x80, 0xFC, 0x1F, 0xC0, 0x6E, 0x0F, 0xC0, 0x3E,
  0x07, 0xE0, 0x1F, 0x03, 0xE0, 0x0F, 0x01, 0xF0, 0x07, 0x80, 0xF0, 0x00,
  0x07, 0x80, 0xF0, 0x38, 0x1E, 0x03, 0x81, 0xC0, 0x3C, 0x38, 0x01, 0xC7,
  0x80, 0x1C, 0xF0, 0x01, 0xEE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xBC, 0x00, 0x71, 0xC0, 0x0E, 0x1C, 0x01, 0xE1, 0xE0, 0x3C, 0x0E, 0x03,
  0x80, 0xF0, 0xF8, 0x07, 0x00, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0xF0, 0x3C,
  0x03, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x70, 0x07, 0x03, 0xC0, 0x1C, 0x0E,
  0x00, 0x70, 0x78, 0x01, 0xC1, 0xC0, 0x07, 0x0F, 0x00, 0x1C, 0x38, 0x00,
  0x71, 0xE0, 0x01, 0xC7, 0x00, 0x03, 0x3C, 0x00, 0x0C, 0xE0, 0x00, 0x37,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x37, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0x00, 0x1C,
  0x01, 0xF0, 0x0F, 0xC0, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x1F, 0x80, 0xF8, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0F, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0x80, 0x03, 0xE0, 0x0F, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x7E, 0x00, 0x7C, 0x03,
  0xF0, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x7F,
  0x00, 0xFC, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0xBF, 0xF0, 0xFF, 0xFF, 0xF8,
  0x1F, 0xE8, 0x01, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Italic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 9, 28, 10, 1, -28 },
  { 33, 12, 10, 15, 4, -28 },
  { 48, 22, 28, 22, 1, -28 },
  { 125, 18, 32, 19, 1, -30 },
  { 197, 24, 28, 28, 3, -28 },
  { 281, 21, 28, 23, 1, -28 },
  { 355, 5, 10, 8, 4, -28 },
  { 362, 13, 34, 11, 1, -28 },
  { 418, 12, 34, 11, -3, -28 },
  { 469, 16, 16, 19, 4, -30 },
  { 501, 17, 19, 20, 2, -23 },
  { 542, 8, 9, 9, -2, -4 },
  { 551, 9, 3, 11, 1, -12 },
  { 555, 4, 5, 9, 1, -5 },
  { 558, 19, 28, 14, -2, -28 },
  { 625, 17, 28, 19, 2, -28 },
  { 685, 11, 28, 19, 5, -28 },
  { 724, 19, 28, 19, 0, -28 },
  { 791, 19, 28, 19, 0, -28 },
  { 858, 19, 28, 19, 0, -28 },
  { 925, 18, 28, 19, 1, -28 },
  { 988, 17, 28, 19, 2, -28 },
  { 1048, 18, 28, 19, 2, -28 },
  { 1111, 18, 28, 19, 1, -28 },
  { 1174, 17, 28, 19, 1, -28 },
  { 1234, 8, 21, 9, 0, -21 },
  { 1255, 10, 26, 9, -2, -21 },
  { 1288, 17, 18, 20, 2, -23 },
  { 1327, 17, 11, 20, 2, -19 },
  { 1351, 17, 18, 20, 2, -23 },
  { 1390, 14, 28, 15, 2, -28 },
  { 1439, 27, 31, 29, 2, -28 },
  { 1544, 20, 28, 20, -2, -28 },
  { 1614, 20, 28, 21, 1, -28 },
  { 1684, 20, 28, 20, 2, -28 },
  { 1754, 21, 28, 23, 1, -28 },
  { 1828, 19, 28, 18, 1, -28 },
  { 1895, 19, 28, 17, 1, -28 },
  { 1962, 22, 28, 24, 2, -28 },
  { 2039, 23, 28, 24, 1, -28 },
  { 2120, 15, 28, 12, -1, -28 },
  { 2173, 16, 35, 10, -6, -28 },
  { 2243, 22, 28, 20, 1, -28 },
  { 2320, 13, 28, 17, 1, -28 },
  { 2366, 29, 28, 30, 1, -28 },
  { 2468, 24, 28, 25, 1, -28 },
  { 2552, 22, 28, 25, 2, -28 },
  { 2629, 19, 28, 20, 1, -28 },
  { 2696, 22, 35, 25, 2, -28 },
  { 2793, 19, 28, 20, 1, -28 },
  { 2860, 19, 28, 18, 0, -28 },
  { 2927, 18, 28, 17, 3, -28 },
  { 2990, 22, 28, 23, 2, -28 },
  { 3067, 19, 28, 19, 4, -28 },
  { 3134, 30, 28, 31, 4, -28 },
  { 3239, 23, 28, 18, -2, -28 },
  { 3320, 18, 28, 18, 3, -28 },
  { 3383, 21, 28, 18, -1, -28 },
  { 3457, 15, 34, 11, -1, -28 },
  { 3521, 7, 28, 14, 4, -28 },
  { 3546, 15, 34, 11, -3, -28 },
  { 3610, 18, 17, 20, 1, -28 },
  { 3649, 15, 3, 14, -4, 3 },
  { 3655, 6, 6, 10, 6, -30 },
  { 3660, 18, 21, 20, 2, -21 },
  { 3708, 18, 30, 20, 1, -30 },
  { 3776, 14, 21, 16, 2, -21 },
  { 3813, 19, 30, 20, 2, -30 },
  { 3885, 15, 21, 18, 2, -21 },
  { 3925, 21, 39, 11, -5, -30 },
  { 4028, 20, 30, 20, 0, -21 },
  { 4103, 17, 30, 20, 1, -30 },
  { 4167, 9, 29, 9, 1, -29 },
  { 4200, 15, 38, 9, -5, -29 },
  { 4272, 18, 30, 17, 1, -30 },
  { 4340, 9, 30, 9, 1, -30 },
  { 4374, 28, 21, 30, 1, -21 },
  { 4448, 17, 21, 20, 1, -21 },
  { 4493, 16, 21, 20, 2, -21 },
  { 4535, 20, 30, 20, -1, -21 },
  { 4610, 18, 30, 20, 2, -21 },
  { 4678, 14, 21, 14, 1, -21 },
  { 4715, 15, 21, 15, 0, -21 },
  { 4755, 11, 26, 12, 2, -26 },
  { 4791, 17, 21, 20, 2, -21 },
  { 4836, 16, 21, 16, 2, -21 },
  { 4878, 25, 21, 26, 2, -21 },
  { 4944, 20, 21, 17, -2, -21 },
  { 4997, 22, 30, 16, -4, -21 },
  { 5080, 16, 21, 15, -1, -21 },
  { 5122, 14, 34, 13, 1, -28 },
  { 5182, 3, 39, 19, 8, -30 },
  { 5197, 15, 34, 13, -2, -28 },
  { 5261, 17, 5, 20, 2, -16 },
};

const GFXfont NotoSans_SemiCondensed_Italic39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic39pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC39PT7B_H_
