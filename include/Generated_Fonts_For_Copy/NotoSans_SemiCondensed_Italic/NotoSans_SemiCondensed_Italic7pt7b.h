#ifndef _NOTOSANS_SEMICONDENSED_ITALIC7PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x5A, 0x80, 0xE0, 0x57, 0x6F, 0xA0, 0x69, 0x3C, 0x5D, 0xAE, 0xB5,
  0x00, 0x66, 0x4B, 0xF0, 0xC0, 0x5A, 0xA0, 0x24, 0x95, 0x80, 0xDD, 0x00,
  0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x29, 0x48, 0x76, 0xDE, 0xD6, 0x80, 0x64,
  0xAE, 0x65, 0x1E, 0x25, 0xF2, 0x6A, 0x9E, 0x6A, 0xDE, 0x72, 0x24, 0xC0,
  0x6D, 0x5E, 0x77, 0x9C, 0x42, 0x42, 0x80, 0x38, 0x80, 0xFC, 0xC7, 0x00,
  0x65, 0x48, 0x3B, 0xF7, 0xF8, 0x38, 0x2D, 0xDA, 0x75, 0x69, 0xE0, 0x74,
  0x88, 0x60, 0x75, 0x59, 0xE0, 0x74, 0x68, 0xE0, 0x74, 0x68, 0x80, 0x74,
  0xB9, 0x70, 0x55, 0x79, 0x90, 0x69, 0x4C, 0x24, 0xA5, 0x80, 0x56, 0x4A,
  0xA0, 0x49, 0x4E, 0x4A, 0x6F, 0x5A, 0x80, 0x4A, 0xAD, 0x69, 0x00, 0x75,
  0x99, 0x60, 0x65, 0xE8, 0x80, 0x75, 0x99, 0x62, 0x65, 0x6A, 0xA0, 0x71,
  0x1C, 0xF2, 0x48, 0x55, 0x99, 0x60, 0xB7, 0x48, 0xAF, 0x7D, 0x6A, 0x00,
  0x56, 0x4A, 0xA0, 0xBA, 0x48, 0x72, 0x48, 0xE0, 0x6A, 0x49, 0x00, 0xF8,
  0x55, 0xA0, 0x4E, 0x80, 0xE0, 0x80, 0x7A, 0xAE, 0x4E, 0xDE, 0x72, 0x70,
  0x16, 0xAA, 0xE0, 0x77, 0x70, 0x36, 0x24, 0x44, 0x80, 0x7A, 0xAE, 0x2C,
  0x4E, 0xDA, 0x5A, 0x80, 0x25, 0x24, 0xA0, 0x4F, 0x6A, 0x5A, 0x80, 0x7D,
  0x6B, 0x50, 0x76, 0xD0, 0x76, 0xF0, 0x76, 0xF9, 0x00, 0x7A, 0xAE, 0x22,
  0x72, 0x40, 0x71, 0x60, 0x7A, 0xC0, 0x76, 0xF0, 0xB7, 0x20, 0xAD, 0x75,
  0x40, 0xA9, 0x50, 0x55, 0x62, 0x48, 0x69, 0x60, 0x29, 0x49, 0x80, 0xFE,
  0x55, 0xA0, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Italic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 5, 2, 0, -5 },
  { 3, 2, 2, 3, 1, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 3, 5, 3, 0, -5 },
  { 9, 5, 5, 5, 0, -5 },
  { 13, 4, 5, 4, 0, -5 },
  { 16, 1, 2, 1, 1, -5 },
  { 17, 2, 6, 2, 0, -5 },
  { 19, 3, 6, 2, -1, -5 },
  { 22, 3, 3, 3, 1, -5 },
  { 24, 3, 3, 4, 0, -4 },
  { 26, 1, 2, 2, 0, -1 },
  { 27, 2, 1, 2, 0, -2 },
  { 28, 1, 1, 2, 0, -1 },
  { 29, 3, 5, 2, 0, -5 },
  { 31, 3, 5, 3, 0, -5 },
  { 33, 2, 5, 3, 1, -5 },
  { 35, 3, 5, 3, 0, -5 },
  { 37, 3, 5, 3, 0, -5 },
  { 39, 3, 5, 3, 0, -5 },
  { 41, 3, 5, 3, 0, -5 },
  { 43, 3, 5, 3, 0, -5 },
  { 45, 4, 5, 3, 0, -5 },
  { 48, 3, 5, 3, 0, -5 },
  { 50, 3, 5, 3, 0, -5 },
  { 52, 2, 4, 2, 0, -4 },
  { 53, 2, 5, 2, 0, -4 },
  { 55, 3, 3, 4, 0, -4 },
  { 57, 3, 2, 4, 0, -3 },
  { 58, 3, 3, 4, 0, -4 },
  { 60, 3, 5, 3, 0, -5 },
  { 62, 5, 6, 5, 0, -5 },
  { 66, 3, 5, 4, 0, -5 },
  { 68, 4, 5, 4, 0, -5 },
  { 71, 4, 5, 4, 0, -5 },
  { 74, 4, 5, 4, 0, -5 },
  { 77, 4, 5, 3, 0, -5 },
  { 80, 4, 5, 3, 0, -5 },
  { 83, 4, 5, 4, 0, -5 },
  { 86, 4, 5, 4, 0, -5 },
  { 89, 3, 5, 2, 0, -5 },
  { 91, 3, 6, 2, -1, -5 },
  { 94, 4, 5, 4, 0, -5 },
  { 97, 3, 5, 3, 0, -5 },
  { 99, 5, 5, 5, 0, -5 },
  { 103, 5, 5, 4, 0, -5 },
  { 107, 4, 5, 4, 0, -5 },
  { 110, 4, 5, 4, 0, -5 },
  { 113, 4, 6, 4, 0, -5 },
  { 116, 4, 5, 4, 0, -5 },
  { 119, 3, 5, 3, 0, -5 },
  { 121, 3, 5, 3, 1, -5 },
  { 123, 4, 5, 4, 0, -5 },
  { 126, 3, 5, 3, 1, -5 },
  { 128, 5, 5, 5, 1, -5 },
  { 132, 4, 5, 3, 0, -5 },
  { 135, 3, 5, 3, 1, -5 },
  { 137, 4, 5, 3, 0, -5 },
  { 140, 3, 6, 2, 0, -5 },
  { 143, 1, 5, 2, 1, -5 },
  { 144, 2, 6, 2, 0, -5 },
  { 146, 3, 3, 4, 0, -5 },
  { 148, 3, 1, 3, -1, 0 },
  { 149, 1, 1, 2, 1, -5 },
  { 150, 4, 4, 4, 0, -4 },
  { 152, 3, 5, 4, 0, -5 },
  { 154, 3, 4, 3, 0, -4 },
  { 156, 4, 5, 4, 0, -5 },
  { 159, 3, 4, 3, 0, -4 },
  { 161, 4, 7, 2, -1, -5 },
  { 165, 4, 6, 4, 0, -4 },
  { 168, 3, 5, 4, 0, -5 },
  { 170, 2, 5, 2, 0, -5 },
  { 172, 3, 7, 2, -1, -5 },
  { 175, 3, 5, 3, 0, -5 },
  { 177, 2, 5, 2, 0, -5 },
  { 179, 5, 4, 5, 0, -4 },
  { 182, 3, 4, 4, 0, -4 },
  { 184, 3, 4, 4, 0, -4 },
  { 186, 3, 6, 4, 0, -4 },
  { 189, 4, 6, 4, 0, -4 },
  { 192, 3, 4, 2, 0, -4 },
  { 194, 3, 4, 3, 0, -4 },
  { 196, 2, 5, 2, 0, -5 },
  { 198, 3, 4, 4, 0, -4 },
  { 200, 3, 4, 3, 0, -4 },
  { 202, 5, 4, 5, 0, -4 },
  { 205, 3, 4, 3, 0, -4 },
  { 207, 4, 6, 3, -1, -4 },
  { 210, 3, 4, 3, 0, -4 },
  { 212, 3, 6, 2, 0, -5 },
  { 215, 1, 7, 3, 1, -5 },
  { 216, 2, 6, 2, 0, -5 },
  { 218, 3, 1, 4, 0, -3 },
};

const GFXfont NotoSans_SemiCondensed_Italic7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic7pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC7PT7B_H_
