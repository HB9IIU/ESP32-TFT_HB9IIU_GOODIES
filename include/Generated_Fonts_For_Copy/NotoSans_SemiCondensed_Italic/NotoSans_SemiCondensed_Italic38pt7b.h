#ifndef _NOTOSANS_SEMICONDENSED_ITALIC38PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x07,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x81, 0xE0, 0xF0, 0x78, 0x38, 0x00, 0x78, 0xEE, 0x3D, 0xC7,
  0x38, 0xE7, 0x1C, 0xC3, 0xB8, 0x67, 0x0C, 0xE3, 0x98, 0x60, 0x00, 0x70,
  0x60, 0x03, 0x87, 0x00, 0x18, 0x30, 0x01, 0xC1, 0x80, 0x0E, 0x1C, 0x00,
  0x60, 0xE0, 0x07, 0x06, 0x00, 0x38, 0x70, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xC0, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x30, 0x60, 0x03, 0x83, 0x00, 0x1C,
  0x38, 0x00, 0xC1, 0xC0, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF0,
  0x18, 0x30, 0x01, 0xC1, 0x80, 0x0E, 0x1C, 0x00, 0x60, 0xC0, 0x07, 0x06,
  0x00, 0x38, 0x70, 0x01, 0x83, 0x80, 0x1C, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x3F, 0xF8, 0x3F, 0xFC, 0x3C, 0xCE,
  0x1C, 0xE0, 0x1C, 0x60, 0x0E, 0x30, 0x07, 0x18, 0x03, 0x8C, 0x01, 0xEC,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xDE, 0x00,
  0x67, 0x80, 0x31, 0xC0, 0x18, 0xE0, 0x1C, 0x70, 0x0C, 0x71, 0x06, 0x78,
  0xFF, 0xF8, 0x7F, 0xF8, 0x1F, 0xF0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x02, 0x00, 0x00, 0x1F, 0x00, 0x78, 0xFF, 0x00, 0xE1,
  0xCE, 0x03, 0x87, 0x0C, 0x06, 0x0E, 0x18, 0x1C, 0x38, 0x30, 0x70, 0x70,
  0x60, 0xC0, 0xE0, 0xC3, 0x81, 0x83, 0x8E, 0x03, 0x07, 0x18, 0x06, 0x0C,
  0x71, 0x8C, 0x39, 0xCF, 0xD8, 0x73, 0x3F, 0xF9, 0xCE, 0xE3, 0xFF, 0x39,
  0xC7, 0x7C, 0x67, 0x06, 0x21, 0xCE, 0x1C, 0x07, 0x1C, 0x38, 0x0C, 0x30,
  0x70, 0x38, 0x60, 0xE0, 0xE1, 0xC1, 0x81, 0x83, 0x87, 0x07, 0x07, 0x0E,
  0x1C, 0x0E, 0x18, 0x30, 0x0C, 0x70, 0xE0, 0x1F, 0xC3, 0x80, 0x1F, 0x00,
  0x00, 0x10, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x3C, 0x70, 0x07, 0x87,
  0x80, 0x70, 0x38, 0x07, 0x07, 0x80, 0x70, 0x70, 0x07, 0x07, 0x00, 0x70,
  0xE0, 0x07, 0x9C, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0xE0, 0x01, 0xEE, 0x07, 0x3C, 0xF0, 0x77, 0x87, 0x0E, 0xF0, 0x78, 0xEE,
  0x03, 0xDC, 0xE0, 0x1F, 0xCE, 0x01, 0xF8, 0xE0, 0x0F, 0x0E, 0x01, 0xF0,
  0xF0, 0x3F, 0x8F, 0xDF, 0xF8, 0x7F, 0xF3, 0xC3, 0xFC, 0x1E, 0x7B, 0xDC,
  0xE7, 0x31, 0x9C, 0xE6, 0x00, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38,
  0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x30, 0x03, 0x80, 0x38, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0,
  0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00,
  0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x0E, 0x18, 0x1F, 0x30, 0x3F, 0xE3, 0x87, 0xFF,
  0x07, 0xFE, 0x1F, 0x00, 0x77, 0x01, 0xE6, 0x07, 0x8E, 0x06, 0x1C, 0x08,
  0x1C, 0x00, 0x20, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x0F, 0x1E, 0x1C, 0x1C,
  0x38, 0x38, 0x70, 0x70, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x2F, 0xFF, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x20, 0x01, 0xFC, 0x07, 0xFE, 0x07, 0x9E, 0x0F, 0x0F, 0x1E,
  0x07, 0x1C, 0x07, 0x3C, 0x07, 0x38, 0x07, 0x78, 0x07, 0x70, 0x07, 0x70,
  0x07, 0x70, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x1E, 0xE0, 0x1E, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0x38, 0xE0,
  0x78, 0xF0, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0x01, 0xE0, 0xF8,
  0x3F, 0x0F, 0xE7, 0xFD, 0xF7, 0x18, 0xE2, 0x1C, 0x03, 0x80, 0xF0, 0x1C,
  0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0x1F, 0x03, 0x03, 0xC0, 0x80,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3,
  0xFF, 0xF8, 0x00, 0x18, 0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x1F, 0x1F, 0x02,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x80, 0x3E, 0x3F, 0x7F,
  0x0F, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x36, 0x00, 0x1F, 0x80, 0x0E, 0xE0, 0x07, 0x38, 0x01, 0xDE, 0x00,
  0xE7, 0x00, 0x71, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x07, 0x0F, 0x03, 0x83,
  0x81, 0xC0, 0xE0, 0xF0, 0x38, 0x38, 0x0E, 0x1C, 0x07, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF8, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0xDC, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x02,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC2, 0x01, 0xF0,
  0xF9, 0xF8, 0x3F, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x3F, 0xC0,
  0x7F, 0xE0, 0x7E, 0x20, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x3E, 0x07, 0x7F, 0x83, 0xFF,
  0xE1, 0xF0, 0x79, 0xF0, 0x3C, 0xF0, 0x0E, 0x70, 0x07, 0x38, 0x03, 0x9C,
  0x01, 0xCE, 0x01, 0xE7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x78, 0xF0, 0x78,
  0x3E, 0xF8, 0x0F, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xE3,
  0xFF, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x10, 0x00, 0x7F,
  0x80, 0x3F, 0xF0, 0x1F, 0x1E, 0x0F, 0x03, 0x83, 0x80, 0xF0, 0xE0, 0x3C,
  0x38, 0x0F, 0x0E, 0x03, 0x83, 0x80, 0xE0, 0xF0, 0x70, 0x1E, 0x78, 0x03,
  0xFC, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7D, 0xE0, 0x3C, 0x3C, 0x1E, 0x07,
  0x87, 0x00, 0xE3, 0xC0, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE3,
  0xC0, 0x78, 0xF0, 0x1E, 0x1F, 0x1F, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x00,
  0x20, 0x00, 0xFE, 0x01, 0xFF, 0x81, 0xF1, 0xE0, 0xE0, 0x70, 0xF0, 0x3C,
  0x70, 0x0E, 0x78, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xE7, 0x00,
  0xF3, 0x80, 0x79, 0xC0, 0x78, 0xF0, 0x7C, 0x3F, 0xFE, 0x0F, 0xF7, 0x03,
  0xE7, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0xF0, 0x73, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0x06,
  0x0F, 0x0F, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x78, 0x78, 0xF8, 0x70, 0x00, 0x80, 0xF0, 0x3C,
  0x0F, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0E, 0x03,
  0x81, 0xC0, 0x60, 0x38, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0,
  0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x70, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x00, 0x7F, 0xC7, 0xFF, 0x8F, 0x3E, 0x20, 0x38, 0x00, 0xF0, 0x03, 0xC0,
  0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00,
  0xF0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x70, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0x83, 0xE0, 0x0F, 0x00,
  0x3C, 0x07, 0x80, 0x07, 0x83, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x18, 0x70,
  0x1E, 0x07, 0x38, 0x1F, 0xE1, 0xCC, 0x0F, 0x78, 0x77, 0x07, 0x0E, 0x1D,
  0xC3, 0x83, 0x87, 0x61, 0xC0, 0xC1, 0xF8, 0x70, 0x70, 0x6E, 0x18, 0x1C,
  0x1B, 0x8E, 0x07, 0x0E, 0xC3, 0x83, 0x83, 0xB0, 0xE0, 0xE0, 0xCC, 0x38,
  0x78, 0x73, 0x0E, 0x1E, 0x38, 0xC3, 0xDD, 0xDE, 0x30, 0x7E, 0x7F, 0x0E,
  0x0F, 0x0F, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x77, 0x00, 0x0E, 0x60, 0x03, 0x8C, 0x00, 0x71, 0xC0,
  0x1E, 0x38, 0x03, 0x87, 0x00, 0xF0, 0xE0, 0x1C, 0x1C, 0x07, 0x83, 0x80,
  0xE0, 0x70, 0x3C, 0x0E, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x38, 0x07, 0x0F,
  0x00, 0xE1, 0xC0, 0x1E, 0x78, 0x03, 0xCE, 0x00, 0x7B, 0xC0, 0x07, 0x78,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0x80, 0x03, 0xFF, 0x00, 0xFF, 0xF8,
  0x1F, 0xFF, 0x03, 0x80, 0xF0, 0x70, 0x1E, 0x0E, 0x01, 0xC3, 0xC0, 0x38,
  0x70, 0x07, 0x0E, 0x01, 0xE1, 0xC0, 0x38, 0x78, 0x0F, 0x0F, 0xFF, 0xC1,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0x03, 0xC1, 0xE0, 0x3C, 0x38, 0x03, 0x87,
  0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x01, 0xC7, 0x80, 0x38, 0xE0, 0x0F, 0x1C,
  0x03, 0xC3, 0x80, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0x9E, 0x07, 0xC0,
  0x20, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x02, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x0E, 0x07, 0xC0, 0x70, 0x0F, 0x03,
  0x80, 0x78, 0x3C, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x78, 0x70, 0x03,
  0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70,
  0x01, 0xC7, 0x80, 0x1E, 0x38, 0x00, 0xF1, 0xC0, 0x07, 0x0E, 0x00, 0x78,
  0x70, 0x07, 0x87, 0x80, 0x3C, 0x38, 0x03, 0xC1, 0xC0, 0x3C, 0x0E, 0x07,
  0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xC1,
  0xFF, 0xF0, 0x7F, 0xFC, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x7F, 0xF8,
  0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0xF0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xF3, 0xE0, 0x7C, 0x01,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x7F, 0x9E, 0x03, 0xFC, 0xF0, 0x1F, 0xE7, 0x80, 0x0F, 0x3C, 0x00,
  0x71, 0xE0, 0x03, 0x8F, 0x00, 0x1C, 0x78, 0x00, 0xE1, 0xC0, 0x0F, 0x0F,
  0x00, 0x70, 0x3C, 0x03, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0x03, 0x80, 0x1C, 0x1E, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x0F,
  0x07, 0x00, 0x3C, 0x1C, 0x00, 0xE0, 0xF0, 0x03, 0x83, 0x80, 0x0E, 0x0E,
  0x00, 0x78, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC1, 0xC0, 0x0E, 0x0F, 0x00, 0x38, 0x38, 0x00, 0xE0,
  0xE0, 0x07, 0x83, 0x80, 0x1E, 0x0E, 0x00, 0x70, 0x78, 0x01, 0xC1, 0xC0,
  0x07, 0x07, 0x00, 0x3C, 0x1C, 0x00, 0xF0, 0x70, 0x03, 0x83, 0xC0, 0x0E,
  0x0E, 0x00, 0x38, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x1E, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0xFF, 0x80, 0xFF,
  0x00, 0xFC, 0x00, 0x03, 0x80, 0x78, 0x3C, 0x07, 0x81, 0xC0, 0x78, 0x0E,
  0x07, 0x80, 0x70, 0x38, 0x03, 0x83, 0xC0, 0x3C, 0x3C, 0x01, 0xC3, 0xC0,
  0x0E, 0x3C, 0x00, 0x73, 0xC0, 0x07, 0xBC, 0x00, 0x3F, 0xC0, 0x01, 0xDE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xCE, 0x00, 0x38, 0x70, 0x01,
  0xC3, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x70, 0x07, 0x83, 0xC0, 0x38, 0x0E,
  0x01, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x07, 0x80, 0x78, 0x38,
  0x03, 0xC0, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xC0,
  0x01, 0xF8, 0x3E, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07,
  0xE0, 0x7E, 0x00, 0x77, 0x07, 0x70, 0x03, 0xF0, 0x3B, 0x80, 0x3B, 0x81,
  0xDC, 0x01, 0xDC, 0x0E, 0xE0, 0x1C, 0xE0, 0x77, 0x00, 0xEF, 0x07, 0xB8,
  0x0E, 0x70, 0x39, 0xC0, 0x73, 0x81, 0xC6, 0x07, 0x1C, 0x0E, 0x38, 0x38,
  0xE0, 0x71, 0xC3, 0x8F, 0x07, 0x0E, 0x1C, 0x70, 0x38, 0x71, 0xC3, 0x81,
  0xC3, 0x8E, 0x1C, 0x0E, 0x1C, 0xE1, 0xE0, 0x70, 0xE7, 0x0F, 0x07, 0x07,
  0x70, 0x70, 0x38, 0x3B, 0x83, 0x81, 0xC1, 0xF8, 0x1C, 0x0E, 0x07, 0xC1,
  0xE0, 0xF0, 0x3C, 0x0E, 0x07, 0x01, 0xE0, 0x70, 0x38, 0x0E, 0x03, 0x80,
  0x03, 0x80, 0x0F, 0x07, 0xC0, 0x0E, 0x07, 0xC0, 0x0E, 0x07, 0xC0, 0x0E,
  0x07, 0xE0, 0x1E, 0x0E, 0xE0, 0x1C, 0x0E, 0xE0, 0x1C, 0x0E, 0xF0, 0x1C,
  0x0E, 0x70, 0x1C, 0x0E, 0x70, 0x3C, 0x1E, 0x70, 0x38, 0x1C, 0x38, 0x38,
  0x1C, 0x38, 0x38, 0x1C, 0x38, 0x38, 0x1C, 0x1C, 0x78, 0x38, 0x1C, 0x70,
  0x38, 0x1C, 0x70, 0x38, 0x1E, 0x70, 0x38, 0x0E, 0x70, 0x38, 0x0E, 0xE0,
  0x70, 0x0E, 0xE0, 0x70, 0x07, 0xE0, 0x70, 0x07, 0xE0, 0x70, 0x07, 0xE0,
  0xF0, 0x03, 0xC0, 0xE0, 0x03, 0xC0, 0xE0, 0x03, 0xC0, 0x00, 0x0C, 0x00,
  0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xEF, 0xE0, 0x78, 0x0F, 0x07, 0x80,
  0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x07, 0x3C, 0x00, 0x39, 0xE0, 0x01, 0xCE,
  0x00, 0x0E, 0xF0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xBC, 0x00, 0x3D, 0xE0,
  0x01, 0xEF, 0x00, 0x1E, 0x78, 0x00, 0xF1, 0xC0, 0x0F, 0x0F, 0x00, 0xF0,
  0x7C, 0x0F, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x0E,
  0x03, 0x83, 0xC0, 0x78, 0x70, 0x0F, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x78,
  0x0F, 0x0F, 0x01, 0xC1, 0xC0, 0xF8, 0x38, 0xFE, 0x07, 0xFF, 0x81, 0xFF,
  0xC0, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF8,
  0x07, 0xEF, 0xE0, 0x78, 0x0F, 0x07, 0x80, 0x3C, 0x78, 0x01, 0xE3, 0xC0,
  0x07, 0x3C, 0x00, 0x39, 0xE0, 0x01, 0xCE, 0x00, 0x0E, 0xF0, 0x00, 0x77,
  0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x0E, 0x78,
  0x00, 0xF1, 0xC0, 0x0F, 0x0F, 0x00, 0xF0, 0x7C, 0x0F, 0x81, 0xFF, 0xF8,
  0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFE,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x0E, 0x03,
  0xC3, 0xC0, 0x78, 0x70, 0x0F, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x78, 0x0F,
  0x0F, 0x03, 0xC1, 0xC1, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x80,
  0x38, 0x78, 0x07, 0x07, 0x00, 0xE0, 0xE0, 0x1C, 0x1E, 0x07, 0x81, 0xC0,
  0xE0, 0x38, 0x1C, 0x07, 0x83, 0x80, 0xF0, 0x70, 0x0E, 0x1E, 0x01, 0xE3,
  0x80, 0x3C, 0x00, 0x00, 0x08, 0x00, 0x3F, 0xE0, 0x3F, 0xFC, 0x1F, 0xFF,
  0x0F, 0x80, 0x83, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0xC0, 0x3C, 0x3F,
  0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0E,
  0x1C, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80,
  0x0E, 0x1C, 0x00, 0xF1, 0xE0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC3,
  0x80, 0x0E, 0x1C, 0x00, 0xF1, 0xE0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x01,
  0xC3, 0x80, 0x1E, 0x1C, 0x00, 0xF1, 0xE0, 0x07, 0x0F, 0x00, 0x38, 0x78,
  0x03, 0xC1, 0xC0, 0x3C, 0x0F, 0x03, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0,
  0x07, 0xFC, 0x00, 0xF0, 0x01, 0xEE, 0x00, 0x39, 0xC0, 0x0F, 0x38, 0x01,
  0xC7, 0x00, 0x78, 0xE0, 0x0F, 0x1C, 0x01, 0xC3, 0x80, 0x78, 0x70, 0x0E,
  0x0E, 0x03, 0xC1, 0xC0, 0x70, 0x38, 0x1E, 0x07, 0x03, 0x80, 0xF0, 0xF0,
  0x1E, 0x1C, 0x01, 0xC7, 0x80, 0x38, 0xE0, 0x07, 0x3C, 0x00, 0xE7, 0x00,
  0x1D, 0xE0, 0x03, 0xB8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x7F,
  0x00, 0x78, 0x03, 0xB8, 0x03, 0xC0, 0x3D, 0xC0, 0x3E, 0x01, 0xCE, 0x01,
  0xF0, 0x0E, 0x70, 0x1F, 0x80, 0xE3, 0x80, 0xFC, 0x07, 0x1C, 0x0E, 0xE0,
  0x78, 0xE0, 0x77, 0x03, 0x87, 0x07, 0x38, 0x3C, 0x38, 0x39, 0xC1, 0xC1,
  0xC1, 0xCE, 0x0E, 0x0E, 0x1C, 0x70, 0xE0, 0x70, 0xE3, 0x87, 0x03, 0x8E,
  0x1C, 0x78, 0x1C, 0x70, 0xE3, 0x80, 0xE7, 0x07, 0x1C, 0x07, 0x38, 0x39,
  0xC0, 0x39, 0xC0, 0xCE, 0x01, 0xDC, 0x06, 0xE0, 0x0E, 0xE0, 0x37, 0x00,
  0x7E, 0x01, 0xB8, 0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8,
  0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x1E, 0x03, 0x80, 0x78, 0x07, 0x01, 0xE0, 0x0F, 0x03, 0x80, 0x0E, 0x0F,
  0x00, 0x1C, 0x3C, 0x00, 0x38, 0x70, 0x00, 0x79, 0xC0, 0x00, 0x77, 0x80,
  0x00, 0xEE, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0x9C, 0x00, 0x0E, 0x38, 0x00, 0x3C, 0x70, 0x00, 0xF0, 0xF0, 0x01, 0xC0,
  0xE0, 0x07, 0x81, 0xC0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x07,
  0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x03, 0xDC, 0x01, 0xE7, 0x00, 0xF1, 0xC0,
  0x38, 0x78, 0x1E, 0x0E, 0x07, 0x03, 0x83, 0xC0, 0xE1, 0xE0, 0x38, 0x70,
  0x0E, 0x3C, 0x01, 0xCE, 0x00, 0x77, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x00, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0xFF, 0x00, 0xE1, 0xC3, 0x87, 0x07, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x1C, 0x38, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x3B, 0x00, 0x39, 0xC0, 0x1C, 0xE0, 0x1C, 0x38, 0x0E, 0x1C,
  0x0E, 0x07, 0x07, 0x03, 0x87, 0x00, 0xC3, 0x80, 0x73, 0x80, 0x39, 0xC0,
  0x0F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE7, 0x9C, 0xE3,
  0x8C, 0x01, 0xC0, 0x03, 0xF9, 0xC3, 0xFE, 0xE3, 0xC3, 0x73, 0xC0, 0xF1,
  0xC0, 0x79, 0xE0, 0x3C, 0xE0, 0x1E, 0xF0, 0x0E, 0x78, 0x07, 0x38, 0x03,
  0x9C, 0x01, 0xCE, 0x01, 0xE7, 0x00, 0xE3, 0x80, 0xF1, 0xC0, 0x78, 0xE0,
  0x7C, 0x70, 0x7E, 0x3E, 0xFE, 0x0F, 0xF7, 0x03, 0xE3, 0x80, 0x03, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x0E, 0x1C, 0x07, 0x3F, 0x83, 0xBF, 0xC3, 0xB8, 0xF1,
  0xF0, 0x38, 0xF0, 0x1C, 0x78, 0x0E, 0x78, 0x07, 0x3C, 0x03, 0x9C, 0x01,
  0xCE, 0x00, 0xE7, 0x00, 0xF7, 0x80, 0x73, 0xC0, 0x39, 0xC0, 0x3C, 0xE0,
  0x1C, 0x78, 0x1E, 0x7C, 0x1E, 0x3B, 0x9F, 0x1D, 0xFF, 0x0C, 0x7E, 0x00,
  0x01, 0xF0, 0x1F, 0xF0, 0xFF, 0x87, 0x82, 0x3C, 0x00, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x8F, 0x8E, 0x1F, 0xF8, 0x3F,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0xE1, 0xC0,
  0x3F, 0x9C, 0x07, 0xFD, 0xC0, 0xF0, 0xF8, 0x1E, 0x07, 0x81, 0xC0, 0x78,
  0x3C, 0x07, 0x83, 0x80, 0x78, 0x78, 0x07, 0x07, 0x80, 0x70, 0x70, 0x07,
  0x07, 0x00, 0xF0, 0x70, 0x0F, 0x07, 0x00, 0xE0, 0xF0, 0x1E, 0x0F, 0x01,
  0xE0, 0x70, 0x3E, 0x07, 0x07, 0xE0, 0x7C, 0xFC, 0x03, 0xFD, 0xC0, 0x1F,
  0x1C, 0x00, 0x00, 0xF0, 0x07, 0xF8, 0x1F, 0xF8, 0x78, 0x71, 0xE0, 0xE3,
  0x81, 0xCF, 0x03, 0x9C, 0x0F, 0x78, 0x3C, 0xEF, 0xF1, 0xFF, 0xC3, 0xFC,
  0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x11,
  0xF9, 0xE1, 0xFF, 0xC1, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x3F, 0x9C, 0x0F, 0xFB, 0x83, 0xC3, 0x70, 0xF0,
  0x3C, 0x1C, 0x07, 0x87, 0x80, 0xF0, 0xE0, 0x1E, 0x3C, 0x03, 0x87, 0x80,
  0x70, 0xE0, 0x0E, 0x1C, 0x03, 0xC3, 0x80, 0x78, 0x70, 0x0E, 0x1E, 0x03,
  0xC3, 0xC0, 0x78, 0x38, 0x1F, 0x07, 0x07, 0xE0, 0xFB, 0xF8, 0x0F, 0xF7,
  0x00, 0xF8, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x03, 0x01, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x1C, 0x07, 0x3F, 0x83, 0xBF,
  0xC3, 0xB8, 0xF1, 0xF0, 0x38, 0xF0, 0x1C, 0x78, 0x0E, 0x38, 0x0F, 0x3C,
  0x07, 0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE7, 0x80, 0xF3, 0x80, 0x71,
  0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x78, 0x0F, 0x38, 0x07, 0x1C, 0x03,
  0x8E, 0x01, 0xC0, 0x03, 0x03, 0xC1, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x07, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x0E,
  0x0F, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x1C, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x03, 0xC3, 0x83, 0xC3, 0xC3, 0xC1, 0xC3,
  0xC0, 0xE3, 0xC0, 0x73, 0xC0, 0x7B, 0xC0, 0x39, 0xC0, 0x1D, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x07, 0xDE, 0x03, 0xC7, 0x01, 0xC3, 0x80, 0xE1, 0xE0,
  0x70, 0x70, 0x78, 0x38, 0x38, 0x1E, 0x1C, 0x07, 0x0E, 0x03, 0xC0, 0x03,
  0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x83,
  0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0x81,
  0xC0, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x0E, 0x00, 0x00, 0x3C, 0x07, 0x01,
  0xCF, 0xC3, 0xF8, 0x33, 0xFC, 0xFF, 0x0E, 0xC3, 0xB8, 0xF1, 0xF0, 0x7C,
  0x0E, 0x3C, 0x0F, 0x81, 0xC7, 0x81, 0xE0, 0x38, 0xE0, 0x38, 0x0F, 0x3C,
  0x07, 0x01, 0xC7, 0x00, 0xE0, 0x38, 0xE0, 0x3C, 0x07, 0x1C, 0x07, 0x00,
  0xE7, 0x80, 0xE0, 0x3C, 0xE0, 0x1C, 0x07, 0x1C, 0x07, 0x80, 0xE3, 0x80,
  0xE0, 0x1C, 0x70, 0x1C, 0x07, 0x9E, 0x03, 0x80, 0xE3, 0x80, 0x70, 0x1C,
  0x70, 0x1E, 0x03, 0x8E, 0x03, 0x80, 0x70, 0x00, 0x3C, 0x07, 0x3F, 0x87,
  0x7F, 0xE3, 0xB8, 0xF1, 0xF0, 0x38, 0xF0, 0x1C, 0x78, 0x1E, 0x78, 0x0F,
  0x3C, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x01, 0xE7, 0x80, 0xF3, 0xC0,
  0x71, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x1E, 0x78, 0x0F, 0x38, 0x07, 0x1C,
  0x03, 0x8E, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0xF8, 0x0F, 0xFC, 0x1E, 0x1E,
  0x3C, 0x0E, 0x38, 0x0F, 0x70, 0x0F, 0x70, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x1C, 0xE0, 0x1C,
  0xE0, 0x38, 0xF0, 0x78, 0x7D, 0xF0, 0x7F, 0xE0, 0x1F, 0xC0, 0x00, 0x07,
  0x00, 0x73, 0xF8, 0x0C, 0xFF, 0x03, 0xB8, 0xF0, 0x7C, 0x0E, 0x0F, 0x01,
  0xC1, 0xE0, 0x38, 0x38, 0x07, 0x0F, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03,
  0x87, 0x00, 0xF1, 0xE0, 0x1C, 0x3C, 0x03, 0x87, 0x00, 0xF0, 0xE0, 0x1C,
  0x1E, 0x07, 0x87, 0xC1, 0xE0, 0xEE, 0x7C, 0x1D, 0xFF, 0x03, 0x9F, 0x80,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0xFE, 0x70, 0x7F, 0xDC, 0x3C, 0x36, 0x1E, 0x07, 0x87, 0x01, 0xE3,
  0xC0, 0x78, 0xE0, 0x1E, 0x78, 0x07, 0x1E, 0x01, 0xC7, 0x00, 0x71, 0xC0,
  0x3C, 0x70, 0x0F, 0x1C, 0x03, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0x70, 0x3E,
  0x1C, 0x1F, 0x87, 0xDF, 0xC0, 0xFF, 0x70, 0x1F, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x02, 0x3C, 0x31, 0xF0, 0xCF, 0x87,
  0x72, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03,
  0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x0F, 0xFC, 0x3F,
  0xF0, 0xF0, 0x61, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x71, 0x01, 0xE3, 0xCF, 0xC7, 0xFF, 0x07, 0xF8, 0x00, 0x06,
  0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC3, 0xFF, 0xBF, 0xF1, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x87, 0xF0, 0x7E, 0x00, 0x1C, 0x03,
  0x9E, 0x03, 0xCE, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x39, 0xE0,
  0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x3C, 0x07, 0x9E, 0x03, 0x8E,
  0x01, 0xC7, 0x01, 0xE3, 0x80, 0xF1, 0xC0, 0xF8, 0xE0, 0xF8, 0x79, 0xFC,
  0x3F, 0xEE, 0x0F, 0xC7, 0x00, 0xE0, 0x0F, 0xE0, 0x1E, 0xE0, 0x1C, 0xE0,
  0x3C, 0xE0, 0x38, 0xF0, 0x38, 0x70, 0x70, 0x70, 0x70, 0x70, 0xE0, 0x70,
  0xE0, 0x71, 0xC0, 0x71, 0xC0, 0x73, 0x80, 0x73, 0x80, 0x77, 0x00, 0x77,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0xE0, 0x3C, 0x07,
  0xF0, 0x1E, 0x07, 0xB8, 0x1F, 0x03, 0x9C, 0x0D, 0x81, 0xCE, 0x0E, 0xC1,
  0xC7, 0x07, 0x60, 0xE3, 0x83, 0x30, 0xF1, 0xC3, 0x98, 0x70, 0xE1, 0x8C,
  0x78, 0x71, 0xC6, 0x38, 0x38, 0xE3, 0x1C, 0x1C, 0xE1, 0x9C, 0x0E, 0x70,
  0xCE, 0x07, 0x70, 0x6E, 0x01, 0xB8, 0x37, 0x00, 0xD8, 0x1B, 0x80, 0x7C,
  0x0F, 0x80, 0x3C, 0x07, 0xC0, 0x1E, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x00,
  0x07, 0x81, 0xF0, 0x38, 0x1C, 0x03, 0x83, 0x80, 0x3C, 0x78, 0x01, 0xCF,
  0x00, 0x1C, 0xE0, 0x01, 0xDC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xB8, 0x00, 0x7B, 0x80, 0x07,
  0x1C, 0x00, 0xE1, 0xC0, 0x1E, 0x1C, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x0F,
  0x00, 0xF0, 0x03, 0x80, 0x3C, 0x0E, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xF0,
  0x1C, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x1C, 0x00, 0x70, 0x70,
  0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x01,
  0xCE, 0x00, 0x07, 0x38, 0x00, 0x0D, 0xC0, 0x00, 0x37, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x0F, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x7F, 0xF8, 0xFF, 0xF0,
  0xFF, 0xF0, 0x00, 0x3C, 0x03, 0xF0, 0x1F, 0xC0, 0x70, 0x01, 0xC0, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x01, 0xE0, 0x3F, 0x00, 0xF0, 0x03, 0xE0, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x1C, 0x01,
  0xF8, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x3F,
  0x80, 0x7E, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xBF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x3F, 0xE8, 0x03, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Italic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 9, 27, 10, 1, -27 },
  { 32, 11, 10, 14, 4, -27 },
  { 46, 21, 27, 21, 1, -27 },
  { 117, 17, 31, 19, 1, -29 },
  { 183, 23, 28, 28, 3, -28 },
  { 264, 20, 28, 22, 1, -28 },
  { 334, 5, 10, 8, 4, -27 },
  { 341, 12, 33, 11, 1, -27 },
  { 391, 12, 33, 11, -3, -27 },
  { 441, 15, 16, 18, 4, -29 },
  { 471, 17, 19, 20, 2, -23 },
  { 512, 8, 9, 9, -2, -4 },
  { 521, 9, 3, 11, 1, -12 },
  { 525, 4, 5, 9, 1, -5 },
  { 528, 18, 27, 13, -2, -27 },
  { 589, 16, 28, 19, 2, -28 },
  { 645, 11, 27, 19, 5, -27 },
  { 683, 18, 28, 19, 0, -28 },
  { 746, 18, 28, 19, 0, -28 },
  { 809, 18, 27, 19, 0, -27 },
  { 870, 18, 27, 19, 1, -27 },
  { 931, 17, 28, 19, 2, -28 },
  { 991, 18, 27, 19, 2, -27 },
  { 1052, 18, 28, 19, 1, -28 },
  { 1115, 17, 28, 19, 1, -28 },
  { 1175, 8, 21, 9, 0, -21 },
  { 1196, 10, 26, 9, -2, -21 },
  { 1229, 17, 18, 20, 2, -23 },
  { 1268, 17, 11, 20, 2, -19 },
  { 1292, 17, 18, 20, 2, -23 },
  { 1331, 14, 28, 14, 2, -28 },
  { 1380, 26, 30, 29, 2, -27 },
  { 1478, 19, 27, 19, -2, -27 },
  { 1543, 19, 27, 20, 1, -27 },
  { 1608, 20, 28, 20, 2, -28 },
  { 1678, 21, 27, 23, 1, -27 },
  { 1749, 18, 27, 17, 1, -27 },
  { 1810, 18, 27, 16, 1, -27 },
  { 1871, 21, 28, 23, 2, -28 },
  { 1945, 22, 27, 23, 1, -27 },
  { 2020, 15, 27, 11, -1, -27 },
  { 2071, 16, 34, 9, -6, -27 },
  { 2139, 21, 27, 19, 1, -27 },
  { 2210, 13, 27, 16, 1, -27 },
  { 2254, 29, 27, 29, 1, -27 },
  { 2352, 24, 27, 24, 1, -27 },
  { 2433, 21, 28, 24, 2, -28 },
  { 2507, 19, 27, 19, 1, -27 },
  { 2572, 21, 34, 24, 2, -28 },
  { 2662, 19, 27, 20, 1, -27 },
  { 2727, 18, 28, 17, 0, -28 },
  { 2790, 17, 27, 17, 3, -27 },
  { 2848, 21, 27, 23, 2, -27 },
  { 2919, 19, 27, 19, 3, -27 },
  { 2984, 29, 27, 30, 4, -27 },
  { 3082, 23, 27, 18, -2, -27 },
  { 3160, 18, 27, 17, 3, -27 },
  { 3221, 20, 27, 17, -1, -27 },
  { 3289, 15, 33, 11, -1, -27 },
  { 3351, 7, 27, 13, 4, -27 },
  { 3375, 15, 33, 11, -3, -27 },
  { 3437, 17, 16, 19, 1, -27 },
  { 3471, 14, 3, 14, -3, 3 },
  { 3477, 5, 6, 10, 6, -29 },
  { 3481, 17, 21, 20, 2, -21 },
  { 3526, 17, 29, 20, 1, -29 },
  { 3588, 14, 21, 15, 2, -21 },
  { 3625, 20, 29, 20, 1, -29 },
  { 3698, 15, 21, 17, 1, -21 },
  { 3738, 19, 38, 11, -4, -29 },
  { 3829, 19, 30, 20, 0, -21 },
  { 3901, 17, 29, 20, 1, -29 },
  { 3963, 9, 28, 9, 1, -28 },
  { 3995, 15, 37, 9, -5, -28 },
  { 4065, 17, 29, 17, 1, -29 },
  { 4127, 9, 29, 9, 1, -29 },
  { 4160, 27, 21, 30, 1, -21 },
  { 4231, 17, 21, 20, 1, -21 },
  { 4276, 16, 21, 19, 2, -21 },
  { 4318, 19, 30, 20, -1, -21 },
  { 4390, 18, 30, 20, 1, -21 },
  { 4458, 14, 21, 13, 1, -21 },
  { 4495, 15, 21, 15, 0, -21 },
  { 4535, 11, 25, 11, 2, -25 },
  { 4570, 17, 20, 20, 2, -20 },
  { 4613, 16, 20, 16, 2, -20 },
  { 4653, 25, 20, 25, 2, -20 },
  { 4716, 20, 20, 16, -2, -20 },
  { 4766, 22, 29, 16, -4, -20 },
  { 4846, 16, 20, 15, -1, -20 },
  { 4886, 14, 33, 13, 1, -27 },
  { 4944, 3, 38, 18, 8, -29 },
  { 4959, 15, 33, 13, -2, -27 },
  { 5021, 17, 5, 20, 2, -16 },
};

const GFXfont NotoSans_SemiCondensed_Italic38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic38pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC38PT7B_H_
