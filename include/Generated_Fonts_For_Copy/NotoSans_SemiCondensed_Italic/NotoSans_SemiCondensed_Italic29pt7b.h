#ifndef _NOTOSANS_SEMICONDENSED_ITALIC29PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x06, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C, 0x1C, 0x18, 0x18,
  0x18, 0x18, 0x30, 0x30, 0x00, 0x00, 0x00, 0x70, 0xF0, 0x60, 0x73, 0xB1,
  0x98, 0xCC, 0xE6, 0x66, 0x33, 0x19, 0x8C, 0x01, 0x8C, 0x01, 0x8C, 0x03,
  0x0C, 0x03, 0x08, 0x03, 0x18, 0x06, 0x18, 0x3F, 0xFF, 0x7F, 0xFF, 0x04,
  0x30, 0x0C, 0x30, 0x0C, 0x60, 0x0C, 0x60, 0x18, 0x60, 0xFF, 0xFC, 0xFF,
  0xFC, 0x30, 0xC0, 0x30, 0xC0, 0x31, 0x80, 0x21, 0x80, 0x61, 0x80, 0x63,
  0x00, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x1F, 0xF1, 0xFF, 0x9C, 0xC8, 0xC4,
  0x06, 0x20, 0x3B, 0x01, 0xD8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0x70,
  0x19, 0x80, 0x8C, 0x04, 0xE4, 0x67, 0x3F, 0xF1, 0xFF, 0x01, 0xC0, 0x04,
  0x00, 0x60, 0x03, 0x00, 0x1E, 0x01, 0x8F, 0xC0, 0xC3, 0x30, 0x61, 0x8C,
  0x18, 0x63, 0x0C, 0x30, 0xC6, 0x0C, 0x31, 0x83, 0x0C, 0xC0, 0xC6, 0x63,
  0x31, 0x9B, 0xEC, 0xED, 0xCF, 0xF6, 0x63, 0x79, 0xB8, 0xC0, 0xCC, 0x30,
  0x63, 0x0C, 0x18, 0xC7, 0x0C, 0x31, 0x87, 0x0C, 0x61, 0x83, 0x30, 0xC0,
  0xFC, 0x70, 0x1E, 0x00, 0x03, 0xE0, 0x0F, 0xE0, 0x38, 0xC0, 0x61, 0x80,
  0xC3, 0x03, 0x86, 0x03, 0x1C, 0x06, 0x70, 0x0F, 0xC0, 0x0E, 0x00, 0x7C,
  0x01, 0xD8, 0x37, 0x38, 0xFC, 0x39, 0xB0, 0x77, 0x60, 0x7C, 0xC0, 0x71,
  0x81, 0xE3, 0x87, 0xC7, 0xFD, 0xC7, 0xF1, 0xC0, 0x77, 0x66, 0x6C, 0xCC,
  0x01, 0x81, 0x81, 0x81, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x38, 0x18,
  0x0C, 0x0E, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07,
  0x01, 0x80, 0xC0, 0x60, 0x18, 0x00, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x38,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0C, 0x06,
  0x07, 0x03, 0x03, 0x81, 0x81, 0xC0, 0xC0, 0xE0, 0xE0, 0x60, 0x60, 0x00,
  0x07, 0x00, 0x70, 0x06, 0x0E, 0x60, 0xFE, 0x03, 0xFF, 0x0F, 0xF1, 0xA0,
  0x33, 0x07, 0x30, 0x23, 0x80, 0x10, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x39, 0xDC, 0xE6, 0x63, 0x00, 0xFF, 0xF8, 0x7F, 0x60,
  0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70,
  0x03, 0x00, 0x38, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x03,
  0xE0, 0x3F, 0x83, 0x9C, 0x38, 0x71, 0x83, 0x9C, 0x1C, 0xC0, 0xEE, 0x07,
  0x70, 0x3B, 0x01, 0xD8, 0x0E, 0xC0, 0x6E, 0x03, 0x70, 0x3B, 0x81, 0xDC,
  0x0C, 0xE0, 0xE7, 0x06, 0x1C, 0x70, 0xFF, 0x03, 0xF0, 0x00, 0x07, 0x0F,
  0x1E, 0x7E, 0xE6, 0xCE, 0x0E, 0x0C, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x18,
  0x38, 0x38, 0x30, 0x30, 0x30, 0x70, 0x70, 0x03, 0xE0, 0x3F, 0xE0, 0xE3,
  0x82, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x01,
  0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x03, 0xE0, 0x3F, 0xE0,
  0xE3, 0x82, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x70,
  0x1F, 0x80, 0xF8, 0x00, 0x78, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xCC, 0x0E, 0x3F, 0xF0, 0x7F, 0x80, 0x00, 0x1C, 0x00,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0xD8, 0x06, 0xE0, 0x3B, 0x81, 0xCC, 0x06,
  0x30, 0x30, 0xC1, 0xC7, 0x0E, 0x1C, 0x30, 0x61, 0x81, 0x8F, 0xFF, 0xFF,
  0xFE, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0xF8,
  0x7F, 0xC3, 0xFE, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x37,
  0x01, 0xFE, 0x0C, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C,
  0x00, 0xE0, 0x07, 0x20, 0x71, 0xFF, 0x0F, 0xF0, 0x00, 0x00, 0xF8, 0x1F,
  0xC1, 0xE0, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x73, 0xC3,
  0xFF, 0x1E, 0x1C, 0xE0, 0xE6, 0x03, 0x70, 0x1B, 0x81, 0xDC, 0x0E, 0xE0,
  0x63, 0x07, 0x1C, 0x70, 0xFF, 0x83, 0xF0, 0x00, 0x7F, 0xFB, 0xFF, 0xDF,
  0xFC, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C,
  0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01,
  0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x03, 0xE0, 0x7F, 0x87, 0x8E,
  0x38, 0x31, 0x81, 0x8C, 0x0C, 0x60, 0xE3, 0x86, 0x0E, 0xE0, 0x7E, 0x03,
  0xE0, 0x7B, 0x87, 0x0E, 0x70, 0x33, 0x81, 0xD8, 0x0E, 0xC0, 0x76, 0x03,
  0x38, 0x38, 0xFF, 0x83, 0xF8, 0x00, 0x07, 0xC0, 0x7F, 0x07, 0x1C, 0x70,
  0x63, 0x03, 0x98, 0x1D, 0xC0, 0xEE, 0x07, 0x70, 0x3B, 0x83, 0x9C, 0x3C,
  0x7F, 0x61, 0xF7, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00,
  0xE1, 0xFE, 0x0F, 0xC0, 0x00, 0x0C, 0x71, 0xC6, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xCF, 0x38, 0x06, 0x1C, 0x38, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x0C, 0x38, 0x60, 0xC3, 0x06, 0x00, 0x00,
  0x10, 0x07, 0x01, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0xE0, 0x0F, 0x00, 0x3C,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x0F,
  0x00, 0xC0, 0x00, 0x1F, 0x1F, 0xE6, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x18,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x30, 0x18, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x03,
  0xC1, 0xC0, 0x70, 0x06, 0x0C, 0x00, 0x71, 0x80, 0x03, 0x38, 0x7E, 0x33,
  0x0F, 0xE3, 0x71, 0x86, 0x36, 0x38, 0x63, 0x63, 0x0C, 0x36, 0x30, 0xC3,
  0xC6, 0x0C, 0x3C, 0x61, 0xC6, 0xC6, 0x18, 0x6C, 0x73, 0xCC, 0xC3, 0xEF,
  0x8E, 0x1C, 0x70, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC1,
  0xC0, 0x0F, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x70, 0x01, 0xF0,
  0x03, 0xE0, 0x0E, 0xC0, 0x19, 0x80, 0x73, 0x00, 0xC6, 0x03, 0x8C, 0x06,
  0x18, 0x1C, 0x30, 0x38, 0x60, 0xFF, 0xC1, 0xFF, 0x87, 0xFF, 0x0E, 0x07,
  0x38, 0x0E, 0x70, 0x1D, 0xC0, 0x3B, 0x80, 0x7E, 0x00, 0xE0, 0x0F, 0xE0,
  0x3F, 0xE0, 0xC7, 0xC7, 0x07, 0x1C, 0x0C, 0x70, 0x31, 0x80, 0xC6, 0x07,
  0x38, 0x38, 0xFF, 0xC3, 0xFE, 0x0C, 0x1C, 0x30, 0x39, 0xC0, 0xE7, 0x03,
  0x98, 0x0E, 0x60, 0x3B, 0x81, 0xCE, 0x0F, 0x3F, 0xF8, 0xFF, 0x80, 0x01,
  0xF8, 0x0F, 0xFC, 0x3C, 0x30, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x81, 0xFE,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0xF0, 0x3F, 0xF0, 0xE0, 0xF1, 0xC0,
  0xE3, 0x80, 0xC6, 0x01, 0x8C, 0x03, 0x38, 0x06, 0x70, 0x0C, 0xC0, 0x19,
  0x80, 0x73, 0x00, 0xEE, 0x01, 0xDC, 0x07, 0x30, 0x0E, 0x60, 0x39, 0xC0,
  0xE3, 0x87, 0x87, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF,
  0x87, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xFF,
  0x83, 0xFE, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xE0,
  0xFF, 0x87, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x01, 0xFC, 0x07,
  0xFF, 0x0F, 0x0E, 0x1E, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0xFC, 0xC0, 0xFC, 0xC0, 0x1C, 0xC0,
  0x1C, 0xC0, 0x18, 0xC0, 0x18, 0xE0, 0x18, 0xE0, 0x38, 0x70, 0x38, 0x3F,
  0xF0, 0x1F, 0xF0, 0x0E, 0x03, 0x86, 0x01, 0xC3, 0x00, 0xC3, 0x80, 0x61,
  0xC0, 0x30, 0xE0, 0x38, 0x60, 0x1C, 0x30, 0x0C, 0x38, 0x06, 0x1F, 0xFF,
  0x0F, 0xFF, 0x86, 0x01, 0xC3, 0x00, 0xC3, 0x80, 0x61, 0xC0, 0x70, 0xC0,
  0x38, 0x60, 0x1C, 0x30, 0x0C, 0x38, 0x06, 0x1C, 0x07, 0x0C, 0x03, 0x80,
  0x0F, 0xF0, 0xFE, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x1C, 0x01, 0xC0, 0x18, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0xFC, 0x0F, 0x80, 0x40,
  0x00, 0x0E, 0x07, 0x0C, 0x0E, 0x0C, 0x1C, 0x1C, 0x38, 0x1C, 0x30, 0x1C,
  0x70, 0x18, 0xE0, 0x19, 0xC0, 0x3B, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x33, 0x80, 0x71, 0x80, 0x71, 0xC0, 0x61, 0xC0, 0x60, 0xC0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0xC0, 0x70, 0x0E, 0x03, 0x00, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x1C,
  0x07, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x07, 0xFE, 0xFF, 0x80, 0x0F, 0x00,
  0x3C, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x87, 0xC0, 0x3E, 0x1B, 0x00, 0xF8,
  0x6C, 0x07, 0xE1, 0xB0, 0x1B, 0x06, 0xC0, 0xCC, 0x3B, 0x03, 0x70, 0xEC,
  0x19, 0xC3, 0x38, 0x66, 0x0C, 0xE3, 0x18, 0x31, 0x8C, 0x61, 0xC6, 0x63,
  0x86, 0x19, 0x8E, 0x18, 0x6C, 0x30, 0x61, 0xB0, 0xC3, 0x87, 0x83, 0x0E,
  0x1E, 0x1C, 0x30, 0x70, 0x70, 0xC1, 0xC1, 0x80, 0x0E, 0x01, 0xC3, 0x80,
  0x70, 0xF0, 0x18, 0x7C, 0x06, 0x1B, 0x03, 0x86, 0xC0, 0xE1, 0xB8, 0x30,
  0x66, 0x0C, 0x39, 0x83, 0x0E, 0x71, 0xC3, 0x0C, 0x70, 0xC3, 0x18, 0x30,
  0xC6, 0x1C, 0x39, 0x86, 0x06, 0xE1, 0x81, 0xB8, 0x60, 0x7C, 0x38, 0x0F,
  0x0E, 0x03, 0xC3, 0x00, 0xF0, 0xC0, 0x3C, 0x00, 0x01, 0xF0, 0x07, 0xFC,
  0x0F, 0x1E, 0x1C, 0x0E, 0x38, 0x06, 0x30, 0x07, 0x70, 0x07, 0x70, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x06, 0xC0, 0x0E, 0xC0, 0x0E,
  0xC0, 0x0E, 0xC0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0x70, 0xF0, 0x7F, 0xE0,
  0x1F, 0xC0, 0x0F, 0xC0, 0x3F, 0xC0, 0xCF, 0x87, 0x07, 0x1C, 0x1C, 0x70,
  0x71, 0x81, 0xC6, 0x07, 0x38, 0x18, 0xE0, 0xE3, 0x0F, 0x0F, 0xF8, 0x3F,
  0x81, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xC0, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0x1E, 0x1C, 0x0E, 0x38,
  0x06, 0x30, 0x07, 0x70, 0x07, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x06, 0xC0, 0x0E, 0xC0, 0x0E, 0xC0, 0x0C, 0xC0, 0x1C, 0xE0,
  0x1C, 0xE0, 0x38, 0x70, 0xF0, 0x7F, 0xE0, 0x1F, 0xC0, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x0F, 0xC0, 0x3F, 0xC0, 0xCF,
  0x87, 0x07, 0x1C, 0x1C, 0x70, 0x71, 0x81, 0xC6, 0x07, 0x38, 0x38, 0xE1,
  0xE3, 0xFF, 0x0F, 0xF0, 0x31, 0x81, 0xC7, 0x07, 0x1C, 0x18, 0x30, 0x60,
  0xE3, 0x83, 0x8E, 0x06, 0x38, 0x1C, 0xC0, 0x70, 0x03, 0xF0, 0x1F, 0xF0,
  0xF1, 0x87, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C,
  0x00, 0x60, 0x03, 0x8C, 0x1E, 0x3F, 0xF0, 0xFF, 0x00, 0x7F, 0xFB, 0xFF,
  0xFF, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00,
  0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x00, 0x18, 0x07, 0x18, 0x07,
  0x38, 0x06, 0x38, 0x06, 0x38, 0x06, 0x30, 0x0E, 0x30, 0x0E, 0x70, 0x0C,
  0x70, 0x0C, 0x60, 0x1C, 0x60, 0x1C, 0x60, 0x1C, 0xE0, 0x18, 0xE0, 0x18,
  0xC0, 0x38, 0xC0, 0x38, 0xC0, 0x30, 0xE0, 0x70, 0xE0, 0xE0, 0x7F, 0xC0,
  0x3F, 0x80, 0xC0, 0x1F, 0x00, 0x6C, 0x03, 0xB0, 0x0C, 0xC0, 0x73, 0x01,
  0x8C, 0x0E, 0x38, 0x30, 0xE1, 0xC3, 0x86, 0x0E, 0x38, 0x38, 0xC0, 0xE7,
  0x01, 0x9C, 0x06, 0xE0, 0x1B, 0x80, 0x6C, 0x01, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0x70, 0x00, 0xC0, 0x30, 0x1F, 0x01, 0xC0, 0x7C, 0x07, 0x01, 0xB0,
  0x3C, 0x0E, 0xC0, 0xF0, 0x33, 0x07, 0xC1, 0xCC, 0x1B, 0x06, 0x30, 0x6C,
  0x38, 0xC3, 0x30, 0xE3, 0x0C, 0xC3, 0x0C, 0x73, 0x1C, 0x31, 0x8C, 0x60,
  0xCE, 0x33, 0x83, 0x30, 0xCC, 0x0C, 0xC3, 0x30, 0x36, 0x0D, 0xC0, 0xD8,
  0x36, 0x03, 0xC0, 0xD8, 0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xE0, 0x38,
  0x00, 0x07, 0x01, 0xC0, 0xC0, 0xE0, 0x30, 0x30, 0x0E, 0x1C, 0x03, 0x8E,
  0x00, 0x63, 0x00, 0x19, 0xC0, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x00, 0xDC, 0x00, 0x73, 0x00, 0x38,
  0xC0, 0x0C, 0x38, 0x07, 0x0E, 0x03, 0x81, 0x81, 0xC0, 0x60, 0xE0, 0x1C,
  0x00, 0xC0, 0x3E, 0x03, 0xB8, 0x19, 0xC1, 0xCE, 0x1C, 0x30, 0xE1, 0x8E,
  0x0C, 0x60, 0x77, 0x03, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00,
  0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0x07, 0xE0, 0xF8, 0x38, 0x07, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80,
  0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0,
  0x38, 0x06, 0x20, 0xF8, 0x1F, 0x00, 0xC6, 0x39, 0xC6, 0x31, 0x8C, 0x63,
  0x9C, 0x63, 0x18, 0xC6, 0x39, 0xC6, 0x31, 0x80, 0x07, 0xE0, 0xFC, 0x03,
  0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01,
  0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0xE0, 0x18, 0x03, 0x00, 0x60, 0xFC, 0x1F, 0x80, 0x03, 0x00, 0x38, 0x01,
  0xE0, 0x1F, 0x00, 0xD8, 0x0E, 0x60, 0x63, 0x07, 0x0C, 0x30, 0x63, 0x83,
  0x98, 0x0D, 0xC0, 0x7C, 0x01, 0x80, 0xFF, 0xE0, 0xE3, 0x8C, 0x70, 0x03,
  0x8C, 0x3F, 0x61, 0xC7, 0x8E, 0x0E, 0x30, 0x39, 0xC0, 0xE6, 0x03, 0x18,
  0x0C, 0xE0, 0x73, 0x81, 0xCE, 0x06, 0x38, 0x38, 0xE0, 0xE3, 0x85, 0x87,
  0xFE, 0x0F, 0x30, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00,
  0x30, 0x00, 0xC7, 0x03, 0x7E, 0x1F, 0xBC, 0x78, 0x71, 0xC1, 0xC7, 0x07,
  0x38, 0x1C, 0xE0, 0x73, 0x81, 0xCC, 0x06, 0x30, 0x39, 0xC0, 0xE7, 0x07,
  0x1E, 0x3C, 0x6F, 0xE3, 0x9F, 0x00, 0x03, 0xC1, 0xFC, 0x79, 0x9C, 0x03,
  0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00,
  0xE1, 0x1F, 0xE1, 0xFC, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x81, 0xE7, 0x07, 0xEC, 0x1C, 0x78, 0x70, 0x70, 0xC0,
  0xE3, 0x81, 0x86, 0x03, 0x0C, 0x06, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0x61,
  0xC1, 0xC3, 0x87, 0x87, 0x0B, 0x07, 0xFE, 0x07, 0x98, 0x00, 0x03, 0xC0,
  0xFE, 0x1C, 0xE3, 0x87, 0x30, 0x67, 0x06, 0x61, 0xEF, 0xFC, 0xFF, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x04, 0x7F, 0x83, 0xF8, 0x00, 0x3E,
  0x00, 0xF8, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x7C, 0x03,
  0xF8, 0x09, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0,
  0x07, 0x80, 0x0E, 0x00, 0x00, 0x03, 0xC6, 0x0F, 0xD8, 0x38, 0xF0, 0xE0,
  0xE1, 0x81, 0xC7, 0x03, 0x8C, 0x06, 0x18, 0x0C, 0x70, 0x38, 0xE0, 0x71,
  0xC0, 0xC3, 0x83, 0x87, 0x0F, 0x0E, 0x3E, 0x0F, 0xFC, 0x0F, 0x30, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x0C, 0x3C, 0x1F, 0xF0, 0x1F, 0x80,
  0x00, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x63,
  0x83, 0x7E, 0x3E, 0x79, 0xE1, 0xCE, 0x0E, 0x70, 0x63, 0x03, 0x38, 0x19,
  0xC1, 0xCC, 0x0E, 0x60, 0x67, 0x03, 0x38, 0x19, 0xC1, 0xCC, 0x0E, 0x60,
  0x60, 0x06, 0x1C, 0x18, 0x00, 0x01, 0x83, 0x0E, 0x1C, 0x30, 0x60, 0xC3,
  0x87, 0x0C, 0x18, 0x70, 0xE1, 0x83, 0x0E, 0x00, 0x00, 0x60, 0x1C, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00,
  0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00,
  0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x83, 0xE0, 0x78, 0x00, 0x07,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC1, 0xC3,
  0x0E, 0x1C, 0x70, 0x73, 0x81, 0x8C, 0x06, 0x60, 0x3B, 0x00, 0xFC, 0x03,
  0xF8, 0x0E, 0xE0, 0x31, 0x81, 0xC7, 0x07, 0x1C, 0x18, 0x30, 0x60, 0xE3,
  0x83, 0x80, 0x07, 0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x1C, 0x1C,
  0x18, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30, 0x70, 0x70, 0x60, 0x60, 0xE0,
  0x0C, 0x70, 0xF0, 0x6F, 0xCF, 0xC7, 0xCE, 0xCE, 0x3C, 0x3C, 0x31, 0xC1,
  0xC1, 0x8E, 0x0C, 0x0C, 0x60, 0xE0, 0xE7, 0x07, 0x07, 0x38, 0x38, 0x31,
  0x81, 0x81, 0x8C, 0x0C, 0x0C, 0xE0, 0xE0, 0xE7, 0x07, 0x07, 0x38, 0x30,
  0x31, 0x81, 0x81, 0x9C, 0x1C, 0x1C, 0x0C, 0xF0, 0x77, 0xE1, 0xFB, 0xC7,
  0x87, 0x1C, 0x1C, 0x70, 0x73, 0x81, 0x8E, 0x06, 0x38, 0x38, 0xC0, 0xE3,
  0x03, 0x9C, 0x0C, 0x70, 0x71, 0xC1, 0xC6, 0x07, 0x38, 0x18, 0x03, 0x80,
  0x7F, 0x07, 0x3C, 0x70, 0x63, 0x03, 0x38, 0x1D, 0x80, 0xEC, 0x06, 0xE0,
  0x37, 0x03, 0xB8, 0x1D, 0xC0, 0xCE, 0x0E, 0x38, 0xE1, 0xFE, 0x07, 0xE0,
  0x06, 0x38, 0x0D, 0xF8, 0x3E, 0x78, 0x78, 0x70, 0xE0, 0xE1, 0xC1, 0xC3,
  0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x30, 0x18, 0x60, 0x71, 0xC0, 0xE3, 0x83,
  0x87, 0x8F, 0x0D, 0xFC, 0x19, 0xF0, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x03, 0x8C, 0x3F, 0x61,
  0xC7, 0x8E, 0x0E, 0x30, 0x39, 0xC0, 0xE6, 0x03, 0x18, 0x0C, 0xE0, 0x73,
  0x81, 0xCE, 0x06, 0x38, 0x38, 0xE1, 0xE3, 0x8F, 0x87, 0xFE, 0x0F, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x00, 0x19, 0xC6, 0xF3, 0xFC, 0xF0, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70,
  0x18, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0x07, 0x83, 0xFC,
  0xF1, 0x18, 0x03, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x06,
  0x00, 0xC0, 0x19, 0x07, 0x3F, 0xC7, 0xF0, 0x0C, 0x06, 0x06, 0x07, 0xF7,
  0xF5, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x1C, 0x0E, 0x06, 0x03, 0x03, 0x81,
  0xC0, 0xE0, 0x7E, 0x1F, 0x00, 0x18, 0x19, 0xC0, 0xCE, 0x06, 0x60, 0x73,
  0x03, 0x98, 0x19, 0xC0, 0xCE, 0x06, 0x60, 0x73, 0x03, 0x98, 0x19, 0xC1,
  0xCE, 0x1E, 0x71, 0xF1, 0xFB, 0x0F, 0x98, 0xC0, 0x7C, 0x0E, 0xC0, 0xEC,
  0x1C, 0xC1, 0xCC, 0x18, 0xC3, 0x8C, 0x30, 0xC7, 0x0C, 0x60, 0xEE, 0x0E,
  0xC0, 0xFC, 0x07, 0x80, 0x70, 0x07, 0x00, 0xC0, 0xC0, 0xF0, 0x70, 0x7C,
  0x1C, 0x1B, 0x0F, 0x0E, 0xC3, 0xC3, 0xB1, 0xB0, 0xCC, 0x6C, 0x73, 0x3B,
  0x18, 0xCC, 0xCE, 0x33, 0x33, 0x0D, 0x8C, 0xC3, 0x63, 0x60, 0xF0, 0xD8,
  0x3C, 0x3E, 0x0F, 0x0F, 0x03, 0x81, 0xC0, 0x1C, 0x0C, 0x30, 0x70, 0xC3,
  0x83, 0x9C, 0x06, 0x60, 0x1B, 0x80, 0x7C, 0x00, 0xE0, 0x03, 0x80, 0x1E,
  0x00, 0xF8, 0x07, 0x70, 0x38, 0xC0, 0xC3, 0x87, 0x0E, 0x38, 0x18, 0x06,
  0x03, 0x83, 0x01, 0x81, 0x81, 0xC0, 0xC0, 0xC0, 0x60, 0xE0, 0x30, 0x60,
  0x18, 0x70, 0x0E, 0x30, 0x07, 0x38, 0x01, 0x98, 0x00, 0xDC, 0x00, 0x6C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x30,
  0x07, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x00, 0x7F, 0xCF, 0xFC,
  0x00, 0x20, 0x3C, 0x0F, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x06,
  0x00, 0xC0, 0x38, 0x0E, 0x07, 0x81, 0xF0, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0xE0, 0x1E, 0x00, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x04, 0x01, 0xE0, 0x1E,
  0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01,
  0xC0, 0x30, 0x0E, 0x07, 0xC0, 0xF0, 0x10, 0x00, 0x7C, 0x1F, 0xFB, 0x87,
  0xF8, 0x0C,
};

const GFXglyph NotoSans_SemiCondensed_Italic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 8, 21, 7, 0, -21 },
  { 22, 9, 8, 11, 3, -21 },
  { 31, 16, 21, 16, 1, -21 },
  { 73, 13, 24, 14, 1, -22 },
  { 112, 18, 21, 21, 2, -21 },
  { 160, 15, 21, 17, 1, -21 },
  { 200, 4, 8, 6, 3, -21 },
  { 204, 9, 26, 8, 1, -21 },
  { 234, 9, 26, 8, -2, -21 },
  { 264, 12, 12, 14, 3, -22 },
  { 282, 12, 14, 15, 2, -17 },
  { 303, 5, 7, 7, -1, -3 },
  { 308, 7, 2, 9, 1, -9 },
  { 310, 4, 3, 7, 0, -3 },
  { 312, 13, 21, 10, -1, -21 },
  { 347, 13, 21, 14, 1, -21 },
  { 382, 8, 21, 14, 4, -21 },
  { 403, 14, 21, 14, 0, -21 },
  { 440, 14, 21, 14, 0, -21 },
  { 477, 14, 21, 14, 0, -21 },
  { 514, 13, 21, 14, 1, -21 },
  { 549, 13, 21, 14, 1, -21 },
  { 584, 13, 21, 14, 2, -21 },
  { 619, 13, 21, 14, 1, -21 },
  { 654, 13, 21, 14, 1, -21 },
  { 689, 6, 16, 7, 0, -16 },
  { 701, 7, 20, 7, -1, -16 },
  { 719, 12, 13, 15, 2, -17 },
  { 739, 12, 8, 15, 2, -14 },
  { 751, 12, 13, 15, 2, -17 },
  { 771, 10, 21, 11, 2, -21 },
  { 798, 20, 24, 22, 1, -21 },
  { 858, 15, 21, 15, -2, -21 },
  { 898, 14, 21, 16, 1, -21 },
  { 935, 15, 21, 15, 2, -21 },
  { 975, 15, 21, 17, 1, -21 },
  { 1015, 14, 21, 13, 1, -21 },
  { 1052, 14, 21, 12, 1, -21 },
  { 1089, 16, 21, 18, 2, -21 },
  { 1131, 17, 21, 18, 1, -21 },
  { 1176, 12, 21, 9, -1, -21 },
  { 1208, 12, 27, 7, -4, -21 },
  { 1249, 16, 21, 15, 1, -21 },
  { 1291, 10, 21, 12, 1, -21 },
  { 1318, 22, 21, 22, 1, -21 },
  { 1376, 18, 21, 18, 1, -21 },
  { 1424, 16, 21, 19, 2, -21 },
  { 1466, 14, 21, 15, 1, -21 },
  { 1503, 16, 26, 19, 2, -21 },
  { 1555, 14, 21, 15, 1, -21 },
  { 1592, 14, 21, 13, 0, -21 },
  { 1629, 13, 21, 13, 2, -21 },
  { 1664, 16, 21, 17, 2, -21 },
  { 1706, 14, 21, 14, 3, -21 },
  { 1743, 22, 21, 23, 3, -21 },
  { 1801, 18, 21, 14, -2, -21 },
  { 1849, 13, 21, 13, 3, -21 },
  { 1884, 16, 21, 13, -1, -21 },
  { 1926, 11, 26, 8, 0, -21 },
  { 1962, 5, 21, 10, 3, -21 },
  { 1976, 11, 26, 8, -2, -21 },
  { 2012, 13, 13, 15, 1, -21 },
  { 2034, 11, 1, 10, -3, 3 },
  { 2036, 5, 4, 8, 4, -22 },
  { 2039, 14, 16, 15, 1, -16 },
  { 2067, 14, 22, 15, 0, -22 },
  { 2106, 11, 16, 12, 1, -16 },
  { 2128, 15, 22, 15, 1, -22 },
  { 2170, 12, 16, 13, 1, -16 },
  { 2194, 15, 29, 8, -3, -22 },
  { 2249, 15, 23, 15, 0, -16 },
  { 2293, 13, 22, 15, 1, -22 },
  { 2329, 7, 21, 7, 0, -21 },
  { 2348, 11, 28, 7, -4, -21 },
  { 2387, 14, 22, 13, 0, -22 },
  { 2426, 8, 22, 7, 0, -22 },
  { 2448, 21, 16, 23, 0, -16 },
  { 2490, 14, 16, 15, 0, -16 },
  { 2518, 13, 16, 15, 1, -16 },
  { 2544, 15, 23, 15, -1, -16 },
  { 2588, 14, 23, 15, 1, -16 },
  { 2629, 10, 16, 10, 1, -16 },
  { 2649, 11, 16, 11, 0, -16 },
  { 2671, 9, 19, 9, 1, -19 },
  { 2693, 13, 16, 15, 1, -16 },
  { 2719, 12, 16, 12, 2, -16 },
  { 2743, 18, 16, 19, 2, -16 },
  { 2779, 14, 16, 13, -1, -16 },
  { 2807, 17, 23, 12, -3, -16 },
  { 2856, 12, 16, 11, -1, -16 },
  { 2880, 11, 26, 10, 0, -21 },
  { 2916, 2, 29, 14, 6, -22 },
  { 2924, 11, 26, 10, -1, -21 },
  { 2960, 12, 4, 15, 2, -12 },
};

const GFXfont NotoSans_SemiCondensed_Italic29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic29pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC29PT7B_H_
