#ifndef _JETBRAINSMONO_MEDIUMITALIC35PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC1, 0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0xF8, 0xFC, 0x3C, 0x00, 0x78, 0x7B, 0xC3, 0xDE, 0x3C,
  0xF1, 0xE7, 0x8F, 0x38, 0x79, 0xC3, 0xDE, 0x1C, 0xF0, 0xE7, 0x87, 0x38,
  0x38, 0x00, 0x70, 0x70, 0x06, 0x06, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x01,
  0xC1, 0xC0, 0x1C, 0x1C, 0x01, 0xC1, 0xC1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x07, 0x07, 0x00, 0x70, 0x70, 0x07, 0x07, 0x00, 0xE0, 0xE0,
  0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x1C, 0x1C, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF,
  0x83, 0x83, 0x80, 0x38, 0x38, 0x03, 0x83, 0x80, 0x70, 0x70, 0x07, 0x07,
  0x00, 0x70, 0x70, 0x0E, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x07, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x3F,
  0xFF, 0x0F, 0x39, 0xE1, 0xE6, 0x3C, 0x78, 0xC7, 0x8F, 0x18, 0x01, 0xE3,
  0x00, 0x3E, 0x60, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x0E, 0x78, 0x01, 0x8F, 0x00, 0x30,
  0xE3, 0xC6, 0x3C, 0x78, 0xC7, 0x8F, 0x19, 0xF1, 0xF7, 0x7C, 0x3F, 0xFF,
  0x03, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x07, 0xF0, 0x0E,
  0x0F, 0xF8, 0x0E, 0x0E, 0x38, 0x1C, 0x1C, 0x38, 0x38, 0x1C, 0x38, 0x70,
  0x1C, 0x38, 0xE0, 0x1C, 0x39, 0xC0, 0x1C, 0x39, 0xC0, 0x1F, 0xF3, 0x80,
  0x0F, 0xE7, 0x00, 0x07, 0xCE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x77, 0xF0, 0x00, 0xEF, 0xF8, 0x01, 0xCE, 0x38,
  0x03, 0x9C, 0x38, 0x07, 0x1C, 0x38, 0x0E, 0x1C, 0x38, 0x1C, 0x1C, 0x38,
  0x1C, 0x1C, 0x70, 0x38, 0x1E, 0xF0, 0x70, 0x1F, 0xE0, 0xE0, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xE7, 0xC0, 0xF0, 0x78,
  0x1E, 0x07, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x83, 0xDE, 0x78, 0x7B,
  0xC7, 0x9E, 0x70, 0xF7, 0x9E, 0x0F, 0xE3, 0xC1, 0xFC, 0x78, 0x1F, 0x0F,
  0x03, 0xC1, 0xE0, 0x7C, 0x3C, 0x3F, 0x87, 0xFF, 0xF8, 0x7F, 0xE7, 0x87,
  0xF0, 0xF0, 0x7B, 0xDF, 0xEF, 0x7B, 0xDE, 0xE7, 0x38, 0x00, 0x02, 0x00,
  0x1C, 0x00, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x03,
  0x80, 0x04, 0x00, 0x1C, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x7E, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x40, 0xE0,
  0x5C, 0x38, 0xFF, 0xCC, 0xFF, 0xFB, 0x7F, 0x3F, 0xFF, 0x00, 0x70, 0x00,
  0x3E, 0x00, 0x1D, 0xC0, 0x0E, 0x78, 0x07, 0x9E, 0x03, 0xC3, 0xC1, 0xE0,
  0xF8, 0x38, 0x1C, 0x04, 0x04, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x00, 0x0F, 0xC3, 0xE1, 0xF0, 0x7C,
  0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x38, 0xFB, 0xFF, 0xEF, 0xCF, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0x7E,
  0x1E, 0x07, 0xC7, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x38, 0x03, 0xCE,
  0x00, 0xE7, 0x80, 0x39, 0xE7, 0x8E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x1E,
  0x79, 0xC0, 0x1E, 0x70, 0x07, 0x3C, 0x01, 0xCF, 0x00, 0xF3, 0xC0, 0x3C,
  0xF0, 0x0F, 0x3C, 0x07, 0x8F, 0x83, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0xFD,
  0xE0, 0x78, 0xE0, 0x38, 0xF0, 0x30, 0x78, 0x10, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7E,
  0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x03, 0xF7, 0xE0, 0xF0, 0x3E, 0x3C, 0x03,
  0xC7, 0x80, 0x78, 0xE0, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x23, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x3C, 0x03, 0xC7,
  0x80, 0x70, 0xF0, 0x1E, 0x1F, 0x07, 0x81, 0xFF, 0xF0, 0x3F, 0xFC, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0xF1, 0xE0, 0x71, 0xE0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E,
  0xF0, 0x0F, 0x7F, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFE, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x1E, 0x03, 0xDF, 0xE0, 0xFF,
  0xFC, 0x3F, 0x3F, 0x0F, 0x03, 0xC3, 0x80, 0xF0, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0xF0, 0x0E, 0x3C, 0x07, 0x8F,
  0x83, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF3, 0xC0, 0x3F, 0xFC,
  0x1F, 0xFF, 0x8F, 0xC3, 0xE3, 0xC0, 0x7D, 0xF0, 0x0F, 0x78, 0x03, 0xDE,
  0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x03, 0xC7, 0xC1,
  0xF0, 0xFF, 0xF8, 0x1F, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xBF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x7B, 0xC0, 0x39, 0xE0,
  0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03,
  0xF7, 0xE0, 0xF0, 0x3E, 0x1E, 0x03, 0xC3, 0x80, 0x78, 0xF0, 0x0E, 0x1E,
  0x03, 0xC1, 0xE0, 0xF0, 0x3E, 0x3E, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x03, 0xEF, 0xC0, 0xF0, 0x78, 0x3C, 0x07, 0x87, 0x00, 0xF1, 0xE0,
  0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x1E, 0x1F, 0x07, 0xC1, 0xFF,
  0xF0, 0x3F, 0xFC, 0x01, 0xFE, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x07, 0xFF,
  0xC7, 0xF7, 0xE3, 0xC0, 0xFB, 0xC0, 0x3D, 0xE0, 0x1E, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x01, 0xE7, 0x81, 0xF3, 0xFF, 0xF0,
  0xFF, 0x78, 0x3F, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x00, 0x06, 0x0F, 0x87, 0xE7, 0xF1, 0xF0, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x7C, 0x7E, 0x3F, 0x0F,
  0x00, 0x00, 0xC0, 0x3E, 0x03, 0xF0, 0x7F, 0x03, 0xE0, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x38, 0x07,
  0x80, 0x70, 0x0F, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x07, 0xE0, 0x0F,
  0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x70,
  0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0x01, 0x00, 0x3F, 0xFF, 0x9F,
  0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x9F, 0xFF, 0xDF, 0xFF, 0xE0, 0x20,
  0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x03, 0x80, 0x07, 0xC0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x70,
  0x00, 0x20, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0x83, 0xFF, 0x1F, 0xFE, 0x00,
  0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80,
  0x7C, 0x1F, 0xF0, 0xFF, 0x83, 0xF8, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0x81,
  0xE0, 0x70, 0x07, 0x87, 0x80, 0x1C, 0x78, 0x00, 0xE3, 0x80, 0x07, 0x1C,
  0x00, 0x39, 0xE0, 0xF9, 0xCE, 0x0F, 0xEE, 0x70, 0xF9, 0xF3, 0x87, 0x07,
  0x1C, 0x38, 0x38, 0xE3, 0xC1, 0xCF, 0x1E, 0x0E, 0x78, 0xE0, 0x73, 0x87,
  0x07, 0x9C, 0x38, 0x38, 0xE1, 0xC1, 0xC7, 0x0E, 0x1E, 0x38, 0x79, 0xF3,
  0xC3, 0xFB, 0x9E, 0x0F, 0x9C, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0x77, 0x00, 0x3D, 0xC0, 0x0F, 0x70, 0x03, 0x9C, 0x01, 0xE7, 0x00, 0x71,
  0xC0, 0x3C, 0x70, 0x0F, 0x1E, 0x03, 0x87, 0x81, 0xE1, 0xE0, 0x70, 0x78,
  0x3C, 0x1E, 0x0F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x3C,
  0x03, 0x8F, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0F, 0x78, 0x03, 0xFC, 0x00,
  0xF0, 0x0F, 0xF0, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xF0,
  0x3E, 0x1C, 0x03, 0xC3, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xC3, 0xC0,
  0x78, 0x78, 0x1E, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0x07,
  0xE1, 0xE0, 0x3C, 0x3C, 0x03, 0xC7, 0x00, 0x78, 0xE0, 0x0E, 0x3C, 0x01,
  0xC7, 0x80, 0x78, 0xF0, 0x1F, 0x1E, 0x0F, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC,
  0x1F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0x7E,
  0x1F, 0x07, 0xC7, 0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x3C,
  0xF0, 0x0F, 0x3C, 0x07, 0x87, 0x83, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07,
  0xF8, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0,
  0xF0, 0x7C, 0x1C, 0x07, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3,
  0xC0, 0x38, 0x78, 0x0F, 0x0E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8F,
  0x00, 0xF1, 0xE0, 0x1C, 0x3C, 0x03, 0x87, 0x80, 0xF0, 0xE0, 0x1E, 0x3C,
  0x03, 0xC7, 0x80, 0xF0, 0xF0, 0x3E, 0x1E, 0x3F, 0x83, 0xFF, 0xE0, 0x7F,
  0xF8, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F,
  0xFF, 0xE1, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F,
  0xFE, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xFF,
  0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F,
  0xFF, 0x8F, 0xFF, 0xF1, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xFF,
  0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF,
  0xC0, 0x7F, 0xF8, 0x3F, 0x7E, 0x1F, 0x07, 0xC7, 0x80, 0xF3, 0xC0, 0x3C,
  0xF0, 0x0F, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x3F, 0xE7, 0x8F, 0xF9, 0xE3, 0xFE, 0x78, 0x07, 0x1C, 0x03,
  0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x07, 0x87, 0x83, 0xE1,
  0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0x00, 0xF0, 0xF0, 0x0E,
  0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xE0, 0x1E, 0x0E, 0x01,
  0xE1, 0xE0, 0x1C, 0x1E, 0x03, 0xC1, 0xE0, 0x3C, 0x1E, 0x03, 0xC1, 0xFF,
  0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xC0, 0x78, 0x3C,
  0x07, 0x83, 0xC0, 0x78, 0x38, 0x07, 0x87, 0x80, 0x78, 0x78, 0x07, 0x07,
  0x80, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x70, 0x0F, 0x0F, 0x00, 0xF0,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x23, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x87, 0x80,
  0x78, 0x78, 0x07, 0x87, 0x80, 0xF0, 0x7C, 0x1F, 0x03, 0xFF, 0xE0, 0x3F,
  0xFC, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x78, 0x78, 0x07, 0x83, 0xC0, 0x7C,
  0x1E, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x03, 0xE0, 0x78, 0x1E, 0x03, 0xC1,
  0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0xF0, 0x07, 0x8F, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xF1, 0xE0, 0x07, 0x87, 0x80, 0x3C, 0x3C,
  0x01, 0xE1, 0xE0, 0x0E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C,
  0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x70, 0x07, 0x87, 0x80, 0x3C,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7F,
  0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0x0F, 0x01, 0xF0, 0xF8, 0x1F, 0x1F, 0x81,
  0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0x71, 0xF8, 0x76, 0x1D, 0x86, 0xE1, 0xD8,
  0xEE, 0x1D, 0xCE, 0xE3, 0xDD, 0xCE, 0x3D, 0xDD, 0xE3, 0x9F, 0x9C, 0x38,
  0xF9, 0xC3, 0x8F, 0x1C, 0x38, 0xF3, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7,
  0x80, 0x3C, 0x78, 0x03, 0x87, 0x00, 0x38, 0x70, 0x07, 0x8F, 0x00, 0x78,
  0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x0E, 0x00, 0x70, 0x0F, 0x80,
  0xF0, 0xF8, 0x0F, 0x0F, 0x80, 0xE0, 0xFC, 0x0E, 0x0F, 0xC0, 0xE0, 0xFC,
  0x1E, 0x1F, 0xC1, 0xE1, 0xFC, 0x1E, 0x1C, 0xE1, 0xC1, 0xCE, 0x1C, 0x1C,
  0xE1, 0xC1, 0xCE, 0x3C, 0x3C, 0xE3, 0xC3, 0xC7, 0x3C, 0x3C, 0x73, 0x83,
  0x87, 0x38, 0x38, 0x73, 0x83, 0x87, 0x38, 0x78, 0x7F, 0x87, 0x83, 0xF8,
  0x78, 0x3F, 0x87, 0x83, 0xF0, 0x70, 0x3F, 0x07, 0x03, 0xF0, 0x70, 0x1F,
  0x0F, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0x7E,
  0x1E, 0x07, 0xC7, 0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0x8F,
  0x01, 0xE3, 0x80, 0x78, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80,
  0x79, 0xE0, 0x1C, 0x78, 0x0F, 0x1C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C,
  0xF0, 0x0E, 0x3C, 0x07, 0x87, 0x83, 0xC1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x0F, 0x01, 0xF0, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00,
  0xF1, 0xE0, 0x0E, 0x1E, 0x01, 0xE1, 0xC0, 0x3E, 0x1F, 0xFF, 0xC3, 0xFF,
  0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0x80, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0,
  0x7F, 0xF8, 0x3F, 0x7E, 0x1E, 0x07, 0xC7, 0x80, 0xF3, 0xC0, 0x3C, 0xF0,
  0x0F, 0x3C, 0x03, 0xCE, 0x00, 0xE7, 0x80, 0x39, 0xE0, 0x1E, 0x78, 0x07,
  0x9E, 0x01, 0xE7, 0x80, 0x79, 0xC0, 0x1E, 0x70, 0x07, 0x3C, 0x03, 0xCF,
  0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x07, 0x8F, 0x83, 0xE1, 0xFF,
  0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0x03, 0xE0, 0xE0, 0x1E, 0x1E, 0x01,
  0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x03, 0xC1, 0xC0,
  0x7C, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3C,
  0x3C, 0x03, 0xC3, 0xC0, 0x38, 0x3C, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x70, 0x0F, 0x0F, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xF7, 0xF0, 0xF0, 0x1E,
  0x1E, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x3C, 0x03, 0xC7,
  0x80, 0x78, 0xF0, 0x1F, 0x1F, 0x07, 0xC3, 0xFF, 0xF0, 0x3F, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x0F, 0x01, 0xE1, 0xE0,
  0x3C, 0x38, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0x87, 0x80,
  0xF0, 0xF0, 0x1E, 0x1C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01,
  0xC3, 0xC0, 0x38, 0x78, 0x0F, 0x0E, 0x01, 0xE1, 0xC0, 0x3C, 0x78, 0x07,
  0x8F, 0x01, 0xE1, 0xE0, 0x3C, 0x1E, 0x0F, 0x03, 0xFF, 0xE0, 0x3F, 0xF8,
  0x03, 0xFC, 0x00, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7B, 0xC0, 0x1E,
  0xF0, 0x07, 0x1C, 0x03, 0xC7, 0x00, 0xF1, 0xC0, 0x78, 0x70, 0x1E, 0x1E,
  0x07, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0x87,
  0x01, 0xE3, 0xC0, 0x38, 0xE0, 0x0E, 0x78, 0x03, 0x9E, 0x00, 0xE7, 0x00,
  0x3B, 0xC0, 0x0E, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x00, 0x78, 0x78, 0x7B, 0x83, 0xC3, 0xDC, 0x1E, 0x1C, 0xE1, 0xF0,
  0xE7, 0x0D, 0x8F, 0x38, 0x7C, 0x71, 0xC3, 0xE3, 0x8E, 0x3F, 0x1C, 0x71,
  0xB1, 0xE3, 0x8D, 0x8E, 0x1C, 0xEC, 0x70, 0xE6, 0x63, 0x87, 0x33, 0x3C,
  0x39, 0x99, 0xC1, 0xDC, 0xCE, 0x1E, 0xC6, 0x70, 0xF6, 0x37, 0x07, 0x71,
  0xB8, 0x3B, 0x0D, 0xC1, 0xD8, 0x6E, 0x0E, 0xC3, 0xE0, 0x7E, 0x1F, 0x03,
  0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3C, 0x07, 0xC3, 0xE0, 0x00, 0x0F,
  0x00, 0x3C, 0x1E, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0xC1,
  0xE0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0x79, 0xE0, 0x01, 0xEF, 0x00,
  0x03, 0xBC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xDE, 0x00, 0x0F, 0x78,
  0x00, 0x79, 0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x78, 0x1E, 0x03,
  0xC0, 0x78, 0x1F, 0x01, 0xE0, 0x78, 0x03, 0xC3, 0xC0, 0x0F, 0x00, 0xE0,
  0x03, 0xFE, 0x00, 0x7B, 0xC0, 0x1E, 0x78, 0x03, 0xC7, 0x80, 0xF0, 0xF0,
  0x3C, 0x1E, 0x07, 0x81, 0xE1, 0xE0, 0x3C, 0x38, 0x07, 0x8F, 0x00, 0x73,
  0xC0, 0x0F, 0x78, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0xF8, 0x7F, 0xFF,
  0x1F, 0xFF, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0xC3, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF,
  0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x70, 0x0F, 0x01, 0xE0,
  0x3C, 0x03, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x0F,
  0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xC0,
  0x78, 0x0F, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xE0, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC3, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0xF0, 0x00,
  0xF0, 0x01, 0xF0, 0x03, 0xF8, 0x03, 0xB8, 0x07, 0xB8, 0x07, 0x3C, 0x0E,
  0x1C, 0x1E, 0x1C, 0x1C, 0x1C, 0x3C, 0x1E, 0x38, 0x0E, 0x70, 0x0E, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0xF0, 0xF0, 0xF0,
  0x00, 0x80, 0x41, 0xFC, 0xE0, 0xFF, 0xB8, 0x7F, 0xFE, 0x3E, 0x0F, 0x8F,
  0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x1E, 0x03, 0xC7, 0x80,
  0xF1, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x01, 0xE3, 0xC0, 0x78,
  0xF8, 0x3E, 0x1F, 0xFF, 0x87, 0xFD, 0xE0, 0xFE, 0x78, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x80, 0x79, 0xFC, 0x1E, 0xFF, 0x87, 0xFF, 0xE1, 0xF0, 0x7C, 0x78, 0x0F,
  0x1C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0E, 0x3C, 0x07, 0x8F,
  0x01, 0xE3, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x1F, 0x03, 0xC7, 0xC1,
  0xF1, 0xFF, 0xF8, 0x77, 0xFC, 0x3C, 0xFE, 0x00, 0x00, 0x60, 0x03, 0xFF,
  0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xE0, 0xF9, 0xE0, 0x3D, 0xE0, 0x1E, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x3D, 0xE0, 0x3C, 0x78, 0x3E, 0x3F, 0xFE, 0x0F, 0xFE,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x20, 0xF0, 0x3F, 0x9C, 0x0F, 0xFB,
  0x83, 0xFF, 0xF0, 0xF8, 0x3E, 0x1E, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F,
  0x1E, 0x01, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0E, 0x01, 0xE3, 0xC0, 0x3C,
  0x78, 0x07, 0x8F, 0x01, 0xE1, 0xE0, 0x3C, 0x3E, 0x0F, 0x83, 0xFF, 0xF0,
  0x7F, 0xDE, 0x07, 0xF3, 0xC0, 0x00, 0x60, 0x01, 0xFE, 0x03, 0xFF, 0x83,
  0xF7, 0xE3, 0xC0, 0xF1, 0xE0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07,
  0x3F, 0xFF, 0x9F, 0xFF, 0xCE, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x3C, 0x78, 0x3E, 0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x80, 0x41, 0xFC, 0xE0, 0xFF, 0xB8, 0x7F, 0xFE, 0x3E, 0x0F, 0x8F,
  0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x1E, 0x03, 0xC7, 0x80,
  0xF1, 0xC0, 0x3C, 0xF0, 0x0F, 0x3E, 0x07, 0xC7, 0x81, 0xE1, 0xFB, 0xB8,
  0x7F, 0xFE, 0x0F, 0xF7, 0x80, 0xF1, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x07, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x80, 0x79, 0xFC, 0x1E, 0xFF, 0x87, 0xFF, 0xE1, 0xF0, 0x7C,
  0x78, 0x0F, 0x1E, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x38, 0xF0, 0x1E, 0x3C,
  0x07, 0x8F, 0x01, 0xE3, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x1E, 0x01,
  0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x70, 0x0F, 0x3C, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x11, 0xE0, 0x1E, 0x1E,
  0x03, 0xC1, 0xE0, 0x7C, 0x1E, 0x0F, 0x81, 0xE0, 0xF0, 0x1C, 0x1E, 0x03,
  0xC3, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x80,
  0x38, 0x78, 0x03, 0x83, 0xC0, 0x78, 0x3C, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x80, 0xF0, 0x78, 0x0F, 0x0F, 0x00, 0xF8, 0x7F, 0xC0, 0xFF, 0x83,
  0xFF, 0x07, 0xFE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0xE0, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x41, 0x07,
  0xBC, 0xF8, 0xEF, 0xFF, 0x9E, 0x7C, 0xF3, 0x87, 0x1E, 0x70, 0xE3, 0xCE,
  0x1C, 0x7B, 0xC7, 0x0E, 0x78, 0xE1, 0xCF, 0x1C, 0x39, 0xC3, 0x87, 0x38,
  0x71, 0xE7, 0x0E, 0x3C, 0xE1, 0x87, 0x3C, 0x70, 0xE7, 0x8E, 0x1C, 0xE1,
  0xC3, 0x9C, 0x38, 0xF3, 0x87, 0x1E, 0x70, 0xC3, 0x80, 0x00, 0x08, 0x07,
  0x9F, 0xC1, 0xEF, 0xF8, 0x7F, 0xFE, 0x1F, 0x07, 0xC7, 0x80, 0xF1, 0xE0,
  0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E,
  0x38, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x71, 0xE0, 0x1C, 0x78, 0x0F, 0x1E,
  0x03, 0xC7, 0x00, 0xF3, 0xC0, 0x3C, 0x00, 0x60, 0x03, 0xFE, 0x03, 0xFF,
  0x83, 0xFF, 0xE3, 0xE0, 0xF1, 0xE0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78,
  0x07, 0xBC, 0x03, 0x9E, 0x03, 0xCE, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x7B,
  0xC0, 0x39, 0xE0, 0x3C, 0x78, 0x3C, 0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0xFC,
  0x00, 0x00, 0x04, 0x01, 0xE7, 0xF0, 0x3D, 0xFF, 0x07, 0xFF, 0xE0, 0xF8,
  0x3E, 0x1E, 0x03, 0xC3, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xC3, 0xC0,
  0x38, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00,
  0xE1, 0xF0, 0x3C, 0x3E, 0x0F, 0x87, 0xFF, 0xE0, 0xEF, 0xF8, 0x3C, 0xFE,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x80, 0x41, 0xFC, 0xE0, 0xFF, 0xB8, 0x7F, 0xFE,
  0x3E, 0x0F, 0x8F, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1C, 0x78, 0x07, 0x1E,
  0x03, 0xC7, 0x80, 0xF1, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x01,
  0xE3, 0xC0, 0x78, 0xF8, 0x3E, 0x1F, 0xFF, 0x87, 0xFD, 0xE0, 0xFE, 0x78,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x00, 0x18, 0x07, 0xBF, 0xC1, 0xDF, 0xF8, 0x77, 0xFE, 0x3F,
  0x07, 0xCF, 0x81, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x07, 0x8E, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x70, 0x03, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xF3, 0xC0, 0x79, 0xE0, 0x3C,
  0xE0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3D, 0xE0, 0x1C, 0xF0, 0x1E, 0x7F,
  0xFF, 0x1F, 0xFF, 0x07, 0xFE, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x00,
  0x3C, 0x03, 0xCF, 0x00, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x38, 0x07, 0x9E,
  0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80,
  0xF1, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x07, 0x8F, 0x81, 0xE1, 0xE0, 0xF0,
  0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0xF0, 0x07, 0xDC, 0x01, 0xE7,
  0x00, 0x71, 0xE0, 0x3C, 0x78, 0x0E, 0x1E, 0x07, 0x87, 0x81, 0xE0, 0xE0,
  0xF0, 0x38, 0x3C, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF3, 0xC0, 0x3C, 0xF0,
  0x07, 0x78, 0x01, 0xDE, 0x00, 0x77, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0xF0, 0xF0, 0xFF, 0x0F, 0x0E, 0xF1, 0xF0, 0xEF, 0x1F, 0x1C,
  0xF1, 0xF1, 0xCF, 0x1F, 0x1C, 0xE3, 0x73, 0x8E, 0x37, 0x38, 0xE3, 0x73,
  0x8E, 0x67, 0x70, 0xE6, 0x77, 0x0E, 0x67, 0x70, 0xEC, 0x76, 0x0E, 0xC7,
  0xE0, 0xEC, 0x7E, 0x0F, 0xC7, 0xE0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF8,
  0x7C, 0x00, 0x0F, 0x01, 0xF0, 0xF8, 0x1E, 0x07, 0x83, 0xC0, 0x7C, 0x78,
  0x03, 0xCF, 0x80, 0x1C, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xDE, 0x00, 0x79,
  0xE0, 0x0F, 0x1F, 0x01, 0xE0, 0xF0, 0x3C, 0x0F, 0x87, 0xC0, 0x78, 0xF8,
  0x07, 0xC0, 0x3C, 0x03, 0xCF, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x38,
  0x07, 0x9E, 0x01, 0xE7, 0x80, 0x71, 0xE0, 0x1C, 0x78, 0x0F, 0x1E, 0x03,
  0xC7, 0x00, 0xF3, 0xC0, 0x3C, 0xF8, 0x1F, 0x1E, 0x0F, 0x87, 0xFF, 0xE1,
  0xFF, 0xF8, 0x3F, 0xDE, 0x03, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x1F, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x0F,
  0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x7F,
  0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x03,
  0xFC, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x3E, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01,
  0xFF, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x03, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0xF0, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x27, 0xC0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0x00,
  0x3F, 0xC0, 0x3F, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF0, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0x01, 0xCF, 0xF0, 0xF7, 0xFC, 0x3F, 0xC7, 0x8E, 0xF1,
  0xFF, 0xB8, 0x3F, 0xCE, 0x07, 0xE0, 0x00, 0x40,
};

const GFXglyph JetBrainsMono_MediumItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 9, 26, 21, 6, -26 },
  { 31, 13, 11, 21, 6, -26 },
  { 49, 20, 26, 21, 1, -26 },
  { 114, 19, 35, 21, 1, -30 },
  { 198, 24, 26, 21, -1, -26 },
  { 276, 19, 26, 21, 1, -26 },
  { 338, 5, 11, 21, 10, -26 },
  { 345, 15, 34, 21, 5, -30 },
  { 409, 14, 34, 21, 2, -30 },
  { 469, 18, 18, 21, 2, -21 },
  { 510, 17, 17, 21, 2, -20 },
  { 547, 10, 11, 21, 3, -5 },
  { 561, 12, 3, 21, 5, -13 },
  { 566, 7, 6, 21, 6, -6 },
  { 572, 22, 33, 21, 0, -29 },
  { 663, 18, 26, 21, 2, -26 },
  { 722, 17, 26, 21, 1, -26 },
  { 778, 19, 26, 21, 1, -26 },
  { 840, 19, 26, 21, 1, -26 },
  { 902, 17, 26, 21, 2, -26 },
  { 958, 18, 26, 21, 2, -26 },
  { 1017, 18, 26, 21, 1, -26 },
  { 1076, 17, 26, 21, 4, -26 },
  { 1132, 19, 26, 21, 1, -26 },
  { 1194, 17, 26, 21, 3, -26 },
  { 1250, 9, 20, 21, 6, -20 },
  { 1273, 12, 26, 21, 3, -20 },
  { 1312, 17, 19, 21, 3, -21 },
  { 1353, 17, 12, 21, 2, -18 },
  { 1379, 17, 19, 21, 2, -21 },
  { 1420, 14, 26, 21, 5, -26 },
  { 1466, 21, 32, 21, 0, -26 },
  { 1550, 18, 26, 21, 0, -26 },
  { 1609, 19, 26, 21, 1, -26 },
  { 1671, 18, 26, 21, 2, -26 },
  { 1730, 19, 26, 21, 1, -26 },
  { 1792, 19, 26, 21, 2, -26 },
  { 1854, 19, 26, 21, 2, -26 },
  { 1916, 18, 26, 21, 2, -26 },
  { 1975, 20, 26, 21, 1, -26 },
  { 2040, 18, 26, 21, 2, -26 },
  { 2099, 20, 26, 21, 0, -26 },
  { 2164, 21, 26, 21, 1, -26 },
  { 2233, 16, 26, 21, 2, -26 },
  { 2285, 20, 26, 21, 1, -26 },
  { 2350, 20, 26, 21, 1, -26 },
  { 2415, 18, 26, 21, 2, -26 },
  { 2474, 20, 26, 21, 1, -26 },
  { 2539, 18, 32, 21, 2, -26 },
  { 2611, 20, 26, 21, 1, -26 },
  { 2676, 19, 26, 21, 1, -26 },
  { 2738, 18, 26, 21, 4, -26 },
  { 2797, 19, 26, 21, 2, -26 },
  { 2859, 18, 26, 21, 4, -26 },
  { 2918, 21, 26, 21, 2, -26 },
  { 2987, 22, 26, 21, 0, -26 },
  { 3059, 19, 26, 21, 4, -26 },
  { 3121, 19, 26, 21, 1, -26 },
  { 3183, 14, 33, 21, 5, -29 },
  { 3241, 11, 33, 21, 5, -29 },
  { 3287, 14, 33, 21, 3, -29 },
  { 3345, 16, 14, 21, 3, -26 },
  { 3373, 17, 3, 21, 0, 1 },
  { 3380, 7, 4, 21, 9, -27 },
  { 3384, 18, 20, 21, 2, -20 },
  { 3429, 18, 26, 21, 1, -26 },
  { 3488, 17, 20, 21, 2, -20 },
  { 3531, 19, 26, 21, 2, -26 },
  { 3593, 17, 20, 21, 2, -20 },
  { 3636, 24, 32, 21, -2, -26 },
  { 3732, 18, 26, 21, 2, -20 },
  { 3791, 18, 26, 21, 1, -26 },
  { 3850, 17, 27, 21, 1, -27 },
  { 3908, 19, 33, 21, 0, -27 },
  { 3987, 20, 26, 21, 1, -26 },
  { 4052, 15, 26, 21, 3, -26 },
  { 4101, 19, 20, 21, 1, -20 },
  { 4149, 18, 20, 21, 1, -20 },
  { 4194, 17, 20, 21, 2, -20 },
  { 4237, 19, 26, 21, 0, -20 },
  { 4299, 18, 26, 21, 2, -20 },
  { 4358, 18, 20, 21, 2, -20 },
  { 4403, 17, 20, 21, 2, -20 },
  { 4446, 17, 25, 21, 3, -25 },
  { 4500, 18, 19, 21, 2, -19 },
  { 4543, 18, 19, 21, 3, -19 },
  { 4586, 20, 19, 21, 2, -19 },
  { 4634, 20, 19, 21, 0, -19 },
  { 4682, 18, 25, 21, 2, -19 },
  { 4739, 18, 19, 21, 1, -19 },
  { 4782, 18, 33, 21, 3, -29 },
  { 4857, 9, 33, 21, 6, -29 },
  { 4895, 18, 33, 21, 1, -29 },
  { 4970, 18, 8, 21, 2, -16 },
};

const GFXfont JetBrainsMono_MediumItalic35pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic35pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic35pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _JETBRAINSMONO_MEDIUMITALIC35PT7B_H_
