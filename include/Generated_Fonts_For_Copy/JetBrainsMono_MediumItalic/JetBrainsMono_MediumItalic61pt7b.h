#ifndef _JETBRAINSMONO_MEDIUMITALIC61PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x83, 0xFF, 0x03, 0xFC, 0x07,
  0xF0, 0x00, 0x3F, 0x81, 0xFC, 0xFC, 0x07, 0xE7, 0xF0, 0x3F, 0x9F, 0xC0,
  0xFE, 0x7F, 0x03, 0xF9, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0x80, 0xFC,
  0x7E, 0x07, 0xF1, 0xF8, 0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0x81, 0xFC, 0xFC,
  0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07,
  0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x1F, 0x00,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0xF8, 0x03,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xE0, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x0F,
  0x80, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0x80,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0xF3, 0xFC, 0x03, 0xF8, 0x78, 0xFF,
  0x03, 0xF8, 0x38, 0x3F, 0x81, 0xFC, 0x3C, 0x1F, 0xC0, 0xFC, 0x1E, 0x0F,
  0xE0, 0x7E, 0x0F, 0x07, 0xF0, 0x7F, 0x07, 0x80, 0x00, 0x3F, 0x83, 0xC0,
  0x00, 0x1F, 0xC1, 0xC0, 0x00, 0x0F, 0xF0, 0xE0, 0x00, 0x07, 0xF8, 0xF0,
  0x00, 0x01, 0xFE, 0x78, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x38, 0xFF, 0x80, 0x00,
  0x3C, 0x3F, 0xC0, 0x00, 0x1E, 0x0F, 0xE0, 0x00, 0x0F, 0x07, 0xF0, 0x00,
  0x07, 0x83, 0xF8, 0x00, 0x03, 0xC1, 0xFC, 0x3F, 0x81, 0xC0, 0xFE, 0x1F,
  0xC0, 0xE0, 0x7F, 0x0F, 0xE0, 0xF0, 0x3F, 0x07, 0xF0, 0x78, 0x3F, 0x83,
  0xFC, 0x3C, 0x3F, 0x81, 0xFF, 0x1E, 0x3F, 0xC0, 0x7F, 0xEF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0xF0,
  0x00, 0x3E, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0x80, 0x1F, 0xFF, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x00,
  0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x00, 0x7C,
  0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x1F, 0x00, 0x03, 0xF0, 0x1F,
  0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x80, 0xFC, 0x7E,
  0x00, 0x01, 0xF0, 0x1F, 0x0F, 0x80, 0x00, 0x3F, 0x07, 0xE3, 0xE0, 0x00,
  0x03, 0xFF, 0xF8, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x3E, 0x00, 0x00, 0x07,
  0xFF, 0x8F, 0x80, 0x00, 0x00, 0x7F, 0xE3, 0xF0, 0x00, 0x00, 0x01, 0xC0,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE3, 0xFF, 0x80, 0x00,
  0x01, 0xF9, 0xFF, 0xF8, 0x00, 0x00, 0x3E, 0x3F, 0xFF, 0x00, 0x00, 0x0F,
  0x8F, 0xC7, 0xF0, 0x00, 0x03, 0xE3, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x7C,
  0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x1F,
  0x00, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x7C, 0x00,
  0x1F, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x01, 0xF0,
  0x07, 0xC0, 0x7C, 0x00, 0x7E, 0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x87, 0xE0, 0x03, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x3E, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xF9,
  0xFF, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0x1F, 0xC7, 0xF0, 0x1F, 0x87, 0xE1,
  0xFC, 0x0F, 0xE3, 0xF8, 0x3F, 0x87, 0xF0, 0xFC, 0x0F, 0xE1, 0xF8, 0x3F,
  0x01, 0xFC, 0xFC, 0x0F, 0xC0, 0x3F, 0x7F, 0x03, 0xF0, 0x0F, 0xFF, 0x81,
  0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0x00, 0x7F, 0xF0, 0x1F, 0xC0, 0x0F, 0xF8,
  0x07, 0xE0, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3F,
  0xC0, 0x1F, 0x80, 0x1F, 0xF8, 0x07, 0xF0, 0x0F, 0xFE, 0x01, 0xFE, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFB, 0xF8, 0x0F, 0xFF, 0xFC, 0xFE, 0x03, 0xFF,
  0xFE, 0x1F, 0xC0, 0x7F, 0xFF, 0x07, 0xF0, 0x07, 0xFF, 0x00, 0xFE, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0xCF, 0xE7, 0xE7, 0xF3, 0xF9, 0xFC,
  0xFE, 0x7F, 0x3F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x10, 0x03, 0xF0, 0x03, 0x1F, 0x00, 0xF0,
  0x0F, 0x8F, 0xE0, 0x78, 0x3F, 0xCF, 0xFC, 0x3C, 0x7F, 0xE7, 0xFF, 0x1C,
  0x7F, 0xF7, 0xFF, 0xCE, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xE0, 0x07,
  0xF8, 0x07, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x04, 0x00, 0x10, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0x87, 0xF9, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0xFF, 0x8F, 0xE0, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFE,
  0x01, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xE0,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xC0,
  0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0xC0,
  0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFE, 0x1F, 0x80,
  0x00, 0xFE, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x8F,
  0xF0, 0xFC, 0x3F, 0x8F, 0xF0, 0xFC, 0x3F, 0x8F, 0xF0, 0xFC, 0x3F, 0x07,
  0xF1, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x00, 0x81, 0xF8, 0x3F, 0x00,
  0x01, 0xF8, 0x7F, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x03, 0xF8, 0x7E, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0x7E, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0xE0,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFE, 0xFC, 0x00, 0x7F, 0xEF, 0xE0, 0x07, 0xFC, 0x7F, 0x00, 0x3F,
  0xC3, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x0F, 0x80, 0xFC, 0x00, 0x70, 0x07,
  0xE0, 0x03, 0x00, 0x7F, 0x00, 0x20, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07,
  0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC0,
  0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x0F, 0xC0, 0x3F, 0xC0, 0x1F, 0x80, 0xFF, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x80, 0x07,
  0xE0, 0xFE, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE1, 0xFF, 0x00, 0x0F,
  0xE7, 0xFF, 0xC0, 0x0F, 0xEF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x3F, 0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x1F,
  0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x7E,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x3F, 0xC0, 0x7F, 0xE0, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x60, 0x00, 0x3F, 0x9F, 0xF8, 0x01, 0xFD, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFC, 0x03,
  0xFE, 0x3F, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x3F,
  0xDF, 0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x7E, 0xFE, 0x00, 0x01, 0xFB, 0xF8,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFC, 0xFE, 0x00,
  0x07, 0xF3, 0xFC, 0x00, 0x3F, 0x87, 0xF8, 0x03, 0xFE, 0x1F, 0xF8, 0x3F,
  0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x9F, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0x3F, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0xFE, 0x07, 0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x01,
  0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x0F,
  0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F,
  0xE0, 0x1F, 0xC0, 0x0F, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x07,
  0xF0, 0x7F, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x03,
  0xF0, 0xFE, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x1F,
  0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE,
  0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF1,
  0xF8, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x01, 0xFC, 0xFC,
  0x00, 0x03, 0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xBF, 0x80, 0x1F, 0xFC,
  0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x07, 0xF8, 0x1F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0x83,
  0xFF, 0x07, 0xFC, 0x07, 0xF0, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0xFF, 0x03, 0xFE, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0x80, 0xFE, 0x00, 0x20, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xFE, 0x00,
  0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0,
  0x07, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0x80,
  0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE0, 0x04, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x1F,
  0xC0, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x78, 0x3E, 0x0F, 0xC0, 0x0F, 0xF9, 0xF0, 0x7E, 0x01, 0xFF,
  0xEF, 0x83, 0xE0, 0x1F, 0xFF, 0x7C, 0x1F, 0x00, 0xFF, 0xFF, 0xE0, 0xF8,
  0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x7E, 0x07, 0xE0, 0x0F,
  0x83, 0xF0, 0x3F, 0x00, 0x7C, 0x1F, 0x81, 0xF0, 0x07, 0xE0, 0xF8, 0x0F,
  0x80, 0x3F, 0x07, 0xC0, 0xFC, 0x01, 0xF8, 0x7E, 0x07, 0xE0, 0x0F, 0xC3,
  0xF0, 0x3F, 0x00, 0x7C, 0x1F, 0x81, 0xF8, 0x03, 0xE0, 0xFC, 0x0F, 0xC0,
  0x1F, 0x07, 0xC0, 0x7C, 0x01, 0xF8, 0x3E, 0x03, 0xE0, 0x0F, 0xC3, 0xF0,
  0x3F, 0x00, 0x7E, 0x1F, 0x81, 0xF8, 0x03, 0xE0, 0xFC, 0x0F, 0xC0, 0x3F,
  0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x3E, 0x01, 0xFF, 0xFF, 0xC1, 0xF0, 0x0F,
  0xFF, 0xBE, 0x0F, 0x80, 0x3F, 0xF9, 0xF0, 0xFC, 0x00, 0xFF, 0x9F, 0x87,
  0xE0, 0x01, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x02, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7F, 0x3F, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE0, 0xF8, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x01,
  0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x1F,
  0xC0, 0x7E, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xFC,
  0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0x80, 0x03,
  0xF0, 0x7F, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x1F,
  0xC7, 0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFE,
  0xFE, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x0F, 0xFC, 0x07, 0xF0, 0x01,
  0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x0F, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x80,
  0x01, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07,
  0xE0, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x01,
  0xFC, 0x3F, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xC3, 0xF8, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03,
  0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0xF1, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0,
  0x7F, 0xF8, 0x07, 0xF0, 0x03, 0xFE, 0x03, 0xF8, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x03, 0xF0, 0x3F, 0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x3F, 0x81,
  0xF8, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x07, 0xE0,
  0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xFC,
  0x0F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x3F,
  0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x01,
  0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0xFE, 0x03, 0xF0, 0x00, 0xFF, 0x01, 0xF8, 0x00, 0xFF, 0x01, 0xFC, 0x01,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC,
  0x3F, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0xFF, 0xFE, 0x1F, 0x81, 0xFF, 0xFC, 0x7F, 0x03, 0xFF, 0xF8, 0xFE, 0x07,
  0xFF, 0xF1, 0xFC, 0x1F, 0xFF, 0xC3, 0xF8, 0x3F, 0xFF, 0x87, 0xE0, 0x00,
  0x7F, 0x0F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8,
  0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x7E, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xE0, 0x1F, 0x80,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xFC, 0x03,
  0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x0F, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xF8, 0x07,
  0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x01,
  0xFC, 0x03, 0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x07, 0xE0, 0x1F, 0xC0, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x02, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x03,
  0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x1F,
  0x80, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xF8, 0x03,
  0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x7F,
  0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xF8,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x01, 0xF8, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x7E, 0x00, 0x03,
  0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x1F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x03,
  0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xDE, 0x03, 0xEF,
  0x00, 0x7F, 0xE0, 0x3E, 0xF0, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0,
  0x3E, 0xF8, 0x0F, 0x7E, 0x03, 0xEF, 0x81, 0xF7, 0xC0, 0x3E, 0xF8, 0x1E,
  0x7C, 0x07, 0xE7, 0x83, 0xE7, 0xC0, 0x7E, 0x78, 0x3E, 0xFC, 0x07, 0xE7,
  0xC7, 0xCF, 0xC0, 0x7E, 0x7C, 0x7C, 0xFC, 0x07, 0xE7, 0xCF, 0x8F, 0x80,
  0x7C, 0x7C, 0xF8, 0xF8, 0x07, 0xC7, 0xDF, 0x1F, 0x80, 0xFC, 0x3D, 0xF1,
  0xF8, 0x0F, 0xC3, 0xDE, 0x1F, 0x80, 0xFC, 0x3F, 0xE1, 0xF8, 0x0F, 0xC3,
  0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0xC3, 0xF0, 0x0F, 0xC3, 0xFC, 0x3F, 0x01,
  0xFC, 0x1F, 0x83, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x1F, 0x80, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x00, 0x7E, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7F, 0x00,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xFC, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xC0, 0x7F,
  0xC0, 0x03, 0xF0, 0x1F, 0xF0, 0x00, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0x01,
  0xFF, 0x00, 0x1F, 0x80, 0x7F, 0xE0, 0x07, 0xE0, 0x3F, 0xF8, 0x01, 0xF8,
  0x0F, 0xFE, 0x00, 0x7E, 0x03, 0xFF, 0x80, 0x1F, 0x80, 0xFB, 0xE0, 0x07,
  0xE0, 0x3E, 0xFC, 0x03, 0xF0, 0x0F, 0xBF, 0x00, 0xFC, 0x07, 0xEF, 0xC0,
  0x3F, 0x01, 0xF9, 0xF0, 0x0F, 0xC0, 0x7E, 0x7C, 0x03, 0xF0, 0x1F, 0x9F,
  0x00, 0xFC, 0x07, 0xE7, 0xE0, 0x7F, 0x01, 0xF9, 0xF8, 0x1F, 0x80, 0xFE,
  0x3E, 0x07, 0xE0, 0x3F, 0x0F, 0x81, 0xF8, 0x0F, 0xC3, 0xE0, 0x7E, 0x03,
  0xF0, 0xFC, 0x1F, 0x80, 0xFC, 0x3F, 0x0F, 0xE0, 0x3F, 0x07, 0xC3, 0xF0,
  0x1F, 0xC1, 0xF0, 0xFC, 0x07, 0xE0, 0x7C, 0x3F, 0x01, 0xF8, 0x1F, 0x8F,
  0xC0, 0x7E, 0x07, 0xE3, 0xF0, 0x1F, 0x80, 0xF8, 0xFC, 0x07, 0xE0, 0x3E,
  0x7E, 0x01, 0xF8, 0x0F, 0x9F, 0x80, 0xFE, 0x03, 0xF7, 0xE0, 0x3F, 0x00,
  0xFD, 0xF8, 0x0F, 0xC0, 0x1F, 0x7E, 0x03, 0xF0, 0x07, 0xDF, 0x80, 0xFC,
  0x01, 0xF7, 0xC0, 0x3F, 0x00, 0x7F, 0xF0, 0x1F, 0xC0, 0x1F, 0xFC, 0x07,
  0xE0, 0x07, 0xFF, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x7E, 0x00, 0x3F, 0xF0,
  0x1F, 0x80, 0x0F, 0xFC, 0x07, 0xE0, 0x03, 0xFE, 0x03, 0xF8, 0x00, 0xFF,
  0x80, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x00,
  0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0x80, 0x01, 0xFC,
  0x3F, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x0F, 0xC3,
  0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0xFE, 0x1F,
  0x80, 0x01, 0xF8, 0x7F, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x07, 0xE1, 0xFC,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x7F, 0x0F, 0xC0,
  0x00, 0xFE, 0x3F, 0x80, 0x01, 0xF8, 0x7F, 0x00, 0x03, 0xF0, 0xFE, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0x7E, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F,
  0xE0, 0x3F, 0xF1, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0xFF, 0xE0,
  0x1F, 0xC0, 0x03, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x03,
  0xF8, 0x0F, 0xC0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x07, 0xF0,
  0x1F, 0x80, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x1F,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFE,
  0x03, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x07, 0xF0,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0xC0,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0xFE, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80,
  0x01, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x01, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0xE0,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xF8,
  0x0F, 0xE0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F,
  0xE0, 0x3F, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x1F, 0x81, 0xFC, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x1F, 0xC0, 0x7E,
  0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x07, 0xF8, 0x0F, 0xE0, 0x07, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xE0, 0x1F,
  0xC0, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xF0, 0x07,
  0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0,
  0x1F, 0xC0, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x03,
  0xF8, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x3F, 0x80,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x07, 0xF0,
  0x00, 0x3F, 0x83, 0xFC, 0x00, 0x3F, 0x81, 0xFF, 0x00, 0x3F, 0xC0, 0x7F,
  0xF0, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0,
  0x7E, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8,
  0x1F, 0xC0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F,
  0xC0, 0xFE, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03,
  0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0xFE, 0x07, 0xE0, 0x00,
  0x7E, 0x07, 0xF0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x07, 0xF0, 0x3F, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0xFC, 0x0F, 0xE0,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xF8,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x07, 0xE0, 0x7F,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F,
  0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFE,
  0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xE1,
  0xF8, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFC, 0x0F,
  0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0x3F,
  0x00, 0x3F, 0x80, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8,
  0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0x0F, 0xC0,
  0x3F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7F, 0x03,
  0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x7F,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC7, 0xF0,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0xF8, 0x07, 0xF0,
  0x0F, 0x87, 0xC0, 0x3F, 0x80, 0xFC, 0x3E, 0x01, 0xFC, 0x07, 0xE3, 0xF0,
  0x1F, 0xE0, 0x3F, 0x1F, 0x80, 0xFF, 0x01, 0xF0, 0xFC, 0x07, 0xF8, 0x1F,
  0x87, 0xE0, 0x3B, 0xC0, 0xFC, 0x3F, 0x03, 0xDC, 0x07, 0xE1, 0xF8, 0x1E,
  0xE0, 0x3E, 0x0F, 0xC0, 0xF7, 0x03, 0xF0, 0x7E, 0x07, 0x38, 0x1F, 0x83,
  0xF0, 0x79, 0xC0, 0xF8, 0x1F, 0x83, 0xDE, 0x07, 0xC0, 0xFC, 0x1E, 0xF0,
  0x7E, 0x07, 0xC1, 0xE7, 0x83, 0xF0, 0x3E, 0x0F, 0x3C, 0x1F, 0x01, 0xF0,
  0x79, 0xE0, 0xF8, 0x0F, 0x83, 0x8F, 0x0F, 0xC0, 0x7C, 0x3C, 0x78, 0x7E,
  0x03, 0xE1, 0xE3, 0xC3, 0xE0, 0x1F, 0x0F, 0x1E, 0x1F, 0x00, 0xF8, 0xF0,
  0xF1, 0xF8, 0x0F, 0xC7, 0x87, 0x8F, 0x80, 0x7E, 0x3C, 0x3C, 0x7C, 0x03,
  0xF1, 0xE1, 0xE3, 0xE0, 0x1F, 0x9E, 0x0F, 0x3F, 0x00, 0xFC, 0xF0, 0x79,
  0xF0, 0x07, 0xE7, 0x83, 0xCF, 0x80, 0x3F, 0x78, 0x1E, 0x7C, 0x01, 0xF3,
  0xC0, 0xE7, 0xE0, 0x0F, 0x9E, 0x07, 0x3E, 0x00, 0x7C, 0xF0, 0x39, 0xF0,
  0x03, 0xEF, 0x01, 0xCF, 0x80, 0x1F, 0x78, 0x1E, 0xF8, 0x00, 0xFB, 0xC0,
  0xF7, 0xC0, 0x07, 0xDC, 0x07, 0xBE, 0x00, 0x3F, 0xE0, 0x3D, 0xF0, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x7F,
  0xC0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x0F, 0xF0,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x01,
  0xFD, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x0F, 0xE1, 0xF8, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0x80,
  0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8,
  0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03,
  0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x3F,
  0x3E, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0xC1, 0xF0,
  0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x7E,
  0x00, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F,
  0xC1, 0xF8, 0x00, 0x7C, 0x3F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x7E,
  0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xC0,
  0x7E, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x7E, 0x00, 0xFF, 0xF1, 0xFC, 0x03,
  0xFF, 0xF3, 0xF8, 0x0F, 0xFF, 0xF7, 0xF0, 0x3F, 0xFF, 0xEF, 0xC0, 0xFF,
  0xFF, 0xDF, 0x81, 0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xE0,
  0x03, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFC, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7E, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF0,
  0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x83,
  0xFC, 0x01, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0xFD, 0xFC, 0x0F,
  0xFF, 0xFB, 0xF0, 0x0F, 0xFF, 0xE7, 0xE0, 0x0F, 0xFF, 0x8F, 0xC0, 0x0F,
  0xFC, 0x3F, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0x83, 0xFC, 0x00, 0x3F, 0x1F, 0xFE, 0x00, 0xFE, 0x7F,
  0xFE, 0x01, 0xFD, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xEF, 0xFF,
  0xFC, 0x0F, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x07,
  0xF0, 0xFF, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F,
  0x87, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8,
  0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3,
  0xF0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x3F,
  0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x1F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFE, 0x1F, 0xF0,
  0x07, 0xF8, 0x3F, 0xF8, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x01, 0xF9, 0xFF, 0xFC, 0x03, 0xF1, 0xFF, 0xF0, 0x0F, 0xE1, 0xFF,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0x87, 0xF8, 0x01, 0xFE,
  0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x8F,
  0xC0, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F,
  0xC0, 0x0F, 0xE0, 0x7F, 0xE1, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x01, 0xFE, 0x0F, 0xC0, 0x07, 0xFF, 0x8F, 0xE0,
  0x07, 0xFF, 0xE7, 0xF0, 0x07, 0xFF, 0xFB, 0xF8, 0x07, 0xFF, 0xFD, 0xFC,
  0x07, 0xFF, 0xFE, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0xFF,
  0x01, 0xFC, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x03,
  0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x7F, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x0F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0xFF,
  0xC1, 0xFF, 0xC0, 0x3F, 0xFF, 0xEF, 0xE0, 0x1F, 0xFF, 0xF7, 0xE0, 0x07,
  0xFF, 0xF3, 0xF0, 0x01, 0xFF, 0xF1, 0xF8, 0x00, 0x7F, 0xE1, 0xFC, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x03, 0xFC,
  0x0F, 0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x03,
  0xF9, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0x7E, 0x00, 0x07, 0xF3,
  0xF0, 0x00, 0x3F, 0x3F, 0x80, 0x01, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFD, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x3F, 0x80, 0x07, 0xF1, 0xFE, 0x00, 0x7F, 0x07, 0xF8, 0x07,
  0xF8, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0xFC, 0x03, 0xFF, 0xC7,
  0xF0, 0x1F, 0xFF, 0x9F, 0xC0, 0xFF, 0xFF, 0x7F, 0x07, 0xFF, 0xFD, 0xF8,
  0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0x00, 0xFF, 0x87, 0xF8, 0x01, 0xFE, 0x1F,
  0xC0, 0x07, 0xF8, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x8F, 0xC0,
  0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x0F, 0xC7, 0xF0, 0x00,
  0x7F, 0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0xFE, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0xFF,
  0x00, 0x3F, 0xC1, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0xFE, 0xFC, 0x1F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xDF, 0xC0, 0x7F, 0xFE, 0x7F, 0x00, 0xFF, 0xE1,
  0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0x83, 0xFC, 0x00, 0x3F, 0x1F, 0xFE, 0x00, 0xFE, 0x7F, 0xFE,
  0x01, 0xFD, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xEF, 0xDF, 0xFC,
  0x0F, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0,
  0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF8, 0x7F,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0x80,
  0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01,
  0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x7E,
  0x00, 0x07, 0xF8, 0x3F, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x07, 0xF8, 0x1F,
  0xC0, 0x07, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x03, 0xF8, 0x03,
  0xF0, 0x03, 0xFC, 0x01, 0xF8, 0x03, 0xFC, 0x00, 0xFC, 0x03, 0xFC, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x81, 0xFE, 0x00,
  0x1F, 0x81, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x3F, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0xFF, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F,
  0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xFC, 0x01, 0xF8, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x0F, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xFE, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xE3, 0xE0, 0x7E, 0x01, 0xFB,
  0xFC, 0x3F, 0xC0, 0x7C, 0xFF, 0x9F, 0xF8, 0x1F, 0x7F, 0xEF, 0xFE, 0x07,
  0xFF, 0xFB, 0xFF, 0x83, 0xF8, 0x3F, 0x87, 0xF0, 0xFE, 0x0F, 0xC1, 0xFC,
  0x3F, 0x03, 0xE0, 0x3F, 0x0F, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x3E, 0x07,
  0xE0, 0xFC, 0x0F, 0x81, 0xF8, 0x7E, 0x03, 0xE0, 0x7E, 0x1F, 0x80, 0xF8,
  0x1F, 0x87, 0xE0, 0x7C, 0x07, 0xE1, 0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x07,
  0xC0, 0xFC, 0x1F, 0x81, 0xF0, 0x3F, 0x07, 0xC0, 0x7C, 0x0F, 0xC3, 0xF0,
  0x1F, 0x03, 0xF0, 0xFC, 0x0F, 0x80, 0xFC, 0x3F, 0x03, 0xE0, 0x3E, 0x0F,
  0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x0F, 0x81, 0xF8,
  0x7E, 0x03, 0xE0, 0x7E, 0x1F, 0x81, 0xF0, 0x1F, 0x87, 0xE0, 0x7C, 0x07,
  0xE1, 0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0xFC, 0x1F, 0x81, 0xF0,
  0x3F, 0x0F, 0xC0, 0x7C, 0x0F, 0xC3, 0xF0, 0x1F, 0x03, 0xF0, 0xFC, 0x0F,
  0x80, 0xFC, 0x3F, 0x03, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x7F, 0x80, 0x07,
  0xE3, 0xFF, 0xC0, 0x1F, 0xCF, 0xFF, 0xC0, 0x3F, 0xBF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xC0, 0xFD, 0xFB, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80,
  0x03, 0xF8, 0x7F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01,
  0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE,
  0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x07, 0xE1, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x00, 0xFE,
  0x1F, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0x7E,
  0x00, 0x07, 0xF3, 0xF0, 0x00, 0x3F, 0x3F, 0x80, 0x01, 0xF9, 0xFC, 0x00,
  0x0F, 0xCF, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x3F,
  0x9F, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x7E, 0x7F,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC, 0xFE, 0x00,
  0x0F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0xFF,
  0x07, 0xFE, 0x3F, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xF8, 0x3F, 0xC0, 0x01, 0xF8, 0xFF, 0xF0, 0x03, 0xF9,
  0xFF, 0xF8, 0x03, 0xFB, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xF7,
  0xFF, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x7F, 0x07, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x7E, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0xFE, 0x0F, 0xC0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0,
  0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0,
  0x07, 0xF8, 0x3F, 0xF0, 0x0F, 0xF0, 0x3F, 0xFC, 0x3F, 0xF0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xBF, 0xFF, 0xC0, 0x3F, 0x3F, 0xFF, 0x80, 0x3F, 0x1F,
  0xFF, 0x00, 0x7F, 0x0F, 0xFC, 0x00, 0x7F, 0x01, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x7E, 0x00, 0xFF, 0xF1, 0xFC, 0x03, 0xFF,
  0xF3, 0xF8, 0x0F, 0xFF, 0xF7, 0xF0, 0x3F, 0xFF, 0xEF, 0xC0, 0xFF, 0xFF,
  0xDF, 0x83, 0xFE, 0x03, 0xBF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x03,
  0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE,
  0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7E, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF0, 0x7F,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x83, 0xFC,
  0x01, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0xFD, 0xF8, 0x0F, 0xFF,
  0xFB, 0xF0, 0x0F, 0xFF, 0xE7, 0xE0, 0x0F, 0xFF, 0x9F, 0xC0, 0x0F, 0xFC,
  0x3F, 0x80, 0x01, 0xC0, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0xFF,
  0x80, 0x0F, 0xC7, 0xFF, 0xC0, 0x1F, 0x9F, 0xFF, 0xC0, 0x7F, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFB, 0xF7, 0xFF, 0x83, 0xFE, 0x01, 0xFF,
  0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xF8,
  0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3,
  0xF0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x7F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3,
  0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x7E, 0x3F, 0xC0, 0x03, 0xF8, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x1F, 0xC0, 0x01, 0xFC, 0x3F,
  0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xF8,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x1F, 0xC0,
  0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x00,
  0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07,
  0xF0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF0,
  0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x7F, 0x03,
  0xFC, 0x01, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x68, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00,
  0x07, 0xF1, 0xF8, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x03,
  0xF8, 0x7E, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xF8,
  0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x01, 0xFC, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0xFC, 0x00, 0x7E,
  0x07, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x1F, 0x83,
  0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFD, 0xFC, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0x00, 0xFC, 0x03, 0xEF,
  0xC0, 0x7F, 0x00, 0xFB, 0xF0, 0x1F, 0xC0, 0x7E, 0xFC, 0x07, 0xF0, 0x1F,
  0x3F, 0x03, 0xFC, 0x07, 0xCF, 0xC0, 0xFF, 0x03, 0xF3, 0xF0, 0x3B, 0xC0,
  0xF8, 0xFC, 0x1E, 0xF0, 0x3E, 0x3F, 0x07, 0xBC, 0x1F, 0x8F, 0xC1, 0xEF,
  0x07, 0xC3, 0xF0, 0x73, 0xC1, 0xF0, 0xFC, 0x3C, 0xF0, 0xFC, 0x3F, 0x0F,
  0x3C, 0x3E, 0x0F, 0xC3, 0x8F, 0x0F, 0x83, 0xE1, 0xE3, 0xC3, 0xE0, 0xF8,
  0x78, 0xF1, 0xF0, 0x3E, 0x1C, 0x3C, 0x7C, 0x0F, 0x8F, 0x0F, 0x1F, 0x03,
  0xE3, 0xC3, 0xCF, 0x80, 0xF8, 0xE0, 0xF3, 0xE0, 0x3E, 0x78, 0x3C, 0xF8,
  0x0F, 0x9E, 0x0F, 0x7E, 0x03, 0xE7, 0x83, 0xDF, 0x00, 0xFB, 0xC0, 0xF7,
  0xC0, 0x3E, 0xF0, 0x3D, 0xF0, 0x0F, 0xBC, 0x0F, 0xF8, 0x03, 0xEE, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x01, 0xFC, 0x7F,
  0x00, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00,
  0x07, 0xF1, 0xFC, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0xFE,
  0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x07, 0xF0,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x0F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF8, 0xFE,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00,
  0x03, 0xF1, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x01,
  0xFC, 0x7F, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E,
  0x1F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x8F,
  0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF,
  0x07, 0xBF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xF7, 0xF0, 0x3F, 0xFF,
  0x9F, 0xC0, 0x7F, 0xFC, 0x7E, 0x00, 0x7F, 0xE1, 0xF8, 0x00, 0x18, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC,
  0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8,
  0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x3F, 0x0F, 0xFF, 0x80, 0x3E, 0x1F, 0xFF, 0xC0, 0x7E, 0x3F, 0xFF,
  0xC0, 0x7E, 0x3F, 0x1F, 0xE0, 0x7E, 0x7E, 0x0F, 0xF0, 0x7E, 0x7E, 0x07,
  0xF8, 0xFC, 0x7E, 0x03, 0xFF, 0xFC, 0x7E, 0x03, 0xFF, 0xF8, 0x7C, 0x01,
  0xFF, 0xF0, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x80,
};

const GFXglyph JetBrainsMono_MediumItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 15, 45, 37, 11, -45 },
  { 86, 22, 19, 37, 11, -45 },
  { 139, 36, 45, 37, 1, -45 },
  { 342, 33, 62, 37, 2, -53 },
  { 598, 43, 45, 37, -2, -45 },
  { 840, 34, 46, 37, 1, -45 },
  { 1036, 9, 19, 37, 17, -45 },
  { 1058, 26, 60, 37, 9, -52 },
  { 1253, 26, 60, 37, 3, -52 },
  { 1448, 33, 32, 37, 3, -37 },
  { 1580, 30, 29, 37, 4, -35 },
  { 1689, 17, 19, 37, 5, -9 },
  { 1730, 21, 6, 37, 8, -23 },
  { 1746, 11, 11, 37, 11, -10 },
  { 1762, 38, 58, 37, 0, -51 },
  { 2038, 32, 46, 37, 3, -45 },
  { 2222, 29, 45, 37, 3, -45 },
  { 2386, 33, 45, 37, 2, -45 },
  { 2572, 32, 46, 37, 3, -45 },
  { 2756, 31, 45, 37, 3, -45 },
  { 2931, 32, 46, 37, 3, -45 },
  { 3115, 30, 46, 37, 3, -45 },
  { 3288, 30, 45, 37, 7, -45 },
  { 3457, 32, 46, 37, 3, -45 },
  { 3641, 31, 45, 37, 5, -45 },
  { 3816, 15, 35, 37, 11, -34 },
  { 3882, 20, 44, 37, 6, -34 },
  { 3992, 30, 33, 37, 5, -37 },
  { 4116, 30, 21, 37, 4, -31 },
  { 4195, 30, 33, 37, 3, -37 },
  { 4319, 26, 45, 37, 8, -45 },
  { 4466, 37, 56, 37, 0, -45 },
  { 4725, 31, 45, 37, 0, -45 },
  { 4900, 33, 45, 37, 2, -45 },
  { 5086, 31, 46, 37, 4, -45 },
  { 5265, 33, 45, 37, 2, -45 },
  { 5451, 33, 45, 37, 3, -45 },
  { 5637, 34, 45, 37, 3, -45 },
  { 5829, 31, 46, 37, 4, -45 },
  { 6008, 34, 45, 37, 2, -45 },
  { 6200, 32, 45, 37, 3, -45 },
  { 6380, 34, 46, 37, 1, -45 },
  { 6576, 36, 45, 37, 2, -45 },
  { 6779, 27, 45, 37, 4, -45 },
  { 6931, 36, 45, 37, 1, -45 },
  { 7134, 34, 45, 37, 2, -45 },
  { 7326, 31, 46, 37, 4, -45 },
  { 7505, 35, 45, 37, 2, -45 },
  { 7702, 32, 56, 37, 3, -45 },
  { 7926, 34, 45, 37, 2, -45 },
  { 8118, 33, 46, 37, 2, -45 },
  { 8308, 31, 45, 37, 7, -45 },
  { 8483, 33, 46, 37, 3, -45 },
  { 8673, 31, 45, 37, 7, -45 },
  { 8848, 37, 45, 37, 3, -45 },
  { 9057, 39, 45, 37, -1, -45 },
  { 9277, 33, 45, 37, 6, -45 },
  { 9463, 33, 45, 37, 2, -45 },
  { 9649, 25, 58, 37, 8, -51 },
  { 9831, 20, 58, 37, 9, -51 },
  { 9976, 25, 58, 37, 5, -51 },
  { 10158, 28, 24, 37, 5, -45 },
  { 10242, 30, 5, 37, 0, 2 },
  { 10261, 12, 9, 37, 16, -48 },
  { 10275, 31, 35, 37, 3, -34 },
  { 10411, 31, 46, 37, 2, -45 },
  { 10590, 30, 35, 37, 4, -34 },
  { 10722, 33, 46, 37, 3, -45 },
  { 10912, 29, 35, 37, 4, -34 },
  { 11039, 42, 56, 37, -3, -45 },
  { 11333, 30, 45, 37, 4, -34 },
  { 11502, 31, 45, 37, 2, -45 },
  { 11677, 30, 48, 37, 2, -48 },
  { 11857, 32, 59, 37, 1, -48 },
  { 12093, 33, 45, 37, 3, -45 },
  { 12279, 26, 45, 37, 6, -45 },
  { 12426, 34, 34, 37, 1, -34 },
  { 12571, 31, 34, 37, 2, -34 },
  { 12703, 29, 35, 37, 4, -34 },
  { 12830, 32, 45, 37, 1, -34 },
  { 13010, 31, 45, 37, 3, -34 },
  { 13185, 31, 34, 37, 4, -34 },
  { 13317, 30, 35, 37, 3, -34 },
  { 13449, 30, 43, 37, 5, -43 },
  { 13611, 31, 35, 37, 3, -34 },
  { 13747, 30, 34, 37, 6, -34 },
  { 13875, 34, 34, 37, 4, -34 },
  { 14020, 36, 34, 37, 0, -34 },
  { 14173, 30, 45, 37, 4, -34 },
  { 14342, 31, 34, 37, 2, -34 },
  { 14474, 32, 58, 37, 5, -51 },
  { 14706, 16, 58, 37, 11, -51 },
  { 14822, 32, 58, 37, 1, -51 },
  { 15054, 32, 13, 37, 3, -28 },
};

const GFXfont JetBrainsMono_MediumItalic61pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic61pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic61pt7bGlyphs,
  0x20, 0x7E, 81
};

#endif // _JETBRAINSMONO_MEDIUMITALIC61PT7B_H_
