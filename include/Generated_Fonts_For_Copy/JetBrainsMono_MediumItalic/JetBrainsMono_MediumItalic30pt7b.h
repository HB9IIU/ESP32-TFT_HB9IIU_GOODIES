#ifndef _JETBRAINSMONO_MEDIUMITALIC30PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x18, 0x18, 0x00, 0x00, 0x00, 0x30, 0x78, 0x78, 0x78, 0x78,
  0xEE, 0x3D, 0xC7, 0xB8, 0xE7, 0x1C, 0xE3, 0xB8, 0x77, 0x0E, 0xE1, 0x80,
  0x01, 0xC3, 0x80, 0xC1, 0x80, 0x61, 0xC0, 0x70, 0xE0, 0x30, 0x60, 0x18,
  0x70, 0xFF, 0xFE, 0x7F, 0xFF, 0x06, 0x1C, 0x07, 0x0E, 0x03, 0x06, 0x01,
  0x87, 0x01, 0xC3, 0x80, 0xC1, 0x83, 0xFF, 0xF9, 0xFF, 0xFC, 0x30, 0x60,
  0x18, 0x70, 0x1C, 0x38, 0x0C, 0x18, 0x06, 0x1C, 0x07, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x01, 0xFC, 0x07, 0xFE, 0x0F,
  0xFF, 0x1E, 0x6F, 0x1C, 0x47, 0x1C, 0xC7, 0x1C, 0xC0, 0x1C, 0xC0, 0x1E,
  0xC0, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFC, 0x01, 0xBE, 0x01,
  0x9E, 0x01, 0x9E, 0xF1, 0x9E, 0xF1, 0x1C, 0x73, 0x3C, 0x7F, 0xF8, 0x3F,
  0xF0, 0x1F, 0xE0, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07,
  0xC0, 0x38, 0x7F, 0x03, 0x87, 0x18, 0x38, 0x38, 0xE1, 0x81, 0x86, 0x18,
  0x0C, 0x31, 0x80, 0x61, 0x9C, 0x03, 0x9D, 0xC0, 0x1F, 0xDC, 0x00, 0x7D,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0xF0, 0x00, 0xEF, 0xE0,
  0x0E, 0xE7, 0x00, 0xE6, 0x18, 0x0E, 0x30, 0xC0, 0x63, 0x86, 0x06, 0x1C,
  0x70, 0x70, 0xE3, 0x07, 0x03, 0xF8, 0x70, 0x0F, 0x80, 0x03, 0xF8, 0x07,
  0xFC, 0x0F, 0xFC, 0x0E, 0x1E, 0x1C, 0x0E, 0x1C, 0x10, 0x1C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x7B, 0x87, 0x73, 0x8E, 0xF1,
  0xCE, 0xE1, 0xFC, 0xE0, 0xF8, 0xE0, 0xF8, 0xE0, 0x70, 0xE0, 0xF8, 0xFB,
  0xF8, 0xFF, 0x9C, 0x7F, 0x1E, 0x7B, 0xDC, 0xE7, 0x3B, 0xDC, 0xE0, 0x00,
  0x18, 0x03, 0xC0, 0x7E, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x38, 0x03, 0xC0,
  0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01,
  0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x1E,
  0x0F, 0xC0, 0xF8, 0x0E, 0x00, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x18, 0x03, 0x0C, 0x33, 0xE6, 0xFB, 0xFA, 0xFC, 0x3F, 0xF8,
  0x01, 0xC0, 0x03, 0xF0, 0x03, 0xB8, 0x03, 0xCE, 0x03, 0xC7, 0x81, 0xC1,
  0xC0, 0x40, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x1F, 0x1E, 0x1E, 0x3C, 0x3C, 0x78,
  0x70, 0x70, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x39, 0xFF, 0xFE, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xF8, 0x7F,
  0xF9, 0xE0, 0xF3, 0x80, 0xE7, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x1E,
  0xE7, 0x39, 0xDE, 0x73, 0x9C, 0xEF, 0x39, 0xDC, 0x03, 0xB8, 0x07, 0x70,
  0x1C, 0xE0, 0x39, 0xC0, 0x73, 0xC1, 0xE7, 0xFF, 0x87, 0xFE, 0x07, 0xF0,
  0x00, 0x00, 0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x7B, 0x81, 0xE7, 0x03, 0x0E,
  0x04, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x03, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0x80, 0x01, 0xF8, 0x07, 0xFE, 0x0F,
  0xFE, 0x1E, 0x0F, 0x1C, 0x0F, 0x3C, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x7F, 0xFC, 0xFF,
  0xFC, 0xFF, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xE0, 0x03, 0xF8, 0x03,
  0xFC, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0xF0,
  0x1C, 0xF0, 0x3C, 0x70, 0x38, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x00,
  0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x3C, 0x38, 0xF0, 0xF3, 0xC1, 0xEF, 0x03, 0x9C,
  0x07, 0x38, 0x0E, 0x7F, 0xFC, 0xFF, 0xF8, 0x00, 0xF0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3B, 0xF0, 0xFF, 0xF1,
  0xF1, 0xE3, 0xC1, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x39, 0xC0, 0x73, 0x81, 0xC7, 0xFF, 0x87, 0xFE, 0x07, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x0E, 0x20, 0x3F, 0xF0, 0xFF, 0xF1, 0xE1, 0xF7, 0x81, 0xEE,
  0x01, 0xDC, 0x03, 0xB8, 0x07, 0xF0, 0x1E, 0xE0, 0x39, 0xE0, 0xF3, 0xFF,
  0xC3, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0x80,
  0xF7, 0x01, 0xDE, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x0E,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x01,
  0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x1E, 0x0F, 0x1C, 0x07, 0x1C, 0x07, 0x1C,
  0x0E, 0x1C, 0x0E, 0x1E, 0x3C, 0x0F, 0xF8, 0x07, 0xE0, 0x0F, 0xF0, 0x1E,
  0x78, 0x38, 0x1C, 0x78, 0x1C, 0x70, 0x1E, 0x70, 0x1C, 0x70, 0x1C, 0x70,
  0x3C, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0, 0x07, 0xE0, 0x3F, 0xF0, 0xFF,
  0xF3, 0xC1, 0xE7, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x1D,
  0xC0, 0x7B, 0xC1, 0xE3, 0xFF, 0xC7, 0xFF, 0x01, 0x1C, 0x00, 0x70, 0x01,
  0xE0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x00, 0x0E, 0x1F, 0x3F, 0x3E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0xFC, 0xF8, 0x78, 0x03, 0x81, 0xF0, 0xFC, 0x3E, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x07, 0x81,
  0xE0, 0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xC0, 0xE0, 0x38, 0x00, 0x00, 0x02,
  0x00, 0x1C, 0x00, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0x3C,
  0x00, 0x70, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x1E, 0x00, 0x0C, 0x7F, 0xFE, 0xFF, 0xF9, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF0, 0x10,
  0x00, 0x38, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x0F,
  0x80, 0x1C, 0x00, 0x60, 0x00, 0x3F, 0x81, 0xFE, 0x0F, 0xF8, 0x83, 0xE0,
  0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0F, 0x07, 0xF0, 0x7F,
  0x03, 0xE0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x01,
  0xF0, 0x0F, 0x80, 0x78, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x7C, 0x78,
  0x38, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x67, 0x38,
  0x7F, 0xCE, 0x3D, 0xF3, 0x0E, 0x39, 0xC7, 0x0E, 0x71, 0xC3, 0x9C, 0x70,
  0xE7, 0x1C, 0x39, 0xC7, 0x0E, 0x61, 0x83, 0x98, 0x71, 0xCE, 0x1F, 0xB3,
  0x87, 0xFC, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xF0,
  0x07, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0xF7, 0x01, 0xCE, 0x03, 0x9C, 0x0E,
  0x38, 0x1C, 0x70, 0x78, 0xE0, 0xE1, 0xC3, 0xC1, 0xC7, 0xFF, 0x8F, 0xFF,
  0x3C, 0x0E, 0x70, 0x1D, 0xE0, 0x3B, 0x80, 0x77, 0x00, 0xFE, 0x01, 0xC0,
  0x0F, 0xF8, 0x1F, 0xFE, 0x1F, 0xFE, 0x1C, 0x0F, 0x1C, 0x07, 0x1C, 0x07,
  0x1C, 0x07, 0x1C, 0x0E, 0x3C, 0x1E, 0x3F, 0xFC, 0x3F, 0xF0, 0x3F, 0xFC,
  0x38, 0x3C, 0x38, 0x1E, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x1E, 0x70, 0x1C,
  0x70, 0x3C, 0x7F, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0x03, 0xF8, 0x1F, 0xF8,
  0x7F, 0xF9, 0xE0, 0xF3, 0x80, 0xE7, 0x01, 0xDE, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0xE0, 0x39, 0xC0, 0x73, 0xC1, 0xE7, 0xFF, 0x87, 0xFE, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFE, 0x1C, 0x1F, 0x1C, 0x0F,
  0x1C, 0x07, 0x1C, 0x07, 0x3C, 0x0F, 0x3C, 0x0F, 0x38, 0x0E, 0x38, 0x0E,
  0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x78, 0x1E, 0x70, 0x1C, 0x70, 0x1C,
  0x70, 0x3C, 0x70, 0x78, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x0F, 0xFF,
  0x87, 0xFF, 0xC3, 0xFF, 0xC3, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xC0, 0x0F, 0xFF, 0x87,
  0xFF, 0xC7, 0xFF, 0xE3, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0x83, 0xFF,
  0xC1, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF8, 0x1F, 0xF8,
  0x7F, 0xF9, 0xE0, 0xF3, 0x80, 0xE7, 0x01, 0xDE, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x8F, 0xE7, 0x1F, 0xDE, 0x03, 0xBC, 0x0F,
  0x70, 0x1E, 0xE0, 0x39, 0xC0, 0x73, 0xC1, 0xE7, 0xFF, 0x87, 0xFE, 0x07,
  0xF0, 0x00, 0x0E, 0x07, 0x8F, 0x03, 0x87, 0x81, 0xC3, 0x80, 0xE1, 0xC0,
  0x70, 0xE0, 0x38, 0x70, 0x3C, 0x38, 0x1C, 0x3C, 0x0E, 0x1F, 0xFF, 0x0F,
  0xFF, 0x87, 0xFF, 0xC3, 0x81, 0xE1, 0xC0, 0xE1, 0xE0, 0x70, 0xF0, 0x38,
  0x70, 0x1C, 0x38, 0x0E, 0x1C, 0x0F, 0x0E, 0x07, 0x8F, 0x03, 0x87, 0x81,
  0xC0, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x07, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x3F, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x70, 0x1E, 0x38, 0x0E, 0x1E, 0x0F, 0x0F,
  0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x0E, 0x03, 0xC7, 0x81, 0xE1, 0xE0,
  0x70, 0x70, 0x3C, 0x1C, 0x1E, 0x07, 0x07, 0x01, 0xC3, 0xC0, 0xF1, 0xE0,
  0x3C, 0x70, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x38, 0xF0, 0x0E,
  0x3C, 0x07, 0x87, 0x01, 0xC1, 0xC0, 0x70, 0x78, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xF0, 0xF0, 0x1C, 0x3C, 0x07, 0x80, 0x1E, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x07, 0x8F, 0x07,
  0xC7, 0x83, 0xE3, 0xE1, 0xF3, 0xF1, 0xB9, 0xD8, 0xD8, 0xEC, 0xFC, 0x76,
  0x6E, 0x3B, 0x77, 0x1D, 0xB3, 0x9C, 0xF9, 0xCE, 0x79, 0xC7, 0x00, 0xE3,
  0x80, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x1E, 0x70, 0x0E, 0x38, 0x07,
  0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE0, 0x0F, 0x03, 0x8F, 0x83, 0xC7,
  0xC1, 0xC3, 0xE0, 0xE1, 0xF0, 0x70, 0xFC, 0x38, 0x6E, 0x1C, 0x77, 0x0E,
  0x39, 0x8E, 0x1C, 0xC7, 0x0E, 0x73, 0x87, 0x39, 0xC3, 0x9C, 0xE3, 0x86,
  0x71, 0xC3, 0x70, 0xE1, 0xF8, 0x70, 0xFC, 0x38, 0x7E, 0x1C, 0x1F, 0x1E,
  0x0F, 0x8E, 0x07, 0xC7, 0x03, 0xC0, 0x03, 0xF0, 0x1F, 0xF8, 0x7F, 0xF1,
  0xE0, 0xF3, 0x80, 0xE7, 0x01, 0xDE, 0x07, 0xBC, 0x0F, 0x70, 0x1C, 0xE0,
  0x39, 0xC0, 0x73, 0x80, 0xE7, 0x01, 0xDE, 0x07, 0xBC, 0x0F, 0x70, 0x1C,
  0xE0, 0x39, 0xC0, 0xF3, 0xC1, 0xC7, 0xFF, 0x87, 0xFE, 0x07, 0xF0, 0x00,
  0x0F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0x81, 0xF1, 0xC0, 0x78, 0xE0,
  0x1C, 0x70, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x1C, 0x07, 0x8F, 0xFF, 0x87,
  0xFF, 0x83, 0xFF, 0x81, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xF0, 0x1F, 0xF8, 0x7F, 0xF1, 0xE0, 0xF3, 0x80, 0xE7, 0x01, 0xDE, 0x03,
  0xB8, 0x0F, 0x70, 0x1E, 0xE0, 0x39, 0xC0, 0x73, 0x80, 0xEF, 0x01, 0xDC,
  0x03, 0xB8, 0x0F, 0x70, 0x1C, 0xE0, 0x39, 0xC0, 0x73, 0xC1, 0xE7, 0xFF,
  0x87, 0xFE, 0x07, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0xC0, 0x0F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0x81, 0xE1, 0xC0,
  0x70, 0xE0, 0x38, 0x70, 0x1C, 0x78, 0x0E, 0x3C, 0x0F, 0x1C, 0x0F, 0x0F,
  0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xC7, 0x01, 0xE3, 0xC0, 0xE0, 0xE0,
  0x70, 0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x0E, 0x07, 0x0F, 0x03, 0xC7, 0x80,
  0xE0, 0x01, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0x1E, 0x0F, 0x1C, 0x07, 0x1C,
  0x07, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0xF0, 0x1E, 0xF0,
  0x1C, 0x70, 0x3C, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFE, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x0F, 0x3C, 0x0F, 0x38, 0x0E, 0x38,
  0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x70,
  0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0xF0, 0x3C, 0xF0, 0x38, 0xE0,
  0x38, 0xE0, 0x38, 0xE0, 0x78, 0xF0, 0x70, 0xFF, 0xF0, 0x7F, 0xE0, 0x3F,
  0x80, 0xF0, 0x0F, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x1C, 0x70, 0x1C, 0x70,
  0x3C, 0x70, 0x38, 0x70, 0x38, 0x70, 0x70, 0x70, 0x70, 0x78, 0xF0, 0x38,
  0xE0, 0x38, 0xE0, 0x39, 0xC0, 0x39, 0xC0, 0x3B, 0xC0, 0x3B, 0x80, 0x3B,
  0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x70, 0xE1, 0xDC,
  0x78, 0xE6, 0x1E, 0x39, 0x87, 0x8E, 0x63, 0x63, 0x18, 0xD1, 0xCE, 0x34,
  0x73, 0x89, 0x1C, 0xE6, 0xC6, 0x39, 0xB3, 0x8E, 0x6C, 0xE3, 0xB3, 0x30,
  0xEC, 0xCC, 0x3B, 0x37, 0x0E, 0xCD, 0xC3, 0xE3, 0x60, 0xF8, 0xD8, 0x36,
  0x3E, 0x0D, 0x0F, 0x83, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x00, 0x0E,
  0x01, 0xE1, 0xE0, 0x78, 0x3C, 0x1E, 0x03, 0x83, 0x80, 0x78, 0xF0, 0x07,
  0x3C, 0x00, 0xE7, 0x00, 0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xDE, 0x00, 0x79,
  0xC0, 0x0E, 0x3C, 0x03, 0x87, 0x80, 0xF0, 0x70, 0x3C, 0x0F, 0x07, 0x00,
  0xE1, 0xE0, 0x1E, 0x00, 0xE0, 0x07, 0xF0, 0x0E, 0x70, 0x1E, 0x70, 0x1C,
  0x78, 0x3C, 0x38, 0x38, 0x38, 0x70, 0x3C, 0xF0, 0x1C, 0xE0, 0x1D, 0xC0,
  0x1D, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0,
  0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x7F, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xE0, 0x70, 0x38, 0x1E, 0x07, 0x03, 0x81, 0xC0, 0xF0, 0x78,
  0x1C, 0x0E, 0x07, 0x03, 0xC0, 0xE0, 0x70, 0x38, 0x1E, 0x0F, 0x03, 0x81,
  0xC0, 0xE0, 0x78, 0x1C, 0x0E, 0x07, 0x03, 0xC1, 0xE0, 0x70, 0x07, 0xF8,
  0x3F, 0xC3, 0xFC, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x83, 0xFC, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xC0, 0x1E, 0x01,
  0xF0, 0x0D, 0xC0, 0xEE, 0x0E, 0x30, 0x71, 0xC7, 0x0E, 0x38, 0x73, 0x81,
  0xB8, 0x0F, 0xC0, 0x70, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF0, 0xE3, 0xC7,
  0x0E, 0x3C, 0x07, 0x8E, 0x3F, 0xBC, 0xFF, 0xF1, 0xE1, 0xE7, 0x83, 0xCE,
  0x03, 0x9C, 0x07, 0x38, 0x1E, 0xF0, 0x3D, 0xE0, 0x73, 0x80, 0xE7, 0x01,
  0xCE, 0x07, 0x9E, 0x0F, 0x3F, 0xFE, 0x3F, 0xF8, 0x3E, 0x70, 0x0E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x8E, 0x07, 0x7F, 0x1F,
  0xFF, 0x3E, 0x1E, 0x78, 0x1C, 0xE0, 0x39, 0xC0, 0x73, 0x80, 0xE7, 0x03,
  0xDE, 0x07, 0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x39, 0xE0, 0xF3, 0xFF, 0xCF,
  0xFF, 0x1E, 0xFC, 0x00, 0x03, 0xC0, 0x1F, 0xF0, 0x7F, 0xF1, 0xE1, 0xE7,
  0x81, 0xCE, 0x03, 0x9C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80,
  0x07, 0x01, 0xCE, 0x03, 0x9E, 0x0F, 0x3F, 0xFC, 0x3F, 0xF0, 0x3F, 0x80,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x07, 0x8E,
  0x1F, 0xDE, 0x3F, 0xFC, 0x3C, 0x3C, 0x78, 0x3C, 0x70, 0x1C, 0x70, 0x1C,
  0x70, 0x3C, 0xF0, 0x3C, 0xF0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x78,
  0xF0, 0x78, 0xFF, 0xF8, 0x7F, 0xF0, 0x3E, 0x70, 0x03, 0xE0, 0x3F, 0xC1,
  0xFF, 0x8F, 0x0F, 0x78, 0x1D, 0xC0, 0x77, 0x01, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x81, 0xEF, 0x9F, 0x1F, 0xF8,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x07, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0x8E, 0x3F, 0xBC, 0xFF, 0xF1, 0xE1, 0xE7, 0x83, 0xCE, 0x03,
  0x9C, 0x07, 0x38, 0x1E, 0xF0, 0x3D, 0xE0, 0x73, 0x80, 0xE7, 0x83, 0xCF,
  0x0F, 0x8F, 0xF7, 0x1F, 0xFE, 0x1F, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0xC0, 0x0F, 0x07, 0xFE, 0x0F, 0xF0, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x8E, 0x07, 0x7F, 0x1F, 0xFF, 0x3E, 0x1E,
  0x78, 0x1C, 0xE0, 0x39, 0xC0, 0x73, 0x81, 0xE7, 0x03, 0xDE, 0x07, 0x38,
  0x0E, 0x70, 0x1C, 0xE0, 0x39, 0xC0, 0x73, 0x81, 0xEF, 0x03, 0x9E, 0x07,
  0x00, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x07,
  0xFE, 0x0F, 0xFC, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x7F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x3C, 0x70, 0x3C, 0x38, 0x3C, 0x3C, 0x1C,
  0x1E, 0x1E, 0x0E, 0x1E, 0x07, 0x1E, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFF,
  0x80, 0xF1, 0xC0, 0x70, 0xF0, 0x38, 0x38, 0x1C, 0x1E, 0x0E, 0x07, 0x07,
  0x03, 0xC7, 0x81, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0x0E, 0x00, 0xF0,
  0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01,
  0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x3F,
  0xF1, 0xFF, 0x83, 0xF8, 0x1D, 0xC7, 0x0F, 0xF7, 0xC6, 0xFF, 0xE3, 0x9C,
  0x73, 0x8E, 0x39, 0xC7, 0x1C, 0xE3, 0x8E, 0x71, 0x86, 0x38, 0xC7, 0x1C,
  0x63, 0x9C, 0x71, 0xCE, 0x38, 0xE7, 0x1C, 0x73, 0x8C, 0x31, 0xC6, 0x38,
  0xE3, 0x1C, 0xE3, 0x8E, 0x00, 0x1C, 0x70, 0x3B, 0xF8, 0xFF, 0xF9, 0xF0,
  0xF3, 0xC0, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x0F, 0x38, 0x1E, 0xF0, 0x39,
  0xC0, 0x73, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x0F, 0x78, 0x1C, 0xF0,
  0x38, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0x8F, 0x0F, 0x78, 0x1D, 0xC0, 0x77,
  0x01, 0xDC, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xB8, 0x0E, 0xE0, 0x3B,
  0xC1, 0xCF, 0xFF, 0x1F, 0xF8, 0x3F, 0x80, 0x0E, 0x38, 0x0E, 0xFE, 0x1F,
  0xFF, 0x1F, 0x0F, 0x1E, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C,
  0x0F, 0x3C, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x3C, 0x1E, 0x3F,
  0xFC, 0x7F, 0xF8, 0x7B, 0xF0, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0x07, 0x8E, 0x3F, 0xBC, 0xFF, 0xF1, 0xE1, 0xE7, 0x83,
  0xCE, 0x03, 0x9C, 0x07, 0x38, 0x1E, 0xF0, 0x3D, 0xE0, 0x73, 0x80, 0xE7,
  0x01, 0xCE, 0x07, 0x9E, 0x0F, 0x3F, 0xFE, 0x3F, 0xF8, 0x3E, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0xF0, 0x77,
  0xF8, 0xEF, 0xF1, 0xF0, 0xF3, 0x81, 0xE7, 0x03, 0xDE, 0x07, 0xB8, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x01, 0xF0, 0x1F, 0xF8, 0x7F, 0xF8, 0xE0,
  0xF3, 0xC0, 0xE7, 0x00, 0x0F, 0x00, 0x1F, 0xE0, 0x1F, 0xF8, 0x07, 0xF8,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0xCE, 0x07, 0x9F, 0x3E, 0x3F, 0xFC, 0x3F,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x07, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0x83, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7F,
  0xE0, 0x7F, 0x80, 0x7F, 0x00, 0x38, 0x0E, 0x70, 0x3D, 0xE0, 0x7B, 0xC0,
  0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x07, 0x38, 0x1E, 0xF0, 0x3D, 0xE0, 0x73,
  0x80, 0xE7, 0x01, 0xCE, 0x07, 0x9E, 0x0E, 0x3F, 0xFC, 0x3F, 0xF0, 0x3F,
  0x80, 0xE0, 0x1F, 0xC0, 0x3B, 0x80, 0xF7, 0x01, 0xCF, 0x03, 0x8E, 0x0E,
  0x1C, 0x1C, 0x38, 0x70, 0x70, 0xE0, 0xE3, 0x81, 0xE7, 0x01, 0xDC, 0x03,
  0xB8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xE1, 0xC3, 0xE1,
  0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE2, 0xC6, 0xE6, 0xCE, 0xE6, 0xCE, 0xE6,
  0xCC, 0xEC, 0xDC, 0xEC, 0xDC, 0xEC, 0xD8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xE0, 0x1E, 0x03, 0xC3, 0x81, 0xE0,
  0xF0, 0xF0, 0x1C, 0x78, 0x07, 0x9C, 0x00, 0xEF, 0x00, 0x3F, 0x80, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x1D, 0xC0, 0x0E, 0x38,
  0x07, 0x8F, 0x03, 0xC3, 0xC1, 0xE0, 0x78, 0xF0, 0x1E, 0x00, 0x38, 0x1E,
  0x70, 0x3D, 0xE0, 0x73, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x07, 0x38,
  0x1E, 0xF0, 0x39, 0xE0, 0x73, 0x80, 0xE7, 0x83, 0xCF, 0x0F, 0x8F, 0xFF,
  0x1F, 0xDE, 0x0F, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x07,
  0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1F, 0xFF, 0x7F, 0xFC, 0xFF, 0xF8,
  0x00, 0x1E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x78,
  0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F,
  0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x0E, 0x1C, 0x38, 0xF1, 0xE3, 0x87, 0x0E,
  0x1C, 0x78, 0xF1, 0xC3, 0x87, 0x0E, 0x1C, 0x78, 0xF1, 0xC3, 0x87, 0x0E,
  0x3C, 0x78, 0xE1, 0xC3, 0x87, 0x00, 0x0F, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3F, 0xC0, 0x3F, 0x81, 0xFF,
  0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0E, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x1C,
  0x0E, 0xFE, 0x1F, 0xFE, 0x3F, 0x1C, 0x7E, 0x3F, 0xDC, 0x3F, 0x00, 0x3C,
  0x00,
};

const GFXglyph JetBrainsMono_MediumItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 8, 22, 18, 5, -22 },
  { 23, 11, 9, 18, 5, -22 },
  { 36, 17, 22, 18, 1, -22 },
  { 83, 16, 30, 18, 1, -26 },
  { 143, 21, 22, 18, -1, -22 },
  { 201, 16, 22, 18, 1, -22 },
  { 245, 5, 9, 18, 8, -22 },
  { 251, 13, 29, 18, 4, -25 },
  { 299, 12, 29, 18, 2, -25 },
  { 343, 17, 15, 18, 1, -18 },
  { 375, 15, 14, 18, 2, -17 },
  { 402, 8, 10, 18, 3, -5 },
  { 412, 10, 3, 18, 4, -11 },
  { 416, 6, 5, 18, 5, -5 },
  { 420, 19, 28, 18, 0, -25 },
  { 487, 15, 22, 18, 2, -22 },
  { 529, 15, 22, 18, 1, -22 },
  { 571, 16, 22, 18, 1, -22 },
  { 615, 16, 22, 18, 1, -22 },
  { 659, 15, 22, 18, 2, -22 },
  { 701, 15, 22, 18, 2, -22 },
  { 743, 15, 22, 18, 1, -22 },
  { 785, 15, 22, 18, 3, -22 },
  { 827, 16, 22, 18, 1, -22 },
  { 871, 15, 22, 18, 3, -22 },
  { 913, 8, 17, 18, 5, -17 },
  { 930, 10, 22, 18, 3, -17 },
  { 958, 15, 16, 18, 2, -18 },
  { 988, 15, 10, 18, 2, -15 },
  { 1007, 15, 16, 18, 1, -18 },
  { 1037, 13, 22, 18, 4, -22 },
  { 1073, 18, 27, 18, 0, -22 },
  { 1134, 15, 22, 18, 0, -22 },
  { 1176, 16, 22, 18, 1, -22 },
  { 1220, 15, 22, 18, 2, -22 },
  { 1262, 16, 22, 18, 1, -22 },
  { 1306, 17, 22, 18, 1, -22 },
  { 1353, 17, 22, 18, 1, -22 },
  { 1400, 15, 22, 18, 2, -22 },
  { 1442, 17, 22, 18, 1, -22 },
  { 1489, 15, 22, 18, 2, -22 },
  { 1531, 17, 22, 18, 0, -22 },
  { 1578, 18, 22, 18, 1, -22 },
  { 1628, 13, 22, 18, 2, -22 },
  { 1664, 17, 22, 18, 1, -22 },
  { 1711, 17, 22, 18, 1, -22 },
  { 1758, 15, 22, 18, 2, -22 },
  { 1800, 17, 22, 18, 1, -22 },
  { 1847, 15, 27, 18, 2, -22 },
  { 1898, 17, 22, 18, 1, -22 },
  { 1945, 16, 22, 18, 1, -22 },
  { 1989, 16, 22, 18, 3, -22 },
  { 2033, 16, 22, 18, 2, -22 },
  { 2077, 16, 22, 18, 3, -22 },
  { 2121, 18, 22, 18, 2, -22 },
  { 2171, 19, 22, 18, 0, -22 },
  { 2224, 16, 22, 18, 3, -22 },
  { 2268, 16, 22, 18, 1, -22 },
  { 2312, 12, 28, 18, 4, -25 },
  { 2354, 9, 28, 18, 5, -25 },
  { 2386, 13, 28, 18, 2, -25 },
  { 2432, 13, 12, 18, 3, -22 },
  { 2452, 15, 3, 18, 0, 1 },
  { 2458, 6, 5, 18, 8, -24 },
  { 2462, 15, 17, 18, 2, -17 },
  { 2494, 15, 22, 18, 1, -22 },
  { 2536, 15, 17, 18, 2, -17 },
  { 2568, 16, 22, 18, 2, -22 },
  { 2612, 14, 17, 18, 2, -17 },
  { 2642, 21, 27, 18, -2, -22 },
  { 2713, 15, 22, 18, 2, -17 },
  { 2755, 15, 22, 18, 1, -22 },
  { 2797, 15, 23, 18, 1, -23 },
  { 2841, 16, 28, 18, 0, -23 },
  { 2897, 17, 22, 18, 1, -22 },
  { 2944, 13, 22, 18, 3, -22 },
  { 2980, 17, 17, 18, 0, -17 },
  { 3017, 15, 17, 18, 1, -17 },
  { 3049, 14, 17, 18, 2, -17 },
  { 3079, 16, 22, 18, 0, -17 },
  { 3123, 15, 22, 18, 2, -17 },
  { 3165, 15, 17, 18, 2, -17 },
  { 3197, 15, 17, 18, 1, -17 },
  { 3229, 15, 21, 18, 2, -21 },
  { 3269, 15, 17, 18, 2, -17 },
  { 3301, 15, 17, 18, 3, -17 },
  { 3333, 16, 17, 18, 2, -17 },
  { 3367, 18, 17, 18, 0, -17 },
  { 3406, 15, 22, 18, 2, -17 },
  { 3448, 15, 17, 18, 1, -17 },
  { 3480, 15, 28, 18, 3, -25 },
  { 3533, 7, 28, 18, 6, -25 },
  { 3558, 15, 28, 18, 1, -25 },
  { 3611, 15, 7, 18, 2, -14 },
};

const GFXfont JetBrainsMono_MediumItalic30pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic30pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic30pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _JETBRAINSMONO_MEDIUMITALIC30PT7B_H_
