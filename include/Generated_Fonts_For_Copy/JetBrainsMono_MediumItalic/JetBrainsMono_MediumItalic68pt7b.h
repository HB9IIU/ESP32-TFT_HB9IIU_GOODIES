#ifndef _JETBRAINSMONO_MEDIUMITALIC68PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0x7F, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0x80, 0xFF,
  0x3F, 0x80, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x80, 0xFE, 0x7F, 0x81, 0xFE,
  0x7F, 0x81, 0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0x01, 0xFC,
  0x7F, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xF8,
  0xFE, 0x01, 0xF8, 0xFE, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF8,
  0xFC, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x81,
  0x03, 0xF0, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFD, 0xFF, 0xFE, 0x01, 0xFF, 0x1E, 0x3F,
  0xE0, 0x1F, 0xE1, 0xE1, 0xFF, 0x03, 0xFC, 0x1E, 0x0F, 0xF0, 0x3F, 0x81,
  0xE0, 0xFF, 0x03, 0xF8, 0x1E, 0x0F, 0xF0, 0x7F, 0x83, 0xE0, 0xFF, 0x07,
  0xF8, 0x3C, 0x00, 0x00, 0x7F, 0x83, 0xC0, 0x00, 0x07, 0xF8, 0x3C, 0x00,
  0x00, 0x7F, 0x83, 0xC0, 0x00, 0x07, 0xFC, 0x3C, 0x00, 0x00, 0x7F, 0xC7,
  0xC0, 0x00, 0x03, 0xFF, 0x78, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x1F, 0xF0, 0x00, 0x01, 0xF0, 0xFF,
  0x80, 0x00, 0x1E, 0x0F, 0xF8, 0x00, 0x01, 0xE0, 0x7F, 0x80, 0x00, 0x1E,
  0x07, 0xF8, 0x00, 0x01, 0xE0, 0x7F, 0x80, 0x00, 0x1E, 0x07, 0xF8, 0xFF,
  0x03, 0xE0, 0x7F, 0x0F, 0xF0, 0x3E, 0x07, 0xF0, 0xFF, 0x03, 0xC0, 0xFF,
  0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0xFF, 0x83, 0xC1, 0xFE, 0x07, 0xFC, 0x3C,
  0x3F, 0xC0, 0x7F, 0xE7, 0xCF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7E, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x01,
  0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x07,
  0xE0, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0xF8, 0x07, 0xE0, 0x0F,
  0x80, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x3F,
  0x00, 0x01, 0xF8, 0x07, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0xFC,
  0x00, 0x01, 0xF0, 0x07, 0xC1, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0xC1, 0xF0,
  0x00, 0x01, 0xF0, 0x0F, 0xC3, 0xE0, 0x00, 0x01, 0xF8, 0x1F, 0x87, 0xE0,
  0x00, 0x01, 0xFC, 0x3F, 0x8F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x1F, 0x80,
  0x00, 0x00, 0xFF, 0xFE, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0xFC, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xF0, 0xFC, 0x0F, 0xC0, 0x00, 0x03, 0xE1, 0xF8, 0x0F,
  0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF0, 0x0F,
  0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0x80, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF8, 0x03, 0xE0, 0x1F,
  0x80, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xBF, 0xC0, 0x3F, 0xC7, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC1, 0xFE, 0x07,
  0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0,
  0x1F, 0xC7, 0xF0, 0x3F, 0x80, 0x7F, 0xBF, 0x80, 0xFE, 0x00, 0xFF, 0xFE,
  0x03, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xE0, 0x07, 0xFF, 0x80, 0x7F, 0x80,
  0x0F, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x80,
  0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0x3F, 0xF0, 0x07, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xF0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFD, 0xFC, 0x03, 0xFF, 0xFF,
  0xC7, 0xF8, 0x07, 0xFF, 0xFE, 0x0F, 0xE0, 0x0F, 0xFF, 0xF0, 0x3F, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xCF,
  0xF3, 0xFC, 0xFE, 0x3F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xC7, 0xF3,
  0xFC, 0xFF, 0x3F, 0xCF, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xC3, 0xF0, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xE0, 0x07, 0xE0, 0x03, 0x87,
  0xE0, 0x1F, 0x00, 0xFC, 0x7F, 0xC0, 0xF8, 0x3F, 0xE3, 0xFF, 0x07, 0x87,
  0xFF, 0x3F, 0xFE, 0x3C, 0x7F, 0xFB, 0xFF, 0xF9, 0xCF, 0xFF, 0xEF, 0xFF,
  0xEE, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0xFE,
  0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x00, 0x40, 0x00, 0x40, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x0F, 0xC1,
  0xFF, 0x1F, 0xFC, 0xFF, 0xE7, 0xFF, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF,
  0xE3, 0xFF, 0x0F, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x1F, 0xF0, 0x03, 0xFE,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x83, 0xE0,
  0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0xC1, 0xFC, 0x3F, 0x87,
  0xFC, 0x3F, 0x87, 0xF0, 0xFF, 0x87, 0xF0, 0xFE, 0x1F, 0xE1, 0xFC, 0x1F,
  0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0x1F, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00,
  0xFF, 0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x01, 0xFC, 0x3F,
  0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F,
  0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xEF, 0xE0, 0x01, 0xFF, 0x8F, 0xE0, 0x03, 0xFF, 0x0F,
  0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xE0, 0x1F,
  0xC0, 0x03, 0xC0, 0x1F, 0xC0, 0x07, 0x00, 0x1F, 0xC0, 0x06, 0x00, 0x1F,
  0xC0, 0x04, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xE1, 0xFF,
  0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x01, 0xFC,
  0x3F, 0xC0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01,
  0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x03, 0xF8, 0x0F, 0xF8, 0x01, 0xFC, 0x07, 0xF8, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x07, 0xFC, 0x00,
  0x3F, 0x87, 0xFC, 0x00, 0x1F, 0xC7, 0xFC, 0x00, 0x0F, 0xE3, 0xFC, 0x00,
  0x0F, 0xF1, 0xFC, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x01, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x01, 0xC0, 0x00, 0x3F, 0xC7, 0xFF, 0x80,
  0x07, 0xF3, 0xFF, 0xF8, 0x00, 0xFE, 0xFF, 0xFF, 0x80, 0x1F, 0xDF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x1E, 0x00, 0x01, 0xFE,
  0x7F, 0xF0, 0x00, 0xFF, 0x7F, 0xFE, 0x00, 0x7F, 0xBF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC1,
  0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x7F,
  0x8F, 0xF0, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x03, 0xFB, 0xFC, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xC0,
  0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x03, 0xFC, 0x7F,
  0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFC, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00,
  0x7F, 0x8F, 0xE0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0x80,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x07, 0xF8, 0x20,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x03,
  0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFE, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x07, 0xF8, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xFC, 0x00,
  0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x00, 0x7F, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0xC0,
  0x07, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0x40, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xE0, 0x07,
  0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x07, 0xF8, 0xFE, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0xFE, 0xFF,
  0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x07, 0xFB,
  0xFC, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x7F,
  0xC7, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xDF, 0xE0, 0x0F, 0xFF, 0xEF, 0xF0, 0x01, 0xFF, 0xF7, 0xF8, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFC, 0x3F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFC, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x02, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xC1, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x3F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7F, 0x87, 0xE0, 0x7E, 0x00, 0x7F, 0xF1,
  0xF0, 0x3F, 0x80, 0x3F, 0xFE, 0x7C, 0x0F, 0xE0, 0x1F, 0xFF, 0x9F, 0x03,
  0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0x01,
  0xFC, 0x03, 0xFC, 0x0F, 0xC0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x1F, 0x80,
  0x1F, 0x81, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x03, 0xF8, 0x01, 0xF8,
  0x1F, 0x80, 0xFE, 0x00, 0x7E, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x81, 0xF8,
  0x0F, 0xC0, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0xFC,
  0x00, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x1F, 0xC0, 0x0F,
  0xC0, 0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x01, 0xFC, 0x0F,
  0xC0, 0x7E, 0x00, 0x7E, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0x81, 0xFC, 0x07,
  0xF0, 0x0F, 0xE0, 0x7E, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0x80, 0x7F, 0xFF,
  0xFE, 0x07, 0xE0, 0x0F, 0xFF, 0xDF, 0x81, 0xF8, 0x03, 0xFF, 0xE7, 0xE0,
  0x7E, 0x00, 0x7F, 0xF1, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x7C, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0x7E, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x03, 0xF9, 0xF8, 0x00,
  0x00, 0x7F, 0x3F, 0x00, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x03, 0xF8, 0xFC,
  0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xF8,
  0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03,
  0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x07, 0xF0, 0x0F, 0xC0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x3F,
  0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0xC0,
  0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x07, 0xF0, 0x7F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xFC,
  0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x0F, 0xE3,
  0xFC, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x07,
  0xFB, 0xFC, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0,
  0x07, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x01, 0xFE, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xC0, 0x01, 0xFF,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x81, 0xFC, 0x00,
  0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F,
  0x83, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x7F, 0x00, 0x01, 0xFF, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x7F,
  0x00, 0x07, 0xFC, 0x07, 0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x1F, 0xF8, 0x03, 0xFE, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x83,
  0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F,
  0xC3, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0x1F, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xE0,
  0x3F, 0x80, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0xFE, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01,
  0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x03,
  0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xC0,
  0x00, 0x7F, 0x81, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x80,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x07,
  0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x7F,
  0xF0, 0x1F, 0xF8, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0x87, 0xF8, 0x1F, 0xFF, 0xF0,
  0xFF, 0x03, 0xFF, 0xFE, 0x1F, 0xC0, 0x7F, 0xFF, 0x83, 0xF8, 0x0F, 0xFF,
  0xF0, 0x7F, 0x03, 0xFF, 0xFE, 0x0F, 0xE0, 0x7F, 0xFF, 0xC3, 0xFC, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xE1,
  0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F,
  0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFF,
  0x00, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x07,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x03, 0xFE, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x0F, 0xBE, 0x01, 0xF7, 0xE0, 0x1F, 0xFE, 0x01, 0xF7, 0xE0,
  0x1F, 0x7E, 0x01, 0xF3, 0xE0, 0x3F, 0x7E, 0x01, 0xF3, 0xE0, 0x3E, 0x7C,
  0x03, 0xF3, 0xE0, 0x7E, 0xFC, 0x03, 0xF3, 0xE0, 0x7C, 0xFC, 0x03, 0xF3,
  0xE0, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0xF8, 0xFC, 0x03, 0xF1, 0xF0, 0xF9,
  0xFC, 0x03, 0xF1, 0xF1, 0xF9, 0xFC, 0x07, 0xF1, 0xF1, 0xF1, 0xF8, 0x07,
  0xF1, 0xF3, 0xF1, 0xF8, 0x07, 0xF1, 0xF3, 0xE1, 0xF8, 0x07, 0xF1, 0xF7,
  0xE3, 0xF8, 0x07, 0xE1, 0xFF, 0xC3, 0xF8, 0x07, 0xE0, 0xFF, 0xC3, 0xF8,
  0x07, 0xE0, 0xFF, 0x83, 0xF0, 0x0F, 0xE0, 0xFF, 0x87, 0xF0, 0x0F, 0xE0,
  0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0x80, 0x03, 0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0xE0, 0x00, 0xFE,
  0x03, 0xFF, 0x00, 0x07, 0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0x80, 0xFF, 0xE0,
  0x01, 0xF8, 0x0F, 0xFF, 0x00, 0x1F, 0xC0, 0x7F, 0xF8, 0x00, 0xFE, 0x03,
  0xFF, 0xC0, 0x07, 0xF0, 0x1F, 0xFE, 0x00, 0x3F, 0x80, 0xFD, 0xF8, 0x01,
  0xFC, 0x07, 0xEF, 0xC0, 0x0F, 0xC0, 0x7F, 0x7E, 0x00, 0xFE, 0x03, 0xFB,
  0xF0, 0x07, 0xF0, 0x1F, 0xDF, 0x80, 0x3F, 0x80, 0xFE, 0xFE, 0x01, 0xFC,
  0x07, 0xE3, 0xF0, 0x0F, 0xE0, 0x3F, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0xFC,
  0x07, 0xF0, 0x1F, 0xC7, 0xE0, 0x3F, 0x80, 0xFE, 0x3F, 0x81, 0xFC, 0x07,
  0xF0, 0xFC, 0x0F, 0xE0, 0x3F, 0x87, 0xE0, 0x7F, 0x01, 0xFC, 0x3F, 0x03,
  0xF8, 0x0F, 0xC1, 0xF8, 0x1F, 0x80, 0xFE, 0x0F, 0xC1, 0xFC, 0x07, 0xF0,
  0x3F, 0x0F, 0xE0, 0x3F, 0x81, 0xF8, 0x7F, 0x01, 0xFC, 0x0F, 0xC3, 0xF8,
  0x0F, 0xE0, 0x7E, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0x0F,
  0xC7, 0xE0, 0x3F, 0x80, 0x7E, 0x7F, 0x01, 0xFC, 0x03, 0xF3, 0xF8, 0x0F,
  0xE0, 0x1F, 0x9F, 0xC0, 0x7F, 0x00, 0xFC, 0xFE, 0x03, 0xF0, 0x03, 0xF7,
  0xE0, 0x3F, 0x80, 0x1F, 0xBF, 0x01, 0xFC, 0x00, 0xFD, 0xF8, 0x0F, 0xE0,
  0x07, 0xEF, 0xC0, 0x7F, 0x00, 0x3F, 0x7E, 0x03, 0xF8, 0x01, 0xFF, 0xF0,
  0x1F, 0xC0, 0x07, 0xFF, 0x80, 0xFC, 0x00, 0x3F, 0xF8, 0x0F, 0xE0, 0x01,
  0xFF, 0xC0, 0x7F, 0x00, 0x0F, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0xF0, 0x1F,
  0xC0, 0x01, 0xFF, 0x80, 0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x1F, 0xF0, 0x03,
  0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xE0,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x01, 0xFC, 0x1F,
  0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00,
  0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x03, 0xFC, 0x3F,
  0xC0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x01,
  0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x80,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xF8,
  0x3F, 0xC0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03,
  0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xFE,
  0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0x80,
  0x00, 0x7F, 0x80, 0xFE, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0x81, 0xFE, 0x00,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0xE0,
  0x7F, 0x00, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0xFE, 0x00, 0x07, 0xFE, 0x03,
  0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xF0, 0x7F, 0xF0, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F,
  0xF0, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0xC3, 0xF8, 0x00,
  0x07, 0xF0, 0xFF, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xC3, 0xFC,
  0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x1F, 0xE1,
  0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x0F,
  0xE1, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x87, 0xF0, 0x00,
  0x0F, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xF8,
  0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0xC3,
  0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x1F,
  0xC3, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x1F, 0xE1, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0x80, 0x0F, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xC0,
  0x00, 0x7F, 0x80, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x3F, 0x80, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0xFF, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x3F,
  0x80, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0x80,
  0x07, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x3F, 0xC0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0xFE, 0x00,
  0x01, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFE, 0x00,
  0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03, 0xFC, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x7F,
  0x80, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x3F, 0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00,
  0xFF, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x01,
  0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x01, 0xFC, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x03,
  0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xC0,
  0x00, 0x7F, 0x81, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0x80,
  0x00, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0xFE, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFF, 0x00,
  0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1E, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x00,
  0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0xFF, 0x3F,
  0xC0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xF0, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x0F,
  0xF0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x07, 0xF0,
  0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x03,
  0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x01, 0xFC,
  0x7F, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00,
  0x7E, 0x7F, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x01, 0xFB, 0xF8, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x3F, 0x80,
  0x7F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x80, 0x7E, 0x3F, 0x00, 0x7F, 0x80,
  0x7E, 0x3F, 0x00, 0xFF, 0x80, 0x7E, 0x3F, 0x00, 0xFF, 0x80, 0xFE, 0x3F,
  0x00, 0xFF, 0x80, 0xFC, 0x3F, 0x00, 0xFF, 0x00, 0xFC, 0x3F, 0x01, 0xFF,
  0x00, 0xFC, 0x3F, 0x01, 0xEF, 0x01, 0xFC, 0x3F, 0x01, 0xEF, 0x01, 0xF8,
  0x3F, 0x03, 0xEF, 0x01, 0xF8, 0x3F, 0x03, 0xCF, 0x01, 0xF8, 0x3F, 0x03,
  0xCF, 0x03, 0xF0, 0x3F, 0x03, 0xCF, 0x03, 0xF0, 0x3F, 0x07, 0xCF, 0x03,
  0xF0, 0x7F, 0x07, 0x8F, 0x07, 0xF0, 0x7F, 0x07, 0x8F, 0x07, 0xE0, 0x7E,
  0x07, 0x8F, 0x07, 0xE0, 0x7E, 0x0F, 0x8F, 0x07, 0xE0, 0x7E, 0x0F, 0x0F,
  0x0F, 0xE0, 0x7E, 0x0F, 0x0F, 0x0F, 0xC0, 0x7E, 0x1F, 0x0F, 0x0F, 0xC0,
  0x7E, 0x1E, 0x1F, 0x0F, 0xC0, 0x7E, 0x1E, 0x1F, 0x1F, 0x80, 0x7E, 0x1E,
  0x1F, 0x1F, 0x80, 0x7E, 0x3E, 0x1F, 0x1F, 0x80, 0x7E, 0x3C, 0x1F, 0x1F,
  0x80, 0x7E, 0x3C, 0x1E, 0x3F, 0x00, 0x7E, 0x7C, 0x1E, 0x3F, 0x00, 0x7E,
  0x7C, 0x1E, 0x3F, 0x00, 0x7E, 0x78, 0x1E, 0x3F, 0x00, 0x7E, 0x78, 0x1E,
  0x7E, 0x00, 0x7E, 0xF8, 0x1E, 0x7E, 0x00, 0x7C, 0xF0, 0x1E, 0x7E, 0x00,
  0xFC, 0xF0, 0x1E, 0x7C, 0x00, 0xFD, 0xF0, 0x1E, 0xFC, 0x00, 0xFD, 0xF0,
  0x1E, 0xFC, 0x00, 0xFD, 0xE0, 0x1E, 0xFC, 0x00, 0xFD, 0xE0, 0x1E, 0xF8,
  0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC7,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xEF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x07,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x01, 0xFE,
  0x7F, 0x00, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00,
  0x01, 0xFD, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFE, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x1F, 0xC3, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x1F,
  0xC0, 0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0,
  0x0F, 0xC0, 0x7F, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x03,
  0xF8, 0x7F, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x7E,
  0x7F, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0x80, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x87, 0xF0, 0x07, 0xFF, 0xF3, 0xFC, 0x03, 0xFF, 0xFE, 0xFF, 0x01, 0xFF,
  0xFF, 0xBF, 0x80, 0xFF, 0xFF, 0xEF, 0xE0, 0x7F, 0xF0, 0xFB, 0xF8, 0x3F,
  0xF0, 0x0F, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x3F, 0xE1,
  0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F,
  0x0F, 0xF0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x03,
  0xFC, 0x3F, 0x80, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x0F, 0xE1, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0x7F, 0x87, 0xF0, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFE,
  0x0F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xFF, 0xFB,
  0xF8, 0x1F, 0xFF, 0xFE, 0xFE, 0x03, 0xFF, 0xFF, 0x7F, 0x80, 0x7F, 0xFF,
  0x9F, 0xE0, 0x0F, 0xFF, 0xC7, 0xF0, 0x01, 0xFF, 0xC1, 0xFC, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0xFE,
  0x1F, 0xFE, 0x00, 0x7F, 0x9F, 0xFF, 0xC0, 0x1F, 0xCF, 0xFF, 0xF8, 0x07,
  0xF7, 0xFF, 0xFF, 0x01, 0xFD, 0xFF, 0xFF, 0xC0, 0x7F, 0xFC, 0x7F, 0xF8,
  0x1F, 0xF8, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x80,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x1F, 0xE1, 0xFC,
  0x00, 0x07, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x0F,
  0xF0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xFC,
  0x3F, 0x80, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F,
  0xE1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xF0, 0x00,
  0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xDF, 0xFF, 0xFC, 0x0F, 0xF7, 0xFF, 0xFE, 0x03, 0xF9,
  0xFF, 0xFF, 0x00, 0xFE, 0x3F, 0xFF, 0x00, 0x3F, 0x83, 0xFF, 0x80, 0x00,
  0x00, 0x3D, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFE, 0x7F, 0xFC, 0x0F, 0xF8, 0x03,
  0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0x1F, 0xE3, 0xF8, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x07, 0xF9, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x3F, 0x8F,
  0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x3F, 0xE0,
  0xFF, 0xC0, 0x3F, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xFF, 0xE1, 0xFC,
  0x00, 0x7F, 0xFF, 0x3F, 0xC0, 0x0F, 0xFF, 0xFB, 0xFC, 0x01, 0xFF, 0xFF,
  0xBF, 0x80, 0x3F, 0xFF, 0xFB, 0xF8, 0x07, 0xFF, 0x0F, 0xBF, 0x80, 0xFF,
  0xC0, 0x3F, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x0F, 0xF8,
  0x1F, 0xE0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00,
  0x7F, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x01, 0xFE, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07,
  0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x0F, 0xF8, 0x07, 0xFE,
  0x03, 0xFF, 0x80, 0x7F, 0xFF, 0xFB, 0xF8, 0x07, 0xFF, 0xFF, 0xBF, 0x80,
  0x3F, 0xFF, 0xF7, 0xF8, 0x01, 0xFF, 0xFE, 0x7F, 0x80, 0x0F, 0xFF, 0xC7,
  0xF0, 0x00, 0x7F, 0xF0, 0x7F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF,
  0x07, 0xF0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x01,
  0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xE3, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xF8,
  0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x1F, 0xE0, 0x3F,
  0xF0, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x87, 0xF0, 0x07, 0xFF,
  0xF3, 0xFC, 0x03, 0xFF, 0xFE, 0xFF, 0x01, 0xFF, 0xFF, 0xBF, 0x80, 0xFF,
  0xFF, 0xEF, 0xE0, 0x7F, 0xF0, 0xFF, 0xF8, 0x3F, 0xF0, 0x07, 0xFE, 0x0F,
  0xF0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x1F,
  0xC3, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00,
  0xFF, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE1, 0xFE, 0x00,
  0x03, 0xF8, 0x7F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x87, 0xF0,
  0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x1F,
  0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xF0,
  0x7F, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xBF,
  0x80, 0x7F, 0xFF, 0xEF, 0xE0, 0x1F, 0xFF, 0xF3, 0xF8, 0x03, 0xFF, 0xF8,
  0xFE, 0x00, 0x3F, 0xF8, 0x7F, 0x80, 0x01, 0xF0, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0xFE, 0x1F, 0xFE, 0x00, 0x7F, 0x9F,
  0xFF, 0xC0, 0x1F, 0xCF, 0xFF, 0xF8, 0x07, 0xF7, 0xFF, 0xFF, 0x01, 0xFD,
  0xFF, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x03, 0xFE, 0x0F,
  0xFC, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xF8,
  0x3F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F,
  0xE1, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xC0, 0x00,
  0x7F, 0x87, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x03, 0xF8,
  0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00,
  0x7F, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x0F, 0xF0, 0xFE, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x04,
  0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0x80, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x01, 0xFF, 0x00,
  0x7F, 0x00, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x03,
  0xF8, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0xFF,
  0x80, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0xF0,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0x00,
  0x01, 0xFE, 0x03, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0xCF, 0xF8,
  0x7F, 0xC0, 0x3F, 0x7F, 0xE3, 0xFF, 0x01, 0xFD, 0xFF, 0xDF, 0xFE, 0x07,
  0xFF, 0xFF, 0x7F, 0xF8, 0x1F, 0xF3, 0xFF, 0x9F, 0xE0, 0x7F, 0x03, 0xF8,
  0x3F, 0xC1, 0xFC, 0x0F, 0xC0, 0x7F, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0xFE, 0x03, 0xF0, 0x1F, 0x83, 0xF8, 0x0F, 0x80,
  0xFE, 0x0F, 0xE0, 0x3E, 0x03, 0xF8, 0x3F, 0x80, 0xF8, 0x0F, 0xE0, 0xFC,
  0x07, 0xE0, 0x3F, 0x83, 0xF0, 0x1F, 0x80, 0xFC, 0x1F, 0xC0, 0x7E, 0x03,
  0xF0, 0x7F, 0x01, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xC0, 0x7F, 0x07, 0xF0,
  0x1F, 0x01, 0xFC, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x7E, 0x03, 0xF0, 0x1F,
  0x83, 0xF8, 0x0F, 0xC0, 0x7E, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x3F, 0x80,
  0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xE0, 0x3F, 0x83, 0xF0, 0x1F, 0x80, 0xFE,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC1, 0xFC, 0x07,
  0xE0, 0x3F, 0x07, 0xF0, 0x1F, 0x01, 0xFC, 0x1F, 0xC0, 0x7C, 0x07, 0xF0,
  0x7E, 0x01, 0xF0, 0x1F, 0xC1, 0xF8, 0x0F, 0xC0, 0x7F, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0xFE, 0x03, 0xE0, 0x3F, 0x83,
  0xF8, 0x0F, 0x80, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x1F,
  0xFE, 0x00, 0x7F, 0x9F, 0xFF, 0xC0, 0x1F, 0xCF, 0xFF, 0xF8, 0x07, 0xF7,
  0xFF, 0xFF, 0x01, 0xFD, 0xFF, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F,
  0xF8, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x01,
  0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x0F, 0xF0,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x03, 0xFC, 0x3F,
  0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE1,
  0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x7F,
  0x87, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01,
  0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x00,
  0x0F, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFE, 0x3F, 0xF8, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0xFF,
  0x07, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x01,
  0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFF, 0x1F, 0xC0, 0x00,
  0x7F, 0x9F, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x1F, 0xC7, 0xF8, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00,
  0x03, 0xFC, 0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFE, 0x3F, 0xC0,
  0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0x83, 0xFC,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE1, 0xFF,
  0xE0, 0x01, 0xFE, 0x7F, 0xFF, 0x00, 0x1F, 0xCF, 0xFF, 0xF8, 0x01, 0xFD,
  0xFF, 0xFF, 0xC0, 0x1F, 0xDF, 0xFF, 0xFE, 0x01, 0xFF, 0xF1, 0xFF, 0xE0,
  0x1F, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x7F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x01,
  0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x03,
  0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xE0,
  0x00, 0x7F, 0x81, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFD, 0xFF, 0xFF,
  0xC0, 0x3F, 0xDF, 0xFF, 0xF8, 0x03, 0xF8, 0xFF, 0xFF, 0x00, 0x3F, 0x8F,
  0xFF, 0xE0, 0x03, 0xF8, 0x3F, 0xF8, 0x00, 0x3F, 0x80, 0x7C, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x87, 0xF0, 0x07, 0xFF,
  0xF3, 0xFC, 0x07, 0xFF, 0xFC, 0xFF, 0x03, 0xFF, 0xFF, 0xBF, 0x80, 0xFF,
  0xFF, 0xEF, 0xE0, 0x7F, 0xF0, 0xFB, 0xF8, 0x3F, 0xF0, 0x0E, 0xFE, 0x0F,
  0xF0, 0x01, 0xFF, 0x87, 0xF8, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0,
  0x7F, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00,
  0xFF, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x0F, 0xE1, 0xFE, 0x00,
  0x03, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x87, 0xF0,
  0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x3F,
  0xC0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0xFF,
  0x81, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xFF, 0xFB, 0xF8, 0x1F, 0xFF, 0xFE,
  0xFE, 0x03, 0xFF, 0xFF, 0x7F, 0x80, 0x7F, 0xFF, 0x9F, 0xC0, 0x0F, 0xFF,
  0xC7, 0xF0, 0x01, 0xFF, 0xC1, 0xFC, 0x00, 0x0F, 0x80, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x0F, 0xFF, 0x80, 0x0F, 0xE7, 0xFF, 0xF8, 0x03,
  0xF9, 0xFF, 0xFF, 0x80, 0x7F, 0x7F, 0xFF, 0xF8, 0x0F, 0xEF, 0xFF, 0xFF,
  0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xFC, 0x00,
  0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x83,
  0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xE0, 0x0F, 0xF8, 0x1F, 0xE0, 0x01, 0xFF, 0x07, 0xF0, 0x00, 0x3F, 0xC1,
  0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x1F,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x05, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x1F, 0xC3,
  0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0xFF,
  0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x03,
  0xF8, 0x7F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x87, 0xF0, 0x00,
  0x1F, 0xE1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0xC0,
  0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFE,
  0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x01, 0xFE,
  0x1F, 0xC0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFF, 0x07, 0xF0, 0x00,
  0x3F, 0xC1, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xF0,
  0x03, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x07, 0xF9, 0xFC, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFF, 0x1F, 0xE0,
  0x00, 0x3F, 0x87, 0xF8, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x07, 0xF8, 0x3F,
  0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xFC,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x1F,
  0xC0, 0x07, 0xF0, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x81,
  0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x01,
  0xFC, 0x7F, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x7F, 0x7E, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F,
  0xBF, 0x00, 0xFE, 0x00, 0xFD, 0xF8, 0x07, 0xF0, 0x07, 0xEF, 0xC0, 0x3F,
  0x80, 0x7E, 0x7E, 0x03, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0xE0, 0x1F, 0x9F,
  0x80, 0xFF, 0x01, 0xF8, 0xFC, 0x0F, 0x78, 0x0F, 0xC7, 0xE0, 0x7B, 0xC0,
  0x7E, 0x3F, 0x03, 0xDE, 0x03, 0xE1, 0xF8, 0x3C, 0xF0, 0x3F, 0x0F, 0xC1,
  0xE7, 0x81, 0xF8, 0x7E, 0x0F, 0x3C, 0x0F, 0x83, 0xF0, 0xF9, 0xE0, 0xFC,
  0x1F, 0x87, 0x8F, 0x07, 0xE0, 0xFC, 0x3C, 0x78, 0x3E, 0x07, 0xE3, 0xE3,
  0xC3, 0xF0, 0x3F, 0x1E, 0x1E, 0x1F, 0x81, 0xF8, 0xF0, 0xF0, 0xFC, 0x0F,
  0x8F, 0x87, 0x8F, 0xC0, 0x7C, 0x78, 0x3C, 0x7E, 0x03, 0xE3, 0xC1, 0xE3,
  0xF0, 0x1F, 0x1E, 0x0F, 0x1F, 0x00, 0xF9, 0xE0, 0x79, 0xF8, 0x07, 0xCF,
  0x03, 0xCF, 0xC0, 0x3E, 0x78, 0x1E, 0x7C, 0x01, 0xF7, 0x80, 0xF7, 0xE0,
  0x0F, 0xBC, 0x07, 0xBF, 0x00, 0x7D, 0xE0, 0x3D, 0xF0, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x07, 0xF1,
  0xFE, 0x00, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x3F, 0xE7, 0xF0, 0x00,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x01, 0xFE,
  0x00, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x00,
  0x7F, 0x80, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x03,
  0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x0F, 0xE1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xC0,
  0x00, 0x7F, 0x87, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x3F, 0xC3,
  0xF8, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x07,
  0xF8, 0x7F, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0xFE, 0x01, 0xFF, 0xFF, 0x3F, 0x80,
  0x3F, 0xFF, 0x8F, 0xE0, 0x07, 0xFF, 0xC7, 0xF8, 0x00, 0x7F, 0xC1, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x41, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0xFF, 0xF0,
  0x01, 0xFC, 0x3F, 0xFF, 0x00, 0x3F, 0x0F, 0xFF, 0xF0, 0x07, 0xE3, 0xFF,
  0xFF, 0x00, 0xFC, 0xFF, 0xBF, 0xE0, 0x3F, 0x9F, 0xC1, 0xFE, 0x07, 0xF3,
  0xF0, 0x1F, 0xE0, 0xFC, 0xFE, 0x03, 0xFE, 0x7F, 0x9F, 0xC0, 0x3F, 0xFF,
  0xE3, 0xF8, 0x03, 0xFF, 0xFC, 0x7E, 0x00, 0x7F, 0xFF, 0x0F, 0xC0, 0x07,
  0xFF, 0xC1, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
};

const GFXglyph JetBrainsMono_MediumItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 17, 50, 41, 12, -50 },
  { 108, 24, 21, 41, 12, -50 },
  { 171, 41, 50, 41, 1, -50 },
  { 428, 36, 69, 41, 3, -59 },
  { 739, 48, 50, 41, -3, -50 },
  { 1039, 38, 51, 41, 1, -50 },
  { 1282, 10, 21, 41, 19, -50 },
  { 1309, 29, 66, 41, 10, -57 },
  { 1549, 29, 66, 41, 3, -57 },
  { 1789, 37, 35, 41, 3, -41 },
  { 1951, 34, 32, 41, 4, -38 },
  { 2087, 19, 21, 41, 6, -10 },
  { 2137, 24, 7, 41, 9, -26 },
  { 2158, 13, 12, 41, 12, -11 },
  { 2178, 42, 63, 41, 0, -56 },
  { 2509, 35, 51, 41, 4, -50 },
  { 2733, 32, 50, 41, 3, -50 },
  { 2933, 36, 50, 41, 3, -50 },
  { 3158, 35, 51, 41, 3, -50 },
  { 3382, 33, 50, 41, 4, -50 },
  { 3589, 35, 51, 41, 4, -50 },
  { 3813, 34, 51, 41, 3, -50 },
  { 4030, 35, 50, 41, 7, -50 },
  { 4249, 36, 51, 41, 3, -50 },
  { 4479, 34, 50, 41, 6, -50 },
  { 4692, 17, 39, 41, 12, -38 },
  { 4775, 23, 49, 41, 6, -38 },
  { 4916, 34, 37, 41, 5, -41 },
  { 5074, 34, 23, 41, 4, -34 },
  { 5172, 34, 37, 41, 3, -41 },
  { 5330, 28, 50, 41, 9, -50 },
  { 5505, 42, 62, 41, 0, -50 },
  { 5831, 35, 50, 41, 0, -50 },
  { 6050, 36, 50, 41, 3, -50 },
  { 6275, 35, 51, 41, 4, -50 },
  { 6499, 36, 50, 41, 3, -50 },
  { 6724, 37, 50, 41, 3, -50 },
  { 6956, 38, 50, 41, 3, -50 },
  { 7194, 35, 51, 41, 4, -50 },
  { 7418, 37, 50, 41, 3, -50 },
  { 7650, 35, 50, 41, 4, -50 },
  { 7869, 38, 51, 41, 1, -50 },
  { 8112, 40, 50, 41, 3, -50 },
  { 8362, 31, 50, 41, 4, -50 },
  { 8556, 40, 50, 41, 1, -50 },
  { 8806, 37, 50, 41, 3, -50 },
  { 9038, 35, 51, 41, 4, -50 },
  { 9262, 38, 50, 41, 3, -50 },
  { 9500, 35, 62, 41, 4, -50 },
  { 9772, 37, 50, 41, 3, -50 },
  { 10004, 37, 51, 41, 3, -50 },
  { 10240, 35, 50, 41, 7, -50 },
  { 10459, 36, 51, 41, 4, -50 },
  { 10689, 35, 50, 41, 8, -50 },
  { 10908, 40, 50, 41, 4, -50 },
  { 11158, 44, 50, 41, -1, -50 },
  { 11433, 37, 50, 41, 7, -50 },
  { 11665, 36, 50, 41, 3, -50 },
  { 11890, 28, 63, 41, 9, -56 },
  { 12111, 22, 63, 41, 10, -56 },
  { 12285, 27, 63, 41, 6, -56 },
  { 12498, 30, 27, 41, 6, -50 },
  { 12600, 33, 6, 41, 0, 2 },
  { 12625, 14, 9, 41, 17, -53 },
  { 12641, 34, 39, 41, 4, -38 },
  { 12807, 34, 51, 41, 3, -50 },
  { 13024, 33, 39, 41, 4, -38 },
  { 13185, 36, 51, 41, 4, -50 },
  { 13415, 33, 39, 41, 4, -38 },
  { 13576, 46, 62, 41, -3, -50 },
  { 13933, 34, 50, 41, 4, -38 },
  { 14146, 34, 50, 41, 3, -50 },
  { 14359, 34, 53, 41, 2, -53 },
  { 14585, 36, 65, 41, 1, -53 },
  { 14878, 38, 50, 41, 3, -50 },
  { 15116, 30, 50, 41, 6, -50 },
  { 15304, 38, 38, 41, 1, -38 },
  { 15485, 34, 38, 41, 3, -38 },
  { 15647, 33, 39, 41, 4, -38 },
  { 15808, 36, 50, 41, 1, -38 },
  { 16033, 34, 50, 41, 4, -38 },
  { 16246, 35, 38, 41, 4, -38 },
  { 16413, 34, 39, 41, 3, -38 },
  { 16579, 34, 48, 41, 5, -48 },
  { 16783, 34, 38, 41, 4, -37 },
  { 16945, 34, 37, 41, 6, -37 },
  { 17103, 37, 37, 41, 5, -37 },
  { 17275, 40, 37, 41, 0, -37 },
  { 17460, 34, 49, 41, 4, -37 },
  { 17669, 34, 37, 41, 3, -37 },
  { 17827, 35, 63, 41, 6, -56 },
  { 18103, 17, 63, 41, 13, -56 },
  { 18237, 36, 63, 41, 1, -56 },
  { 18521, 35, 14, 41, 4, -31 },
};

const GFXfont JetBrainsMono_MediumItalic68pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic68pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic68pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _JETBRAINSMONO_MEDIUMITALIC68PT7B_H_
