#ifndef _JETBRAINSMONO_MEDIUMITALIC8PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x30, 0x76, 0x80, 0x29, 0xD4, 0xAE, 0x50, 0x11, 0x9A, 0xC3,
  0x59, 0xC8, 0x6D, 0x98, 0x66, 0xD8, 0x32, 0x91, 0x7B, 0x78, 0xE0, 0x16,
  0x44, 0x88, 0x46, 0x42, 0x11, 0x22, 0x2C, 0x27, 0xC8, 0xA0, 0x22, 0xF2,
  0xE0, 0xE0, 0xC0, 0x08, 0x84, 0x42, 0x21, 0x10, 0x32, 0x54, 0xE9, 0x38,
  0x35, 0x22, 0x2F, 0x32, 0x44, 0x44, 0x78, 0x78, 0x8C, 0x29, 0x30, 0x12,
  0x45, 0xF1, 0x7A, 0x1C, 0x29, 0x38, 0x12, 0x75, 0x97, 0xF9, 0x24, 0x48,
  0x32, 0x54, 0xE9, 0x38, 0x69, 0x9E, 0x48, 0x43, 0x43, 0x80, 0x16, 0x86,
  0x20, 0xE3, 0x80, 0x43, 0x16, 0x80, 0xE4, 0xA1, 0x00, 0x32, 0x6F, 0x5A,
  0xDB, 0x80, 0x33, 0x55, 0x79, 0x72, 0x5C, 0xA9, 0x78, 0x32, 0x50, 0x89,
  0x38, 0x72, 0x54, 0xA9, 0x70, 0x7A, 0x1C, 0x84, 0x78, 0x7A, 0x10, 0xE4,
  0x40, 0x32, 0x50, 0xE9, 0x38, 0x4A, 0x5C, 0xA9, 0x48, 0x79, 0x08, 0x42,
  0x78, 0x38, 0x84, 0x29, 0x70, 0x4A, 0x94, 0xC9, 0x48, 0x92, 0x49, 0xC0,
  0x4A, 0xD5, 0x69, 0x48, 0x4B, 0x5C, 0xEB, 0x48, 0x32, 0x54, 0xA9, 0x38,
  0x72, 0x52, 0xE8, 0x40, 0x32, 0x54, 0xA9, 0x38, 0xC0, 0x72, 0x54, 0xC9,
  0x48, 0x32, 0x50, 0x69, 0x38, 0xF4, 0x44, 0x44, 0x4A, 0x54, 0xA9, 0x38,
  0x99, 0xAA, 0xCC, 0x6B, 0x6B, 0xE5, 0x68, 0x4A, 0x88, 0x45, 0x48, 0x9A,
  0xA4, 0x44, 0x78, 0x88, 0x44, 0x78, 0x69, 0x25, 0x26, 0x91, 0x24, 0x89,
  0x64, 0x94, 0x96, 0x4E, 0x80, 0xF0, 0xC0, 0x75, 0x97, 0x46, 0x55, 0x9F,
  0x74, 0x87, 0x09, 0x54, 0xA9, 0x38, 0x77, 0x87, 0x19, 0x1E, 0x42, 0x23,
  0x00, 0x75, 0x57, 0x70, 0x46, 0x55, 0x99, 0x34, 0x22, 0x2F, 0x16, 0x11,
  0x12, 0xE0, 0x42, 0x54, 0xC6, 0x48, 0xC9, 0x28, 0xC0, 0x7D, 0xAD, 0x60,
  0x75, 0x99, 0x75, 0x97, 0x75, 0x9F, 0x80, 0x75, 0x97, 0x10, 0x72, 0x11,
  0x00, 0x76, 0x1F, 0x4F, 0x44, 0x86, 0x55, 0x97, 0xBA, 0xCC, 0xDE, 0xAA,
  0x59, 0x19, 0x20, 0x55, 0x57, 0x70, 0x72, 0x4F, 0x12, 0x24, 0xC4, 0x46,
  0x29, 0x24, 0x94, 0x62, 0x22, 0x34, 0x4C, 0x4D, 0x80,
};

const GFXglyph JetBrainsMono_MediumItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 6, 5, 1, -6 },
  { 3, 3, 3, 5, 1, -6 },
  { 5, 5, 6, 5, 0, -6 },
  { 9, 5, 8, 5, 0, -7 },
  { 14, 5, 6, 5, 0, -6 },
  { 18, 5, 6, 5, 0, -6 },
  { 22, 1, 3, 5, 2, -6 },
  { 23, 4, 8, 5, 1, -7 },
  { 27, 4, 8, 5, 0, -7 },
  { 31, 5, 4, 5, 0, -5 },
  { 34, 4, 4, 5, 0, -5 },
  { 36, 2, 2, 5, 1, -1 },
  { 37, 3, 1, 5, 1, -3 },
  { 38, 2, 1, 5, 1, -1 },
  { 39, 5, 8, 5, 0, -7 },
  { 44, 5, 6, 5, 0, -6 },
  { 48, 4, 6, 5, 0, -6 },
  { 51, 5, 6, 5, 0, -6 },
  { 55, 5, 6, 5, 0, -6 },
  { 59, 4, 6, 5, 0, -6 },
  { 62, 5, 6, 5, 0, -6 },
  { 66, 4, 6, 5, 0, -6 },
  { 69, 4, 6, 5, 1, -6 },
  { 72, 5, 6, 5, 0, -6 },
  { 76, 4, 6, 5, 1, -6 },
  { 79, 2, 4, 5, 1, -4 },
  { 80, 2, 5, 5, 1, -4 },
  { 82, 4, 5, 5, 1, -5 },
  { 85, 3, 3, 5, 1, -4 },
  { 87, 4, 5, 5, 0, -5 },
  { 90, 3, 6, 5, 1, -6 },
  { 93, 5, 7, 5, 0, -6 },
  { 98, 4, 6, 5, 0, -6 },
  { 101, 5, 6, 5, 0, -6 },
  { 105, 5, 6, 5, 0, -6 },
  { 109, 5, 6, 5, 0, -6 },
  { 113, 5, 6, 5, 0, -6 },
  { 117, 5, 6, 5, 0, -6 },
  { 121, 5, 6, 5, 0, -6 },
  { 125, 5, 6, 5, 0, -6 },
  { 129, 5, 6, 5, 0, -6 },
  { 133, 5, 6, 5, 0, -6 },
  { 137, 5, 6, 5, 0, -6 },
  { 141, 3, 6, 5, 1, -6 },
  { 144, 5, 6, 5, 0, -6 },
  { 148, 5, 6, 5, 0, -6 },
  { 152, 5, 6, 5, 0, -6 },
  { 156, 5, 6, 5, 0, -6 },
  { 160, 5, 7, 5, 0, -6 },
  { 165, 5, 6, 5, 0, -6 },
  { 169, 5, 6, 5, 0, -6 },
  { 173, 4, 6, 5, 1, -6 },
  { 176, 5, 6, 5, 0, -6 },
  { 180, 4, 6, 5, 1, -6 },
  { 183, 5, 6, 5, 0, -6 },
  { 187, 5, 6, 5, 0, -6 },
  { 191, 4, 6, 5, 1, -6 },
  { 194, 5, 6, 5, 0, -6 },
  { 198, 3, 8, 5, 1, -7 },
  { 201, 3, 8, 5, 1, -7 },
  { 204, 3, 8, 5, 1, -7 },
  { 207, 3, 3, 5, 1, -6 },
  { 209, 4, 1, 5, 0, 0 },
  { 210, 2, 1, 5, 2, -6 },
  { 211, 4, 4, 5, 0, -4 },
  { 213, 4, 6, 5, 0, -6 },
  { 216, 4, 4, 5, 0, -4 },
  { 218, 5, 6, 5, 0, -6 },
  { 222, 4, 4, 5, 0, -4 },
  { 224, 5, 7, 5, 0, -6 },
  { 229, 4, 5, 5, 0, -4 },
  { 232, 4, 6, 5, 0, -6 },
  { 235, 4, 6, 5, 0, -6 },
  { 238, 4, 7, 5, 0, -6 },
  { 242, 5, 6, 5, 0, -6 },
  { 246, 3, 6, 5, 1, -6 },
  { 249, 5, 4, 5, 0, -4 },
  { 252, 4, 4, 5, 0, -4 },
  { 254, 4, 4, 5, 0, -4 },
  { 256, 4, 5, 5, 0, -4 },
  { 259, 4, 5, 5, 0, -4 },
  { 262, 5, 4, 5, 0, -4 },
  { 265, 4, 4, 5, 0, -4 },
  { 267, 4, 6, 5, 1, -6 },
  { 270, 4, 4, 5, 0, -4 },
  { 272, 4, 4, 5, 1, -4 },
  { 274, 4, 4, 5, 1, -4 },
  { 276, 5, 4, 5, 0, -4 },
  { 279, 4, 5, 5, 0, -4 },
  { 282, 4, 4, 5, 0, -4 },
  { 284, 4, 8, 5, 1, -7 },
  { 288, 3, 8, 5, 1, -7 },
  { 291, 4, 8, 5, 0, -7 },
  { 295, 5, 2, 5, 0, -4 },
};

const GFXfont JetBrainsMono_MediumItalic8pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic8pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _JETBRAINSMONO_MEDIUMITALIC8PT7B_H_
