#ifndef _JETBRAINSMONO_MEDIUMITALIC12PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0xB4, 0x80, 0xC0, 0xDD, 0x99, 0x12, 0x25, 0x79, 0x22, 0x45,
  0x3F, 0x24, 0xD0, 0x08, 0x38, 0xBB, 0x57, 0x07, 0x87, 0x0A, 0x54, 0xF0,
  0x41, 0x00, 0x31, 0x52, 0x54, 0x78, 0x10, 0x1E, 0x32, 0x52, 0x8C, 0x1C,
  0x48, 0x81, 0x07, 0x0A, 0xF3, 0x64, 0x74, 0x5E, 0x19, 0x98, 0x8C, 0x62,
  0x10, 0x86, 0x18, 0x20, 0x61, 0x84, 0x21, 0x08, 0x42, 0x33, 0x31, 0x00,
  0x12, 0x9D, 0xCC, 0x52, 0x60, 0x30, 0xCF, 0xFE, 0x20, 0x80, 0x6D, 0x40,
  0xFF, 0xF0, 0x02, 0x0C, 0x10, 0x60, 0x83, 0x04, 0x10, 0x20, 0x83, 0x00,
  0x39, 0x3C, 0x63, 0xBA, 0x28, 0xA6, 0xF0, 0x1B, 0xA4, 0x21, 0x18, 0xC4,
  0xF8, 0x1C, 0x4D, 0x98, 0x20, 0xC3, 0x0C, 0x30, 0xFC, 0x7C, 0x31, 0x0C,
  0x38, 0x20, 0xA6, 0xF0, 0x0C, 0x63, 0x18, 0x4A, 0x2F, 0x86, 0x18, 0x7D,
  0x04, 0x3E, 0xC8, 0x20, 0xA6, 0xF0, 0x0C, 0x10, 0x41, 0x07, 0xC8, 0x91,
  0x26, 0x78, 0x7D, 0x1C, 0xC2, 0x10, 0x42, 0x18, 0x40, 0x39, 0x34, 0xD2,
  0x33, 0x28, 0xA2, 0xF0, 0x39, 0x3C, 0x63, 0xD9, 0xE1, 0x08, 0x40, 0x6C,
  0x00, 0xB0, 0x33, 0x00, 0x02, 0x64, 0x80, 0x0C, 0xEC, 0x30, 0x70, 0x60,
  0xFC, 0x00, 0x3E, 0xC3, 0x86, 0x37, 0x40, 0xE1, 0x84, 0x27, 0x60, 0x00,
  0xC0, 0x1C, 0x45, 0x0A, 0x75, 0x3A, 0x64, 0xCF, 0x81, 0x81, 0xC0, 0x18,
  0x61, 0xCF, 0x25, 0x97, 0xD1, 0xC4, 0x3C, 0x4C, 0x9B, 0x27, 0x88, 0x91,
  0x26, 0xF8, 0x39, 0x3C, 0xF0, 0x82, 0x08, 0x26, 0xF0, 0x3C, 0x4D, 0x9B,
  0x34, 0x48, 0x91, 0x26, 0xF8, 0x7D, 0x04, 0x30, 0xFA, 0x08, 0x20, 0xF8,
  0x7D, 0x04, 0x30, 0xFA, 0x08, 0x20, 0x80, 0x39, 0x3C, 0xF0, 0x9E, 0xE8,
  0xA6, 0xF0, 0x22, 0x44, 0x9B, 0x37, 0xC8, 0x91, 0x22, 0xCC, 0x7C, 0x43,
  0x0C, 0x20, 0x82, 0x08, 0xF8, 0x1E, 0x0C, 0x18, 0x20, 0x40, 0xB1, 0x66,
  0x78, 0x23, 0x26, 0x24, 0x68, 0x78, 0x48, 0x48, 0x4C, 0xC4, 0x42, 0x10,
  0x8C, 0x62, 0x10, 0xF8, 0x22, 0xCD, 0x5A, 0xD5, 0xE8, 0x91, 0x22, 0xC4,
  0x32, 0x65, 0xCB, 0xB5, 0x4A, 0x93, 0x26, 0xCC, 0x39, 0x3C, 0xF3, 0x8A,
  0x28, 0xA6, 0xF0, 0x3C, 0x4C, 0x8B, 0x17, 0xCE, 0x10, 0x20, 0xC0, 0x39,
  0x3C, 0x73, 0x8A, 0x28, 0xA6, 0xF0, 0xC1, 0x80, 0x3C, 0x4C, 0x8B, 0x37,
  0xC9, 0x12, 0x26, 0xC4, 0x1C, 0x4D, 0x89, 0x03, 0x80, 0x81, 0x22, 0x78,
  0xFC, 0x43, 0x0C, 0x20, 0x82, 0x08, 0x60, 0x45, 0x1C, 0xF3, 0x8A, 0x28,
  0xA6, 0xF0, 0xC7, 0x89, 0x32, 0x44, 0x8A, 0x14, 0x38, 0x60, 0x93, 0x2A,
  0xD5, 0xAB, 0x5B, 0x36, 0x6C, 0x98, 0x63, 0x26, 0x34, 0x18, 0x18, 0x38,
  0x28, 0x4C, 0xC4, 0xC6, 0x89, 0x23, 0xC3, 0x04, 0x08, 0x10, 0x60, 0x3E,
  0x0C, 0x10, 0x41, 0x86, 0x08, 0x20, 0xFC, 0x7A, 0x10, 0x84, 0x23, 0x10,
  0x84, 0x38, 0x88, 0xC4, 0x44, 0x62, 0x22, 0x30, 0x38, 0xC6, 0x21, 0x08,
  0x46, 0x31, 0x38, 0x11, 0x9A, 0x98, 0x80, 0xFC, 0xC0, 0x3D, 0x78, 0xA2,
  0x8A, 0x6F, 0x80, 0x20, 0x40, 0xB3, 0xA6, 0x48, 0x91, 0x26, 0xF8, 0x31,
  0x28, 0xE0, 0x82, 0x6F, 0x00, 0x04, 0x13, 0xD7, 0x8A, 0x28, 0xA6, 0xF8,
  0x31, 0x28, 0xBE, 0x82, 0x2F, 0x00, 0x07, 0x86, 0x02, 0x07, 0xE0, 0x80,
  0x40, 0x60, 0x30, 0x10, 0x08, 0x3C, 0x00, 0x3D, 0x78, 0xA2, 0x8B, 0xE5,
  0x86, 0xF0, 0x20, 0x40, 0xB3, 0xA6, 0x48, 0x91, 0x22, 0xCC, 0x0C, 0x03,
  0x8E, 0x18, 0x61, 0x04, 0xFC, 0x04, 0x03, 0xCF, 0x0C, 0x20, 0x82, 0x08,
  0x6F, 0x00, 0x41, 0x04, 0x72, 0xD3, 0xC9, 0x24, 0x98, 0xF1, 0x08, 0x42,
  0x31, 0x8C, 0x38, 0x54, 0xF5, 0x4A, 0xB5, 0x5A, 0xA5, 0x00, 0x2C, 0xE9,
  0x92, 0x24, 0x48, 0xB3, 0x00, 0x31, 0x68, 0xA2, 0x8A, 0x6F, 0x00, 0x2C,
  0xE9, 0x92, 0x24, 0x49, 0x9E, 0x60, 0xC0, 0x3D, 0x78, 0xA2, 0x8A, 0x6F,
  0x86, 0x10, 0x59, 0xBC, 0xF0, 0x82, 0x08, 0x00, 0x39, 0x2C, 0x1C, 0x0A,
  0x2F, 0x00, 0x33, 0xFF, 0xC8, 0x61, 0x84, 0x1E, 0xCF, 0x38, 0xA2, 0x8A,
  0x6F, 0x00, 0x87, 0x3C, 0x96, 0x51, 0xC6, 0x00, 0x96, 0xDB, 0x76, 0xDB,
  0x69, 0x00, 0x66, 0x48, 0xE0, 0xC2, 0x8D, 0x33, 0x00, 0xCF, 0x38, 0xA2,
  0x8B, 0xE5, 0x86, 0xF0, 0x3E, 0xF8, 0x30, 0xC2, 0x08, 0x3F, 0x00, 0x0C,
  0x61, 0x04, 0x13, 0x83, 0x0C, 0x20, 0x83, 0x80, 0x24, 0xB6, 0x92, 0x4B,
  0x00, 0x30, 0x61, 0x04, 0x10, 0x71, 0x0C, 0x30, 0x8E, 0x00, 0x42, 0x99,
  0x80,
};

const GFXglyph JetBrainsMono_MediumItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 9, 7, 2, -9 },
  { 5, 4, 4, 7, 2, -9 },
  { 7, 7, 9, 7, 0, -9 },
  { 15, 7, 12, 7, 0, -10 },
  { 26, 8, 9, 7, 0, -9 },
  { 35, 7, 9, 7, 0, -9 },
  { 43, 2, 4, 7, 3, -9 },
  { 44, 5, 12, 7, 2, -10 },
  { 52, 5, 12, 7, 1, -10 },
  { 60, 6, 6, 7, 1, -7 },
  { 65, 6, 6, 7, 1, -7 },
  { 70, 3, 4, 7, 1, -2 },
  { 72, 4, 2, 7, 2, -5 },
  { 73, 2, 2, 7, 2, -2 },
  { 74, 7, 11, 7, 0, -10 },
  { 84, 6, 9, 7, 1, -9 },
  { 91, 5, 9, 7, 1, -9 },
  { 97, 7, 9, 7, 0, -9 },
  { 105, 6, 9, 7, 1, -9 },
  { 112, 6, 9, 7, 1, -9 },
  { 119, 6, 9, 7, 1, -9 },
  { 126, 7, 9, 7, 0, -9 },
  { 134, 6, 9, 7, 1, -9 },
  { 141, 6, 9, 7, 1, -9 },
  { 148, 6, 9, 7, 1, -9 },
  { 155, 3, 7, 7, 2, -7 },
  { 158, 4, 9, 7, 1, -7 },
  { 163, 6, 6, 7, 1, -7 },
  { 168, 6, 4, 7, 1, -6 },
  { 171, 5, 6, 7, 1, -7 },
  { 175, 5, 9, 7, 2, -9 },
  { 181, 7, 11, 7, 0, -9 },
  { 191, 6, 9, 7, 0, -9 },
  { 198, 7, 9, 7, 0, -9 },
  { 206, 6, 9, 7, 1, -9 },
  { 213, 7, 9, 7, 0, -9 },
  { 221, 6, 9, 7, 1, -9 },
  { 228, 6, 9, 7, 1, -9 },
  { 235, 6, 9, 7, 1, -9 },
  { 242, 7, 9, 7, 0, -9 },
  { 250, 6, 9, 7, 1, -9 },
  { 257, 7, 9, 7, 0, -9 },
  { 265, 8, 9, 7, 0, -9 },
  { 274, 5, 9, 7, 1, -9 },
  { 280, 7, 9, 7, 0, -9 },
  { 288, 7, 9, 7, 0, -9 },
  { 296, 6, 9, 7, 1, -9 },
  { 303, 7, 9, 7, 0, -9 },
  { 311, 6, 11, 7, 1, -9 },
  { 320, 7, 9, 7, 0, -9 },
  { 328, 7, 9, 7, 0, -9 },
  { 336, 6, 9, 7, 1, -9 },
  { 343, 6, 9, 7, 1, -9 },
  { 350, 7, 9, 7, 1, -9 },
  { 358, 7, 9, 7, 1, -9 },
  { 366, 8, 9, 7, 0, -9 },
  { 375, 7, 9, 7, 1, -9 },
  { 383, 7, 9, 7, 0, -9 },
  { 391, 5, 11, 7, 2, -10 },
  { 398, 4, 11, 7, 2, -10 },
  { 404, 5, 11, 7, 1, -10 },
  { 411, 5, 5, 7, 1, -9 },
  { 415, 6, 1, 7, 0, 0 },
  { 416, 2, 1, 7, 3, -9 },
  { 417, 6, 7, 7, 1, -7 },
  { 423, 7, 9, 7, 0, -9 },
  { 431, 6, 7, 7, 1, -7 },
  { 437, 6, 9, 7, 1, -9 },
  { 444, 6, 7, 7, 1, -7 },
  { 450, 9, 11, 7, -1, -9 },
  { 463, 6, 9, 7, 1, -7 },
  { 470, 7, 9, 7, 0, -9 },
  { 478, 6, 9, 7, 0, -9 },
  { 485, 6, 11, 7, 0, -9 },
  { 494, 6, 9, 7, 1, -9 },
  { 501, 5, 9, 7, 1, -9 },
  { 507, 7, 7, 7, 0, -7 },
  { 514, 7, 7, 7, 0, -7 },
  { 521, 6, 7, 7, 1, -7 },
  { 527, 7, 9, 7, 0, -7 },
  { 535, 6, 9, 7, 1, -7 },
  { 542, 6, 7, 7, 1, -7 },
  { 548, 6, 7, 7, 1, -7 },
  { 554, 6, 8, 7, 1, -8 },
  { 560, 6, 7, 7, 1, -7 },
  { 566, 6, 7, 7, 1, -7 },
  { 572, 6, 7, 7, 1, -7 },
  { 578, 7, 7, 7, 0, -7 },
  { 585, 6, 9, 7, 1, -7 },
  { 592, 7, 7, 7, 0, -7 },
  { 599, 6, 11, 7, 1, -10 },
  { 608, 3, 11, 7, 2, -10 },
  { 613, 6, 11, 7, 0, -10 },
  { 622, 6, 3, 7, 1, -6 },
};

const GFXfont JetBrainsMono_MediumItalic12pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic12pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _JETBRAINSMONO_MEDIUMITALIC12PT7B_H_
