#ifndef _JETBRAINSMONO_MEDIUMITALIC45PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0xFE, 0x3F, 0xC7, 0xF0, 0x7C, 0x00, 0x7C,
  0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x78,
  0x3E, 0xF8, 0x3E, 0xF8, 0x3C, 0xF8, 0x3C, 0xF8, 0x3C, 0xF0, 0x3C, 0xF0,
  0x7C, 0xF0, 0x78, 0x00, 0x0E, 0x03, 0xC0, 0x03, 0xC0, 0x70, 0x00, 0x78,
  0x1E, 0x00, 0x0E, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00,
  0x0E, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x21, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0x1E, 0x03, 0xC0, 0x03,
  0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0xF0,
  0x00, 0x78, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0x78,
  0x1E, 0x01, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0,
  0x1E, 0x03, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x70, 0x1E, 0x00, 0x1E, 0x03,
  0x80, 0x03, 0xC0, 0xF0, 0x00, 0x70, 0x1E, 0x00, 0x1E, 0x03, 0x80, 0x03,
  0xC0, 0xF0, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x07, 0xE7, 0x7E, 0x07, 0xC6, 0x3F, 0x0F, 0x8E, 0x1F, 0x0F, 0x8E,
  0x1F, 0x0F, 0x0E, 0x1F, 0x1F, 0x0E, 0x00, 0x1F, 0x8E, 0x00, 0x1F, 0x8C,
  0x00, 0x0F, 0xDC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x3B,
  0xF8, 0x00, 0x39, 0xF8, 0x00, 0x38, 0xFC, 0x00, 0x38, 0x7C, 0x00, 0x38,
  0x7C, 0xF8, 0x30, 0x78, 0xF8, 0x70, 0xF8, 0xF8, 0x70, 0xF8, 0xFC, 0x71,
  0xF0, 0x7E, 0x73, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x0F, 0x01, 0xFF, 0x80, 0x1E, 0x03, 0xFF, 0x80, 0x3C, 0x03, 0xC7,
  0xC0, 0x78, 0x07, 0x83, 0xC0, 0xF0, 0x07, 0x83, 0xC0, 0xE0, 0x07, 0x83,
  0xC1, 0xE0, 0x07, 0x03, 0xC3, 0xC0, 0x07, 0x03, 0x87, 0x80, 0x0F, 0x07,
  0x8F, 0x00, 0x0F, 0x07, 0x9E, 0x00, 0x07, 0x8F, 0x1C, 0x00, 0x07, 0xFF,
  0x3C, 0x00, 0x03, 0xFE, 0x78, 0x00, 0x01, 0xF8, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0x0F, 0x3F, 0xC0, 0x00, 0x1E, 0x7F, 0xE0, 0x00, 0x3C,
  0xFB, 0xF0, 0x00, 0x79, 0xE0, 0xF0, 0x00, 0xF1, 0xE0, 0xF0, 0x01, 0xE1,
  0xE0, 0xF0, 0x01, 0xC1, 0xC0, 0xF0, 0x03, 0xC1, 0xC0, 0xE0, 0x07, 0x83,
  0xC0, 0xE0, 0x0F, 0x03, 0xC1, 0xE0, 0x1E, 0x01, 0xE3, 0xE0, 0x3C, 0x01,
  0xFF, 0xC0, 0x38, 0x00, 0xFF, 0x80, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F,
  0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x78, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xBE, 0x07, 0xCF, 0x8F, 0x87, 0xCF, 0x87, 0xC7,
  0xC7, 0xC1, 0xF3, 0xC3, 0xE0, 0xFB, 0xE1, 0xF0, 0x3F, 0xE0, 0xF0, 0x1F,
  0xE0, 0x78, 0x07, 0xF0, 0x7C, 0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x1F, 0x01,
  0xFE, 0x0F, 0xC1, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFB, 0xE0, 0x7F,
  0xF0, 0xF8, 0x1F, 0xF0, 0x7E, 0x00, 0x3E, 0x7C, 0xFB, 0xF7, 0xCF, 0x9F,
  0x3E, 0x7C, 0xF1, 0xE3, 0xC7, 0x9E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x00, 0x3E, 0x00, 0x01,
  0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x38, 0x1E, 0x07, 0x7E, 0x1C,
  0x3F, 0x7F, 0x9C, 0xFF, 0xFF, 0xD9, 0xFF, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xEF, 0x00, 0x03, 0xEF,
  0x80, 0x07, 0xCF, 0x80, 0x0F, 0x87, 0xC0, 0x1F, 0x87, 0xC0, 0x3F, 0x07,
  0xE0, 0x3E, 0x03, 0xE0, 0x1C, 0x03, 0xC0, 0x08, 0x01, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x7F, 0x07,
  0xE0, 0xFC, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x7C,
  0x07, 0xC0, 0x78, 0x0F, 0x80, 0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0x08, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x1F, 0x0F, 0x00, 0x1F,
  0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x3E,
  0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x3C, 0x3E, 0x3E, 0x7E, 0x3C,
  0x3E, 0x7E, 0x3C, 0x3C, 0x7E, 0x7C, 0x3C, 0x3C, 0x7C, 0x7C, 0x00, 0x7C,
  0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x78, 0x7C, 0x00, 0x78, 0x78, 0x00, 0x78,
  0x78, 0x00, 0xF8, 0x78, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0,
  0x7E, 0x07, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFB, 0xE0, 0x3F, 0x1F, 0x01, 0xF0, 0xF8,
  0x0E, 0x07, 0x80, 0x60, 0x7C, 0x04, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0x3E,
  0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x08, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3,
  0xE0, 0x07, 0xC7, 0xE0, 0x1F, 0x87, 0xE0, 0x7E, 0x0F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x1F, 0x07, 0xE0, 0x3E, 0x0F, 0x80, 0x78, 0x3E, 0x01, 0xF0,
  0xF8, 0x03, 0xE3, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x03, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x03, 0x00, 0x0F, 0x3F, 0xE0, 0x1F, 0x7F,
  0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0x80, 0xF8, 0x1F, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0xF8, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7E, 0x07, 0xE0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x7F,
  0x00, 0xFB, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFE, 0x07, 0xF3,
  0xE0, 0x0F, 0xDF, 0x80, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xEF, 0xC0, 0x0F,
  0x9F, 0x00, 0x7C, 0x7E, 0x07, 0xF1, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x07,
  0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0x00, 0x1F, 0x3E, 0x00,
  0x3E, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x3E, 0x0F, 0x80,
  0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x00, 0x3E, 0x0F, 0x80,
  0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0xC0, 0xF8, 0x07, 0xE3, 0xF0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x0F, 0xE7,
  0xF0, 0x1F, 0x81, 0xF0, 0x3E, 0x01, 0xF8, 0x3E, 0x00, 0xF8, 0x7C, 0x00,
  0xF8, 0x7C, 0x00, 0xF8, 0x78, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xFC, 0x00,
  0xF8, 0x7C, 0x01, 0xF0, 0x7E, 0x07, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x1F, 0x81, 0xF8, 0xFC, 0x03, 0xF7,
  0xE0, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0xC0, 0x1F,
  0x9F, 0x80, 0xFC, 0x7F, 0x9F, 0xF1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x03,
  0xFD, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC1, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0x83, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x3F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF0, 0x7C,
  0x00, 0x00, 0x7C, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0x80, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x30, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF8, 0x08, 0x00, 0x00, 0x38, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0x80,
  0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xF0, 0x03,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0xE1, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00,
  0x3E, 0x07, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x1E, 0x1F, 0x00, 0x01, 0xE1, 0xE0, 0x1F, 0x1E, 0x1E, 0x03,
  0xFD, 0xE1, 0xE0, 0x7F, 0xDE, 0x1E, 0x0F, 0x87, 0xC1, 0xE0, 0xF0, 0x3C,
  0x3E, 0x1F, 0x03, 0xC3, 0xC1, 0xE0, 0x3C, 0x3C, 0x1E, 0x03, 0xC3, 0xC1,
  0xE0, 0x7C, 0x3C, 0x1E, 0x07, 0x83, 0xC3, 0xE0, 0x78, 0x7C, 0x3C, 0x07,
  0x87, 0x83, 0xC0, 0x78, 0x78, 0x3C, 0x07, 0x87, 0x83, 0xC0, 0xF8, 0x78,
  0x3E, 0x1F, 0x87, 0x83, 0xFF, 0xF0, 0xF8, 0x1F, 0xF7, 0x0F, 0x81, 0xFC,
  0xF0, 0xF8, 0x03, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xBE,
  0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x79, 0xF0, 0x01, 0xF1, 0xE0,
  0x03, 0xE3, 0xC0, 0x0F, 0x87, 0x80, 0x1F, 0x0F, 0x00, 0x3C, 0x1E, 0x00,
  0xF8, 0x3C, 0x01, 0xF0, 0x78, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1E,
  0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x3E, 0x00, 0x78, 0x7C, 0x00, 0xF1, 0xF0, 0x01,
  0xF3, 0xE0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1F,
  0xF8, 0x00, 0x3E, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x0F, 0x81, 0xFE, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x3E,
  0x0F, 0x80, 0x3F, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x3E, 0x1F, 0x00, 0x3E,
  0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x7C, 0x1F, 0x01, 0xF8, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3E, 0x01, 0xF8,
  0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x7C, 0x00, 0x7C,
  0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8,
  0x78, 0x01, 0xF0, 0x78, 0x07, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFE, 0x0F, 0xC1, 0xF0, 0x0F, 0x87,
  0xC0, 0x1F, 0x8F, 0x80, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0x87,
  0xC0, 0x1F, 0x0F, 0xE0, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0x80, 0x7E, 0x0F,
  0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x1F,
  0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F,
  0x00, 0x3E, 0x1E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E,
  0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x78, 0x7C,
  0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7C,
  0x01, 0xF0, 0x7C, 0x03, 0xF0, 0xF8, 0x3F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0xFE, 0x0F, 0xC1, 0xF0, 0x0F, 0x87, 0xC0, 0x1F, 0x8F, 0x80, 0x1F, 0x3E,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x3F,
  0xF8, 0xF8, 0x7F, 0xF1, 0xF0, 0xFF, 0xE3, 0xE1, 0xFF, 0xC7, 0x80, 0x0F,
  0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1,
  0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0xE0, 0xFC, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0x80, 0x1F, 0x0F,
  0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x3E, 0x0F,
  0x80, 0x3E, 0x0F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F,
  0x00, 0x3C, 0x1F, 0x00, 0x7C, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x3E,
  0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C,
  0x00, 0xF8, 0x7C, 0x00, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x78,
  0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xE0, 0xF8,
  0x03, 0xE0, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C,
  0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0x81, 0xF8, 0x07, 0xE0,
  0x3F, 0x03, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x03, 0xE0,
  0x7C, 0x01, 0xF8, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x1F,
  0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x0F, 0x81, 0xF8, 0x03, 0xC0,
  0x7C, 0x01, 0xF0, 0x3F, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x07, 0xC0, 0x07,
  0xC3, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F,
  0x80, 0x0F, 0x03, 0xF0, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x7C,
  0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0,
  0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x03,
  0xE0, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E,
  0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0E, 0xE0,
  0xF7, 0x07, 0xB8, 0x3D, 0xC1, 0xDE, 0x0F, 0x70, 0xF7, 0x83, 0xDE, 0x39,
  0xE0, 0xF7, 0x9E, 0x78, 0x7D, 0xE7, 0xBC, 0x1E, 0x3B, 0xCF, 0x07, 0x8E,
  0xF3, 0xC1, 0xE3, 0xB8, 0xF0, 0x78, 0xFE, 0x7C, 0x1E, 0x3F, 0x1F, 0x0F,
  0x8F, 0xC7, 0xC3, 0xE3, 0xE1, 0xE0, 0xF8, 0x00, 0x78, 0x3E, 0x00, 0x3E,
  0x0F, 0x00, 0x0F, 0x83, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00,
  0x3C, 0x1F, 0x00, 0x0F, 0x07, 0xC0, 0x07, 0xC1, 0xE0, 0x01, 0xF0, 0x78,
  0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0x83, 0xE0, 0x01, 0xE0,
  0xF8, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0x81, 0xF8,
  0x03, 0xC1, 0xFE, 0x01, 0xE0, 0xFF, 0x01, 0xF0, 0x7F, 0x80, 0xF8, 0x3F,
  0xC0, 0x7C, 0x1F, 0xE0, 0x3C, 0x0F, 0x78, 0x1E, 0x0F, 0xBC, 0x0F, 0x07,
  0xDE, 0x0F, 0x83, 0xCF, 0x07, 0xC1, 0xE7, 0x83, 0xE0, 0xF1, 0xE1, 0xE0,
  0x78, 0xF0, 0xF0, 0x7C, 0x78, 0x78, 0x3E, 0x3C, 0x7C, 0x1F, 0x1E, 0x3E,
  0x0F, 0x0F, 0x9F, 0x07, 0x83, 0xCF, 0x83, 0xC1, 0xE7, 0x83, 0xE0, 0xF3,
  0xC1, 0xF0, 0x79, 0xE0, 0xF8, 0x3C, 0xF0, 0x7C, 0x0F, 0xF8, 0x3C, 0x07,
  0xFC, 0x1E, 0x03, 0xFC, 0x0F, 0x01, 0xFE, 0x0F, 0x80, 0xFF, 0x07, 0xC0,
  0x3F, 0x83, 0xE0, 0x1F, 0xC1, 0xE0, 0x0F, 0xE0, 0xF0, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0xFE, 0x1F, 0xC1, 0xF0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x3E,
  0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0,
  0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x00, 0x1E, 0x3E, 0x00, 0x7C, 0x7C, 0x00,
  0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0x80, 0x0F,
  0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1,
  0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0x87, 0xC0, 0x3F, 0x0F, 0xC0, 0xFC, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0x7C, 0x01, 0xF8, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x1F,
  0x0F, 0x80, 0x0F, 0x87, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x03,
  0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xF8, 0x7C, 0x01, 0xF8, 0x3C, 0x07,
  0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xF0, 0x7E, 0x0F, 0xC0,
  0x3E, 0x0F, 0x80, 0x3F, 0x0F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00,
  0x1E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x3E, 0x00,
  0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x3E, 0x00,
  0x7C, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00,
  0x78, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00,
  0xF8, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xF8,
  0x1F, 0xE0, 0x7C, 0x01, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F,
  0x80, 0x1F, 0x07, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1,
  0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x03, 0xE0, 0xF8, 0x01, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x0F,
  0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80,
  0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x07, 0xC1, 0xF0,
  0x03, 0xE0, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x3F,
  0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0xF8,
  0xF8, 0x00, 0xF8, 0xFC, 0x01, 0xF0, 0x7E, 0x07, 0xF0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x0F, 0x83,
  0xE0, 0x07, 0x81, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0,
  0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3C, 0x0F, 0x00, 0x3E,
  0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03,
  0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00,
  0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0,
  0x07, 0x81, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C,
  0x00, 0xF8, 0x3E, 0x00, 0x78, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x7E, 0x07,
  0xE0, 0x7E, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x01,
  0xF7, 0xC0, 0x03, 0xE7, 0x80, 0x07, 0xCF, 0x80, 0x1F, 0x1F, 0x00, 0x3E,
  0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xC1, 0xF0, 0x0F, 0x83,
  0xE0, 0x1F, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xE0, 0x1E,
  0x07, 0xC0, 0x3C, 0x0F, 0x80, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0,
  0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x3E,
  0x00, 0x3E, 0x78, 0x00, 0x3D, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x78, 0x1F, 0x03, 0xDE, 0x07, 0xC0, 0xF7, 0x81, 0xF0,
  0x7D, 0xE0, 0x7C, 0x1E, 0x78, 0x3F, 0x07, 0x9E, 0x0F, 0xC1, 0xE7, 0x83,
  0xF0, 0xF9, 0xE1, 0xDC, 0x3C, 0x78, 0x77, 0x0F, 0x1E, 0x1D, 0xC3, 0xC7,
  0x86, 0x71, 0xF1, 0xE3, 0x9C, 0x78, 0x78, 0xE7, 0x1E, 0x3E, 0x39, 0x87,
  0x8F, 0x9C, 0x63, 0xC3, 0xC7, 0x18, 0xF0, 0xF1, 0xC6, 0x3C, 0x3C, 0x73,
  0x8F, 0x0F, 0x38, 0xE7, 0x83, 0xCE, 0x39, 0xE0, 0xF3, 0x8E, 0x78, 0x3D,
  0xC3, 0x9E, 0x0F, 0x70, 0xEF, 0x03, 0xDC, 0x3B, 0xC0, 0xF7, 0x0E, 0xF0,
  0x3F, 0x83, 0xB8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xEC, 0x0F,
  0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xF8,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x03, 0xE0,
  0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x81, 0xF0,
  0x00, 0xF8, 0x3F, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x07,
  0xCF, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x3F, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0xC0,
  0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0,
  0x7E, 0x00, 0x7E, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C,
  0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x3C, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F,
  0x1F, 0x00, 0x0F, 0x9F, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xBC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x02, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7F,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x3C,
  0x78, 0x07, 0xC7, 0x80, 0x78, 0x3C, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x1E,
  0x03, 0xE3, 0xE0, 0x1E, 0x3C, 0x01, 0xE7, 0xC0, 0x1E, 0x78, 0x01, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x7C, 0x00, 0xFE, 0x3E, 0x07,
  0xFE, 0x7C, 0x1F, 0xFE, 0xF8, 0x7F, 0xFD, 0xF0, 0xFC, 0x1F, 0xC3, 0xF0,
  0x1F, 0x87, 0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00,
  0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x8F, 0x80, 0x1F,
  0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xE1,
  0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x87, 0xE0, 0x7F, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0x7C, 0x0F, 0xFC, 0xF0, 0x0F, 0xF3, 0xE0, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x8F, 0xE0, 0x1E, 0x7F,
  0xE0, 0x7D, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFE, 0x1F, 0xC3, 0xF0, 0x1F,
  0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8,
  0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0x87, 0x80, 0x1F, 0x1F,
  0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0,
  0x07, 0xC3, 0xF0, 0x1F, 0x8F, 0xF0, 0x7E, 0x1F, 0xFF, 0xFC, 0x3E, 0xFF,
  0xF0, 0x7D, 0xFF, 0xC0, 0xF9, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xC3, 0xF8, 0xFC, 0x03, 0xE3,
  0xE0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x07, 0xCF, 0x80, 0x3F, 0x3E,
  0x00, 0xF8, 0xFE, 0x0F, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0xFE, 0x3E, 0x03, 0xFF, 0x3E, 0x07, 0xFF,
  0xBE, 0x0F, 0xFF, 0xBE, 0x0F, 0xC1, 0xFE, 0x1F, 0x80, 0xFC, 0x1F, 0x00,
  0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00,
  0x7C, 0x3E, 0x00, 0x78, 0x3C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00,
  0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x7C, 0x01,
  0xF0, 0x7C, 0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFD,
  0xF0, 0x1F, 0xF9, 0xE0, 0x0F, 0xF3, 0xE0, 0x00, 0xFF, 0x80, 0x1F, 0xFE,
  0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xF8, 0x1F, 0x9F, 0x00, 0x7C, 0xF8,
  0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x1F, 0xFE,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x07, 0xCF,
  0xC0, 0x7C, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x7C, 0x1F, 0xFD, 0xF0, 0xFF, 0xF7, 0xC7, 0xFF, 0xFF, 0x1F, 0x83,
  0xF8, 0xFC, 0x07, 0xE3, 0xE0, 0x0F, 0x9F, 0x80, 0x3E, 0x7C, 0x00, 0xF9,
  0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3C, 0x7C, 0x01, 0xF3, 0xE0,
  0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x03, 0xF3, 0xF0, 0x0F,
  0x8F, 0xE0, 0xDE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFB, 0xE0, 0xFF, 0xEF, 0x81,
  0xFE, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x8F, 0xE0, 0x1E, 0x7F, 0xE0, 0x7D,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE1, 0xFC, 0x1F, 0xC3, 0xF0, 0x1F, 0x87, 0xC0,
  0x1F, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01,
  0xF1, 0xF0, 0x03, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x1F, 0x00, 0x3E,
  0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x07, 0xC3,
  0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C,
  0x00, 0xF8, 0xF8, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xBF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x87,
  0xC0, 0x1F, 0x87, 0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x80,
  0xF8, 0x0F, 0xC0, 0x7C, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x1E, 0x0F, 0xC0,
  0x1F, 0x07, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0xF0, 0x7C, 0x00, 0xF8, 0x3F, 0x00, 0x7C, 0x0F,
  0x80, 0x3E, 0x07, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0,
  0x7E, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0xC1, 0xF0, 0x03, 0xE0, 0xF8,
  0x01, 0xF8, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0x3C, 0x3E, 0x0F, 0x7F, 0x3F, 0x87, 0xBF, 0xBF, 0xC3,
  0xF7, 0xF3, 0xE1, 0xF0, 0xF0, 0xF8, 0xF0, 0x78, 0x78, 0x78, 0x38, 0x3C,
  0x7C, 0x3C, 0x1E, 0x3E, 0x1E, 0x0F, 0x1F, 0x0F, 0x0F, 0x8F, 0x07, 0x87,
  0xC7, 0x83, 0xC3, 0xE3, 0xC1, 0xC1, 0xE3, 0xE1, 0xE0, 0xF1, 0xF0, 0xF0,
  0x78, 0xF8, 0x78, 0x3C, 0x78, 0x3C, 0x3E, 0x3C, 0x1E, 0x1F, 0x1E, 0x0E,
  0x0F, 0x0F, 0x07, 0x07, 0x8F, 0x87, 0x83, 0xC7, 0xC3, 0xC1, 0xE3, 0xC1,
  0xE1, 0xF1, 0xE0, 0xF0, 0xF8, 0xF0, 0x70, 0x78, 0x00, 0x0F, 0x8F, 0xE0,
  0x1E, 0x7F, 0xE0, 0x7D, 0xFF, 0xE0, 0xFF, 0xFF, 0xE1, 0xFC, 0x1F, 0xC3,
  0xF0, 0x1F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x7C, 0x7C,
  0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xC3, 0xE0, 0x0F, 0x87, 0xC0,
  0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01,
  0xF1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E,
  0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xE0, 0x00, 0xFF, 0x80,
  0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xF8, 0x3F, 0x9F, 0x80,
  0xFC, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xDF,
  0x00, 0x3E, 0xF8, 0x01, 0xF7, 0x80, 0x0F, 0x7C, 0x00, 0xFB, 0xE0, 0x07,
  0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0xF9, 0xF0,
  0x0F, 0xCF, 0xC0, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x03, 0xE3, 0xF8, 0x01, 0xE7, 0xFE, 0x01, 0xF7, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0x87, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x00,
  0x7C, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0,
  0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xE0, 0x78, 0x01, 0xF0, 0x7C,
  0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07,
  0xC0, 0x1F, 0x03, 0xF0, 0x1F, 0x83, 0xFC, 0x1F, 0x81, 0xFF, 0xFF, 0xC0,
  0xFB, 0xFF, 0xC0, 0x7D, 0xFF, 0xC0, 0x3E, 0x7F, 0x80, 0x1F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x3E, 0x07, 0xFE, 0x7C, 0x1F, 0xFE, 0xF8, 0x7F, 0xFD, 0xF0, 0xFC,
  0x1B, 0xC3, 0xF0, 0x1F, 0x87, 0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00,
  0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xC3, 0xC0, 0x0F,
  0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8,
  0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x87, 0xE0, 0x7F, 0x0F,
  0xFF, 0xFE, 0x0F, 0xFF, 0x7C, 0x0F, 0xFC, 0xF0, 0x0F, 0xF3, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x1F, 0x1F,
  0xE0, 0x3E, 0x7F, 0xE0, 0x7D, 0xFF, 0xE0, 0xFF, 0xFF, 0xE1, 0xFC, 0x1F,
  0xC3, 0xF0, 0x1F, 0x87, 0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C,
  0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0x80, 0xFC,
  0x7C, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xBE, 0x00, 0x7C, 0xFC, 0x03, 0xF1, 0xFF, 0xFF, 0x87, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xE0, 0x0F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8,
  0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0x87, 0xC0, 0x1F, 0x1F,
  0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0,
  0x03, 0xC3, 0xE0, 0x0F, 0x87, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00,
  0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xF0, 0x1F,
  0x87, 0xE0, 0x7E, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xF9, 0xE0, 0x01, 0xF3,
  0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E,
  0x01, 0xF0, 0x3C, 0x03, 0xE0, 0x78, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0,
  0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC3, 0xE0, 0x07, 0x87, 0xC0, 0x0F, 0x0F,
  0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x78, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0xF0, 0x3E, 0x07, 0xF8, 0x1F, 0x07, 0xBC, 0x0F, 0x83,
  0xDE, 0x0F, 0xC1, 0xEF, 0x07, 0xC1, 0xE7, 0x83, 0x60, 0xF3, 0xC3, 0xB0,
  0x79, 0xE1, 0xD8, 0x38, 0xF0, 0xCC, 0x3C, 0x78, 0xE6, 0x1E, 0x3C, 0x73,
  0x0E, 0x1E, 0x39, 0x8F, 0x0F, 0x38, 0xC7, 0x87, 0x9C, 0x63, 0x83, 0xCE,
  0x33, 0xC1, 0xEE, 0x19, 0xE0, 0xF7, 0x0C, 0xF0, 0x7B, 0x86, 0xF0, 0x3D,
  0x83, 0x78, 0x1F, 0xC1, 0xBC, 0x0F, 0xE0, 0xDC, 0x07, 0xE0, 0x7E, 0x03,
  0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x0F, 0xC1, 0xF8, 0x03, 0xE0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x01,
  0xF0, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE7, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x7E, 0x3F, 0x00,
  0x1F, 0x07, 0xC0, 0x0F, 0x81, 0xF8, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x0F,
  0xC1, 0xF8, 0x01, 0xF0, 0xFC, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x7C, 0xF8,
  0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x78, 0xF8, 0x03,
  0xE3, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7,
  0xC0, 0x0F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80,
  0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x03, 0xF3, 0xF0, 0x1F, 0x8F, 0xE0, 0xFE,
  0x1F, 0xFF, 0xF8, 0x7F, 0xFB, 0xE0, 0xFF, 0xCF, 0x80, 0xFE, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0xF0, 0x1F, 0x1F, 0xF8, 0x1E, 0x3F, 0xFC, 0x1E, 0x7C, 0x7C, 0x1E, 0x78,
  0x3E, 0x3E, 0x78, 0x3F, 0xFC, 0x78, 0x1F, 0xFC, 0x78, 0x0F, 0xF8, 0xF8,
  0x07, 0xE0,
};

const GFXglyph JetBrainsMono_MediumItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 11, 33, 27, 8, -33 },
  { 47, 16, 14, 27, 8, -33 },
  { 75, 27, 33, 27, 1, -33 },
  { 187, 24, 45, 27, 2, -39 },
  { 322, 32, 33, 27, -2, -33 },
  { 454, 25, 33, 27, 1, -33 },
  { 558, 7, 14, 27, 12, -33 },
  { 571, 19, 44, 27, 7, -38 },
  { 676, 19, 44, 27, 2, -38 },
  { 781, 24, 23, 27, 2, -27 },
  { 850, 22, 21, 27, 3, -25 },
  { 908, 12, 14, 27, 4, -7 },
  { 929, 16, 4, 27, 6, -17 },
  { 937, 8, 8, 27, 8, -8 },
  { 945, 28, 42, 27, 0, -37 },
  { 1092, 24, 33, 27, 2, -33 },
  { 1191, 21, 33, 27, 2, -33 },
  { 1278, 24, 33, 27, 2, -33 },
  { 1377, 23, 33, 27, 2, -33 },
  { 1472, 23, 33, 27, 2, -33 },
  { 1567, 24, 33, 27, 2, -33 },
  { 1666, 22, 33, 27, 2, -33 },
  { 1757, 23, 33, 27, 5, -33 },
  { 1852, 24, 33, 27, 2, -33 },
  { 1951, 22, 33, 27, 4, -33 },
  { 2042, 11, 25, 27, 8, -25 },
  { 2077, 15, 32, 27, 4, -25 },
  { 2137, 22, 24, 27, 4, -27 },
  { 2203, 22, 16, 27, 3, -23 },
  { 2247, 22, 24, 27, 2, -27 },
  { 2313, 19, 33, 27, 6, -33 },
  { 2392, 28, 41, 27, 0, -33 },
  { 2536, 23, 33, 27, 0, -33 },
  { 2631, 24, 33, 27, 2, -33 },
  { 2730, 23, 33, 27, 3, -33 },
  { 2825, 24, 33, 27, 2, -33 },
  { 2924, 25, 33, 27, 2, -33 },
  { 3028, 25, 33, 27, 2, -33 },
  { 3132, 23, 33, 27, 3, -33 },
  { 3227, 24, 33, 27, 2, -33 },
  { 3326, 24, 33, 27, 2, -33 },
  { 3425, 26, 33, 27, 0, -33 },
  { 3533, 26, 33, 27, 2, -33 },
  { 3641, 20, 33, 27, 3, -33 },
  { 3724, 26, 33, 27, 1, -33 },
  { 3832, 25, 33, 27, 2, -33 },
  { 3936, 23, 33, 27, 3, -33 },
  { 4031, 25, 33, 27, 2, -33 },
  { 4135, 24, 41, 27, 2, -33 },
  { 4258, 25, 33, 27, 2, -33 },
  { 4362, 24, 33, 27, 2, -33 },
  { 4461, 23, 33, 27, 5, -33 },
  { 4556, 25, 33, 27, 2, -33 },
  { 4660, 23, 33, 27, 5, -33 },
  { 4755, 26, 33, 27, 3, -33 },
  { 4863, 28, 33, 27, 0, -33 },
  { 4979, 24, 33, 27, 5, -33 },
  { 5078, 24, 33, 27, 2, -33 },
  { 5177, 18, 42, 27, 6, -37 },
  { 5272, 14, 42, 27, 7, -37 },
  { 5346, 18, 42, 27, 4, -37 },
  { 5441, 20, 18, 27, 4, -33 },
  { 5486, 22, 4, 27, 0, 1 },
  { 5497, 9, 6, 27, 11, -35 },
  { 5504, 23, 25, 27, 2, -25 },
  { 5576, 23, 33, 27, 2, -33 },
  { 5671, 22, 25, 27, 3, -25 },
  { 5740, 24, 33, 27, 2, -33 },
  { 5839, 21, 25, 27, 3, -25 },
  { 5905, 30, 41, 27, -2, -33 },
  { 6059, 22, 33, 27, 3, -25 },
  { 6150, 23, 33, 27, 2, -33 },
  { 6245, 23, 35, 27, 1, -35 },
  { 6346, 24, 43, 27, 0, -35 },
  { 6475, 25, 33, 27, 2, -33 },
  { 6579, 20, 33, 27, 4, -33 },
  { 6662, 25, 25, 27, 1, -25 },
  { 6741, 23, 25, 27, 2, -25 },
  { 6813, 21, 25, 27, 3, -25 },
  { 6879, 25, 33, 27, 0, -25 },
  { 6983, 23, 33, 27, 2, -25 },
  { 7078, 23, 25, 27, 3, -25 },
  { 7150, 22, 25, 27, 2, -25 },
  { 7219, 23, 32, 27, 3, -32 },
  { 7311, 23, 25, 27, 2, -25 },
  { 7383, 23, 25, 27, 4, -25 },
  { 7455, 25, 25, 27, 3, -25 },
  { 7534, 26, 25, 27, 0, -25 },
  { 7616, 22, 33, 27, 3, -25 },
  { 7707, 23, 25, 27, 2, -25 },
  { 7779, 23, 42, 27, 4, -37 },
  { 7900, 12, 42, 27, 8, -37 },
  { 7963, 23, 42, 27, 1, -37 },
  { 8084, 24, 10, 27, 2, -21 },
};

const GFXfont JetBrainsMono_MediumItalic45pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic45pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic45pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _JETBRAINSMONO_MEDIUMITALIC45PT7B_H_
